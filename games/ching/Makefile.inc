#	$NetBSD: Makefile.inc,v 1.2.12.1 2014/08/20 00:00:22 tls Exp $

CPPFLAGS+=-I${.CURDIR}/../include
BINDIR?=/usr/games
WARNS?=5
