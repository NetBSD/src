#define PACKAGE_REVISION_BASE "0b094aecb5df00cbc8a6a1a9b2668bd586ad5938"
#define PACKAGE_REVISION_CACHED 1
