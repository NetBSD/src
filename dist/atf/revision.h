#define PACKAGE_REVISION_BASE "dc8e3f9b3c86b34f877ff1bfde4a8b17a4ad1326"
