
/* This file is automatically generated. Do Not Edit. */

#ifndef port_ipv6_h
#define port_ipv6_h

#define HAS_INET6_STRUCTS
#define HAVE_SIN6_SCOPE_ID
#define USE_IFNAMELINKID

#endif
