/*	$NetBSD: dlv_65323.c,v 1.1.1.1.2.1.2.1 2008/07/24 22:24:30 ghen Exp $	*/

