/*	$NetBSD: dlv_65323.h,v 1.1.1.1.4.2 2008/07/24 22:18:03 ghen Exp $	*/

