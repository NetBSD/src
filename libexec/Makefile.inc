#	$NetBSD: Makefile.inc,v 1.8.6.1 2012/10/30 18:59:21 yamt Exp $
#	@(#)Makefile.inc	8.1 (Berkeley) 6/4/93

USE_FORT?= yes		# network server

BINDIR?=	/usr/libexec
WARNS?=		5
