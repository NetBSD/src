#	$NetBSD: Makefile.inc,v 1.3.30.1 2020/04/13 08:05:34 martin Exp $

LLVM_TOPLEVEL:=	${.PARSEDIR}/../../external/apache2/llvm
