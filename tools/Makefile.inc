# $NetBSD: Makefile.inc,v 1.16.2.2 2018/05/05 19:25:56 martin Exp $

MKREPRO=no	# Native toolchain might be unable to do it
