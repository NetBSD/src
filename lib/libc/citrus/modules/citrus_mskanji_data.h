#include <wchar.h>
#include "citrus_ctype_local.h"

#define _SHIFTJIS_MSKANJI_TABLE__U2K_LIST_LENGTH 6879
#define _SHIFTJIS_MSKANJI_TABLE__K2U_LIST_LENGTH 6879

/*
 * Data taken from NetBSD iconv
 */

struct unicode2kuten_lookup __shiftjis_mskanji_table__kuten2unicode_lookup[] = {
	{ 0x00008140, 0x00003000 },
	{ 0x00008141, 0x00003001 },
	{ 0x00008142, 0x00003002 },
	{ 0x00008143, 0x0000ff0c },
	{ 0x00008144, 0x0000ff0e },
	{ 0x00008145, 0x000030fb },
	{ 0x00008146, 0x0000ff1a },
	{ 0x00008147, 0x0000ff1b },
	{ 0x00008148, 0x0000ff1f },
	{ 0x00008149, 0x0000ff01 },
	{ 0x0000814a, 0x0000309b },
	{ 0x0000814b, 0x0000309c },
	{ 0x0000814c, 0x000000b4 },
	{ 0x0000814d, 0x0000ff40 },
	{ 0x0000814e, 0x000000a8 },
	{ 0x0000814f, 0x0000ff3e },
	{ 0x00008150, 0x0000ffe3 },
	{ 0x00008151, 0x0000ff3f },
	{ 0x00008152, 0x000030fd },
	{ 0x00008153, 0x000030fe },
	{ 0x00008154, 0x0000309d },
	{ 0x00008155, 0x0000309e },
	{ 0x00008156, 0x00003003 },
	{ 0x00008157, 0x00004edd },
	{ 0x00008158, 0x00003005 },
	{ 0x00008159, 0x00003006 },
	{ 0x0000815a, 0x00003007 },
	{ 0x0000815b, 0x000030fc },
	{ 0x0000815c, 0x00002014 },
	{ 0x0000815d, 0x00002010 },
	{ 0x0000815e, 0x0000ff0f },
	{ 0x0000815f, 0x0000ff3c },
	{ 0x00008160, 0x0000301c },
	{ 0x00008161, 0x00002016 },
	{ 0x00008162, 0x0000ff5c },
	{ 0x00008163, 0x00002026 },
	{ 0x00008164, 0x00002025 },
	{ 0x00008165, 0x00002018 },
	{ 0x00008166, 0x00002019 },
	{ 0x00008167, 0x0000201c },
	{ 0x00008168, 0x0000201d },
	{ 0x00008169, 0x0000ff08 },
	{ 0x0000816a, 0x0000ff09 },
	{ 0x0000816b, 0x00003014 },
	{ 0x0000816c, 0x00003015 },
	{ 0x0000816d, 0x0000ff3b },
	{ 0x0000816e, 0x0000ff3d },
	{ 0x0000816f, 0x0000ff5b },
	{ 0x00008170, 0x0000ff5d },
	{ 0x00008171, 0x00003008 },
	{ 0x00008172, 0x00003009 },
	{ 0x00008173, 0x0000300a },
	{ 0x00008174, 0x0000300b },
	{ 0x00008175, 0x0000300c },
	{ 0x00008176, 0x0000300d },
	{ 0x00008177, 0x0000300e },
	{ 0x00008178, 0x0000300f },
	{ 0x00008179, 0x00003010 },
	{ 0x0000817a, 0x00003011 },
	{ 0x0000817b, 0x0000ff0b },
	{ 0x0000817c, 0x00002212 },
	{ 0x0000817d, 0x000000b1 },
	{ 0x0000817e, 0x000000d7 },
	{ 0x00008180, 0x000000f7 },
	{ 0x00008181, 0x0000ff1d },
	{ 0x00008182, 0x00002260 },
	{ 0x00008183, 0x0000ff1c },
	{ 0x00008184, 0x0000ff1e },
	{ 0x00008185, 0x00002266 },
	{ 0x00008186, 0x00002267 },
	{ 0x00008187, 0x0000221e },
	{ 0x00008188, 0x00002234 },
	{ 0x00008189, 0x00002642 },
	{ 0x0000818a, 0x00002640 },
	{ 0x0000818b, 0x000000b0 },
	{ 0x0000818c, 0x00002032 },
	{ 0x0000818d, 0x00002033 },
	{ 0x0000818e, 0x00002103 },
	{ 0x0000818f, 0x0000ffe5 },
	{ 0x00008190, 0x0000ff04 },
	{ 0x00008191, 0x000000a2 },
	{ 0x00008192, 0x000000a3 },
	{ 0x00008193, 0x0000ff05 },
	{ 0x00008194, 0x0000ff03 },
	{ 0x00008195, 0x0000ff06 },
	{ 0x00008196, 0x0000ff0a },
	{ 0x00008197, 0x0000ff20 },
	{ 0x00008198, 0x000000a7 },
	{ 0x00008199, 0x00002606 },
	{ 0x0000819a, 0x00002605 },
	{ 0x0000819b, 0x000025cb },
	{ 0x0000819c, 0x000025cf },
	{ 0x0000819d, 0x000025ce },
	{ 0x0000819e, 0x000025c7 },
	{ 0x0000819f, 0x000025c6 },
	{ 0x000081a0, 0x000025a1 },
	{ 0x000081a1, 0x000025a0 },
	{ 0x000081a2, 0x000025b3 },
	{ 0x000081a3, 0x000025b2 },
	{ 0x000081a4, 0x000025bd },
	{ 0x000081a5, 0x000025bc },
	{ 0x000081a6, 0x0000203b },
	{ 0x000081a7, 0x00003012 },
	{ 0x000081a8, 0x00002192 },
	{ 0x000081a9, 0x00002190 },
	{ 0x000081aa, 0x00002191 },
	{ 0x000081ab, 0x00002193 },
	{ 0x000081ac, 0x00003013 },
	{ 0x000081b8, 0x00002208 },
	{ 0x000081b9, 0x0000220b },
	{ 0x000081ba, 0x00002286 },
	{ 0x000081bb, 0x00002287 },
	{ 0x000081bc, 0x00002282 },
	{ 0x000081bd, 0x00002283 },
	{ 0x000081be, 0x0000222a },
	{ 0x000081bf, 0x00002229 },
	{ 0x000081c8, 0x00002227 },
	{ 0x000081c9, 0x00002228 },
	{ 0x000081ca, 0x000000ac },
	{ 0x000081cb, 0x000021d2 },
	{ 0x000081cc, 0x000021d4 },
	{ 0x000081cd, 0x00002200 },
	{ 0x000081ce, 0x00002203 },
	{ 0x000081da, 0x00002220 },
	{ 0x000081db, 0x000022a5 },
	{ 0x000081dc, 0x00002312 },
	{ 0x000081dd, 0x00002202 },
	{ 0x000081de, 0x00002207 },
	{ 0x000081df, 0x00002261 },
	{ 0x000081e0, 0x00002252 },
	{ 0x000081e1, 0x0000226a },
	{ 0x000081e2, 0x0000226b },
	{ 0x000081e3, 0x0000221a },
	{ 0x000081e4, 0x0000223d },
	{ 0x000081e5, 0x0000221d },
	{ 0x000081e6, 0x00002235 },
	{ 0x000081e7, 0x0000222b },
	{ 0x000081e8, 0x0000222c },
	{ 0x000081f0, 0x0000212b },
	{ 0x000081f1, 0x00002030 },
	{ 0x000081f2, 0x0000266f },
	{ 0x000081f3, 0x0000266d },
	{ 0x000081f4, 0x0000266a },
	{ 0x000081f5, 0x00002020 },
	{ 0x000081f6, 0x00002021 },
	{ 0x000081f7, 0x000000b6 },
	{ 0x000081fc, 0x000025ef },
	{ 0x0000824f, 0x0000ff10 },
	{ 0x00008250, 0x0000ff11 },
	{ 0x00008251, 0x0000ff12 },
	{ 0x00008252, 0x0000ff13 },
	{ 0x00008253, 0x0000ff14 },
	{ 0x00008254, 0x0000ff15 },
	{ 0x00008255, 0x0000ff16 },
	{ 0x00008256, 0x0000ff17 },
	{ 0x00008257, 0x0000ff18 },
	{ 0x00008258, 0x0000ff19 },
	{ 0x00008260, 0x0000ff21 },
	{ 0x00008261, 0x0000ff22 },
	{ 0x00008262, 0x0000ff23 },
	{ 0x00008263, 0x0000ff24 },
	{ 0x00008264, 0x0000ff25 },
	{ 0x00008265, 0x0000ff26 },
	{ 0x00008266, 0x0000ff27 },
	{ 0x00008267, 0x0000ff28 },
	{ 0x00008268, 0x0000ff29 },
	{ 0x00008269, 0x0000ff2a },
	{ 0x0000826a, 0x0000ff2b },
	{ 0x0000826b, 0x0000ff2c },
	{ 0x0000826c, 0x0000ff2d },
	{ 0x0000826d, 0x0000ff2e },
	{ 0x0000826e, 0x0000ff2f },
	{ 0x0000826f, 0x0000ff30 },
	{ 0x00008270, 0x0000ff31 },
	{ 0x00008271, 0x0000ff32 },
	{ 0x00008272, 0x0000ff33 },
	{ 0x00008273, 0x0000ff34 },
	{ 0x00008274, 0x0000ff35 },
	{ 0x00008275, 0x0000ff36 },
	{ 0x00008276, 0x0000ff37 },
	{ 0x00008277, 0x0000ff38 },
	{ 0x00008278, 0x0000ff39 },
	{ 0x00008279, 0x0000ff3a },
	{ 0x00008281, 0x0000ff41 },
	{ 0x00008282, 0x0000ff42 },
	{ 0x00008283, 0x0000ff43 },
	{ 0x00008284, 0x0000ff44 },
	{ 0x00008285, 0x0000ff45 },
	{ 0x00008286, 0x0000ff46 },
	{ 0x00008287, 0x0000ff47 },
	{ 0x00008288, 0x0000ff48 },
	{ 0x00008289, 0x0000ff49 },
	{ 0x0000828a, 0x0000ff4a },
	{ 0x0000828b, 0x0000ff4b },
	{ 0x0000828c, 0x0000ff4c },
	{ 0x0000828d, 0x0000ff4d },
	{ 0x0000828e, 0x0000ff4e },
	{ 0x0000828f, 0x0000ff4f },
	{ 0x00008290, 0x0000ff50 },
	{ 0x00008291, 0x0000ff51 },
	{ 0x00008292, 0x0000ff52 },
	{ 0x00008293, 0x0000ff53 },
	{ 0x00008294, 0x0000ff54 },
	{ 0x00008295, 0x0000ff55 },
	{ 0x00008296, 0x0000ff56 },
	{ 0x00008297, 0x0000ff57 },
	{ 0x00008298, 0x0000ff58 },
	{ 0x00008299, 0x0000ff59 },
	{ 0x0000829a, 0x0000ff5a },
	{ 0x0000829f, 0x00003041 },
	{ 0x000082a0, 0x00003042 },
	{ 0x000082a1, 0x00003043 },
	{ 0x000082a2, 0x00003044 },
	{ 0x000082a3, 0x00003045 },
	{ 0x000082a4, 0x00003046 },
	{ 0x000082a5, 0x00003047 },
	{ 0x000082a6, 0x00003048 },
	{ 0x000082a7, 0x00003049 },
	{ 0x000082a8, 0x0000304a },
	{ 0x000082a9, 0x0000304b },
	{ 0x000082aa, 0x0000304c },
	{ 0x000082ab, 0x0000304d },
	{ 0x000082ac, 0x0000304e },
	{ 0x000082ad, 0x0000304f },
	{ 0x000082ae, 0x00003050 },
	{ 0x000082af, 0x00003051 },
	{ 0x000082b0, 0x00003052 },
	{ 0x000082b1, 0x00003053 },
	{ 0x000082b2, 0x00003054 },
	{ 0x000082b3, 0x00003055 },
	{ 0x000082b4, 0x00003056 },
	{ 0x000082b5, 0x00003057 },
	{ 0x000082b6, 0x00003058 },
	{ 0x000082b7, 0x00003059 },
	{ 0x000082b8, 0x0000305a },
	{ 0x000082b9, 0x0000305b },
	{ 0x000082ba, 0x0000305c },
	{ 0x000082bb, 0x0000305d },
	{ 0x000082bc, 0x0000305e },
	{ 0x000082bd, 0x0000305f },
	{ 0x000082be, 0x00003060 },
	{ 0x000082bf, 0x00003061 },
	{ 0x000082c0, 0x00003062 },
	{ 0x000082c1, 0x00003063 },
	{ 0x000082c2, 0x00003064 },
	{ 0x000082c3, 0x00003065 },
	{ 0x000082c4, 0x00003066 },
	{ 0x000082c5, 0x00003067 },
	{ 0x000082c6, 0x00003068 },
	{ 0x000082c7, 0x00003069 },
	{ 0x000082c8, 0x0000306a },
	{ 0x000082c9, 0x0000306b },
	{ 0x000082ca, 0x0000306c },
	{ 0x000082cb, 0x0000306d },
	{ 0x000082cc, 0x0000306e },
	{ 0x000082cd, 0x0000306f },
	{ 0x000082ce, 0x00003070 },
	{ 0x000082cf, 0x00003071 },
	{ 0x000082d0, 0x00003072 },
	{ 0x000082d1, 0x00003073 },
	{ 0x000082d2, 0x00003074 },
	{ 0x000082d3, 0x00003075 },
	{ 0x000082d4, 0x00003076 },
	{ 0x000082d5, 0x00003077 },
	{ 0x000082d6, 0x00003078 },
	{ 0x000082d7, 0x00003079 },
	{ 0x000082d8, 0x0000307a },
	{ 0x000082d9, 0x0000307b },
	{ 0x000082da, 0x0000307c },
	{ 0x000082db, 0x0000307d },
	{ 0x000082dc, 0x0000307e },
	{ 0x000082dd, 0x0000307f },
	{ 0x000082de, 0x00003080 },
	{ 0x000082df, 0x00003081 },
	{ 0x000082e0, 0x00003082 },
	{ 0x000082e1, 0x00003083 },
	{ 0x000082e2, 0x00003084 },
	{ 0x000082e3, 0x00003085 },
	{ 0x000082e4, 0x00003086 },
	{ 0x000082e5, 0x00003087 },
	{ 0x000082e6, 0x00003088 },
	{ 0x000082e7, 0x00003089 },
	{ 0x000082e8, 0x0000308a },
	{ 0x000082e9, 0x0000308b },
	{ 0x000082ea, 0x0000308c },
	{ 0x000082eb, 0x0000308d },
	{ 0x000082ec, 0x0000308e },
	{ 0x000082ed, 0x0000308f },
	{ 0x000082ee, 0x00003090 },
	{ 0x000082ef, 0x00003091 },
	{ 0x000082f0, 0x00003092 },
	{ 0x000082f1, 0x00003093 },
	{ 0x00008340, 0x000030a1 },
	{ 0x00008341, 0x000030a2 },
	{ 0x00008342, 0x000030a3 },
	{ 0x00008343, 0x000030a4 },
	{ 0x00008344, 0x000030a5 },
	{ 0x00008345, 0x000030a6 },
	{ 0x00008346, 0x000030a7 },
	{ 0x00008347, 0x000030a8 },
	{ 0x00008348, 0x000030a9 },
	{ 0x00008349, 0x000030aa },
	{ 0x0000834a, 0x000030ab },
	{ 0x0000834b, 0x000030ac },
	{ 0x0000834c, 0x000030ad },
	{ 0x0000834d, 0x000030ae },
	{ 0x0000834e, 0x000030af },
	{ 0x0000834f, 0x000030b0 },
	{ 0x00008350, 0x000030b1 },
	{ 0x00008351, 0x000030b2 },
	{ 0x00008352, 0x000030b3 },
	{ 0x00008353, 0x000030b4 },
	{ 0x00008354, 0x000030b5 },
	{ 0x00008355, 0x000030b6 },
	{ 0x00008356, 0x000030b7 },
	{ 0x00008357, 0x000030b8 },
	{ 0x00008358, 0x000030b9 },
	{ 0x00008359, 0x000030ba },
	{ 0x0000835a, 0x000030bb },
	{ 0x0000835b, 0x000030bc },
	{ 0x0000835c, 0x000030bd },
	{ 0x0000835d, 0x000030be },
	{ 0x0000835e, 0x000030bf },
	{ 0x0000835f, 0x000030c0 },
	{ 0x00008360, 0x000030c1 },
	{ 0x00008361, 0x000030c2 },
	{ 0x00008362, 0x000030c3 },
	{ 0x00008363, 0x000030c4 },
	{ 0x00008364, 0x000030c5 },
	{ 0x00008365, 0x000030c6 },
	{ 0x00008366, 0x000030c7 },
	{ 0x00008367, 0x000030c8 },
	{ 0x00008368, 0x000030c9 },
	{ 0x00008369, 0x000030ca },
	{ 0x0000836a, 0x000030cb },
	{ 0x0000836b, 0x000030cc },
	{ 0x0000836c, 0x000030cd },
	{ 0x0000836d, 0x000030ce },
	{ 0x0000836e, 0x000030cf },
	{ 0x0000836f, 0x000030d0 },
	{ 0x00008370, 0x000030d1 },
	{ 0x00008371, 0x000030d2 },
	{ 0x00008372, 0x000030d3 },
	{ 0x00008373, 0x000030d4 },
	{ 0x00008374, 0x000030d5 },
	{ 0x00008375, 0x000030d6 },
	{ 0x00008376, 0x000030d7 },
	{ 0x00008377, 0x000030d8 },
	{ 0x00008378, 0x000030d9 },
	{ 0x00008379, 0x000030da },
	{ 0x0000837a, 0x000030db },
	{ 0x0000837b, 0x000030dc },
	{ 0x0000837c, 0x000030dd },
	{ 0x0000837d, 0x000030de },
	{ 0x0000837e, 0x000030df },
	{ 0x00008380, 0x000030e0 },
	{ 0x00008381, 0x000030e1 },
	{ 0x00008382, 0x000030e2 },
	{ 0x00008383, 0x000030e3 },
	{ 0x00008384, 0x000030e4 },
	{ 0x00008385, 0x000030e5 },
	{ 0x00008386, 0x000030e6 },
	{ 0x00008387, 0x000030e7 },
	{ 0x00008388, 0x000030e8 },
	{ 0x00008389, 0x000030e9 },
	{ 0x0000838a, 0x000030ea },
	{ 0x0000838b, 0x000030eb },
	{ 0x0000838c, 0x000030ec },
	{ 0x0000838d, 0x000030ed },
	{ 0x0000838e, 0x000030ee },
	{ 0x0000838f, 0x000030ef },
	{ 0x00008390, 0x000030f0 },
	{ 0x00008391, 0x000030f1 },
	{ 0x00008392, 0x000030f2 },
	{ 0x00008393, 0x000030f3 },
	{ 0x00008394, 0x000030f4 },
	{ 0x00008395, 0x000030f5 },
	{ 0x00008396, 0x000030f6 },
	{ 0x0000839f, 0x00000391 },
	{ 0x000083a0, 0x00000392 },
	{ 0x000083a1, 0x00000393 },
	{ 0x000083a2, 0x00000394 },
	{ 0x000083a3, 0x00000395 },
	{ 0x000083a4, 0x00000396 },
	{ 0x000083a5, 0x00000397 },
	{ 0x000083a6, 0x00000398 },
	{ 0x000083a7, 0x00000399 },
	{ 0x000083a8, 0x0000039a },
	{ 0x000083a9, 0x0000039b },
	{ 0x000083aa, 0x0000039c },
	{ 0x000083ab, 0x0000039d },
	{ 0x000083ac, 0x0000039e },
	{ 0x000083ad, 0x0000039f },
	{ 0x000083ae, 0x000003a0 },
	{ 0x000083af, 0x000003a1 },
	{ 0x000083b0, 0x000003a3 },
	{ 0x000083b1, 0x000003a4 },
	{ 0x000083b2, 0x000003a5 },
	{ 0x000083b3, 0x000003a6 },
	{ 0x000083b4, 0x000003a7 },
	{ 0x000083b5, 0x000003a8 },
	{ 0x000083b6, 0x000003a9 },
	{ 0x000083bf, 0x000003b1 },
	{ 0x000083c0, 0x000003b2 },
	{ 0x000083c1, 0x000003b3 },
	{ 0x000083c2, 0x000003b4 },
	{ 0x000083c3, 0x000003b5 },
	{ 0x000083c4, 0x000003b6 },
	{ 0x000083c5, 0x000003b7 },
	{ 0x000083c6, 0x000003b8 },
	{ 0x000083c7, 0x000003b9 },
	{ 0x000083c8, 0x000003ba },
	{ 0x000083c9, 0x000003bb },
	{ 0x000083ca, 0x000003bc },
	{ 0x000083cb, 0x000003bd },
	{ 0x000083cc, 0x000003be },
	{ 0x000083cd, 0x000003bf },
	{ 0x000083ce, 0x000003c0 },
	{ 0x000083cf, 0x000003c1 },
	{ 0x000083d0, 0x000003c3 },
	{ 0x000083d1, 0x000003c4 },
	{ 0x000083d2, 0x000003c5 },
	{ 0x000083d3, 0x000003c6 },
	{ 0x000083d4, 0x000003c7 },
	{ 0x000083d5, 0x000003c8 },
	{ 0x000083d6, 0x000003c9 },
	{ 0x00008440, 0x00000410 },
	{ 0x00008441, 0x00000411 },
	{ 0x00008442, 0x00000412 },
	{ 0x00008443, 0x00000413 },
	{ 0x00008444, 0x00000414 },
	{ 0x00008445, 0x00000415 },
	{ 0x00008446, 0x00000401 },
	{ 0x00008447, 0x00000416 },
	{ 0x00008448, 0x00000417 },
	{ 0x00008449, 0x00000418 },
	{ 0x0000844a, 0x00000419 },
	{ 0x0000844b, 0x0000041a },
	{ 0x0000844c, 0x0000041b },
	{ 0x0000844d, 0x0000041c },
	{ 0x0000844e, 0x0000041d },
	{ 0x0000844f, 0x0000041e },
	{ 0x00008450, 0x0000041f },
	{ 0x00008451, 0x00000420 },
	{ 0x00008452, 0x00000421 },
	{ 0x00008453, 0x00000422 },
	{ 0x00008454, 0x00000423 },
	{ 0x00008455, 0x00000424 },
	{ 0x00008456, 0x00000425 },
	{ 0x00008457, 0x00000426 },
	{ 0x00008458, 0x00000427 },
	{ 0x00008459, 0x00000428 },
	{ 0x0000845a, 0x00000429 },
	{ 0x0000845b, 0x0000042a },
	{ 0x0000845c, 0x0000042b },
	{ 0x0000845d, 0x0000042c },
	{ 0x0000845e, 0x0000042d },
	{ 0x0000845f, 0x0000042e },
	{ 0x00008460, 0x0000042f },
	{ 0x00008470, 0x00000430 },
	{ 0x00008471, 0x00000431 },
	{ 0x00008472, 0x00000432 },
	{ 0x00008473, 0x00000433 },
	{ 0x00008474, 0x00000434 },
	{ 0x00008475, 0x00000435 },
	{ 0x00008476, 0x00000451 },
	{ 0x00008477, 0x00000436 },
	{ 0x00008478, 0x00000437 },
	{ 0x00008479, 0x00000438 },
	{ 0x0000847a, 0x00000439 },
	{ 0x0000847b, 0x0000043a },
	{ 0x0000847c, 0x0000043b },
	{ 0x0000847d, 0x0000043c },
	{ 0x0000847e, 0x0000043d },
	{ 0x00008480, 0x0000043e },
	{ 0x00008481, 0x0000043f },
	{ 0x00008482, 0x00000440 },
	{ 0x00008483, 0x00000441 },
	{ 0x00008484, 0x00000442 },
	{ 0x00008485, 0x00000443 },
	{ 0x00008486, 0x00000444 },
	{ 0x00008487, 0x00000445 },
	{ 0x00008488, 0x00000446 },
	{ 0x00008489, 0x00000447 },
	{ 0x0000848a, 0x00000448 },
	{ 0x0000848b, 0x00000449 },
	{ 0x0000848c, 0x0000044a },
	{ 0x0000848d, 0x0000044b },
	{ 0x0000848e, 0x0000044c },
	{ 0x0000848f, 0x0000044d },
	{ 0x00008490, 0x0000044e },
	{ 0x00008491, 0x0000044f },
	{ 0x0000849f, 0x00002500 },
	{ 0x000084a0, 0x00002502 },
	{ 0x000084a1, 0x0000250c },
	{ 0x000084a2, 0x00002510 },
	{ 0x000084a3, 0x00002518 },
	{ 0x000084a4, 0x00002514 },
	{ 0x000084a5, 0x0000251c },
	{ 0x000084a6, 0x0000252c },
	{ 0x000084a7, 0x00002524 },
	{ 0x000084a8, 0x00002534 },
	{ 0x000084a9, 0x0000253c },
	{ 0x000084aa, 0x00002501 },
	{ 0x000084ab, 0x00002503 },
	{ 0x000084ac, 0x0000250f },
	{ 0x000084ad, 0x00002513 },
	{ 0x000084ae, 0x0000251b },
	{ 0x000084af, 0x00002517 },
	{ 0x000084b0, 0x00002523 },
	{ 0x000084b1, 0x00002533 },
	{ 0x000084b2, 0x0000252b },
	{ 0x000084b3, 0x0000253b },
	{ 0x000084b4, 0x0000254b },
	{ 0x000084b5, 0x00002520 },
	{ 0x000084b6, 0x0000252f },
	{ 0x000084b7, 0x00002528 },
	{ 0x000084b8, 0x00002537 },
	{ 0x000084b9, 0x0000253f },
	{ 0x000084ba, 0x0000251d },
	{ 0x000084bb, 0x00002530 },
	{ 0x000084bc, 0x00002525 },
	{ 0x000084bd, 0x00002538 },
	{ 0x000084be, 0x00002542 },
	{ 0x0000889f, 0x00004e9c },
	{ 0x000088a0, 0x00005516 },
	{ 0x000088a1, 0x00005a03 },
	{ 0x000088a2, 0x0000963f },
	{ 0x000088a3, 0x000054c0 },
	{ 0x000088a4, 0x0000611b },
	{ 0x000088a5, 0x00006328 },
	{ 0x000088a6, 0x000059f6 },
	{ 0x000088a7, 0x00009022 },
	{ 0x000088a8, 0x00008475 },
	{ 0x000088a9, 0x0000831c },
	{ 0x000088aa, 0x00007a50 },
	{ 0x000088ab, 0x000060aa },
	{ 0x000088ac, 0x000063e1 },
	{ 0x000088ad, 0x00006e25 },
	{ 0x000088ae, 0x000065ed },
	{ 0x000088af, 0x00008466 },
	{ 0x000088b0, 0x000082a6 },
	{ 0x000088b1, 0x00009bf5 },
	{ 0x000088b2, 0x00006893 },
	{ 0x000088b3, 0x00005727 },
	{ 0x000088b4, 0x000065a1 },
	{ 0x000088b5, 0x00006271 },
	{ 0x000088b6, 0x00005b9b },
	{ 0x000088b7, 0x000059d0 },
	{ 0x000088b8, 0x0000867b },
	{ 0x000088b9, 0x000098f4 },
	{ 0x000088ba, 0x00007d62 },
	{ 0x000088bb, 0x00007dbe },
	{ 0x000088bc, 0x00009b8e },
	{ 0x000088bd, 0x00006216 },
	{ 0x000088be, 0x00007c9f },
	{ 0x000088bf, 0x000088b7 },
	{ 0x000088c0, 0x00005b89 },
	{ 0x000088c1, 0x00005eb5 },
	{ 0x000088c2, 0x00006309 },
	{ 0x000088c3, 0x00006697 },
	{ 0x000088c4, 0x00006848 },
	{ 0x000088c5, 0x000095c7 },
	{ 0x000088c6, 0x0000978d },
	{ 0x000088c7, 0x0000674f },
	{ 0x000088c8, 0x00004ee5 },
	{ 0x000088c9, 0x00004f0a },
	{ 0x000088ca, 0x00004f4d },
	{ 0x000088cb, 0x00004f9d },
	{ 0x000088cc, 0x00005049 },
	{ 0x000088cd, 0x000056f2 },
	{ 0x000088ce, 0x00005937 },
	{ 0x000088cf, 0x000059d4 },
	{ 0x000088d0, 0x00005a01 },
	{ 0x000088d1, 0x00005c09 },
	{ 0x000088d2, 0x000060df },
	{ 0x000088d3, 0x0000610f },
	{ 0x000088d4, 0x00006170 },
	{ 0x000088d5, 0x00006613 },
	{ 0x000088d6, 0x00006905 },
	{ 0x000088d7, 0x000070ba },
	{ 0x000088d8, 0x0000754f },
	{ 0x000088d9, 0x00007570 },
	{ 0x000088da, 0x000079fb },
	{ 0x000088db, 0x00007dad },
	{ 0x000088dc, 0x00007def },
	{ 0x000088dd, 0x000080c3 },
	{ 0x000088de, 0x0000840e },
	{ 0x000088df, 0x00008863 },
	{ 0x000088e0, 0x00008b02 },
	{ 0x000088e1, 0x00009055 },
	{ 0x000088e2, 0x0000907a },
	{ 0x000088e3, 0x0000533b },
	{ 0x000088e4, 0x00004e95 },
	{ 0x000088e5, 0x00004ea5 },
	{ 0x000088e6, 0x000057df },
	{ 0x000088e7, 0x000080b2 },
	{ 0x000088e8, 0x000090c1 },
	{ 0x000088e9, 0x000078ef },
	{ 0x000088ea, 0x00004e00 },
	{ 0x000088eb, 0x000058f1 },
	{ 0x000088ec, 0x00006ea2 },
	{ 0x000088ed, 0x00009038 },
	{ 0x000088ee, 0x00007a32 },
	{ 0x000088ef, 0x00008328 },
	{ 0x000088f0, 0x0000828b },
	{ 0x000088f1, 0x00009c2f },
	{ 0x000088f2, 0x00005141 },
	{ 0x000088f3, 0x00005370 },
	{ 0x000088f4, 0x000054bd },
	{ 0x000088f5, 0x000054e1 },
	{ 0x000088f6, 0x000056e0 },
	{ 0x000088f7, 0x000059fb },
	{ 0x000088f8, 0x00005f15 },
	{ 0x000088f9, 0x000098f2 },
	{ 0x000088fa, 0x00006deb },
	{ 0x000088fb, 0x000080e4 },
	{ 0x000088fc, 0x0000852d },
	{ 0x00008940, 0x00009662 },
	{ 0x00008941, 0x00009670 },
	{ 0x00008942, 0x000096a0 },
	{ 0x00008943, 0x000097fb },
	{ 0x00008944, 0x0000540b },
	{ 0x00008945, 0x000053f3 },
	{ 0x00008946, 0x00005b87 },
	{ 0x00008947, 0x000070cf },
	{ 0x00008948, 0x00007fbd },
	{ 0x00008949, 0x00008fc2 },
	{ 0x0000894a, 0x000096e8 },
	{ 0x0000894b, 0x0000536f },
	{ 0x0000894c, 0x00009d5c },
	{ 0x0000894d, 0x00007aba },
	{ 0x0000894e, 0x00004e11 },
	{ 0x0000894f, 0x00007893 },
	{ 0x00008950, 0x000081fc },
	{ 0x00008951, 0x00006e26 },
	{ 0x00008952, 0x00005618 },
	{ 0x00008953, 0x00005504 },
	{ 0x00008954, 0x00006b1d },
	{ 0x00008955, 0x0000851a },
	{ 0x00008956, 0x00009c3b },
	{ 0x00008957, 0x000059e5 },
	{ 0x00008958, 0x000053a9 },
	{ 0x00008959, 0x00006d66 },
	{ 0x0000895a, 0x000074dc },
	{ 0x0000895b, 0x0000958f },
	{ 0x0000895c, 0x00005642 },
	{ 0x0000895d, 0x00004e91 },
	{ 0x0000895e, 0x0000904b },
	{ 0x0000895f, 0x000096f2 },
	{ 0x00008960, 0x0000834f },
	{ 0x00008961, 0x0000990c },
	{ 0x00008962, 0x000053e1 },
	{ 0x00008963, 0x000055b6 },
	{ 0x00008964, 0x00005b30 },
	{ 0x00008965, 0x00005f71 },
	{ 0x00008966, 0x00006620 },
	{ 0x00008967, 0x000066f3 },
	{ 0x00008968, 0x00006804 },
	{ 0x00008969, 0x00006c38 },
	{ 0x0000896a, 0x00006cf3 },
	{ 0x0000896b, 0x00006d29 },
	{ 0x0000896c, 0x0000745b },
	{ 0x0000896d, 0x000076c8 },
	{ 0x0000896e, 0x00007a4e },
	{ 0x0000896f, 0x00009834 },
	{ 0x00008970, 0x000082f1 },
	{ 0x00008971, 0x0000885b },
	{ 0x00008972, 0x00008a60 },
	{ 0x00008973, 0x000092ed },
	{ 0x00008974, 0x00006db2 },
	{ 0x00008975, 0x000075ab },
	{ 0x00008976, 0x000076ca },
	{ 0x00008977, 0x000099c5 },
	{ 0x00008978, 0x000060a6 },
	{ 0x00008979, 0x00008b01 },
	{ 0x0000897a, 0x00008d8a },
	{ 0x0000897b, 0x000095b2 },
	{ 0x0000897c, 0x0000698e },
	{ 0x0000897d, 0x000053ad },
	{ 0x0000897e, 0x00005186 },
	{ 0x00008980, 0x00005712 },
	{ 0x00008981, 0x00005830 },
	{ 0x00008982, 0x00005944 },
	{ 0x00008983, 0x00005bb4 },
	{ 0x00008984, 0x00005ef6 },
	{ 0x00008985, 0x00006028 },
	{ 0x00008986, 0x000063a9 },
	{ 0x00008987, 0x000063f4 },
	{ 0x00008988, 0x00006cbf },
	{ 0x00008989, 0x00006f14 },
	{ 0x0000898a, 0x0000708e },
	{ 0x0000898b, 0x00007114 },
	{ 0x0000898c, 0x00007159 },
	{ 0x0000898d, 0x000071d5 },
	{ 0x0000898e, 0x0000733f },
	{ 0x0000898f, 0x00007e01 },
	{ 0x00008990, 0x00008276 },
	{ 0x00008991, 0x000082d1 },
	{ 0x00008992, 0x00008597 },
	{ 0x00008993, 0x00009060 },
	{ 0x00008994, 0x0000925b },
	{ 0x00008995, 0x00009d1b },
	{ 0x00008996, 0x00005869 },
	{ 0x00008997, 0x000065bc },
	{ 0x00008998, 0x00006c5a },
	{ 0x00008999, 0x00007525 },
	{ 0x0000899a, 0x000051f9 },
	{ 0x0000899b, 0x0000592e },
	{ 0x0000899c, 0x00005965 },
	{ 0x0000899d, 0x00005f80 },
	{ 0x0000899e, 0x00005fdc },
	{ 0x0000899f, 0x000062bc },
	{ 0x000089a0, 0x000065fa },
	{ 0x000089a1, 0x00006a2a },
	{ 0x000089a2, 0x00006b27 },
	{ 0x000089a3, 0x00006bb4 },
	{ 0x000089a4, 0x0000738b },
	{ 0x000089a5, 0x00007fc1 },
	{ 0x000089a6, 0x00008956 },
	{ 0x000089a7, 0x00009d2c },
	{ 0x000089a8, 0x00009d0e },
	{ 0x000089a9, 0x00009ec4 },
	{ 0x000089aa, 0x00005ca1 },
	{ 0x000089ab, 0x00006c96 },
	{ 0x000089ac, 0x0000837b },
	{ 0x000089ad, 0x00005104 },
	{ 0x000089ae, 0x00005c4b },
	{ 0x000089af, 0x000061b6 },
	{ 0x000089b0, 0x000081c6 },
	{ 0x000089b1, 0x00006876 },
	{ 0x000089b2, 0x00007261 },
	{ 0x000089b3, 0x00004e59 },
	{ 0x000089b4, 0x00004ffa },
	{ 0x000089b5, 0x00005378 },
	{ 0x000089b6, 0x00006069 },
	{ 0x000089b7, 0x00006e29 },
	{ 0x000089b8, 0x00007a4f },
	{ 0x000089b9, 0x000097f3 },
	{ 0x000089ba, 0x00004e0b },
	{ 0x000089bb, 0x00005316 },
	{ 0x000089bc, 0x00004eee },
	{ 0x000089bd, 0x00004f55 },
	{ 0x000089be, 0x00004f3d },
	{ 0x000089bf, 0x00004fa1 },
	{ 0x000089c0, 0x00004f73 },
	{ 0x000089c1, 0x000052a0 },
	{ 0x000089c2, 0x000053ef },
	{ 0x000089c3, 0x00005609 },
	{ 0x000089c4, 0x0000590f },
	{ 0x000089c5, 0x00005ac1 },
	{ 0x000089c6, 0x00005bb6 },
	{ 0x000089c7, 0x00005be1 },
	{ 0x000089c8, 0x000079d1 },
	{ 0x000089c9, 0x00006687 },
	{ 0x000089ca, 0x0000679c },
	{ 0x000089cb, 0x000067b6 },
	{ 0x000089cc, 0x00006b4c },
	{ 0x000089cd, 0x00006cb3 },
	{ 0x000089ce, 0x0000706b },
	{ 0x000089cf, 0x000073c2 },
	{ 0x000089d0, 0x0000798d },
	{ 0x000089d1, 0x000079be },
	{ 0x000089d2, 0x00007a3c },
	{ 0x000089d3, 0x00007b87 },
	{ 0x000089d4, 0x000082b1 },
	{ 0x000089d5, 0x000082db },
	{ 0x000089d6, 0x00008304 },
	{ 0x000089d7, 0x00008377 },
	{ 0x000089d8, 0x000083ef },
	{ 0x000089d9, 0x000083d3 },
	{ 0x000089da, 0x00008766 },
	{ 0x000089db, 0x00008ab2 },
	{ 0x000089dc, 0x00005629 },
	{ 0x000089dd, 0x00008ca8 },
	{ 0x000089de, 0x00008fe6 },
	{ 0x000089df, 0x0000904e },
	{ 0x000089e0, 0x0000971e },
	{ 0x000089e1, 0x0000868a },
	{ 0x000089e2, 0x00004fc4 },
	{ 0x000089e3, 0x00005ce8 },
	{ 0x000089e4, 0x00006211 },
	{ 0x000089e5, 0x00007259 },
	{ 0x000089e6, 0x0000753b },
	{ 0x000089e7, 0x000081e5 },
	{ 0x000089e8, 0x000082bd },
	{ 0x000089e9, 0x000086fe },
	{ 0x000089ea, 0x00008cc0 },
	{ 0x000089eb, 0x000096c5 },
	{ 0x000089ec, 0x00009913 },
	{ 0x000089ed, 0x000099d5 },
	{ 0x000089ee, 0x00004ecb },
	{ 0x000089ef, 0x00004f1a },
	{ 0x000089f0, 0x000089e3 },
	{ 0x000089f1, 0x000056de },
	{ 0x000089f2, 0x0000584a },
	{ 0x000089f3, 0x000058ca },
	{ 0x000089f4, 0x00005efb },
	{ 0x000089f5, 0x00005feb },
	{ 0x000089f6, 0x0000602a },
	{ 0x000089f7, 0x00006094 },
	{ 0x000089f8, 0x00006062 },
	{ 0x000089f9, 0x000061d0 },
	{ 0x000089fa, 0x00006212 },
	{ 0x000089fb, 0x000062d0 },
	{ 0x000089fc, 0x00006539 },
	{ 0x00008a40, 0x00009b41 },
	{ 0x00008a41, 0x00006666 },
	{ 0x00008a42, 0x000068b0 },
	{ 0x00008a43, 0x00006d77 },
	{ 0x00008a44, 0x00007070 },
	{ 0x00008a45, 0x0000754c },
	{ 0x00008a46, 0x00007686 },
	{ 0x00008a47, 0x00007d75 },
	{ 0x00008a48, 0x000082a5 },
	{ 0x00008a49, 0x000087f9 },
	{ 0x00008a4a, 0x0000958b },
	{ 0x00008a4b, 0x0000968e },
	{ 0x00008a4c, 0x00008c9d },
	{ 0x00008a4d, 0x000051f1 },
	{ 0x00008a4e, 0x000052be },
	{ 0x00008a4f, 0x00005916 },
	{ 0x00008a50, 0x000054b3 },
	{ 0x00008a51, 0x00005bb3 },
	{ 0x00008a52, 0x00005d16 },
	{ 0x00008a53, 0x00006168 },
	{ 0x00008a54, 0x00006982 },
	{ 0x00008a55, 0x00006daf },
	{ 0x00008a56, 0x0000788d },
	{ 0x00008a57, 0x000084cb },
	{ 0x00008a58, 0x00008857 },
	{ 0x00008a59, 0x00008a72 },
	{ 0x00008a5a, 0x000093a7 },
	{ 0x00008a5b, 0x00009ab8 },
	{ 0x00008a5c, 0x00006d6c },
	{ 0x00008a5d, 0x000099a8 },
	{ 0x00008a5e, 0x000086d9 },
	{ 0x00008a5f, 0x000057a3 },
	{ 0x00008a60, 0x000067ff },
	{ 0x00008a61, 0x000086ce },
	{ 0x00008a62, 0x0000920e },
	{ 0x00008a63, 0x00005283 },
	{ 0x00008a64, 0x00005687 },
	{ 0x00008a65, 0x00005404 },
	{ 0x00008a66, 0x00005ed3 },
	{ 0x00008a67, 0x000062e1 },
	{ 0x00008a68, 0x000064b9 },
	{ 0x00008a69, 0x0000683c },
	{ 0x00008a6a, 0x00006838 },
	{ 0x00008a6b, 0x00006bbb },
	{ 0x00008a6c, 0x00007372 },
	{ 0x00008a6d, 0x000078ba },
	{ 0x00008a6e, 0x00007a6b },
	{ 0x00008a6f, 0x0000899a },
	{ 0x00008a70, 0x000089d2 },
	{ 0x00008a71, 0x00008d6b },
	{ 0x00008a72, 0x00008f03 },
	{ 0x00008a73, 0x000090ed },
	{ 0x00008a74, 0x000095a3 },
	{ 0x00008a75, 0x00009694 },
	{ 0x00008a76, 0x00009769 },
	{ 0x00008a77, 0x00005b66 },
	{ 0x00008a78, 0x00005cb3 },
	{ 0x00008a79, 0x0000697d },
	{ 0x00008a7a, 0x0000984d },
	{ 0x00008a7b, 0x0000984e },
	{ 0x00008a7c, 0x0000639b },
	{ 0x00008a7d, 0x00007b20 },
	{ 0x00008a7e, 0x00006a2b },
	{ 0x00008a80, 0x00006a7f },
	{ 0x00008a81, 0x000068b6 },
	{ 0x00008a82, 0x00009c0d },
	{ 0x00008a83, 0x00006f5f },
	{ 0x00008a84, 0x00005272 },
	{ 0x00008a85, 0x0000559d },
	{ 0x00008a86, 0x00006070 },
	{ 0x00008a87, 0x000062ec },
	{ 0x00008a88, 0x00006d3b },
	{ 0x00008a89, 0x00006e07 },
	{ 0x00008a8a, 0x00006ed1 },
	{ 0x00008a8b, 0x0000845b },
	{ 0x00008a8c, 0x00008910 },
	{ 0x00008a8d, 0x00008f44 },
	{ 0x00008a8e, 0x00004e14 },
	{ 0x00008a8f, 0x00009c39 },
	{ 0x00008a90, 0x000053f6 },
	{ 0x00008a91, 0x0000691b },
	{ 0x00008a92, 0x00006a3a },
	{ 0x00008a93, 0x00009784 },
	{ 0x00008a94, 0x0000682a },
	{ 0x00008a95, 0x0000515c },
	{ 0x00008a96, 0x00007ac3 },
	{ 0x00008a97, 0x000084b2 },
	{ 0x00008a98, 0x000091dc },
	{ 0x00008a99, 0x0000938c },
	{ 0x00008a9a, 0x0000565b },
	{ 0x00008a9b, 0x00009d28 },
	{ 0x00008a9c, 0x00006822 },
	{ 0x00008a9d, 0x00008305 },
	{ 0x00008a9e, 0x00008431 },
	{ 0x00008a9f, 0x00007ca5 },
	{ 0x00008aa0, 0x00005208 },
	{ 0x00008aa1, 0x000082c5 },
	{ 0x00008aa2, 0x000074e6 },
	{ 0x00008aa3, 0x00004e7e },
	{ 0x00008aa4, 0x00004f83 },
	{ 0x00008aa5, 0x000051a0 },
	{ 0x00008aa6, 0x00005bd2 },
	{ 0x00008aa7, 0x0000520a },
	{ 0x00008aa8, 0x000052d8 },
	{ 0x00008aa9, 0x000052e7 },
	{ 0x00008aaa, 0x00005dfb },
	{ 0x00008aab, 0x0000559a },
	{ 0x00008aac, 0x0000582a },
	{ 0x00008aad, 0x000059e6 },
	{ 0x00008aae, 0x00005b8c },
	{ 0x00008aaf, 0x00005b98 },
	{ 0x00008ab0, 0x00005bdb },
	{ 0x00008ab1, 0x00005e72 },
	{ 0x00008ab2, 0x00005e79 },
	{ 0x00008ab3, 0x000060a3 },
	{ 0x00008ab4, 0x0000611f },
	{ 0x00008ab5, 0x00006163 },
	{ 0x00008ab6, 0x000061be },
	{ 0x00008ab7, 0x000063db },
	{ 0x00008ab8, 0x00006562 },
	{ 0x00008ab9, 0x000067d1 },
	{ 0x00008aba, 0x00006853 },
	{ 0x00008abb, 0x000068fa },
	{ 0x00008abc, 0x00006b3e },
	{ 0x00008abd, 0x00006b53 },
	{ 0x00008abe, 0x00006c57 },
	{ 0x00008abf, 0x00006f22 },
	{ 0x00008ac0, 0x00006f97 },
	{ 0x00008ac1, 0x00006f45 },
	{ 0x00008ac2, 0x000074b0 },
	{ 0x00008ac3, 0x00007518 },
	{ 0x00008ac4, 0x000076e3 },
	{ 0x00008ac5, 0x0000770b },
	{ 0x00008ac6, 0x00007aff },
	{ 0x00008ac7, 0x00007ba1 },
	{ 0x00008ac8, 0x00007c21 },
	{ 0x00008ac9, 0x00007de9 },
	{ 0x00008aca, 0x00007f36 },
	{ 0x00008acb, 0x00007ff0 },
	{ 0x00008acc, 0x0000809d },
	{ 0x00008acd, 0x00008266 },
	{ 0x00008ace, 0x0000839e },
	{ 0x00008acf, 0x000089b3 },
	{ 0x00008ad0, 0x00008acc },
	{ 0x00008ad1, 0x00008cab },
	{ 0x00008ad2, 0x00009084 },
	{ 0x00008ad3, 0x00009451 },
	{ 0x00008ad4, 0x00009593 },
	{ 0x00008ad5, 0x00009591 },
	{ 0x00008ad6, 0x000095a2 },
	{ 0x00008ad7, 0x00009665 },
	{ 0x00008ad8, 0x000097d3 },
	{ 0x00008ad9, 0x00009928 },
	{ 0x00008ada, 0x00008218 },
	{ 0x00008adb, 0x00004e38 },
	{ 0x00008adc, 0x0000542b },
	{ 0x00008add, 0x00005cb8 },
	{ 0x00008ade, 0x00005dcc },
	{ 0x00008adf, 0x000073a9 },
	{ 0x00008ae0, 0x0000764c },
	{ 0x00008ae1, 0x0000773c },
	{ 0x00008ae2, 0x00005ca9 },
	{ 0x00008ae3, 0x00007feb },
	{ 0x00008ae4, 0x00008d0b },
	{ 0x00008ae5, 0x000096c1 },
	{ 0x00008ae6, 0x00009811 },
	{ 0x00008ae7, 0x00009854 },
	{ 0x00008ae8, 0x00009858 },
	{ 0x00008ae9, 0x00004f01 },
	{ 0x00008aea, 0x00004f0e },
	{ 0x00008aeb, 0x00005371 },
	{ 0x00008aec, 0x0000559c },
	{ 0x00008aed, 0x00005668 },
	{ 0x00008aee, 0x000057fa },
	{ 0x00008aef, 0x00005947 },
	{ 0x00008af0, 0x00005b09 },
	{ 0x00008af1, 0x00005bc4 },
	{ 0x00008af2, 0x00005c90 },
	{ 0x00008af3, 0x00005e0c },
	{ 0x00008af4, 0x00005e7e },
	{ 0x00008af5, 0x00005fcc },
	{ 0x00008af6, 0x000063ee },
	{ 0x00008af7, 0x0000673a },
	{ 0x00008af8, 0x000065d7 },
	{ 0x00008af9, 0x000065e2 },
	{ 0x00008afa, 0x0000671f },
	{ 0x00008afb, 0x000068cb },
	{ 0x00008afc, 0x000068c4 },
	{ 0x00008b40, 0x00006a5f },
	{ 0x00008b41, 0x00005e30 },
	{ 0x00008b42, 0x00006bc5 },
	{ 0x00008b43, 0x00006c17 },
	{ 0x00008b44, 0x00006c7d },
	{ 0x00008b45, 0x0000757f },
	{ 0x00008b46, 0x00007948 },
	{ 0x00008b47, 0x00005b63 },
	{ 0x00008b48, 0x00007a00 },
	{ 0x00008b49, 0x00007d00 },
	{ 0x00008b4a, 0x00005fbd },
	{ 0x00008b4b, 0x0000898f },
	{ 0x00008b4c, 0x00008a18 },
	{ 0x00008b4d, 0x00008cb4 },
	{ 0x00008b4e, 0x00008d77 },
	{ 0x00008b4f, 0x00008ecc },
	{ 0x00008b50, 0x00008f1d },
	{ 0x00008b51, 0x000098e2 },
	{ 0x00008b52, 0x00009a0e },
	{ 0x00008b53, 0x00009b3c },
	{ 0x00008b54, 0x00004e80 },
	{ 0x00008b55, 0x0000507d },
	{ 0x00008b56, 0x00005100 },
	{ 0x00008b57, 0x00005993 },
	{ 0x00008b58, 0x00005b9c },
	{ 0x00008b59, 0x0000622f },
	{ 0x00008b5a, 0x00006280 },
	{ 0x00008b5b, 0x000064ec },
	{ 0x00008b5c, 0x00006b3a },
	{ 0x00008b5d, 0x000072a0 },
	{ 0x00008b5e, 0x00007591 },
	{ 0x00008b5f, 0x00007947 },
	{ 0x00008b60, 0x00007fa9 },
	{ 0x00008b61, 0x000087fb },
	{ 0x00008b62, 0x00008abc },
	{ 0x00008b63, 0x00008b70 },
	{ 0x00008b64, 0x000063ac },
	{ 0x00008b65, 0x000083ca },
	{ 0x00008b66, 0x000097a0 },
	{ 0x00008b67, 0x00005409 },
	{ 0x00008b68, 0x00005403 },
	{ 0x00008b69, 0x000055ab },
	{ 0x00008b6a, 0x00006854 },
	{ 0x00008b6b, 0x00006a58 },
	{ 0x00008b6c, 0x00008a70 },
	{ 0x00008b6d, 0x00007827 },
	{ 0x00008b6e, 0x00006775 },
	{ 0x00008b6f, 0x00009ecd },
	{ 0x00008b70, 0x00005374 },
	{ 0x00008b71, 0x00005ba2 },
	{ 0x00008b72, 0x0000811a },
	{ 0x00008b73, 0x00008650 },
	{ 0x00008b74, 0x00009006 },
	{ 0x00008b75, 0x00004e18 },
	{ 0x00008b76, 0x00004e45 },
	{ 0x00008b77, 0x00004ec7 },
	{ 0x00008b78, 0x00004f11 },
	{ 0x00008b79, 0x000053ca },
	{ 0x00008b7a, 0x00005438 },
	{ 0x00008b7b, 0x00005bae },
	{ 0x00008b7c, 0x00005f13 },
	{ 0x00008b7d, 0x00006025 },
	{ 0x00008b7e, 0x00006551 },
	{ 0x00008b80, 0x0000673d },
	{ 0x00008b81, 0x00006c42 },
	{ 0x00008b82, 0x00006c72 },
	{ 0x00008b83, 0x00006ce3 },
	{ 0x00008b84, 0x00007078 },
	{ 0x00008b85, 0x00007403 },
	{ 0x00008b86, 0x00007a76 },
	{ 0x00008b87, 0x00007aae },
	{ 0x00008b88, 0x00007b08 },
	{ 0x00008b89, 0x00007d1a },
	{ 0x00008b8a, 0x00007cfe },
	{ 0x00008b8b, 0x00007d66 },
	{ 0x00008b8c, 0x000065e7 },
	{ 0x00008b8d, 0x0000725b },
	{ 0x00008b8e, 0x000053bb },
	{ 0x00008b8f, 0x00005c45 },
	{ 0x00008b90, 0x00005de8 },
	{ 0x00008b91, 0x000062d2 },
	{ 0x00008b92, 0x000062e0 },
	{ 0x00008b93, 0x00006319 },
	{ 0x00008b94, 0x00006e20 },
	{ 0x00008b95, 0x0000865a },
	{ 0x00008b96, 0x00008a31 },
	{ 0x00008b97, 0x00008ddd },
	{ 0x00008b98, 0x000092f8 },
	{ 0x00008b99, 0x00006f01 },
	{ 0x00008b9a, 0x000079a6 },
	{ 0x00008b9b, 0x00009b5a },
	{ 0x00008b9c, 0x00004ea8 },
	{ 0x00008b9d, 0x00004eab },
	{ 0x00008b9e, 0x00004eac },
	{ 0x00008b9f, 0x00004f9b },
	{ 0x00008ba0, 0x00004fa0 },
	{ 0x00008ba1, 0x000050d1 },
	{ 0x00008ba2, 0x00005147 },
	{ 0x00008ba3, 0x00007af6 },
	{ 0x00008ba4, 0x00005171 },
	{ 0x00008ba5, 0x000051f6 },
	{ 0x00008ba6, 0x00005354 },
	{ 0x00008ba7, 0x00005321 },
	{ 0x00008ba8, 0x0000537f },
	{ 0x00008ba9, 0x000053eb },
	{ 0x00008baa, 0x000055ac },
	{ 0x00008bab, 0x00005883 },
	{ 0x00008bac, 0x00005ce1 },
	{ 0x00008bad, 0x00005f37 },
	{ 0x00008bae, 0x00005f4a },
	{ 0x00008baf, 0x0000602f },
	{ 0x00008bb0, 0x00006050 },
	{ 0x00008bb1, 0x0000606d },
	{ 0x00008bb2, 0x0000631f },
	{ 0x00008bb3, 0x00006559 },
	{ 0x00008bb4, 0x00006a4b },
	{ 0x00008bb5, 0x00006cc1 },
	{ 0x00008bb6, 0x000072c2 },
	{ 0x00008bb7, 0x000072ed },
	{ 0x00008bb8, 0x000077ef },
	{ 0x00008bb9, 0x000080f8 },
	{ 0x00008bba, 0x00008105 },
	{ 0x00008bbb, 0x00008208 },
	{ 0x00008bbc, 0x0000854e },
	{ 0x00008bbd, 0x000090f7 },
	{ 0x00008bbe, 0x000093e1 },
	{ 0x00008bbf, 0x000097ff },
	{ 0x00008bc0, 0x00009957 },
	{ 0x00008bc1, 0x00009a5a },
	{ 0x00008bc2, 0x00004ef0 },
	{ 0x00008bc3, 0x000051dd },
	{ 0x00008bc4, 0x00005c2d },
	{ 0x00008bc5, 0x00006681 },
	{ 0x00008bc6, 0x0000696d },
	{ 0x00008bc7, 0x00005c40 },
	{ 0x00008bc8, 0x000066f2 },
	{ 0x00008bc9, 0x00006975 },
	{ 0x00008bca, 0x00007389 },
	{ 0x00008bcb, 0x00006850 },
	{ 0x00008bcc, 0x00007c81 },
	{ 0x00008bcd, 0x000050c5 },
	{ 0x00008bce, 0x000052e4 },
	{ 0x00008bcf, 0x00005747 },
	{ 0x00008bd0, 0x00005dfe },
	{ 0x00008bd1, 0x00009326 },
	{ 0x00008bd2, 0x000065a4 },
	{ 0x00008bd3, 0x00006b23 },
	{ 0x00008bd4, 0x00006b3d },
	{ 0x00008bd5, 0x00007434 },
	{ 0x00008bd6, 0x00007981 },
	{ 0x00008bd7, 0x000079bd },
	{ 0x00008bd8, 0x00007b4b },
	{ 0x00008bd9, 0x00007dca },
	{ 0x00008bda, 0x000082b9 },
	{ 0x00008bdb, 0x000083cc },
	{ 0x00008bdc, 0x0000887f },
	{ 0x00008bdd, 0x0000895f },
	{ 0x00008bde, 0x00008b39 },
	{ 0x00008bdf, 0x00008fd1 },
	{ 0x00008be0, 0x000091d1 },
	{ 0x00008be1, 0x0000541f },
	{ 0x00008be2, 0x00009280 },
	{ 0x00008be3, 0x00004e5d },
	{ 0x00008be4, 0x00005036 },
	{ 0x00008be5, 0x000053e5 },
	{ 0x00008be6, 0x0000533a },
	{ 0x00008be7, 0x000072d7 },
	{ 0x00008be8, 0x00007396 },
	{ 0x00008be9, 0x000077e9 },
	{ 0x00008bea, 0x000082e6 },
	{ 0x00008beb, 0x00008eaf },
	{ 0x00008bec, 0x000099c6 },
	{ 0x00008bed, 0x000099c8 },
	{ 0x00008bee, 0x000099d2 },
	{ 0x00008bef, 0x00005177 },
	{ 0x00008bf0, 0x0000611a },
	{ 0x00008bf1, 0x0000865e },
	{ 0x00008bf2, 0x000055b0 },
	{ 0x00008bf3, 0x00007a7a },
	{ 0x00008bf4, 0x00005076 },
	{ 0x00008bf5, 0x00005bd3 },
	{ 0x00008bf6, 0x00009047 },
	{ 0x00008bf7, 0x00009685 },
	{ 0x00008bf8, 0x00004e32 },
	{ 0x00008bf9, 0x00006adb },
	{ 0x00008bfa, 0x000091e7 },
	{ 0x00008bfb, 0x00005c51 },
	{ 0x00008bfc, 0x00005c48 },
	{ 0x00008c40, 0x00006398 },
	{ 0x00008c41, 0x00007a9f },
	{ 0x00008c42, 0x00006c93 },
	{ 0x00008c43, 0x00009774 },
	{ 0x00008c44, 0x00008f61 },
	{ 0x00008c45, 0x00007aaa },
	{ 0x00008c46, 0x0000718a },
	{ 0x00008c47, 0x00009688 },
	{ 0x00008c48, 0x00007c82 },
	{ 0x00008c49, 0x00006817 },
	{ 0x00008c4a, 0x00007e70 },
	{ 0x00008c4b, 0x00006851 },
	{ 0x00008c4c, 0x0000936c },
	{ 0x00008c4d, 0x000052f2 },
	{ 0x00008c4e, 0x0000541b },
	{ 0x00008c4f, 0x000085ab },
	{ 0x00008c50, 0x00008a13 },
	{ 0x00008c51, 0x00007fa4 },
	{ 0x00008c52, 0x00008ecd },
	{ 0x00008c53, 0x000090e1 },
	{ 0x00008c54, 0x00005366 },
	{ 0x00008c55, 0x00008888 },
	{ 0x00008c56, 0x00007941 },
	{ 0x00008c57, 0x00004fc2 },
	{ 0x00008c58, 0x000050be },
	{ 0x00008c59, 0x00005211 },
	{ 0x00008c5a, 0x00005144 },
	{ 0x00008c5b, 0x00005553 },
	{ 0x00008c5c, 0x0000572d },
	{ 0x00008c5d, 0x000073ea },
	{ 0x00008c5e, 0x0000578b },
	{ 0x00008c5f, 0x00005951 },
	{ 0x00008c60, 0x00005f62 },
	{ 0x00008c61, 0x00005f84 },
	{ 0x00008c62, 0x00006075 },
	{ 0x00008c63, 0x00006176 },
	{ 0x00008c64, 0x00006167 },
	{ 0x00008c65, 0x000061a9 },
	{ 0x00008c66, 0x000063b2 },
	{ 0x00008c67, 0x0000643a },
	{ 0x00008c68, 0x0000656c },
	{ 0x00008c69, 0x0000666f },
	{ 0x00008c6a, 0x00006842 },
	{ 0x00008c6b, 0x00006e13 },
	{ 0x00008c6c, 0x00007566 },
	{ 0x00008c6d, 0x00007a3d },
	{ 0x00008c6e, 0x00007cfb },
	{ 0x00008c6f, 0x00007d4c },
	{ 0x00008c70, 0x00007d99 },
	{ 0x00008c71, 0x00007e4b },
	{ 0x00008c72, 0x00007f6b },
	{ 0x00008c73, 0x0000830e },
	{ 0x00008c74, 0x0000834a },
	{ 0x00008c75, 0x000086cd },
	{ 0x00008c76, 0x00008a08 },
	{ 0x00008c77, 0x00008a63 },
	{ 0x00008c78, 0x00008b66 },
	{ 0x00008c79, 0x00008efd },
	{ 0x00008c7a, 0x0000981a },
	{ 0x00008c7b, 0x00009d8f },
	{ 0x00008c7c, 0x000082b8 },
	{ 0x00008c7d, 0x00008fce },
	{ 0x00008c7e, 0x00009be8 },
	{ 0x00008c80, 0x00005287 },
	{ 0x00008c81, 0x0000621f },
	{ 0x00008c82, 0x00006483 },
	{ 0x00008c83, 0x00006fc0 },
	{ 0x00008c84, 0x00009699 },
	{ 0x00008c85, 0x00006841 },
	{ 0x00008c86, 0x00005091 },
	{ 0x00008c87, 0x00006b20 },
	{ 0x00008c88, 0x00006c7a },
	{ 0x00008c89, 0x00006f54 },
	{ 0x00008c8a, 0x00007a74 },
	{ 0x00008c8b, 0x00007d50 },
	{ 0x00008c8c, 0x00008840 },
	{ 0x00008c8d, 0x00008a23 },
	{ 0x00008c8e, 0x00006708 },
	{ 0x00008c8f, 0x00004ef6 },
	{ 0x00008c90, 0x00005039 },
	{ 0x00008c91, 0x00005026 },
	{ 0x00008c92, 0x00005065 },
	{ 0x00008c93, 0x0000517c },
	{ 0x00008c94, 0x00005238 },
	{ 0x00008c95, 0x00005263 },
	{ 0x00008c96, 0x000055a7 },
	{ 0x00008c97, 0x0000570f },
	{ 0x00008c98, 0x00005805 },
	{ 0x00008c99, 0x00005acc },
	{ 0x00008c9a, 0x00005efa },
	{ 0x00008c9b, 0x000061b2 },
	{ 0x00008c9c, 0x000061f8 },
	{ 0x00008c9d, 0x000062f3 },
	{ 0x00008c9e, 0x00006372 },
	{ 0x00008c9f, 0x0000691c },
	{ 0x00008ca0, 0x00006a29 },
	{ 0x00008ca1, 0x0000727d },
	{ 0x00008ca2, 0x000072ac },
	{ 0x00008ca3, 0x0000732e },
	{ 0x00008ca4, 0x00007814 },
	{ 0x00008ca5, 0x0000786f },
	{ 0x00008ca6, 0x00007d79 },
	{ 0x00008ca7, 0x0000770c },
	{ 0x00008ca8, 0x000080a9 },
	{ 0x00008ca9, 0x0000898b },
	{ 0x00008caa, 0x00008b19 },
	{ 0x00008cab, 0x00008ce2 },
	{ 0x00008cac, 0x00008ed2 },
	{ 0x00008cad, 0x00009063 },
	{ 0x00008cae, 0x00009375 },
	{ 0x00008caf, 0x0000967a },
	{ 0x00008cb0, 0x00009855 },
	{ 0x00008cb1, 0x00009a13 },
	{ 0x00008cb2, 0x00009e78 },
	{ 0x00008cb3, 0x00005143 },
	{ 0x00008cb4, 0x0000539f },
	{ 0x00008cb5, 0x000053b3 },
	{ 0x00008cb6, 0x00005e7b },
	{ 0x00008cb7, 0x00005f26 },
	{ 0x00008cb8, 0x00006e1b },
	{ 0x00008cb9, 0x00006e90 },
	{ 0x00008cba, 0x00007384 },
	{ 0x00008cbb, 0x000073fe },
	{ 0x00008cbc, 0x00007d43 },
	{ 0x00008cbd, 0x00008237 },
	{ 0x00008cbe, 0x00008a00 },
	{ 0x00008cbf, 0x00008afa },
	{ 0x00008cc0, 0x00009650 },
	{ 0x00008cc1, 0x00004e4e },
	{ 0x00008cc2, 0x0000500b },
	{ 0x00008cc3, 0x000053e4 },
	{ 0x00008cc4, 0x0000547c },
	{ 0x00008cc5, 0x000056fa },
	{ 0x00008cc6, 0x000059d1 },
	{ 0x00008cc7, 0x00005b64 },
	{ 0x00008cc8, 0x00005df1 },
	{ 0x00008cc9, 0x00005eab },
	{ 0x00008cca, 0x00005f27 },
	{ 0x00008ccb, 0x00006238 },
	{ 0x00008ccc, 0x00006545 },
	{ 0x00008ccd, 0x000067af },
	{ 0x00008cce, 0x00006e56 },
	{ 0x00008ccf, 0x000072d0 },
	{ 0x00008cd0, 0x00007cca },
	{ 0x00008cd1, 0x000088b4 },
	{ 0x00008cd2, 0x000080a1 },
	{ 0x00008cd3, 0x000080e1 },
	{ 0x00008cd4, 0x000083f0 },
	{ 0x00008cd5, 0x0000864e },
	{ 0x00008cd6, 0x00008a87 },
	{ 0x00008cd7, 0x00008de8 },
	{ 0x00008cd8, 0x00009237 },
	{ 0x00008cd9, 0x000096c7 },
	{ 0x00008cda, 0x00009867 },
	{ 0x00008cdb, 0x00009f13 },
	{ 0x00008cdc, 0x00004e94 },
	{ 0x00008cdd, 0x00004e92 },
	{ 0x00008cde, 0x00004f0d },
	{ 0x00008cdf, 0x00005348 },
	{ 0x00008ce0, 0x00005449 },
	{ 0x00008ce1, 0x0000543e },
	{ 0x00008ce2, 0x00005a2f },
	{ 0x00008ce3, 0x00005f8c },
	{ 0x00008ce4, 0x00005fa1 },
	{ 0x00008ce5, 0x0000609f },
	{ 0x00008ce6, 0x000068a7 },
	{ 0x00008ce7, 0x00006a8e },
	{ 0x00008ce8, 0x0000745a },
	{ 0x00008ce9, 0x00007881 },
	{ 0x00008cea, 0x00008a9e },
	{ 0x00008ceb, 0x00008aa4 },
	{ 0x00008cec, 0x00008b77 },
	{ 0x00008ced, 0x00009190 },
	{ 0x00008cee, 0x00004e5e },
	{ 0x00008cef, 0x00009bc9 },
	{ 0x00008cf0, 0x00004ea4 },
	{ 0x00008cf1, 0x00004f7c },
	{ 0x00008cf2, 0x00004faf },
	{ 0x00008cf3, 0x00005019 },
	{ 0x00008cf4, 0x00005016 },
	{ 0x00008cf5, 0x00005149 },
	{ 0x00008cf6, 0x0000516c },
	{ 0x00008cf7, 0x0000529f },
	{ 0x00008cf8, 0x000052b9 },
	{ 0x00008cf9, 0x000052fe },
	{ 0x00008cfa, 0x0000539a },
	{ 0x00008cfb, 0x000053e3 },
	{ 0x00008cfc, 0x00005411 },
	{ 0x00008d40, 0x0000540e },
	{ 0x00008d41, 0x00005589 },
	{ 0x00008d42, 0x00005751 },
	{ 0x00008d43, 0x000057a2 },
	{ 0x00008d44, 0x0000597d },
	{ 0x00008d45, 0x00005b54 },
	{ 0x00008d46, 0x00005b5d },
	{ 0x00008d47, 0x00005b8f },
	{ 0x00008d48, 0x00005de5 },
	{ 0x00008d49, 0x00005de7 },
	{ 0x00008d4a, 0x00005df7 },
	{ 0x00008d4b, 0x00005e78 },
	{ 0x00008d4c, 0x00005e83 },
	{ 0x00008d4d, 0x00005e9a },
	{ 0x00008d4e, 0x00005eb7 },
	{ 0x00008d4f, 0x00005f18 },
	{ 0x00008d50, 0x00006052 },
	{ 0x00008d51, 0x0000614c },
	{ 0x00008d52, 0x00006297 },
	{ 0x00008d53, 0x000062d8 },
	{ 0x00008d54, 0x000063a7 },
	{ 0x00008d55, 0x0000653b },
	{ 0x00008d56, 0x00006602 },
	{ 0x00008d57, 0x00006643 },
	{ 0x00008d58, 0x000066f4 },
	{ 0x00008d59, 0x0000676d },
	{ 0x00008d5a, 0x00006821 },
	{ 0x00008d5b, 0x00006897 },
	{ 0x00008d5c, 0x000069cb },
	{ 0x00008d5d, 0x00006c5f },
	{ 0x00008d5e, 0x00006d2a },
	{ 0x00008d5f, 0x00006d69 },
	{ 0x00008d60, 0x00006e2f },
	{ 0x00008d61, 0x00006e9d },
	{ 0x00008d62, 0x00007532 },
	{ 0x00008d63, 0x00007687 },
	{ 0x00008d64, 0x0000786c },
	{ 0x00008d65, 0x00007a3f },
	{ 0x00008d66, 0x00007ce0 },
	{ 0x00008d67, 0x00007d05 },
	{ 0x00008d68, 0x00007d18 },
	{ 0x00008d69, 0x00007d5e },
	{ 0x00008d6a, 0x00007db1 },
	{ 0x00008d6b, 0x00008015 },
	{ 0x00008d6c, 0x00008003 },
	{ 0x00008d6d, 0x000080af },
	{ 0x00008d6e, 0x000080b1 },
	{ 0x00008d6f, 0x00008154 },
	{ 0x00008d70, 0x0000818f },
	{ 0x00008d71, 0x0000822a },
	{ 0x00008d72, 0x00008352 },
	{ 0x00008d73, 0x0000884c },
	{ 0x00008d74, 0x00008861 },
	{ 0x00008d75, 0x00008b1b },
	{ 0x00008d76, 0x00008ca2 },
	{ 0x00008d77, 0x00008cfc },
	{ 0x00008d78, 0x000090ca },
	{ 0x00008d79, 0x00009175 },
	{ 0x00008d7a, 0x00009271 },
	{ 0x00008d7b, 0x0000783f },
	{ 0x00008d7c, 0x000092fc },
	{ 0x00008d7d, 0x000095a4 },
	{ 0x00008d7e, 0x0000964d },
	{ 0x00008d80, 0x00009805 },
	{ 0x00008d81, 0x00009999 },
	{ 0x00008d82, 0x00009ad8 },
	{ 0x00008d83, 0x00009d3b },
	{ 0x00008d84, 0x0000525b },
	{ 0x00008d85, 0x000052ab },
	{ 0x00008d86, 0x000053f7 },
	{ 0x00008d87, 0x00005408 },
	{ 0x00008d88, 0x000058d5 },
	{ 0x00008d89, 0x000062f7 },
	{ 0x00008d8a, 0x00006fe0 },
	{ 0x00008d8b, 0x00008c6a },
	{ 0x00008d8c, 0x00008f5f },
	{ 0x00008d8d, 0x00009eb9 },
	{ 0x00008d8e, 0x0000514b },
	{ 0x00008d8f, 0x0000523b },
	{ 0x00008d90, 0x0000544a },
	{ 0x00008d91, 0x000056fd },
	{ 0x00008d92, 0x00007a40 },
	{ 0x00008d93, 0x00009177 },
	{ 0x00008d94, 0x00009d60 },
	{ 0x00008d95, 0x00009ed2 },
	{ 0x00008d96, 0x00007344 },
	{ 0x00008d97, 0x00006f09 },
	{ 0x00008d98, 0x00008170 },
	{ 0x00008d99, 0x00007511 },
	{ 0x00008d9a, 0x00005ffd },
	{ 0x00008d9b, 0x000060da },
	{ 0x00008d9c, 0x00009aa8 },
	{ 0x00008d9d, 0x000072db },
	{ 0x00008d9e, 0x00008fbc },
	{ 0x00008d9f, 0x00006b64 },
	{ 0x00008da0, 0x00009803 },
	{ 0x00008da1, 0x00004eca },
	{ 0x00008da2, 0x000056f0 },
	{ 0x00008da3, 0x00005764 },
	{ 0x00008da4, 0x000058be },
	{ 0x00008da5, 0x00005a5a },
	{ 0x00008da6, 0x00006068 },
	{ 0x00008da7, 0x000061c7 },
	{ 0x00008da8, 0x0000660f },
	{ 0x00008da9, 0x00006606 },
	{ 0x00008daa, 0x00006839 },
	{ 0x00008dab, 0x000068b1 },
	{ 0x00008dac, 0x00006df7 },
	{ 0x00008dad, 0x000075d5 },
	{ 0x00008dae, 0x00007d3a },
	{ 0x00008daf, 0x0000826e },
	{ 0x00008db0, 0x00009b42 },
	{ 0x00008db1, 0x00004e9b },
	{ 0x00008db2, 0x00004f50 },
	{ 0x00008db3, 0x000053c9 },
	{ 0x00008db4, 0x00005506 },
	{ 0x00008db5, 0x00005d6f },
	{ 0x00008db6, 0x00005de6 },
	{ 0x00008db7, 0x00005dee },
	{ 0x00008db8, 0x000067fb },
	{ 0x00008db9, 0x00006c99 },
	{ 0x00008dba, 0x00007473 },
	{ 0x00008dbb, 0x00007802 },
	{ 0x00008dbc, 0x00008a50 },
	{ 0x00008dbd, 0x00009396 },
	{ 0x00008dbe, 0x000088df },
	{ 0x00008dbf, 0x00005750 },
	{ 0x00008dc0, 0x00005ea7 },
	{ 0x00008dc1, 0x0000632b },
	{ 0x00008dc2, 0x000050b5 },
	{ 0x00008dc3, 0x000050ac },
	{ 0x00008dc4, 0x0000518d },
	{ 0x00008dc5, 0x00006700 },
	{ 0x00008dc6, 0x000054c9 },
	{ 0x00008dc7, 0x0000585e },
	{ 0x00008dc8, 0x000059bb },
	{ 0x00008dc9, 0x00005bb0 },
	{ 0x00008dca, 0x00005f69 },
	{ 0x00008dcb, 0x0000624d },
	{ 0x00008dcc, 0x000063a1 },
	{ 0x00008dcd, 0x0000683d },
	{ 0x00008dce, 0x00006b73 },
	{ 0x00008dcf, 0x00006e08 },
	{ 0x00008dd0, 0x0000707d },
	{ 0x00008dd1, 0x000091c7 },
	{ 0x00008dd2, 0x00007280 },
	{ 0x00008dd3, 0x00007815 },
	{ 0x00008dd4, 0x00007826 },
	{ 0x00008dd5, 0x0000796d },
	{ 0x00008dd6, 0x0000658e },
	{ 0x00008dd7, 0x00007d30 },
	{ 0x00008dd8, 0x000083dc },
	{ 0x00008dd9, 0x000088c1 },
	{ 0x00008dda, 0x00008f09 },
	{ 0x00008ddb, 0x0000969b },
	{ 0x00008ddc, 0x00005264 },
	{ 0x00008ddd, 0x00005728 },
	{ 0x00008dde, 0x00006750 },
	{ 0x00008ddf, 0x00007f6a },
	{ 0x00008de0, 0x00008ca1 },
	{ 0x00008de1, 0x000051b4 },
	{ 0x00008de2, 0x00005742 },
	{ 0x00008de3, 0x0000962a },
	{ 0x00008de4, 0x0000583a },
	{ 0x00008de5, 0x0000698a },
	{ 0x00008de6, 0x000080b4 },
	{ 0x00008de7, 0x000054b2 },
	{ 0x00008de8, 0x00005d0e },
	{ 0x00008de9, 0x000057fc },
	{ 0x00008dea, 0x00007895 },
	{ 0x00008deb, 0x00009dfa },
	{ 0x00008dec, 0x00004f5c },
	{ 0x00008ded, 0x0000524a },
	{ 0x00008dee, 0x0000548b },
	{ 0x00008def, 0x0000643e },
	{ 0x00008df0, 0x00006628 },
	{ 0x00008df1, 0x00006714 },
	{ 0x00008df2, 0x000067f5 },
	{ 0x00008df3, 0x00007a84 },
	{ 0x00008df4, 0x00007b56 },
	{ 0x00008df5, 0x00007d22 },
	{ 0x00008df6, 0x0000932f },
	{ 0x00008df7, 0x0000685c },
	{ 0x00008df8, 0x00009bad },
	{ 0x00008df9, 0x00007b39 },
	{ 0x00008dfa, 0x00005319 },
	{ 0x00008dfb, 0x0000518a },
	{ 0x00008dfc, 0x00005237 },
	{ 0x00008e40, 0x00005bdf },
	{ 0x00008e41, 0x000062f6 },
	{ 0x00008e42, 0x000064ae },
	{ 0x00008e43, 0x000064e6 },
	{ 0x00008e44, 0x0000672d },
	{ 0x00008e45, 0x00006bba },
	{ 0x00008e46, 0x000085a9 },
	{ 0x00008e47, 0x000096d1 },
	{ 0x00008e48, 0x00007690 },
	{ 0x00008e49, 0x00009bd6 },
	{ 0x00008e4a, 0x0000634c },
	{ 0x00008e4b, 0x00009306 },
	{ 0x00008e4c, 0x00009bab },
	{ 0x00008e4d, 0x000076bf },
	{ 0x00008e4e, 0x00006652 },
	{ 0x00008e4f, 0x00004e09 },
	{ 0x00008e50, 0x00005098 },
	{ 0x00008e51, 0x000053c2 },
	{ 0x00008e52, 0x00005c71 },
	{ 0x00008e53, 0x000060e8 },
	{ 0x00008e54, 0x00006492 },
	{ 0x00008e55, 0x00006563 },
	{ 0x00008e56, 0x0000685f },
	{ 0x00008e57, 0x000071e6 },
	{ 0x00008e58, 0x000073ca },
	{ 0x00008e59, 0x00007523 },
	{ 0x00008e5a, 0x00007b97 },
	{ 0x00008e5b, 0x00007e82 },
	{ 0x00008e5c, 0x00008695 },
	{ 0x00008e5d, 0x00008b83 },
	{ 0x00008e5e, 0x00008cdb },
	{ 0x00008e5f, 0x00009178 },
	{ 0x00008e60, 0x00009910 },
	{ 0x00008e61, 0x000065ac },
	{ 0x00008e62, 0x000066ab },
	{ 0x00008e63, 0x00006b8b },
	{ 0x00008e64, 0x00004ed5 },
	{ 0x00008e65, 0x00004ed4 },
	{ 0x00008e66, 0x00004f3a },
	{ 0x00008e67, 0x00004f7f },
	{ 0x00008e68, 0x0000523a },
	{ 0x00008e69, 0x000053f8 },
	{ 0x00008e6a, 0x000053f2 },
	{ 0x00008e6b, 0x000055e3 },
	{ 0x00008e6c, 0x000056db },
	{ 0x00008e6d, 0x000058eb },
	{ 0x00008e6e, 0x000059cb },
	{ 0x00008e6f, 0x000059c9 },
	{ 0x00008e70, 0x000059ff },
	{ 0x00008e71, 0x00005b50 },
	{ 0x00008e72, 0x00005c4d },
	{ 0x00008e73, 0x00005e02 },
	{ 0x00008e74, 0x00005e2b },
	{ 0x00008e75, 0x00005fd7 },
	{ 0x00008e76, 0x0000601d },
	{ 0x00008e77, 0x00006307 },
	{ 0x00008e78, 0x0000652f },
	{ 0x00008e79, 0x00005b5c },
	{ 0x00008e7a, 0x000065af },
	{ 0x00008e7b, 0x000065bd },
	{ 0x00008e7c, 0x000065e8 },
	{ 0x00008e7d, 0x0000679d },
	{ 0x00008e7e, 0x00006b62 },
	{ 0x00008e80, 0x00006b7b },
	{ 0x00008e81, 0x00006c0f },
	{ 0x00008e82, 0x00007345 },
	{ 0x00008e83, 0x00007949 },
	{ 0x00008e84, 0x000079c1 },
	{ 0x00008e85, 0x00007cf8 },
	{ 0x00008e86, 0x00007d19 },
	{ 0x00008e87, 0x00007d2b },
	{ 0x00008e88, 0x000080a2 },
	{ 0x00008e89, 0x00008102 },
	{ 0x00008e8a, 0x000081f3 },
	{ 0x00008e8b, 0x00008996 },
	{ 0x00008e8c, 0x00008a5e },
	{ 0x00008e8d, 0x00008a69 },
	{ 0x00008e8e, 0x00008a66 },
	{ 0x00008e8f, 0x00008a8c },
	{ 0x00008e90, 0x00008aee },
	{ 0x00008e91, 0x00008cc7 },
	{ 0x00008e92, 0x00008cdc },
	{ 0x00008e93, 0x000096cc },
	{ 0x00008e94, 0x000098fc },
	{ 0x00008e95, 0x00006b6f },
	{ 0x00008e96, 0x00004e8b },
	{ 0x00008e97, 0x00004f3c },
	{ 0x00008e98, 0x00004f8d },
	{ 0x00008e99, 0x00005150 },
	{ 0x00008e9a, 0x00005b57 },
	{ 0x00008e9b, 0x00005bfa },
	{ 0x00008e9c, 0x00006148 },
	{ 0x00008e9d, 0x00006301 },
	{ 0x00008e9e, 0x00006642 },
	{ 0x00008e9f, 0x00006b21 },
	{ 0x00008ea0, 0x00006ecb },
	{ 0x00008ea1, 0x00006cbb },
	{ 0x00008ea2, 0x0000723e },
	{ 0x00008ea3, 0x000074bd },
	{ 0x00008ea4, 0x000075d4 },
	{ 0x00008ea5, 0x000078c1 },
	{ 0x00008ea6, 0x0000793a },
	{ 0x00008ea7, 0x0000800c },
	{ 0x00008ea8, 0x00008033 },
	{ 0x00008ea9, 0x000081ea },
	{ 0x00008eaa, 0x00008494 },
	{ 0x00008eab, 0x00008f9e },
	{ 0x00008eac, 0x00006c50 },
	{ 0x00008ead, 0x00009e7f },
	{ 0x00008eae, 0x00005f0f },
	{ 0x00008eaf, 0x00008b58 },
	{ 0x00008eb0, 0x00009d2b },
	{ 0x00008eb1, 0x00007afa },
	{ 0x00008eb2, 0x00008ef8 },
	{ 0x00008eb3, 0x00005b8d },
	{ 0x00008eb4, 0x000096eb },
	{ 0x00008eb5, 0x00004e03 },
	{ 0x00008eb6, 0x000053f1 },
	{ 0x00008eb7, 0x000057f7 },
	{ 0x00008eb8, 0x00005931 },
	{ 0x00008eb9, 0x00005ac9 },
	{ 0x00008eba, 0x00005ba4 },
	{ 0x00008ebb, 0x00006089 },
	{ 0x00008ebc, 0x00006e7f },
	{ 0x00008ebd, 0x00006f06 },
	{ 0x00008ebe, 0x000075be },
	{ 0x00008ebf, 0x00008cea },
	{ 0x00008ec0, 0x00005b9f },
	{ 0x00008ec1, 0x00008500 },
	{ 0x00008ec2, 0x00007be0 },
	{ 0x00008ec3, 0x00005072 },
	{ 0x00008ec4, 0x000067f4 },
	{ 0x00008ec5, 0x0000829d },
	{ 0x00008ec6, 0x00005c61 },
	{ 0x00008ec7, 0x0000854a },
	{ 0x00008ec8, 0x00007e1e },
	{ 0x00008ec9, 0x0000820e },
	{ 0x00008eca, 0x00005199 },
	{ 0x00008ecb, 0x00005c04 },
	{ 0x00008ecc, 0x00006368 },
	{ 0x00008ecd, 0x00008d66 },
	{ 0x00008ece, 0x0000659c },
	{ 0x00008ecf, 0x0000716e },
	{ 0x00008ed0, 0x0000793e },
	{ 0x00008ed1, 0x00007d17 },
	{ 0x00008ed2, 0x00008005 },
	{ 0x00008ed3, 0x00008b1d },
	{ 0x00008ed4, 0x00008eca },
	{ 0x00008ed5, 0x0000906e },
	{ 0x00008ed6, 0x000086c7 },
	{ 0x00008ed7, 0x000090aa },
	{ 0x00008ed8, 0x0000501f },
	{ 0x00008ed9, 0x000052fa },
	{ 0x00008eda, 0x00005c3a },
	{ 0x00008edb, 0x00006753 },
	{ 0x00008edc, 0x0000707c },
	{ 0x00008edd, 0x00007235 },
	{ 0x00008ede, 0x0000914c },
	{ 0x00008edf, 0x000091c8 },
	{ 0x00008ee0, 0x0000932b },
	{ 0x00008ee1, 0x000082e5 },
	{ 0x00008ee2, 0x00005bc2 },
	{ 0x00008ee3, 0x00005f31 },
	{ 0x00008ee4, 0x000060f9 },
	{ 0x00008ee5, 0x00004e3b },
	{ 0x00008ee6, 0x000053d6 },
	{ 0x00008ee7, 0x00005b88 },
	{ 0x00008ee8, 0x0000624b },
	{ 0x00008ee9, 0x00006731 },
	{ 0x00008eea, 0x00006b8a },
	{ 0x00008eeb, 0x000072e9 },
	{ 0x00008eec, 0x000073e0 },
	{ 0x00008eed, 0x00007a2e },
	{ 0x00008eee, 0x0000816b },
	{ 0x00008eef, 0x00008da3 },
	{ 0x00008ef0, 0x00009152 },
	{ 0x00008ef1, 0x00009996 },
	{ 0x00008ef2, 0x00005112 },
	{ 0x00008ef3, 0x000053d7 },
	{ 0x00008ef4, 0x0000546a },
	{ 0x00008ef5, 0x00005bff },
	{ 0x00008ef6, 0x00006388 },
	{ 0x00008ef7, 0x00006a39 },
	{ 0x00008ef8, 0x00007dac },
	{ 0x00008ef9, 0x00009700 },
	{ 0x00008efa, 0x000056da },
	{ 0x00008efb, 0x000053ce },
	{ 0x00008efc, 0x00005468 },
	{ 0x00008f40, 0x00005b97 },
	{ 0x00008f41, 0x00005c31 },
	{ 0x00008f42, 0x00005dde },
	{ 0x00008f43, 0x00004fee },
	{ 0x00008f44, 0x00006101 },
	{ 0x00008f45, 0x000062fe },
	{ 0x00008f46, 0x00006d32 },
	{ 0x00008f47, 0x000079c0 },
	{ 0x00008f48, 0x000079cb },
	{ 0x00008f49, 0x00007d42 },
	{ 0x00008f4a, 0x00007e4d },
	{ 0x00008f4b, 0x00007fd2 },
	{ 0x00008f4c, 0x000081ed },
	{ 0x00008f4d, 0x0000821f },
	{ 0x00008f4e, 0x00008490 },
	{ 0x00008f4f, 0x00008846 },
	{ 0x00008f50, 0x00008972 },
	{ 0x00008f51, 0x00008b90 },
	{ 0x00008f52, 0x00008e74 },
	{ 0x00008f53, 0x00008f2f },
	{ 0x00008f54, 0x00009031 },
	{ 0x00008f55, 0x0000914b },
	{ 0x00008f56, 0x0000916c },
	{ 0x00008f57, 0x000096c6 },
	{ 0x00008f58, 0x0000919c },
	{ 0x00008f59, 0x00004ec0 },
	{ 0x00008f5a, 0x00004f4f },
	{ 0x00008f5b, 0x00005145 },
	{ 0x00008f5c, 0x00005341 },
	{ 0x00008f5d, 0x00005f93 },
	{ 0x00008f5e, 0x0000620e },
	{ 0x00008f5f, 0x000067d4 },
	{ 0x00008f60, 0x00006c41 },
	{ 0x00008f61, 0x00006e0b },
	{ 0x00008f62, 0x00007363 },
	{ 0x00008f63, 0x00007e26 },
	{ 0x00008f64, 0x000091cd },
	{ 0x00008f65, 0x00009283 },
	{ 0x00008f66, 0x000053d4 },
	{ 0x00008f67, 0x00005919 },
	{ 0x00008f68, 0x00005bbf },
	{ 0x00008f69, 0x00006dd1 },
	{ 0x00008f6a, 0x0000795d },
	{ 0x00008f6b, 0x00007e2e },
	{ 0x00008f6c, 0x00007c9b },
	{ 0x00008f6d, 0x0000587e },
	{ 0x00008f6e, 0x0000719f },
	{ 0x00008f6f, 0x000051fa },
	{ 0x00008f70, 0x00008853 },
	{ 0x00008f71, 0x00008ff0 },
	{ 0x00008f72, 0x00004fca },
	{ 0x00008f73, 0x00005cfb },
	{ 0x00008f74, 0x00006625 },
	{ 0x00008f75, 0x000077ac },
	{ 0x00008f76, 0x00007ae3 },
	{ 0x00008f77, 0x0000821c },
	{ 0x00008f78, 0x000099ff },
	{ 0x00008f79, 0x000051c6 },
	{ 0x00008f7a, 0x00005faa },
	{ 0x00008f7b, 0x000065ec },
	{ 0x00008f7c, 0x0000696f },
	{ 0x00008f7d, 0x00006b89 },
	{ 0x00008f7e, 0x00006df3 },
	{ 0x00008f80, 0x00006e96 },
	{ 0x00008f81, 0x00006f64 },
	{ 0x00008f82, 0x000076fe },
	{ 0x00008f83, 0x00007d14 },
	{ 0x00008f84, 0x00005de1 },
	{ 0x00008f85, 0x00009075 },
	{ 0x00008f86, 0x00009187 },
	{ 0x00008f87, 0x00009806 },
	{ 0x00008f88, 0x000051e6 },
	{ 0x00008f89, 0x0000521d },
	{ 0x00008f8a, 0x00006240 },
	{ 0x00008f8b, 0x00006691 },
	{ 0x00008f8c, 0x000066d9 },
	{ 0x00008f8d, 0x00006e1a },
	{ 0x00008f8e, 0x00005eb6 },
	{ 0x00008f8f, 0x00007dd2 },
	{ 0x00008f90, 0x00007f72 },
	{ 0x00008f91, 0x000066f8 },
	{ 0x00008f92, 0x000085af },
	{ 0x00008f93, 0x000085f7 },
	{ 0x00008f94, 0x00008af8 },
	{ 0x00008f95, 0x000052a9 },
	{ 0x00008f96, 0x000053d9 },
	{ 0x00008f97, 0x00005973 },
	{ 0x00008f98, 0x00005e8f },
	{ 0x00008f99, 0x00005f90 },
	{ 0x00008f9a, 0x00006055 },
	{ 0x00008f9b, 0x000092e4 },
	{ 0x00008f9c, 0x00009664 },
	{ 0x00008f9d, 0x000050b7 },
	{ 0x00008f9e, 0x0000511f },
	{ 0x00008f9f, 0x000052dd },
	{ 0x00008fa0, 0x00005320 },
	{ 0x00008fa1, 0x00005347 },
	{ 0x00008fa2, 0x000053ec },
	{ 0x00008fa3, 0x000054e8 },
	{ 0x00008fa4, 0x00005546 },
	{ 0x00008fa5, 0x00005531 },
	{ 0x00008fa6, 0x00005617 },
	{ 0x00008fa7, 0x00005968 },
	{ 0x00008fa8, 0x000059be },
	{ 0x00008fa9, 0x00005a3c },
	{ 0x00008faa, 0x00005bb5 },
	{ 0x00008fab, 0x00005c06 },
	{ 0x00008fac, 0x00005c0f },
	{ 0x00008fad, 0x00005c11 },
	{ 0x00008fae, 0x00005c1a },
	{ 0x00008faf, 0x00005e84 },
	{ 0x00008fb0, 0x00005e8a },
	{ 0x00008fb1, 0x00005ee0 },
	{ 0x00008fb2, 0x00005f70 },
	{ 0x00008fb3, 0x0000627f },
	{ 0x00008fb4, 0x00006284 },
	{ 0x00008fb5, 0x000062db },
	{ 0x00008fb6, 0x0000638c },
	{ 0x00008fb7, 0x00006377 },
	{ 0x00008fb8, 0x00006607 },
	{ 0x00008fb9, 0x0000660c },
	{ 0x00008fba, 0x0000662d },
	{ 0x00008fbb, 0x00006676 },
	{ 0x00008fbc, 0x0000677e },
	{ 0x00008fbd, 0x000068a2 },
	{ 0x00008fbe, 0x00006a1f },
	{ 0x00008fbf, 0x00006a35 },
	{ 0x00008fc0, 0x00006cbc },
	{ 0x00008fc1, 0x00006d88 },
	{ 0x00008fc2, 0x00006e09 },
	{ 0x00008fc3, 0x00006e58 },
	{ 0x00008fc4, 0x0000713c },
	{ 0x00008fc5, 0x00007126 },
	{ 0x00008fc6, 0x00007167 },
	{ 0x00008fc7, 0x000075c7 },
	{ 0x00008fc8, 0x00007701 },
	{ 0x00008fc9, 0x0000785d },
	{ 0x00008fca, 0x00007901 },
	{ 0x00008fcb, 0x00007965 },
	{ 0x00008fcc, 0x000079f0 },
	{ 0x00008fcd, 0x00007ae0 },
	{ 0x00008fce, 0x00007b11 },
	{ 0x00008fcf, 0x00007ca7 },
	{ 0x00008fd0, 0x00007d39 },
	{ 0x00008fd1, 0x00008096 },
	{ 0x00008fd2, 0x000083d6 },
	{ 0x00008fd3, 0x0000848b },
	{ 0x00008fd4, 0x00008549 },
	{ 0x00008fd5, 0x0000885d },
	{ 0x00008fd6, 0x000088f3 },
	{ 0x00008fd7, 0x00008a1f },
	{ 0x00008fd8, 0x00008a3c },
	{ 0x00008fd9, 0x00008a54 },
	{ 0x00008fda, 0x00008a73 },
	{ 0x00008fdb, 0x00008c61 },
	{ 0x00008fdc, 0x00008cde },
	{ 0x00008fdd, 0x000091a4 },
	{ 0x00008fde, 0x00009266 },
	{ 0x00008fdf, 0x0000937e },
	{ 0x00008fe0, 0x00009418 },
	{ 0x00008fe1, 0x0000969c },
	{ 0x00008fe2, 0x00009798 },
	{ 0x00008fe3, 0x00004e0a },
	{ 0x00008fe4, 0x00004e08 },
	{ 0x00008fe5, 0x00004e1e },
	{ 0x00008fe6, 0x00004e57 },
	{ 0x00008fe7, 0x00005197 },
	{ 0x00008fe8, 0x00005270 },
	{ 0x00008fe9, 0x000057ce },
	{ 0x00008fea, 0x00005834 },
	{ 0x00008feb, 0x000058cc },
	{ 0x00008fec, 0x00005b22 },
	{ 0x00008fed, 0x00005e38 },
	{ 0x00008fee, 0x000060c5 },
	{ 0x00008fef, 0x000064fe },
	{ 0x00008ff0, 0x00006761 },
	{ 0x00008ff1, 0x00006756 },
	{ 0x00008ff2, 0x00006d44 },
	{ 0x00008ff3, 0x000072b6 },
	{ 0x00008ff4, 0x00007573 },
	{ 0x00008ff5, 0x00007a63 },
	{ 0x00008ff6, 0x000084b8 },
	{ 0x00008ff7, 0x00008b72 },
	{ 0x00008ff8, 0x000091b8 },
	{ 0x00008ff9, 0x00009320 },
	{ 0x00008ffa, 0x00005631 },
	{ 0x00008ffb, 0x000057f4 },
	{ 0x00008ffc, 0x000098fe },
	{ 0x00009040, 0x000062ed },
	{ 0x00009041, 0x0000690d },
	{ 0x00009042, 0x00006b96 },
	{ 0x00009043, 0x000071ed },
	{ 0x00009044, 0x00007e54 },
	{ 0x00009045, 0x00008077 },
	{ 0x00009046, 0x00008272 },
	{ 0x00009047, 0x000089e6 },
	{ 0x00009048, 0x000098df },
	{ 0x00009049, 0x00008755 },
	{ 0x0000904a, 0x00008fb1 },
	{ 0x0000904b, 0x00005c3b },
	{ 0x0000904c, 0x00004f38 },
	{ 0x0000904d, 0x00004fe1 },
	{ 0x0000904e, 0x00004fb5 },
	{ 0x0000904f, 0x00005507 },
	{ 0x00009050, 0x00005a20 },
	{ 0x00009051, 0x00005bdd },
	{ 0x00009052, 0x00005be9 },
	{ 0x00009053, 0x00005fc3 },
	{ 0x00009054, 0x0000614e },
	{ 0x00009055, 0x0000632f },
	{ 0x00009056, 0x000065b0 },
	{ 0x00009057, 0x0000664b },
	{ 0x00009058, 0x000068ee },
	{ 0x00009059, 0x0000699b },
	{ 0x0000905a, 0x00006d78 },
	{ 0x0000905b, 0x00006df1 },
	{ 0x0000905c, 0x00007533 },
	{ 0x0000905d, 0x000075b9 },
	{ 0x0000905e, 0x0000771f },
	{ 0x0000905f, 0x0000795e },
	{ 0x00009060, 0x000079e6 },
	{ 0x00009061, 0x00007d33 },
	{ 0x00009062, 0x000081e3 },
	{ 0x00009063, 0x000082af },
	{ 0x00009064, 0x000085aa },
	{ 0x00009065, 0x000089aa },
	{ 0x00009066, 0x00008a3a },
	{ 0x00009067, 0x00008eab },
	{ 0x00009068, 0x00008f9b },
	{ 0x00009069, 0x00009032 },
	{ 0x0000906a, 0x000091dd },
	{ 0x0000906b, 0x00009707 },
	{ 0x0000906c, 0x00004eba },
	{ 0x0000906d, 0x00004ec1 },
	{ 0x0000906e, 0x00005203 },
	{ 0x0000906f, 0x00005875 },
	{ 0x00009070, 0x000058ec },
	{ 0x00009071, 0x00005c0b },
	{ 0x00009072, 0x0000751a },
	{ 0x00009073, 0x00005c3d },
	{ 0x00009074, 0x0000814e },
	{ 0x00009075, 0x00008a0a },
	{ 0x00009076, 0x00008fc5 },
	{ 0x00009077, 0x00009663 },
	{ 0x00009078, 0x0000976d },
	{ 0x00009079, 0x00007b25 },
	{ 0x0000907a, 0x00008acf },
	{ 0x0000907b, 0x00009808 },
	{ 0x0000907c, 0x00009162 },
	{ 0x0000907d, 0x000056f3 },
	{ 0x0000907e, 0x000053a8 },
	{ 0x00009080, 0x00009017 },
	{ 0x00009081, 0x00005439 },
	{ 0x00009082, 0x00005782 },
	{ 0x00009083, 0x00005e25 },
	{ 0x00009084, 0x000063a8 },
	{ 0x00009085, 0x00006c34 },
	{ 0x00009086, 0x0000708a },
	{ 0x00009087, 0x00007761 },
	{ 0x00009088, 0x00007c8b },
	{ 0x00009089, 0x00007fe0 },
	{ 0x0000908a, 0x00008870 },
	{ 0x0000908b, 0x00009042 },
	{ 0x0000908c, 0x00009154 },
	{ 0x0000908d, 0x00009310 },
	{ 0x0000908e, 0x00009318 },
	{ 0x0000908f, 0x0000968f },
	{ 0x00009090, 0x0000745e },
	{ 0x00009091, 0x00009ac4 },
	{ 0x00009092, 0x00005d07 },
	{ 0x00009093, 0x00005d69 },
	{ 0x00009094, 0x00006570 },
	{ 0x00009095, 0x000067a2 },
	{ 0x00009096, 0x00008da8 },
	{ 0x00009097, 0x000096db },
	{ 0x00009098, 0x0000636e },
	{ 0x00009099, 0x00006749 },
	{ 0x0000909a, 0x00006919 },
	{ 0x0000909b, 0x000083c5 },
	{ 0x0000909c, 0x00009817 },
	{ 0x0000909d, 0x000096c0 },
	{ 0x0000909e, 0x000088fe },
	{ 0x0000909f, 0x00006f84 },
	{ 0x000090a0, 0x0000647a },
	{ 0x000090a1, 0x00005bf8 },
	{ 0x000090a2, 0x00004e16 },
	{ 0x000090a3, 0x0000702c },
	{ 0x000090a4, 0x0000755d },
	{ 0x000090a5, 0x0000662f },
	{ 0x000090a6, 0x000051c4 },
	{ 0x000090a7, 0x00005236 },
	{ 0x000090a8, 0x000052e2 },
	{ 0x000090a9, 0x000059d3 },
	{ 0x000090aa, 0x00005f81 },
	{ 0x000090ab, 0x00006027 },
	{ 0x000090ac, 0x00006210 },
	{ 0x000090ad, 0x0000653f },
	{ 0x000090ae, 0x00006574 },
	{ 0x000090af, 0x0000661f },
	{ 0x000090b0, 0x00006674 },
	{ 0x000090b1, 0x000068f2 },
	{ 0x000090b2, 0x00006816 },
	{ 0x000090b3, 0x00006b63 },
	{ 0x000090b4, 0x00006e05 },
	{ 0x000090b5, 0x00007272 },
	{ 0x000090b6, 0x0000751f },
	{ 0x000090b7, 0x000076db },
	{ 0x000090b8, 0x00007cbe },
	{ 0x000090b9, 0x00008056 },
	{ 0x000090ba, 0x000058f0 },
	{ 0x000090bb, 0x000088fd },
	{ 0x000090bc, 0x0000897f },
	{ 0x000090bd, 0x00008aa0 },
	{ 0x000090be, 0x00008a93 },
	{ 0x000090bf, 0x00008acb },
	{ 0x000090c0, 0x0000901d },
	{ 0x000090c1, 0x00009192 },
	{ 0x000090c2, 0x00009752 },
	{ 0x000090c3, 0x00009759 },
	{ 0x000090c4, 0x00006589 },
	{ 0x000090c5, 0x00007a0e },
	{ 0x000090c6, 0x00008106 },
	{ 0x000090c7, 0x000096bb },
	{ 0x000090c8, 0x00005e2d },
	{ 0x000090c9, 0x000060dc },
	{ 0x000090ca, 0x0000621a },
	{ 0x000090cb, 0x000065a5 },
	{ 0x000090cc, 0x00006614 },
	{ 0x000090cd, 0x00006790 },
	{ 0x000090ce, 0x000077f3 },
	{ 0x000090cf, 0x00007a4d },
	{ 0x000090d0, 0x00007c4d },
	{ 0x000090d1, 0x00007e3e },
	{ 0x000090d2, 0x0000810a },
	{ 0x000090d3, 0x00008cac },
	{ 0x000090d4, 0x00008d64 },
	{ 0x000090d5, 0x00008de1 },
	{ 0x000090d6, 0x00008e5f },
	{ 0x000090d7, 0x000078a9 },
	{ 0x000090d8, 0x00005207 },
	{ 0x000090d9, 0x000062d9 },
	{ 0x000090da, 0x000063a5 },
	{ 0x000090db, 0x00006442 },
	{ 0x000090dc, 0x00006298 },
	{ 0x000090dd, 0x00008a2d },
	{ 0x000090de, 0x00007a83 },
	{ 0x000090df, 0x00007bc0 },
	{ 0x000090e0, 0x00008aac },
	{ 0x000090e1, 0x000096ea },
	{ 0x000090e2, 0x00007d76 },
	{ 0x000090e3, 0x0000820c },
	{ 0x000090e4, 0x00008749 },
	{ 0x000090e5, 0x00004ed9 },
	{ 0x000090e6, 0x00005148 },
	{ 0x000090e7, 0x00005343 },
	{ 0x000090e8, 0x00005360 },
	{ 0x000090e9, 0x00005ba3 },
	{ 0x000090ea, 0x00005c02 },
	{ 0x000090eb, 0x00005c16 },
	{ 0x000090ec, 0x00005ddd },
	{ 0x000090ed, 0x00006226 },
	{ 0x000090ee, 0x00006247 },
	{ 0x000090ef, 0x000064b0 },
	{ 0x000090f0, 0x00006813 },
	{ 0x000090f1, 0x00006834 },
	{ 0x000090f2, 0x00006cc9 },
	{ 0x000090f3, 0x00006d45 },
	{ 0x000090f4, 0x00006d17 },
	{ 0x000090f5, 0x000067d3 },
	{ 0x000090f6, 0x00006f5c },
	{ 0x000090f7, 0x0000714e },
	{ 0x000090f8, 0x0000717d },
	{ 0x000090f9, 0x000065cb },
	{ 0x000090fa, 0x00007a7f },
	{ 0x000090fb, 0x00007bad },
	{ 0x000090fc, 0x00007dda },
	{ 0x00009140, 0x00007e4a },
	{ 0x00009141, 0x00007fa8 },
	{ 0x00009142, 0x0000817a },
	{ 0x00009143, 0x0000821b },
	{ 0x00009144, 0x00008239 },
	{ 0x00009145, 0x000085a6 },
	{ 0x00009146, 0x00008a6e },
	{ 0x00009147, 0x00008cce },
	{ 0x00009148, 0x00008df5 },
	{ 0x00009149, 0x00009078 },
	{ 0x0000914a, 0x00009077 },
	{ 0x0000914b, 0x000092ad },
	{ 0x0000914c, 0x00009291 },
	{ 0x0000914d, 0x00009583 },
	{ 0x0000914e, 0x00009bae },
	{ 0x0000914f, 0x0000524d },
	{ 0x00009150, 0x00005584 },
	{ 0x00009151, 0x00006f38 },
	{ 0x00009152, 0x00007136 },
	{ 0x00009153, 0x00005168 },
	{ 0x00009154, 0x00007985 },
	{ 0x00009155, 0x00007e55 },
	{ 0x00009156, 0x000081b3 },
	{ 0x00009157, 0x00007cce },
	{ 0x00009158, 0x0000564c },
	{ 0x00009159, 0x00005851 },
	{ 0x0000915a, 0x00005ca8 },
	{ 0x0000915b, 0x000063aa },
	{ 0x0000915c, 0x000066fe },
	{ 0x0000915d, 0x000066fd },
	{ 0x0000915e, 0x0000695a },
	{ 0x0000915f, 0x000072d9 },
	{ 0x00009160, 0x0000758f },
	{ 0x00009161, 0x0000758e },
	{ 0x00009162, 0x0000790e },
	{ 0x00009163, 0x00007956 },
	{ 0x00009164, 0x000079df },
	{ 0x00009165, 0x00007c97 },
	{ 0x00009166, 0x00007d20 },
	{ 0x00009167, 0x00007d44 },
	{ 0x00009168, 0x00008607 },
	{ 0x00009169, 0x00008a34 },
	{ 0x0000916a, 0x0000963b },
	{ 0x0000916b, 0x00009061 },
	{ 0x0000916c, 0x00009f20 },
	{ 0x0000916d, 0x000050e7 },
	{ 0x0000916e, 0x00005275 },
	{ 0x0000916f, 0x000053cc },
	{ 0x00009170, 0x000053e2 },
	{ 0x00009171, 0x00005009 },
	{ 0x00009172, 0x000055aa },
	{ 0x00009173, 0x000058ee },
	{ 0x00009174, 0x0000594f },
	{ 0x00009175, 0x0000723d },
	{ 0x00009176, 0x00005b8b },
	{ 0x00009177, 0x00005c64 },
	{ 0x00009178, 0x0000531d },
	{ 0x00009179, 0x000060e3 },
	{ 0x0000917a, 0x000060f3 },
	{ 0x0000917b, 0x0000635c },
	{ 0x0000917c, 0x00006383 },
	{ 0x0000917d, 0x0000633f },
	{ 0x0000917e, 0x000063bb },
	{ 0x00009180, 0x000064cd },
	{ 0x00009181, 0x000065e9 },
	{ 0x00009182, 0x000066f9 },
	{ 0x00009183, 0x00005de3 },
	{ 0x00009184, 0x000069cd },
	{ 0x00009185, 0x000069fd },
	{ 0x00009186, 0x00006f15 },
	{ 0x00009187, 0x000071e5 },
	{ 0x00009188, 0x00004e89 },
	{ 0x00009189, 0x000075e9 },
	{ 0x0000918a, 0x000076f8 },
	{ 0x0000918b, 0x00007a93 },
	{ 0x0000918c, 0x00007cdf },
	{ 0x0000918d, 0x00007dcf },
	{ 0x0000918e, 0x00007d9c },
	{ 0x0000918f, 0x00008061 },
	{ 0x00009190, 0x00008349 },
	{ 0x00009191, 0x00008358 },
	{ 0x00009192, 0x0000846c },
	{ 0x00009193, 0x000084bc },
	{ 0x00009194, 0x000085fb },
	{ 0x00009195, 0x000088c5 },
	{ 0x00009196, 0x00008d70 },
	{ 0x00009197, 0x00009001 },
	{ 0x00009198, 0x0000906d },
	{ 0x00009199, 0x00009397 },
	{ 0x0000919a, 0x0000971c },
	{ 0x0000919b, 0x00009a12 },
	{ 0x0000919c, 0x000050cf },
	{ 0x0000919d, 0x00005897 },
	{ 0x0000919e, 0x0000618e },
	{ 0x0000919f, 0x000081d3 },
	{ 0x000091a0, 0x00008535 },
	{ 0x000091a1, 0x00008d08 },
	{ 0x000091a2, 0x00009020 },
	{ 0x000091a3, 0x00004fc3 },
	{ 0x000091a4, 0x00005074 },
	{ 0x000091a5, 0x00005247 },
	{ 0x000091a6, 0x00005373 },
	{ 0x000091a7, 0x0000606f },
	{ 0x000091a8, 0x00006349 },
	{ 0x000091a9, 0x0000675f },
	{ 0x000091aa, 0x00006e2c },
	{ 0x000091ab, 0x00008db3 },
	{ 0x000091ac, 0x0000901f },
	{ 0x000091ad, 0x00004fd7 },
	{ 0x000091ae, 0x00005c5e },
	{ 0x000091af, 0x00008cca },
	{ 0x000091b0, 0x000065cf },
	{ 0x000091b1, 0x00007d9a },
	{ 0x000091b2, 0x00005352 },
	{ 0x000091b3, 0x00008896 },
	{ 0x000091b4, 0x00005176 },
	{ 0x000091b5, 0x000063c3 },
	{ 0x000091b6, 0x00005b58 },
	{ 0x000091b7, 0x00005b6b },
	{ 0x000091b8, 0x00005c0a },
	{ 0x000091b9, 0x0000640d },
	{ 0x000091ba, 0x00006751 },
	{ 0x000091bb, 0x0000905c },
	{ 0x000091bc, 0x00004ed6 },
	{ 0x000091bd, 0x0000591a },
	{ 0x000091be, 0x0000592a },
	{ 0x000091bf, 0x00006c70 },
	{ 0x000091c0, 0x00008a51 },
	{ 0x000091c1, 0x0000553e },
	{ 0x000091c2, 0x00005815 },
	{ 0x000091c3, 0x000059a5 },
	{ 0x000091c4, 0x000060f0 },
	{ 0x000091c5, 0x00006253 },
	{ 0x000091c6, 0x000067c1 },
	{ 0x000091c7, 0x00008235 },
	{ 0x000091c8, 0x00006955 },
	{ 0x000091c9, 0x00009640 },
	{ 0x000091ca, 0x000099c4 },
	{ 0x000091cb, 0x00009a28 },
	{ 0x000091cc, 0x00004f53 },
	{ 0x000091cd, 0x00005806 },
	{ 0x000091ce, 0x00005bfe },
	{ 0x000091cf, 0x00008010 },
	{ 0x000091d0, 0x00005cb1 },
	{ 0x000091d1, 0x00005e2f },
	{ 0x000091d2, 0x00005f85 },
	{ 0x000091d3, 0x00006020 },
	{ 0x000091d4, 0x0000614b },
	{ 0x000091d5, 0x00006234 },
	{ 0x000091d6, 0x000066ff },
	{ 0x000091d7, 0x00006cf0 },
	{ 0x000091d8, 0x00006ede },
	{ 0x000091d9, 0x000080ce },
	{ 0x000091da, 0x0000817f },
	{ 0x000091db, 0x000082d4 },
	{ 0x000091dc, 0x0000888b },
	{ 0x000091dd, 0x00008cb8 },
	{ 0x000091de, 0x00009000 },
	{ 0x000091df, 0x0000902e },
	{ 0x000091e0, 0x0000968a },
	{ 0x000091e1, 0x00009edb },
	{ 0x000091e2, 0x00009bdb },
	{ 0x000091e3, 0x00004ee3 },
	{ 0x000091e4, 0x000053f0 },
	{ 0x000091e5, 0x00005927 },
	{ 0x000091e6, 0x00007b2c },
	{ 0x000091e7, 0x0000918d },
	{ 0x000091e8, 0x0000984c },
	{ 0x000091e9, 0x00009df9 },
	{ 0x000091ea, 0x00006edd },
	{ 0x000091eb, 0x00007027 },
	{ 0x000091ec, 0x00005353 },
	{ 0x000091ed, 0x00005544 },
	{ 0x000091ee, 0x00005b85 },
	{ 0x000091ef, 0x00006258 },
	{ 0x000091f0, 0x0000629e },
	{ 0x000091f1, 0x000062d3 },
	{ 0x000091f2, 0x00006ca2 },
	{ 0x000091f3, 0x00006fef },
	{ 0x000091f4, 0x00007422 },
	{ 0x000091f5, 0x00008a17 },
	{ 0x000091f6, 0x00009438 },
	{ 0x000091f7, 0x00006fc1 },
	{ 0x000091f8, 0x00008afe },
	{ 0x000091f9, 0x00008338 },
	{ 0x000091fa, 0x000051e7 },
	{ 0x000091fb, 0x000086f8 },
	{ 0x000091fc, 0x000053ea },
	{ 0x00009240, 0x000053e9 },
	{ 0x00009241, 0x00004f46 },
	{ 0x00009242, 0x00009054 },
	{ 0x00009243, 0x00008fb0 },
	{ 0x00009244, 0x0000596a },
	{ 0x00009245, 0x00008131 },
	{ 0x00009246, 0x00005dfd },
	{ 0x00009247, 0x00007aea },
	{ 0x00009248, 0x00008fbf },
	{ 0x00009249, 0x000068da },
	{ 0x0000924a, 0x00008c37 },
	{ 0x0000924b, 0x000072f8 },
	{ 0x0000924c, 0x00009c48 },
	{ 0x0000924d, 0x00006a3d },
	{ 0x0000924e, 0x00008ab0 },
	{ 0x0000924f, 0x00004e39 },
	{ 0x00009250, 0x00005358 },
	{ 0x00009251, 0x00005606 },
	{ 0x00009252, 0x00005766 },
	{ 0x00009253, 0x000062c5 },
	{ 0x00009254, 0x000063a2 },
	{ 0x00009255, 0x000065e6 },
	{ 0x00009256, 0x00006b4e },
	{ 0x00009257, 0x00006de1 },
	{ 0x00009258, 0x00006e5b },
	{ 0x00009259, 0x000070ad },
	{ 0x0000925a, 0x000077ed },
	{ 0x0000925b, 0x00007aef },
	{ 0x0000925c, 0x00007baa },
	{ 0x0000925d, 0x00007dbb },
	{ 0x0000925e, 0x0000803d },
	{ 0x0000925f, 0x000080c6 },
	{ 0x00009260, 0x000086cb },
	{ 0x00009261, 0x00008a95 },
	{ 0x00009262, 0x0000935b },
	{ 0x00009263, 0x000056e3 },
	{ 0x00009264, 0x000058c7 },
	{ 0x00009265, 0x00005f3e },
	{ 0x00009266, 0x000065ad },
	{ 0x00009267, 0x00006696 },
	{ 0x00009268, 0x00006a80 },
	{ 0x00009269, 0x00006bb5 },
	{ 0x0000926a, 0x00007537 },
	{ 0x0000926b, 0x00008ac7 },
	{ 0x0000926c, 0x00005024 },
	{ 0x0000926d, 0x000077e5 },
	{ 0x0000926e, 0x00005730 },
	{ 0x0000926f, 0x00005f1b },
	{ 0x00009270, 0x00006065 },
	{ 0x00009271, 0x0000667a },
	{ 0x00009272, 0x00006c60 },
	{ 0x00009273, 0x000075f4 },
	{ 0x00009274, 0x00007a1a },
	{ 0x00009275, 0x00007f6e },
	{ 0x00009276, 0x000081f4 },
	{ 0x00009277, 0x00008718 },
	{ 0x00009278, 0x00009045 },
	{ 0x00009279, 0x000099b3 },
	{ 0x0000927a, 0x00007bc9 },
	{ 0x0000927b, 0x0000755c },
	{ 0x0000927c, 0x00007af9 },
	{ 0x0000927d, 0x00007b51 },
	{ 0x0000927e, 0x000084c4 },
	{ 0x00009280, 0x00009010 },
	{ 0x00009281, 0x000079e9 },
	{ 0x00009282, 0x00007a92 },
	{ 0x00009283, 0x00008336 },
	{ 0x00009284, 0x00005ae1 },
	{ 0x00009285, 0x00007740 },
	{ 0x00009286, 0x00004e2d },
	{ 0x00009287, 0x00004ef2 },
	{ 0x00009288, 0x00005b99 },
	{ 0x00009289, 0x00005fe0 },
	{ 0x0000928a, 0x000062bd },
	{ 0x0000928b, 0x0000663c },
	{ 0x0000928c, 0x000067f1 },
	{ 0x0000928d, 0x00006ce8 },
	{ 0x0000928e, 0x0000866b },
	{ 0x0000928f, 0x00008877 },
	{ 0x00009290, 0x00008a3b },
	{ 0x00009291, 0x0000914e },
	{ 0x00009292, 0x000092f3 },
	{ 0x00009293, 0x000099d0 },
	{ 0x00009294, 0x00006a17 },
	{ 0x00009295, 0x00007026 },
	{ 0x00009296, 0x0000732a },
	{ 0x00009297, 0x000082e7 },
	{ 0x00009298, 0x00008457 },
	{ 0x00009299, 0x00008caf },
	{ 0x0000929a, 0x00004e01 },
	{ 0x0000929b, 0x00005146 },
	{ 0x0000929c, 0x000051cb },
	{ 0x0000929d, 0x0000558b },
	{ 0x0000929e, 0x00005bf5 },
	{ 0x0000929f, 0x00005e16 },
	{ 0x000092a0, 0x00005e33 },
	{ 0x000092a1, 0x00005e81 },
	{ 0x000092a2, 0x00005f14 },
	{ 0x000092a3, 0x00005f35 },
	{ 0x000092a4, 0x00005f6b },
	{ 0x000092a5, 0x00005fb4 },
	{ 0x000092a6, 0x000061f2 },
	{ 0x000092a7, 0x00006311 },
	{ 0x000092a8, 0x000066a2 },
	{ 0x000092a9, 0x0000671d },
	{ 0x000092aa, 0x00006f6e },
	{ 0x000092ab, 0x00007252 },
	{ 0x000092ac, 0x0000753a },
	{ 0x000092ad, 0x0000773a },
	{ 0x000092ae, 0x00008074 },
	{ 0x000092af, 0x00008139 },
	{ 0x000092b0, 0x00008178 },
	{ 0x000092b1, 0x00008776 },
	{ 0x000092b2, 0x00008abf },
	{ 0x000092b3, 0x00008adc },
	{ 0x000092b4, 0x00008d85 },
	{ 0x000092b5, 0x00008df3 },
	{ 0x000092b6, 0x0000929a },
	{ 0x000092b7, 0x00009577 },
	{ 0x000092b8, 0x00009802 },
	{ 0x000092b9, 0x00009ce5 },
	{ 0x000092ba, 0x000052c5 },
	{ 0x000092bb, 0x00006357 },
	{ 0x000092bc, 0x000076f4 },
	{ 0x000092bd, 0x00006715 },
	{ 0x000092be, 0x00006c88 },
	{ 0x000092bf, 0x000073cd },
	{ 0x000092c0, 0x00008cc3 },
	{ 0x000092c1, 0x000093ae },
	{ 0x000092c2, 0x00009673 },
	{ 0x000092c3, 0x00006d25 },
	{ 0x000092c4, 0x0000589c },
	{ 0x000092c5, 0x0000690e },
	{ 0x000092c6, 0x000069cc },
	{ 0x000092c7, 0x00008ffd },
	{ 0x000092c8, 0x0000939a },
	{ 0x000092c9, 0x000075db },
	{ 0x000092ca, 0x0000901a },
	{ 0x000092cb, 0x0000585a },
	{ 0x000092cc, 0x00006802 },
	{ 0x000092cd, 0x000063b4 },
	{ 0x000092ce, 0x000069fb },
	{ 0x000092cf, 0x00004f43 },
	{ 0x000092d0, 0x00006f2c },
	{ 0x000092d1, 0x000067d8 },
	{ 0x000092d2, 0x00008fbb },
	{ 0x000092d3, 0x00008526 },
	{ 0x000092d4, 0x00007db4 },
	{ 0x000092d5, 0x00009354 },
	{ 0x000092d6, 0x0000693f },
	{ 0x000092d7, 0x00006f70 },
	{ 0x000092d8, 0x0000576a },
	{ 0x000092d9, 0x000058f7 },
	{ 0x000092da, 0x00005b2c },
	{ 0x000092db, 0x00007d2c },
	{ 0x000092dc, 0x0000722a },
	{ 0x000092dd, 0x0000540a },
	{ 0x000092de, 0x000091e3 },
	{ 0x000092df, 0x00009db4 },
	{ 0x000092e0, 0x00004ead },
	{ 0x000092e1, 0x00004f4e },
	{ 0x000092e2, 0x0000505c },
	{ 0x000092e3, 0x00005075 },
	{ 0x000092e4, 0x00005243 },
	{ 0x000092e5, 0x00008c9e },
	{ 0x000092e6, 0x00005448 },
	{ 0x000092e7, 0x00005824 },
	{ 0x000092e8, 0x00005b9a },
	{ 0x000092e9, 0x00005e1d },
	{ 0x000092ea, 0x00005e95 },
	{ 0x000092eb, 0x00005ead },
	{ 0x000092ec, 0x00005ef7 },
	{ 0x000092ed, 0x00005f1f },
	{ 0x000092ee, 0x0000608c },
	{ 0x000092ef, 0x000062b5 },
	{ 0x000092f0, 0x0000633a },
	{ 0x000092f1, 0x000063d0 },
	{ 0x000092f2, 0x000068af },
	{ 0x000092f3, 0x00006c40 },
	{ 0x000092f4, 0x00007887 },
	{ 0x000092f5, 0x0000798e },
	{ 0x000092f6, 0x00007a0b },
	{ 0x000092f7, 0x00007de0 },
	{ 0x000092f8, 0x00008247 },
	{ 0x000092f9, 0x00008a02 },
	{ 0x000092fa, 0x00008ae6 },
	{ 0x000092fb, 0x00008e44 },
	{ 0x000092fc, 0x00009013 },
	{ 0x00009340, 0x000090b8 },
	{ 0x00009341, 0x0000912d },
	{ 0x00009342, 0x000091d8 },
	{ 0x00009343, 0x00009f0e },
	{ 0x00009344, 0x00006ce5 },
	{ 0x00009345, 0x00006458 },
	{ 0x00009346, 0x000064e2 },
	{ 0x00009347, 0x00006575 },
	{ 0x00009348, 0x00006ef4 },
	{ 0x00009349, 0x00007684 },
	{ 0x0000934a, 0x00007b1b },
	{ 0x0000934b, 0x00009069 },
	{ 0x0000934c, 0x000093d1 },
	{ 0x0000934d, 0x00006eba },
	{ 0x0000934e, 0x000054f2 },
	{ 0x0000934f, 0x00005fb9 },
	{ 0x00009350, 0x000064a4 },
	{ 0x00009351, 0x00008f4d },
	{ 0x00009352, 0x00008fed },
	{ 0x00009353, 0x00009244 },
	{ 0x00009354, 0x00005178 },
	{ 0x00009355, 0x0000586b },
	{ 0x00009356, 0x00005929 },
	{ 0x00009357, 0x00005c55 },
	{ 0x00009358, 0x00005e97 },
	{ 0x00009359, 0x00006dfb },
	{ 0x0000935a, 0x00007e8f },
	{ 0x0000935b, 0x0000751c },
	{ 0x0000935c, 0x00008cbc },
	{ 0x0000935d, 0x00008ee2 },
	{ 0x0000935e, 0x0000985b },
	{ 0x0000935f, 0x000070b9 },
	{ 0x00009360, 0x00004f1d },
	{ 0x00009361, 0x00006bbf },
	{ 0x00009362, 0x00006fb1 },
	{ 0x00009363, 0x00007530 },
	{ 0x00009364, 0x000096fb },
	{ 0x00009365, 0x0000514e },
	{ 0x00009366, 0x00005410 },
	{ 0x00009367, 0x00005835 },
	{ 0x00009368, 0x00005857 },
	{ 0x00009369, 0x000059ac },
	{ 0x0000936a, 0x00005c60 },
	{ 0x0000936b, 0x00005f92 },
	{ 0x0000936c, 0x00006597 },
	{ 0x0000936d, 0x0000675c },
	{ 0x0000936e, 0x00006e21 },
	{ 0x0000936f, 0x0000767b },
	{ 0x00009370, 0x000083df },
	{ 0x00009371, 0x00008ced },
	{ 0x00009372, 0x00009014 },
	{ 0x00009373, 0x000090fd },
	{ 0x00009374, 0x0000934d },
	{ 0x00009375, 0x00007825 },
	{ 0x00009376, 0x0000783a },
	{ 0x00009377, 0x000052aa },
	{ 0x00009378, 0x00005ea6 },
	{ 0x00009379, 0x0000571f },
	{ 0x0000937a, 0x00005974 },
	{ 0x0000937b, 0x00006012 },
	{ 0x0000937c, 0x00005012 },
	{ 0x0000937d, 0x0000515a },
	{ 0x0000937e, 0x000051ac },
	{ 0x00009380, 0x000051cd },
	{ 0x00009381, 0x00005200 },
	{ 0x00009382, 0x00005510 },
	{ 0x00009383, 0x00005854 },
	{ 0x00009384, 0x00005858 },
	{ 0x00009385, 0x00005957 },
	{ 0x00009386, 0x00005b95 },
	{ 0x00009387, 0x00005cf6 },
	{ 0x00009388, 0x00005d8b },
	{ 0x00009389, 0x000060bc },
	{ 0x0000938a, 0x00006295 },
	{ 0x0000938b, 0x0000642d },
	{ 0x0000938c, 0x00006771 },
	{ 0x0000938d, 0x00006843 },
	{ 0x0000938e, 0x000068bc },
	{ 0x0000938f, 0x000068df },
	{ 0x00009390, 0x000076d7 },
	{ 0x00009391, 0x00006dd8 },
	{ 0x00009392, 0x00006e6f },
	{ 0x00009393, 0x00006d9b },
	{ 0x00009394, 0x0000706f },
	{ 0x00009395, 0x000071c8 },
	{ 0x00009396, 0x00005f53 },
	{ 0x00009397, 0x000075d8 },
	{ 0x00009398, 0x00007977 },
	{ 0x00009399, 0x00007b49 },
	{ 0x0000939a, 0x00007b54 },
	{ 0x0000939b, 0x00007b52 },
	{ 0x0000939c, 0x00007cd6 },
	{ 0x0000939d, 0x00007d71 },
	{ 0x0000939e, 0x00005230 },
	{ 0x0000939f, 0x00008463 },
	{ 0x000093a0, 0x00008569 },
	{ 0x000093a1, 0x000085e4 },
	{ 0x000093a2, 0x00008a0e },
	{ 0x000093a3, 0x00008b04 },
	{ 0x000093a4, 0x00008c46 },
	{ 0x000093a5, 0x00008e0f },
	{ 0x000093a6, 0x00009003 },
	{ 0x000093a7, 0x0000900f },
	{ 0x000093a8, 0x00009419 },
	{ 0x000093a9, 0x00009676 },
	{ 0x000093aa, 0x0000982d },
	{ 0x000093ab, 0x00009a30 },
	{ 0x000093ac, 0x000095d8 },
	{ 0x000093ad, 0x000050cd },
	{ 0x000093ae, 0x000052d5 },
	{ 0x000093af, 0x0000540c },
	{ 0x000093b0, 0x00005802 },
	{ 0x000093b1, 0x00005c0e },
	{ 0x000093b2, 0x000061a7 },
	{ 0x000093b3, 0x0000649e },
	{ 0x000093b4, 0x00006d1e },
	{ 0x000093b5, 0x000077b3 },
	{ 0x000093b6, 0x00007ae5 },
	{ 0x000093b7, 0x000080f4 },
	{ 0x000093b8, 0x00008404 },
	{ 0x000093b9, 0x00009053 },
	{ 0x000093ba, 0x00009285 },
	{ 0x000093bb, 0x00005ce0 },
	{ 0x000093bc, 0x00009d07 },
	{ 0x000093bd, 0x0000533f },
	{ 0x000093be, 0x00005f97 },
	{ 0x000093bf, 0x00005fb3 },
	{ 0x000093c0, 0x00006d9c },
	{ 0x000093c1, 0x00007279 },
	{ 0x000093c2, 0x00007763 },
	{ 0x000093c3, 0x000079bf },
	{ 0x000093c4, 0x00007be4 },
	{ 0x000093c5, 0x00006bd2 },
	{ 0x000093c6, 0x000072ec },
	{ 0x000093c7, 0x00008aad },
	{ 0x000093c8, 0x00006803 },
	{ 0x000093c9, 0x00006a61 },
	{ 0x000093ca, 0x000051f8 },
	{ 0x000093cb, 0x00007a81 },
	{ 0x000093cc, 0x00006934 },
	{ 0x000093cd, 0x00005c4a },
	{ 0x000093ce, 0x00009cf6 },
	{ 0x000093cf, 0x000082eb },
	{ 0x000093d0, 0x00005bc5 },
	{ 0x000093d1, 0x00009149 },
	{ 0x000093d2, 0x0000701e },
	{ 0x000093d3, 0x00005678 },
	{ 0x000093d4, 0x00005c6f },
	{ 0x000093d5, 0x000060c7 },
	{ 0x000093d6, 0x00006566 },
	{ 0x000093d7, 0x00006c8c },
	{ 0x000093d8, 0x00008c5a },
	{ 0x000093d9, 0x00009041 },
	{ 0x000093da, 0x00009813 },
	{ 0x000093db, 0x00005451 },
	{ 0x000093dc, 0x000066c7 },
	{ 0x000093dd, 0x0000920d },
	{ 0x000093de, 0x00005948 },
	{ 0x000093df, 0x000090a3 },
	{ 0x000093e0, 0x00005185 },
	{ 0x000093e1, 0x00004e4d },
	{ 0x000093e2, 0x000051ea },
	{ 0x000093e3, 0x00008599 },
	{ 0x000093e4, 0x00008b0e },
	{ 0x000093e5, 0x00007058 },
	{ 0x000093e6, 0x0000637a },
	{ 0x000093e7, 0x0000934b },
	{ 0x000093e8, 0x00006962 },
	{ 0x000093e9, 0x000099b4 },
	{ 0x000093ea, 0x00007e04 },
	{ 0x000093eb, 0x00007577 },
	{ 0x000093ec, 0x00005357 },
	{ 0x000093ed, 0x00006960 },
	{ 0x000093ee, 0x00008edf },
	{ 0x000093ef, 0x000096e3 },
	{ 0x000093f0, 0x00006c5d },
	{ 0x000093f1, 0x00004e8c },
	{ 0x000093f2, 0x00005c3c },
	{ 0x000093f3, 0x00005f10 },
	{ 0x000093f4, 0x00008fe9 },
	{ 0x000093f5, 0x00005302 },
	{ 0x000093f6, 0x00008cd1 },
	{ 0x000093f7, 0x00008089 },
	{ 0x000093f8, 0x00008679 },
	{ 0x000093f9, 0x00005eff },
	{ 0x000093fa, 0x000065e5 },
	{ 0x000093fb, 0x00004e73 },
	{ 0x000093fc, 0x00005165 },
	{ 0x00009440, 0x00005982 },
	{ 0x00009441, 0x00005c3f },
	{ 0x00009442, 0x000097ee },
	{ 0x00009443, 0x00004efb },
	{ 0x00009444, 0x0000598a },
	{ 0x00009445, 0x00005fcd },
	{ 0x00009446, 0x00008a8d },
	{ 0x00009447, 0x00006fe1 },
	{ 0x00009448, 0x000079b0 },
	{ 0x00009449, 0x00007962 },
	{ 0x0000944a, 0x00005be7 },
	{ 0x0000944b, 0x00008471 },
	{ 0x0000944c, 0x0000732b },
	{ 0x0000944d, 0x000071b1 },
	{ 0x0000944e, 0x00005e74 },
	{ 0x0000944f, 0x00005ff5 },
	{ 0x00009450, 0x0000637b },
	{ 0x00009451, 0x0000649a },
	{ 0x00009452, 0x000071c3 },
	{ 0x00009453, 0x00007c98 },
	{ 0x00009454, 0x00004e43 },
	{ 0x00009455, 0x00005efc },
	{ 0x00009456, 0x00004e4b },
	{ 0x00009457, 0x000057dc },
	{ 0x00009458, 0x000056a2 },
	{ 0x00009459, 0x000060a9 },
	{ 0x0000945a, 0x00006fc3 },
	{ 0x0000945b, 0x00007d0d },
	{ 0x0000945c, 0x000080fd },
	{ 0x0000945d, 0x00008133 },
	{ 0x0000945e, 0x000081bf },
	{ 0x0000945f, 0x00008fb2 },
	{ 0x00009460, 0x00008997 },
	{ 0x00009461, 0x000086a4 },
	{ 0x00009462, 0x00005df4 },
	{ 0x00009463, 0x0000628a },
	{ 0x00009464, 0x000064ad },
	{ 0x00009465, 0x00008987 },
	{ 0x00009466, 0x00006777 },
	{ 0x00009467, 0x00006ce2 },
	{ 0x00009468, 0x00006d3e },
	{ 0x00009469, 0x00007436 },
	{ 0x0000946a, 0x00007834 },
	{ 0x0000946b, 0x00005a46 },
	{ 0x0000946c, 0x00007f75 },
	{ 0x0000946d, 0x000082ad },
	{ 0x0000946e, 0x000099ac },
	{ 0x0000946f, 0x00004ff3 },
	{ 0x00009470, 0x00005ec3 },
	{ 0x00009471, 0x000062dd },
	{ 0x00009472, 0x00006392 },
	{ 0x00009473, 0x00006557 },
	{ 0x00009474, 0x0000676f },
	{ 0x00009475, 0x000076c3 },
	{ 0x00009476, 0x0000724c },
	{ 0x00009477, 0x000080cc },
	{ 0x00009478, 0x000080ba },
	{ 0x00009479, 0x00008f29 },
	{ 0x0000947a, 0x0000914d },
	{ 0x0000947b, 0x0000500d },
	{ 0x0000947c, 0x000057f9 },
	{ 0x0000947d, 0x00005a92 },
	{ 0x0000947e, 0x00006885 },
	{ 0x00009480, 0x00006973 },
	{ 0x00009481, 0x00007164 },
	{ 0x00009482, 0x000072fd },
	{ 0x00009483, 0x00008cb7 },
	{ 0x00009484, 0x000058f2 },
	{ 0x00009485, 0x00008ce0 },
	{ 0x00009486, 0x0000966a },
	{ 0x00009487, 0x00009019 },
	{ 0x00009488, 0x0000877f },
	{ 0x00009489, 0x000079e4 },
	{ 0x0000948a, 0x000077e7 },
	{ 0x0000948b, 0x00008429 },
	{ 0x0000948c, 0x00004f2f },
	{ 0x0000948d, 0x00005265 },
	{ 0x0000948e, 0x0000535a },
	{ 0x0000948f, 0x000062cd },
	{ 0x00009490, 0x000067cf },
	{ 0x00009491, 0x00006cca },
	{ 0x00009492, 0x0000767d },
	{ 0x00009493, 0x00007b94 },
	{ 0x00009494, 0x00007c95 },
	{ 0x00009495, 0x00008236 },
	{ 0x00009496, 0x00008584 },
	{ 0x00009497, 0x00008feb },
	{ 0x00009498, 0x000066dd },
	{ 0x00009499, 0x00006f20 },
	{ 0x0000949a, 0x00007206 },
	{ 0x0000949b, 0x00007e1b },
	{ 0x0000949c, 0x000083ab },
	{ 0x0000949d, 0x000099c1 },
	{ 0x0000949e, 0x00009ea6 },
	{ 0x0000949f, 0x000051fd },
	{ 0x000094a0, 0x00007bb1 },
	{ 0x000094a1, 0x00007872 },
	{ 0x000094a2, 0x00007bb8 },
	{ 0x000094a3, 0x00008087 },
	{ 0x000094a4, 0x00007b48 },
	{ 0x000094a5, 0x00006ae8 },
	{ 0x000094a6, 0x00005e61 },
	{ 0x000094a7, 0x0000808c },
	{ 0x000094a8, 0x00007551 },
	{ 0x000094a9, 0x00007560 },
	{ 0x000094aa, 0x0000516b },
	{ 0x000094ab, 0x00009262 },
	{ 0x000094ac, 0x00006e8c },
	{ 0x000094ad, 0x0000767a },
	{ 0x000094ae, 0x00009197 },
	{ 0x000094af, 0x00009aea },
	{ 0x000094b0, 0x00004f10 },
	{ 0x000094b1, 0x00007f70 },
	{ 0x000094b2, 0x0000629c },
	{ 0x000094b3, 0x00007b4f },
	{ 0x000094b4, 0x000095a5 },
	{ 0x000094b5, 0x00009ce9 },
	{ 0x000094b6, 0x0000567a },
	{ 0x000094b7, 0x00005859 },
	{ 0x000094b8, 0x000086e4 },
	{ 0x000094b9, 0x000096bc },
	{ 0x000094ba, 0x00004f34 },
	{ 0x000094bb, 0x00005224 },
	{ 0x000094bc, 0x0000534a },
	{ 0x000094bd, 0x000053cd },
	{ 0x000094be, 0x000053db },
	{ 0x000094bf, 0x00005e06 },
	{ 0x000094c0, 0x0000642c },
	{ 0x000094c1, 0x00006591 },
	{ 0x000094c2, 0x0000677f },
	{ 0x000094c3, 0x00006c3e },
	{ 0x000094c4, 0x00006c4e },
	{ 0x000094c5, 0x00007248 },
	{ 0x000094c6, 0x000072af },
	{ 0x000094c7, 0x000073ed },
	{ 0x000094c8, 0x00007554 },
	{ 0x000094c9, 0x00007e41 },
	{ 0x000094ca, 0x0000822c },
	{ 0x000094cb, 0x000085e9 },
	{ 0x000094cc, 0x00008ca9 },
	{ 0x000094cd, 0x00007bc4 },
	{ 0x000094ce, 0x000091c6 },
	{ 0x000094cf, 0x00007169 },
	{ 0x000094d0, 0x00009812 },
	{ 0x000094d1, 0x000098ef },
	{ 0x000094d2, 0x0000633d },
	{ 0x000094d3, 0x00006669 },
	{ 0x000094d4, 0x0000756a },
	{ 0x000094d5, 0x000076e4 },
	{ 0x000094d6, 0x000078d0 },
	{ 0x000094d7, 0x00008543 },
	{ 0x000094d8, 0x000086ee },
	{ 0x000094d9, 0x0000532a },
	{ 0x000094da, 0x00005351 },
	{ 0x000094db, 0x00005426 },
	{ 0x000094dc, 0x00005983 },
	{ 0x000094dd, 0x00005e87 },
	{ 0x000094de, 0x00005f7c },
	{ 0x000094df, 0x000060b2 },
	{ 0x000094e0, 0x00006249 },
	{ 0x000094e1, 0x00006279 },
	{ 0x000094e2, 0x000062ab },
	{ 0x000094e3, 0x00006590 },
	{ 0x000094e4, 0x00006bd4 },
	{ 0x000094e5, 0x00006ccc },
	{ 0x000094e6, 0x000075b2 },
	{ 0x000094e7, 0x000076ae },
	{ 0x000094e8, 0x00007891 },
	{ 0x000094e9, 0x000079d8 },
	{ 0x000094ea, 0x00007dcb },
	{ 0x000094eb, 0x00007f77 },
	{ 0x000094ec, 0x000080a5 },
	{ 0x000094ed, 0x000088ab },
	{ 0x000094ee, 0x00008ab9 },
	{ 0x000094ef, 0x00008cbb },
	{ 0x000094f0, 0x0000907f },
	{ 0x000094f1, 0x0000975e },
	{ 0x000094f2, 0x000098db },
	{ 0x000094f3, 0x00006a0b },
	{ 0x000094f4, 0x00007c38 },
	{ 0x000094f5, 0x00005099 },
	{ 0x000094f6, 0x00005c3e },
	{ 0x000094f7, 0x00005fae },
	{ 0x000094f8, 0x00006787 },
	{ 0x000094f9, 0x00006bd8 },
	{ 0x000094fa, 0x00007435 },
	{ 0x000094fb, 0x00007709 },
	{ 0x000094fc, 0x00007f8e },
	{ 0x00009540, 0x00009f3b },
	{ 0x00009541, 0x000067ca },
	{ 0x00009542, 0x00007a17 },
	{ 0x00009543, 0x00005339 },
	{ 0x00009544, 0x0000758b },
	{ 0x00009545, 0x00009aed },
	{ 0x00009546, 0x00005f66 },
	{ 0x00009547, 0x0000819d },
	{ 0x00009548, 0x000083f1 },
	{ 0x00009549, 0x00008098 },
	{ 0x0000954a, 0x00005f3c },
	{ 0x0000954b, 0x00005fc5 },
	{ 0x0000954c, 0x00007562 },
	{ 0x0000954d, 0x00007b46 },
	{ 0x0000954e, 0x0000903c },
	{ 0x0000954f, 0x00006867 },
	{ 0x00009550, 0x000059eb },
	{ 0x00009551, 0x00005a9b },
	{ 0x00009552, 0x00007d10 },
	{ 0x00009553, 0x0000767e },
	{ 0x00009554, 0x00008b2c },
	{ 0x00009555, 0x00004ff5 },
	{ 0x00009556, 0x00005f6a },
	{ 0x00009557, 0x00006a19 },
	{ 0x00009558, 0x00006c37 },
	{ 0x00009559, 0x00006f02 },
	{ 0x0000955a, 0x000074e2 },
	{ 0x0000955b, 0x00007968 },
	{ 0x0000955c, 0x00008868 },
	{ 0x0000955d, 0x00008a55 },
	{ 0x0000955e, 0x00008c79 },
	{ 0x0000955f, 0x00005edf },
	{ 0x00009560, 0x000063cf },
	{ 0x00009561, 0x000075c5 },
	{ 0x00009562, 0x000079d2 },
	{ 0x00009563, 0x000082d7 },
	{ 0x00009564, 0x00009328 },
	{ 0x00009565, 0x000092f2 },
	{ 0x00009566, 0x0000849c },
	{ 0x00009567, 0x000086ed },
	{ 0x00009568, 0x00009c2d },
	{ 0x00009569, 0x000054c1 },
	{ 0x0000956a, 0x00005f6c },
	{ 0x0000956b, 0x0000658c },
	{ 0x0000956c, 0x00006d5c },
	{ 0x0000956d, 0x00007015 },
	{ 0x0000956e, 0x00008ca7 },
	{ 0x0000956f, 0x00008cd3 },
	{ 0x00009570, 0x0000983b },
	{ 0x00009571, 0x0000654f },
	{ 0x00009572, 0x000074f6 },
	{ 0x00009573, 0x00004e0d },
	{ 0x00009574, 0x00004ed8 },
	{ 0x00009575, 0x000057e0 },
	{ 0x00009576, 0x0000592b },
	{ 0x00009577, 0x00005a66 },
	{ 0x00009578, 0x00005bcc },
	{ 0x00009579, 0x000051a8 },
	{ 0x0000957a, 0x00005e03 },
	{ 0x0000957b, 0x00005e9c },
	{ 0x0000957c, 0x00006016 },
	{ 0x0000957d, 0x00006276 },
	{ 0x0000957e, 0x00006577 },
	{ 0x00009580, 0x000065a7 },
	{ 0x00009581, 0x0000666e },
	{ 0x00009582, 0x00006d6e },
	{ 0x00009583, 0x00007236 },
	{ 0x00009584, 0x00007b26 },
	{ 0x00009585, 0x00008150 },
	{ 0x00009586, 0x0000819a },
	{ 0x00009587, 0x00008299 },
	{ 0x00009588, 0x00008b5c },
	{ 0x00009589, 0x00008ca0 },
	{ 0x0000958a, 0x00008ce6 },
	{ 0x0000958b, 0x00008d74 },
	{ 0x0000958c, 0x0000961c },
	{ 0x0000958d, 0x00009644 },
	{ 0x0000958e, 0x00004fae },
	{ 0x0000958f, 0x000064ab },
	{ 0x00009590, 0x00006b66 },
	{ 0x00009591, 0x0000821e },
	{ 0x00009592, 0x00008461 },
	{ 0x00009593, 0x0000856a },
	{ 0x00009594, 0x000090e8 },
	{ 0x00009595, 0x00005c01 },
	{ 0x00009596, 0x00006953 },
	{ 0x00009597, 0x000098a8 },
	{ 0x00009598, 0x0000847a },
	{ 0x00009599, 0x00008557 },
	{ 0x0000959a, 0x00004f0f },
	{ 0x0000959b, 0x0000526f },
	{ 0x0000959c, 0x00005fa9 },
	{ 0x0000959d, 0x00005e45 },
	{ 0x0000959e, 0x0000670d },
	{ 0x0000959f, 0x0000798f },
	{ 0x000095a0, 0x00008179 },
	{ 0x000095a1, 0x00008907 },
	{ 0x000095a2, 0x00008986 },
	{ 0x000095a3, 0x00006df5 },
	{ 0x000095a4, 0x00005f17 },
	{ 0x000095a5, 0x00006255 },
	{ 0x000095a6, 0x00006cb8 },
	{ 0x000095a7, 0x00004ecf },
	{ 0x000095a8, 0x00007269 },
	{ 0x000095a9, 0x00009b92 },
	{ 0x000095aa, 0x00005206 },
	{ 0x000095ab, 0x0000543b },
	{ 0x000095ac, 0x00005674 },
	{ 0x000095ad, 0x000058b3 },
	{ 0x000095ae, 0x000061a4 },
	{ 0x000095af, 0x0000626e },
	{ 0x000095b0, 0x0000711a },
	{ 0x000095b1, 0x0000596e },
	{ 0x000095b2, 0x00007c89 },
	{ 0x000095b3, 0x00007cde },
	{ 0x000095b4, 0x00007d1b },
	{ 0x000095b5, 0x000096f0 },
	{ 0x000095b6, 0x00006587 },
	{ 0x000095b7, 0x0000805e },
	{ 0x000095b8, 0x00004e19 },
	{ 0x000095b9, 0x00004f75 },
	{ 0x000095ba, 0x00005175 },
	{ 0x000095bb, 0x00005840 },
	{ 0x000095bc, 0x00005e63 },
	{ 0x000095bd, 0x00005e73 },
	{ 0x000095be, 0x00005f0a },
	{ 0x000095bf, 0x000067c4 },
	{ 0x000095c0, 0x00004e26 },
	{ 0x000095c1, 0x0000853d },
	{ 0x000095c2, 0x00009589 },
	{ 0x000095c3, 0x0000965b },
	{ 0x000095c4, 0x00007c73 },
	{ 0x000095c5, 0x00009801 },
	{ 0x000095c6, 0x000050fb },
	{ 0x000095c7, 0x000058c1 },
	{ 0x000095c8, 0x00007656 },
	{ 0x000095c9, 0x000078a7 },
	{ 0x000095ca, 0x00005225 },
	{ 0x000095cb, 0x000077a5 },
	{ 0x000095cc, 0x00008511 },
	{ 0x000095cd, 0x00007b86 },
	{ 0x000095ce, 0x0000504f },
	{ 0x000095cf, 0x00005909 },
	{ 0x000095d0, 0x00007247 },
	{ 0x000095d1, 0x00007bc7 },
	{ 0x000095d2, 0x00007de8 },
	{ 0x000095d3, 0x00008fba },
	{ 0x000095d4, 0x00008fd4 },
	{ 0x000095d5, 0x0000904d },
	{ 0x000095d6, 0x00004fbf },
	{ 0x000095d7, 0x000052c9 },
	{ 0x000095d8, 0x00005a29 },
	{ 0x000095d9, 0x00005f01 },
	{ 0x000095da, 0x000097ad },
	{ 0x000095db, 0x00004fdd },
	{ 0x000095dc, 0x00008217 },
	{ 0x000095dd, 0x000092ea },
	{ 0x000095de, 0x00005703 },
	{ 0x000095df, 0x00006355 },
	{ 0x000095e0, 0x00006b69 },
	{ 0x000095e1, 0x0000752b },
	{ 0x000095e2, 0x000088dc },
	{ 0x000095e3, 0x00008f14 },
	{ 0x000095e4, 0x00007a42 },
	{ 0x000095e5, 0x000052df },
	{ 0x000095e6, 0x00005893 },
	{ 0x000095e7, 0x00006155 },
	{ 0x000095e8, 0x0000620a },
	{ 0x000095e9, 0x000066ae },
	{ 0x000095ea, 0x00006bcd },
	{ 0x000095eb, 0x00007c3f },
	{ 0x000095ec, 0x000083e9 },
	{ 0x000095ed, 0x00005023 },
	{ 0x000095ee, 0x00004ff8 },
	{ 0x000095ef, 0x00005305 },
	{ 0x000095f0, 0x00005446 },
	{ 0x000095f1, 0x00005831 },
	{ 0x000095f2, 0x00005949 },
	{ 0x000095f3, 0x00005b9d },
	{ 0x000095f4, 0x00005cf0 },
	{ 0x000095f5, 0x00005cef },
	{ 0x000095f6, 0x00005d29 },
	{ 0x000095f7, 0x00005e96 },
	{ 0x000095f8, 0x000062b1 },
	{ 0x000095f9, 0x00006367 },
	{ 0x000095fa, 0x0000653e },
	{ 0x000095fb, 0x000065b9 },
	{ 0x000095fc, 0x0000670b },
	{ 0x00009640, 0x00006cd5 },
	{ 0x00009641, 0x00006ce1 },
	{ 0x00009642, 0x000070f9 },
	{ 0x00009643, 0x00007832 },
	{ 0x00009644, 0x00007e2b },
	{ 0x00009645, 0x000080de },
	{ 0x00009646, 0x000082b3 },
	{ 0x00009647, 0x0000840c },
	{ 0x00009648, 0x000084ec },
	{ 0x00009649, 0x00008702 },
	{ 0x0000964a, 0x00008912 },
	{ 0x0000964b, 0x00008a2a },
	{ 0x0000964c, 0x00008c4a },
	{ 0x0000964d, 0x000090a6 },
	{ 0x0000964e, 0x000092d2 },
	{ 0x0000964f, 0x000098fd },
	{ 0x00009650, 0x00009cf3 },
	{ 0x00009651, 0x00009d6c },
	{ 0x00009652, 0x00004e4f },
	{ 0x00009653, 0x00004ea1 },
	{ 0x00009654, 0x0000508d },
	{ 0x00009655, 0x00005256 },
	{ 0x00009656, 0x0000574a },
	{ 0x00009657, 0x000059a8 },
	{ 0x00009658, 0x00005e3d },
	{ 0x00009659, 0x00005fd8 },
	{ 0x0000965a, 0x00005fd9 },
	{ 0x0000965b, 0x0000623f },
	{ 0x0000965c, 0x000066b4 },
	{ 0x0000965d, 0x0000671b },
	{ 0x0000965e, 0x000067d0 },
	{ 0x0000965f, 0x000068d2 },
	{ 0x00009660, 0x00005192 },
	{ 0x00009661, 0x00007d21 },
	{ 0x00009662, 0x000080aa },
	{ 0x00009663, 0x000081a8 },
	{ 0x00009664, 0x00008b00 },
	{ 0x00009665, 0x00008c8c },
	{ 0x00009666, 0x00008cbf },
	{ 0x00009667, 0x0000927e },
	{ 0x00009668, 0x00009632 },
	{ 0x00009669, 0x00005420 },
	{ 0x0000966a, 0x0000982c },
	{ 0x0000966b, 0x00005317 },
	{ 0x0000966c, 0x000050d5 },
	{ 0x0000966d, 0x0000535c },
	{ 0x0000966e, 0x000058a8 },
	{ 0x0000966f, 0x000064b2 },
	{ 0x00009670, 0x00006734 },
	{ 0x00009671, 0x00007267 },
	{ 0x00009672, 0x00007766 },
	{ 0x00009673, 0x00007a46 },
	{ 0x00009674, 0x000091e6 },
	{ 0x00009675, 0x000052c3 },
	{ 0x00009676, 0x00006ca1 },
	{ 0x00009677, 0x00006b86 },
	{ 0x00009678, 0x00005800 },
	{ 0x00009679, 0x00005e4c },
	{ 0x0000967a, 0x00005954 },
	{ 0x0000967b, 0x0000672c },
	{ 0x0000967c, 0x00007ffb },
	{ 0x0000967d, 0x000051e1 },
	{ 0x0000967e, 0x000076c6 },
	{ 0x00009680, 0x00006469 },
	{ 0x00009681, 0x000078e8 },
	{ 0x00009682, 0x00009b54 },
	{ 0x00009683, 0x00009ebb },
	{ 0x00009684, 0x000057cb },
	{ 0x00009685, 0x000059b9 },
	{ 0x00009686, 0x00006627 },
	{ 0x00009687, 0x0000679a },
	{ 0x00009688, 0x00006bce },
	{ 0x00009689, 0x000054e9 },
	{ 0x0000968a, 0x000069d9 },
	{ 0x0000968b, 0x00005e55 },
	{ 0x0000968c, 0x0000819c },
	{ 0x0000968d, 0x00006795 },
	{ 0x0000968e, 0x00009baa },
	{ 0x0000968f, 0x000067fe },
	{ 0x00009690, 0x00009c52 },
	{ 0x00009691, 0x0000685d },
	{ 0x00009692, 0x00004ea6 },
	{ 0x00009693, 0x00004fe3 },
	{ 0x00009694, 0x000053c8 },
	{ 0x00009695, 0x000062b9 },
	{ 0x00009696, 0x0000672b },
	{ 0x00009697, 0x00006cab },
	{ 0x00009698, 0x00008fc4 },
	{ 0x00009699, 0x00004fad },
	{ 0x0000969a, 0x00007e6d },
	{ 0x0000969b, 0x00009ebf },
	{ 0x0000969c, 0x00004e07 },
	{ 0x0000969d, 0x00006162 },
	{ 0x0000969e, 0x00006e80 },
	{ 0x0000969f, 0x00006f2b },
	{ 0x000096a0, 0x00008513 },
	{ 0x000096a1, 0x00005473 },
	{ 0x000096a2, 0x0000672a },
	{ 0x000096a3, 0x00009b45 },
	{ 0x000096a4, 0x00005df3 },
	{ 0x000096a5, 0x00007b95 },
	{ 0x000096a6, 0x00005cac },
	{ 0x000096a7, 0x00005bc6 },
	{ 0x000096a8, 0x0000871c },
	{ 0x000096a9, 0x00006e4a },
	{ 0x000096aa, 0x000084d1 },
	{ 0x000096ab, 0x00007a14 },
	{ 0x000096ac, 0x00008108 },
	{ 0x000096ad, 0x00005999 },
	{ 0x000096ae, 0x00007c8d },
	{ 0x000096af, 0x00006c11 },
	{ 0x000096b0, 0x00007720 },
	{ 0x000096b1, 0x000052d9 },
	{ 0x000096b2, 0x00005922 },
	{ 0x000096b3, 0x00007121 },
	{ 0x000096b4, 0x0000725f },
	{ 0x000096b5, 0x000077db },
	{ 0x000096b6, 0x00009727 },
	{ 0x000096b7, 0x00009d61 },
	{ 0x000096b8, 0x0000690b },
	{ 0x000096b9, 0x00005a7f },
	{ 0x000096ba, 0x00005a18 },
	{ 0x000096bb, 0x000051a5 },
	{ 0x000096bc, 0x0000540d },
	{ 0x000096bd, 0x0000547d },
	{ 0x000096be, 0x0000660e },
	{ 0x000096bf, 0x000076df },
	{ 0x000096c0, 0x00008ff7 },
	{ 0x000096c1, 0x00009298 },
	{ 0x000096c2, 0x00009cf4 },
	{ 0x000096c3, 0x000059ea },
	{ 0x000096c4, 0x0000725d },
	{ 0x000096c5, 0x00006ec5 },
	{ 0x000096c6, 0x0000514d },
	{ 0x000096c7, 0x000068c9 },
	{ 0x000096c8, 0x00007dbf },
	{ 0x000096c9, 0x00007dec },
	{ 0x000096ca, 0x00009762 },
	{ 0x000096cb, 0x00009eba },
	{ 0x000096cc, 0x00006478 },
	{ 0x000096cd, 0x00006a21 },
	{ 0x000096ce, 0x00008302 },
	{ 0x000096cf, 0x00005984 },
	{ 0x000096d0, 0x00005b5f },
	{ 0x000096d1, 0x00006bdb },
	{ 0x000096d2, 0x0000731b },
	{ 0x000096d3, 0x000076f2 },
	{ 0x000096d4, 0x00007db2 },
	{ 0x000096d5, 0x00008017 },
	{ 0x000096d6, 0x00008499 },
	{ 0x000096d7, 0x00005132 },
	{ 0x000096d8, 0x00006728 },
	{ 0x000096d9, 0x00009ed9 },
	{ 0x000096da, 0x000076ee },
	{ 0x000096db, 0x00006762 },
	{ 0x000096dc, 0x000052ff },
	{ 0x000096dd, 0x00009905 },
	{ 0x000096de, 0x00005c24 },
	{ 0x000096df, 0x0000623b },
	{ 0x000096e0, 0x00007c7e },
	{ 0x000096e1, 0x00008cb0 },
	{ 0x000096e2, 0x0000554f },
	{ 0x000096e3, 0x000060b6 },
	{ 0x000096e4, 0x00007d0b },
	{ 0x000096e5, 0x00009580 },
	{ 0x000096e6, 0x00005301 },
	{ 0x000096e7, 0x00004e5f },
	{ 0x000096e8, 0x000051b6 },
	{ 0x000096e9, 0x0000591c },
	{ 0x000096ea, 0x0000723a },
	{ 0x000096eb, 0x00008036 },
	{ 0x000096ec, 0x000091ce },
	{ 0x000096ed, 0x00005f25 },
	{ 0x000096ee, 0x000077e2 },
	{ 0x000096ef, 0x00005384 },
	{ 0x000096f0, 0x00005f79 },
	{ 0x000096f1, 0x00007d04 },
	{ 0x000096f2, 0x000085ac },
	{ 0x000096f3, 0x00008a33 },
	{ 0x000096f4, 0x00008e8d },
	{ 0x000096f5, 0x00009756 },
	{ 0x000096f6, 0x000067f3 },
	{ 0x000096f7, 0x000085ae },
	{ 0x000096f8, 0x00009453 },
	{ 0x000096f9, 0x00006109 },
	{ 0x000096fa, 0x00006108 },
	{ 0x000096fb, 0x00006cb9 },
	{ 0x000096fc, 0x00007652 },
	{ 0x00009740, 0x00008aed },
	{ 0x00009741, 0x00008f38 },
	{ 0x00009742, 0x0000552f },
	{ 0x00009743, 0x00004f51 },
	{ 0x00009744, 0x0000512a },
	{ 0x00009745, 0x000052c7 },
	{ 0x00009746, 0x000053cb },
	{ 0x00009747, 0x00005ba5 },
	{ 0x00009748, 0x00005e7d },
	{ 0x00009749, 0x000060a0 },
	{ 0x0000974a, 0x00006182 },
	{ 0x0000974b, 0x000063d6 },
	{ 0x0000974c, 0x00006709 },
	{ 0x0000974d, 0x000067da },
	{ 0x0000974e, 0x00006e67 },
	{ 0x0000974f, 0x00006d8c },
	{ 0x00009750, 0x00007336 },
	{ 0x00009751, 0x00007337 },
	{ 0x00009752, 0x00007531 },
	{ 0x00009753, 0x00007950 },
	{ 0x00009754, 0x000088d5 },
	{ 0x00009755, 0x00008a98 },
	{ 0x00009756, 0x0000904a },
	{ 0x00009757, 0x00009091 },
	{ 0x00009758, 0x000090f5 },
	{ 0x00009759, 0x000096c4 },
	{ 0x0000975a, 0x0000878d },
	{ 0x0000975b, 0x00005915 },
	{ 0x0000975c, 0x00004e88 },
	{ 0x0000975d, 0x00004f59 },
	{ 0x0000975e, 0x00004e0e },
	{ 0x0000975f, 0x00008a89 },
	{ 0x00009760, 0x00008f3f },
	{ 0x00009761, 0x00009810 },
	{ 0x00009762, 0x000050ad },
	{ 0x00009763, 0x00005e7c },
	{ 0x00009764, 0x00005996 },
	{ 0x00009765, 0x00005bb9 },
	{ 0x00009766, 0x00005eb8 },
	{ 0x00009767, 0x000063da },
	{ 0x00009768, 0x000063fa },
	{ 0x00009769, 0x000064c1 },
	{ 0x0000976a, 0x000066dc },
	{ 0x0000976b, 0x0000694a },
	{ 0x0000976c, 0x000069d8 },
	{ 0x0000976d, 0x00006d0b },
	{ 0x0000976e, 0x00006eb6 },
	{ 0x0000976f, 0x00007194 },
	{ 0x00009770, 0x00007528 },
	{ 0x00009771, 0x00007aaf },
	{ 0x00009772, 0x00007f8a },
	{ 0x00009773, 0x00008000 },
	{ 0x00009774, 0x00008449 },
	{ 0x00009775, 0x000084c9 },
	{ 0x00009776, 0x00008981 },
	{ 0x00009777, 0x00008b21 },
	{ 0x00009778, 0x00008e0a },
	{ 0x00009779, 0x00009065 },
	{ 0x0000977a, 0x0000967d },
	{ 0x0000977b, 0x0000990a },
	{ 0x0000977c, 0x0000617e },
	{ 0x0000977d, 0x00006291 },
	{ 0x0000977e, 0x00006b32 },
	{ 0x00009780, 0x00006c83 },
	{ 0x00009781, 0x00006d74 },
	{ 0x00009782, 0x00007fcc },
	{ 0x00009783, 0x00007ffc },
	{ 0x00009784, 0x00006dc0 },
	{ 0x00009785, 0x00007f85 },
	{ 0x00009786, 0x000087ba },
	{ 0x00009787, 0x000088f8 },
	{ 0x00009788, 0x00006765 },
	{ 0x00009789, 0x000083b1 },
	{ 0x0000978a, 0x0000983c },
	{ 0x0000978b, 0x000096f7 },
	{ 0x0000978c, 0x00006d1b },
	{ 0x0000978d, 0x00007d61 },
	{ 0x0000978e, 0x0000843d },
	{ 0x0000978f, 0x0000916a },
	{ 0x00009790, 0x00004e71 },
	{ 0x00009791, 0x00005375 },
	{ 0x00009792, 0x00005d50 },
	{ 0x00009793, 0x00006b04 },
	{ 0x00009794, 0x00006feb },
	{ 0x00009795, 0x000085cd },
	{ 0x00009796, 0x0000862d },
	{ 0x00009797, 0x000089a7 },
	{ 0x00009798, 0x00005229 },
	{ 0x00009799, 0x0000540f },
	{ 0x0000979a, 0x00005c65 },
	{ 0x0000979b, 0x0000674e },
	{ 0x0000979c, 0x000068a8 },
	{ 0x0000979d, 0x00007406 },
	{ 0x0000979e, 0x00007483 },
	{ 0x0000979f, 0x000075e2 },
	{ 0x000097a0, 0x000088cf },
	{ 0x000097a1, 0x000088e1 },
	{ 0x000097a2, 0x000091cc },
	{ 0x000097a3, 0x000096e2 },
	{ 0x000097a4, 0x00009678 },
	{ 0x000097a5, 0x00005f8b },
	{ 0x000097a6, 0x00007387 },
	{ 0x000097a7, 0x00007acb },
	{ 0x000097a8, 0x0000844e },
	{ 0x000097a9, 0x000063a0 },
	{ 0x000097aa, 0x00007565 },
	{ 0x000097ab, 0x00005289 },
	{ 0x000097ac, 0x00006d41 },
	{ 0x000097ad, 0x00006e9c },
	{ 0x000097ae, 0x00007409 },
	{ 0x000097af, 0x00007559 },
	{ 0x000097b0, 0x0000786b },
	{ 0x000097b1, 0x00007c92 },
	{ 0x000097b2, 0x00009686 },
	{ 0x000097b3, 0x00007adc },
	{ 0x000097b4, 0x00009f8d },
	{ 0x000097b5, 0x00004fb6 },
	{ 0x000097b6, 0x0000616e },
	{ 0x000097b7, 0x000065c5 },
	{ 0x000097b8, 0x0000865c },
	{ 0x000097b9, 0x00004e86 },
	{ 0x000097ba, 0x00004eae },
	{ 0x000097bb, 0x000050da },
	{ 0x000097bc, 0x00004e21 },
	{ 0x000097bd, 0x000051cc },
	{ 0x000097be, 0x00005bee },
	{ 0x000097bf, 0x00006599 },
	{ 0x000097c0, 0x00006881 },
	{ 0x000097c1, 0x00006dbc },
	{ 0x000097c2, 0x0000731f },
	{ 0x000097c3, 0x00007642 },
	{ 0x000097c4, 0x000077ad },
	{ 0x000097c5, 0x00007a1c },
	{ 0x000097c6, 0x00007ce7 },
	{ 0x000097c7, 0x0000826f },
	{ 0x000097c8, 0x00008ad2 },
	{ 0x000097c9, 0x0000907c },
	{ 0x000097ca, 0x000091cf },
	{ 0x000097cb, 0x00009675 },
	{ 0x000097cc, 0x00009818 },
	{ 0x000097cd, 0x0000529b },
	{ 0x000097ce, 0x00007dd1 },
	{ 0x000097cf, 0x0000502b },
	{ 0x000097d0, 0x00005398 },
	{ 0x000097d1, 0x00006797 },
	{ 0x000097d2, 0x00006dcb },
	{ 0x000097d3, 0x000071d0 },
	{ 0x000097d4, 0x00007433 },
	{ 0x000097d5, 0x000081e8 },
	{ 0x000097d6, 0x00008f2a },
	{ 0x000097d7, 0x000096a3 },
	{ 0x000097d8, 0x00009c57 },
	{ 0x000097d9, 0x00009e9f },
	{ 0x000097da, 0x00007460 },
	{ 0x000097db, 0x00005841 },
	{ 0x000097dc, 0x00006d99 },
	{ 0x000097dd, 0x00007d2f },
	{ 0x000097de, 0x0000985e },
	{ 0x000097df, 0x00004ee4 },
	{ 0x000097e0, 0x00004f36 },
	{ 0x000097e1, 0x00004f8b },
	{ 0x000097e2, 0x000051b7 },
	{ 0x000097e3, 0x000052b1 },
	{ 0x000097e4, 0x00005dba },
	{ 0x000097e5, 0x0000601c },
	{ 0x000097e6, 0x000073b2 },
	{ 0x000097e7, 0x0000793c },
	{ 0x000097e8, 0x000082d3 },
	{ 0x000097e9, 0x00009234 },
	{ 0x000097ea, 0x000096b7 },
	{ 0x000097eb, 0x000096f6 },
	{ 0x000097ec, 0x0000970a },
	{ 0x000097ed, 0x00009e97 },
	{ 0x000097ee, 0x00009f62 },
	{ 0x000097ef, 0x000066a6 },
	{ 0x000097f0, 0x00006b74 },
	{ 0x000097f1, 0x00005217 },
	{ 0x000097f2, 0x000052a3 },
	{ 0x000097f3, 0x000070c8 },
	{ 0x000097f4, 0x000088c2 },
	{ 0x000097f5, 0x00005ec9 },
	{ 0x000097f6, 0x0000604b },
	{ 0x000097f7, 0x00006190 },
	{ 0x000097f8, 0x00006f23 },
	{ 0x000097f9, 0x00007149 },
	{ 0x000097fa, 0x00007c3e },
	{ 0x000097fb, 0x00007df4 },
	{ 0x000097fc, 0x0000806f },
	{ 0x00009840, 0x000084ee },
	{ 0x00009841, 0x00009023 },
	{ 0x00009842, 0x0000932c },
	{ 0x00009843, 0x00005442 },
	{ 0x00009844, 0x00009b6f },
	{ 0x00009845, 0x00006ad3 },
	{ 0x00009846, 0x00007089 },
	{ 0x00009847, 0x00008cc2 },
	{ 0x00009848, 0x00008def },
	{ 0x00009849, 0x00009732 },
	{ 0x0000984a, 0x000052b4 },
	{ 0x0000984b, 0x00005a41 },
	{ 0x0000984c, 0x00005eca },
	{ 0x0000984d, 0x00005f04 },
	{ 0x0000984e, 0x00006717 },
	{ 0x0000984f, 0x0000697c },
	{ 0x00009850, 0x00006994 },
	{ 0x00009851, 0x00006d6a },
	{ 0x00009852, 0x00006f0f },
	{ 0x00009853, 0x00007262 },
	{ 0x00009854, 0x000072fc },
	{ 0x00009855, 0x00007bed },
	{ 0x00009856, 0x00008001 },
	{ 0x00009857, 0x0000807e },
	{ 0x00009858, 0x0000874b },
	{ 0x00009859, 0x000090ce },
	{ 0x0000985a, 0x0000516d },
	{ 0x0000985b, 0x00009e93 },
	{ 0x0000985c, 0x00007984 },
	{ 0x0000985d, 0x0000808b },
	{ 0x0000985e, 0x00009332 },
	{ 0x0000985f, 0x00008ad6 },
	{ 0x00009860, 0x0000502d },
	{ 0x00009861, 0x0000548c },
	{ 0x00009862, 0x00008a71 },
	{ 0x00009863, 0x00006b6a },
	{ 0x00009864, 0x00008cc4 },
	{ 0x00009865, 0x00008107 },
	{ 0x00009866, 0x000060d1 },
	{ 0x00009867, 0x000067a0 },
	{ 0x00009868, 0x00009df2 },
	{ 0x00009869, 0x00004e99 },
	{ 0x0000986a, 0x00004e98 },
	{ 0x0000986b, 0x00009c10 },
	{ 0x0000986c, 0x00008a6b },
	{ 0x0000986d, 0x000085c1 },
	{ 0x0000986e, 0x00008568 },
	{ 0x0000986f, 0x00006900 },
	{ 0x00009870, 0x00006e7e },
	{ 0x00009871, 0x00007897 },
	{ 0x00009872, 0x00008155 },
	{ 0x0000989f, 0x00005f0c },
	{ 0x000098a0, 0x00004e10 },
	{ 0x000098a1, 0x00004e15 },
	{ 0x000098a2, 0x00004e2a },
	{ 0x000098a3, 0x00004e31 },
	{ 0x000098a4, 0x00004e36 },
	{ 0x000098a5, 0x00004e3c },
	{ 0x000098a6, 0x00004e3f },
	{ 0x000098a7, 0x00004e42 },
	{ 0x000098a8, 0x00004e56 },
	{ 0x000098a9, 0x00004e58 },
	{ 0x000098aa, 0x00004e82 },
	{ 0x000098ab, 0x00004e85 },
	{ 0x000098ac, 0x00008c6b },
	{ 0x000098ad, 0x00004e8a },
	{ 0x000098ae, 0x00008212 },
	{ 0x000098af, 0x00005f0d },
	{ 0x000098b0, 0x00004e8e },
	{ 0x000098b1, 0x00004e9e },
	{ 0x000098b2, 0x00004e9f },
	{ 0x000098b3, 0x00004ea0 },
	{ 0x000098b4, 0x00004ea2 },
	{ 0x000098b5, 0x00004eb0 },
	{ 0x000098b6, 0x00004eb3 },
	{ 0x000098b7, 0x00004eb6 },
	{ 0x000098b8, 0x00004ece },
	{ 0x000098b9, 0x00004ecd },
	{ 0x000098ba, 0x00004ec4 },
	{ 0x000098bb, 0x00004ec6 },
	{ 0x000098bc, 0x00004ec2 },
	{ 0x000098bd, 0x00004ed7 },
	{ 0x000098be, 0x00004ede },
	{ 0x000098bf, 0x00004eed },
	{ 0x000098c0, 0x00004edf },
	{ 0x000098c1, 0x00004ef7 },
	{ 0x000098c2, 0x00004f09 },
	{ 0x000098c3, 0x00004f5a },
	{ 0x000098c4, 0x00004f30 },
	{ 0x000098c5, 0x00004f5b },
	{ 0x000098c6, 0x00004f5d },
	{ 0x000098c7, 0x00004f57 },
	{ 0x000098c8, 0x00004f47 },
	{ 0x000098c9, 0x00004f76 },
	{ 0x000098ca, 0x00004f88 },
	{ 0x000098cb, 0x00004f8f },
	{ 0x000098cc, 0x00004f98 },
	{ 0x000098cd, 0x00004f7b },
	{ 0x000098ce, 0x00004f69 },
	{ 0x000098cf, 0x00004f70 },
	{ 0x000098d0, 0x00004f91 },
	{ 0x000098d1, 0x00004f6f },
	{ 0x000098d2, 0x00004f86 },
	{ 0x000098d3, 0x00004f96 },
	{ 0x000098d4, 0x00005118 },
	{ 0x000098d5, 0x00004fd4 },
	{ 0x000098d6, 0x00004fdf },
	{ 0x000098d7, 0x00004fce },
	{ 0x000098d8, 0x00004fd8 },
	{ 0x000098d9, 0x00004fdb },
	{ 0x000098da, 0x00004fd1 },
	{ 0x000098db, 0x00004fda },
	{ 0x000098dc, 0x00004fd0 },
	{ 0x000098dd, 0x00004fe4 },
	{ 0x000098de, 0x00004fe5 },
	{ 0x000098df, 0x0000501a },
	{ 0x000098e0, 0x00005028 },
	{ 0x000098e1, 0x00005014 },
	{ 0x000098e2, 0x0000502a },
	{ 0x000098e3, 0x00005025 },
	{ 0x000098e4, 0x00005005 },
	{ 0x000098e5, 0x00004f1c },
	{ 0x000098e6, 0x00004ff6 },
	{ 0x000098e7, 0x00005021 },
	{ 0x000098e8, 0x00005029 },
	{ 0x000098e9, 0x0000502c },
	{ 0x000098ea, 0x00004ffe },
	{ 0x000098eb, 0x00004fef },
	{ 0x000098ec, 0x00005011 },
	{ 0x000098ed, 0x00005006 },
	{ 0x000098ee, 0x00005043 },
	{ 0x000098ef, 0x00005047 },
	{ 0x000098f0, 0x00006703 },
	{ 0x000098f1, 0x00005055 },
	{ 0x000098f2, 0x00005050 },
	{ 0x000098f3, 0x00005048 },
	{ 0x000098f4, 0x0000505a },
	{ 0x000098f5, 0x00005056 },
	{ 0x000098f6, 0x0000506c },
	{ 0x000098f7, 0x00005078 },
	{ 0x000098f8, 0x00005080 },
	{ 0x000098f9, 0x0000509a },
	{ 0x000098fa, 0x00005085 },
	{ 0x000098fb, 0x000050b4 },
	{ 0x000098fc, 0x000050b2 },
	{ 0x00009940, 0x000050c9 },
	{ 0x00009941, 0x000050ca },
	{ 0x00009942, 0x000050b3 },
	{ 0x00009943, 0x000050c2 },
	{ 0x00009944, 0x000050d6 },
	{ 0x00009945, 0x000050de },
	{ 0x00009946, 0x000050e5 },
	{ 0x00009947, 0x000050ed },
	{ 0x00009948, 0x000050e3 },
	{ 0x00009949, 0x000050ee },
	{ 0x0000994a, 0x000050f9 },
	{ 0x0000994b, 0x000050f5 },
	{ 0x0000994c, 0x00005109 },
	{ 0x0000994d, 0x00005101 },
	{ 0x0000994e, 0x00005102 },
	{ 0x0000994f, 0x00005116 },
	{ 0x00009950, 0x00005115 },
	{ 0x00009951, 0x00005114 },
	{ 0x00009952, 0x0000511a },
	{ 0x00009953, 0x00005121 },
	{ 0x00009954, 0x0000513a },
	{ 0x00009955, 0x00005137 },
	{ 0x00009956, 0x0000513c },
	{ 0x00009957, 0x0000513b },
	{ 0x00009958, 0x0000513f },
	{ 0x00009959, 0x00005140 },
	{ 0x0000995a, 0x00005152 },
	{ 0x0000995b, 0x0000514c },
	{ 0x0000995c, 0x00005154 },
	{ 0x0000995d, 0x00005162 },
	{ 0x0000995e, 0x00007af8 },
	{ 0x0000995f, 0x00005169 },
	{ 0x00009960, 0x0000516a },
	{ 0x00009961, 0x0000516e },
	{ 0x00009962, 0x00005180 },
	{ 0x00009963, 0x00005182 },
	{ 0x00009964, 0x000056d8 },
	{ 0x00009965, 0x0000518c },
	{ 0x00009966, 0x00005189 },
	{ 0x00009967, 0x0000518f },
	{ 0x00009968, 0x00005191 },
	{ 0x00009969, 0x00005193 },
	{ 0x0000996a, 0x00005195 },
	{ 0x0000996b, 0x00005196 },
	{ 0x0000996c, 0x000051a4 },
	{ 0x0000996d, 0x000051a6 },
	{ 0x0000996e, 0x000051a2 },
	{ 0x0000996f, 0x000051a9 },
	{ 0x00009970, 0x000051aa },
	{ 0x00009971, 0x000051ab },
	{ 0x00009972, 0x000051b3 },
	{ 0x00009973, 0x000051b1 },
	{ 0x00009974, 0x000051b2 },
	{ 0x00009975, 0x000051b0 },
	{ 0x00009976, 0x000051b5 },
	{ 0x00009977, 0x000051bd },
	{ 0x00009978, 0x000051c5 },
	{ 0x00009979, 0x000051c9 },
	{ 0x0000997a, 0x000051db },
	{ 0x0000997b, 0x000051e0 },
	{ 0x0000997c, 0x00008655 },
	{ 0x0000997d, 0x000051e9 },
	{ 0x0000997e, 0x000051ed },
	{ 0x00009980, 0x000051f0 },
	{ 0x00009981, 0x000051f5 },
	{ 0x00009982, 0x000051fe },
	{ 0x00009983, 0x00005204 },
	{ 0x00009984, 0x0000520b },
	{ 0x00009985, 0x00005214 },
	{ 0x00009986, 0x0000520e },
	{ 0x00009987, 0x00005227 },
	{ 0x00009988, 0x0000522a },
	{ 0x00009989, 0x0000522e },
	{ 0x0000998a, 0x00005233 },
	{ 0x0000998b, 0x00005239 },
	{ 0x0000998c, 0x0000524f },
	{ 0x0000998d, 0x00005244 },
	{ 0x0000998e, 0x0000524b },
	{ 0x0000998f, 0x0000524c },
	{ 0x00009990, 0x0000525e },
	{ 0x00009991, 0x00005254 },
	{ 0x00009992, 0x0000526a },
	{ 0x00009993, 0x00005274 },
	{ 0x00009994, 0x00005269 },
	{ 0x00009995, 0x00005273 },
	{ 0x00009996, 0x0000527f },
	{ 0x00009997, 0x0000527d },
	{ 0x00009998, 0x0000528d },
	{ 0x00009999, 0x00005294 },
	{ 0x0000999a, 0x00005292 },
	{ 0x0000999b, 0x00005271 },
	{ 0x0000999c, 0x00005288 },
	{ 0x0000999d, 0x00005291 },
	{ 0x0000999e, 0x00008fa8 },
	{ 0x0000999f, 0x00008fa7 },
	{ 0x000099a0, 0x000052ac },
	{ 0x000099a1, 0x000052ad },
	{ 0x000099a2, 0x000052bc },
	{ 0x000099a3, 0x000052b5 },
	{ 0x000099a4, 0x000052c1 },
	{ 0x000099a5, 0x000052cd },
	{ 0x000099a6, 0x000052d7 },
	{ 0x000099a7, 0x000052de },
	{ 0x000099a8, 0x000052e3 },
	{ 0x000099a9, 0x000052e6 },
	{ 0x000099aa, 0x000098ed },
	{ 0x000099ab, 0x000052e0 },
	{ 0x000099ac, 0x000052f3 },
	{ 0x000099ad, 0x000052f5 },
	{ 0x000099ae, 0x000052f8 },
	{ 0x000099af, 0x000052f9 },
	{ 0x000099b0, 0x00005306 },
	{ 0x000099b1, 0x00005308 },
	{ 0x000099b2, 0x00007538 },
	{ 0x000099b3, 0x0000530d },
	{ 0x000099b4, 0x00005310 },
	{ 0x000099b5, 0x0000530f },
	{ 0x000099b6, 0x00005315 },
	{ 0x000099b7, 0x0000531a },
	{ 0x000099b8, 0x00005323 },
	{ 0x000099b9, 0x0000532f },
	{ 0x000099ba, 0x00005331 },
	{ 0x000099bb, 0x00005333 },
	{ 0x000099bc, 0x00005338 },
	{ 0x000099bd, 0x00005340 },
	{ 0x000099be, 0x00005346 },
	{ 0x000099bf, 0x00005345 },
	{ 0x000099c0, 0x00004e17 },
	{ 0x000099c1, 0x00005349 },
	{ 0x000099c2, 0x0000534d },
	{ 0x000099c3, 0x000051d6 },
	{ 0x000099c4, 0x0000535e },
	{ 0x000099c5, 0x00005369 },
	{ 0x000099c6, 0x0000536e },
	{ 0x000099c7, 0x00005918 },
	{ 0x000099c8, 0x0000537b },
	{ 0x000099c9, 0x00005377 },
	{ 0x000099ca, 0x00005382 },
	{ 0x000099cb, 0x00005396 },
	{ 0x000099cc, 0x000053a0 },
	{ 0x000099cd, 0x000053a6 },
	{ 0x000099ce, 0x000053a5 },
	{ 0x000099cf, 0x000053ae },
	{ 0x000099d0, 0x000053b0 },
	{ 0x000099d1, 0x000053b6 },
	{ 0x000099d2, 0x000053c3 },
	{ 0x000099d3, 0x00007c12 },
	{ 0x000099d4, 0x000096d9 },
	{ 0x000099d5, 0x000053df },
	{ 0x000099d6, 0x000066fc },
	{ 0x000099d7, 0x000071ee },
	{ 0x000099d8, 0x000053ee },
	{ 0x000099d9, 0x000053e8 },
	{ 0x000099da, 0x000053ed },
	{ 0x000099db, 0x000053fa },
	{ 0x000099dc, 0x00005401 },
	{ 0x000099dd, 0x0000543d },
	{ 0x000099de, 0x00005440 },
	{ 0x000099df, 0x0000542c },
	{ 0x000099e0, 0x0000542d },
	{ 0x000099e1, 0x0000543c },
	{ 0x000099e2, 0x0000542e },
	{ 0x000099e3, 0x00005436 },
	{ 0x000099e4, 0x00005429 },
	{ 0x000099e5, 0x0000541d },
	{ 0x000099e6, 0x0000544e },
	{ 0x000099e7, 0x0000548f },
	{ 0x000099e8, 0x00005475 },
	{ 0x000099e9, 0x0000548e },
	{ 0x000099ea, 0x0000545f },
	{ 0x000099eb, 0x00005471 },
	{ 0x000099ec, 0x00005477 },
	{ 0x000099ed, 0x00005470 },
	{ 0x000099ee, 0x00005492 },
	{ 0x000099ef, 0x0000547b },
	{ 0x000099f0, 0x00005480 },
	{ 0x000099f1, 0x00005476 },
	{ 0x000099f2, 0x00005484 },
	{ 0x000099f3, 0x00005490 },
	{ 0x000099f4, 0x00005486 },
	{ 0x000099f5, 0x000054c7 },
	{ 0x000099f6, 0x000054a2 },
	{ 0x000099f7, 0x000054b8 },
	{ 0x000099f8, 0x000054a5 },
	{ 0x000099f9, 0x000054ac },
	{ 0x000099fa, 0x000054c4 },
	{ 0x000099fb, 0x000054c8 },
	{ 0x000099fc, 0x000054a8 },
	{ 0x00009a40, 0x000054ab },
	{ 0x00009a41, 0x000054c2 },
	{ 0x00009a42, 0x000054a4 },
	{ 0x00009a43, 0x000054be },
	{ 0x00009a44, 0x000054bc },
	{ 0x00009a45, 0x000054d8 },
	{ 0x00009a46, 0x000054e5 },
	{ 0x00009a47, 0x000054e6 },
	{ 0x00009a48, 0x0000550f },
	{ 0x00009a49, 0x00005514 },
	{ 0x00009a4a, 0x000054fd },
	{ 0x00009a4b, 0x000054ee },
	{ 0x00009a4c, 0x000054ed },
	{ 0x00009a4d, 0x000054fa },
	{ 0x00009a4e, 0x000054e2 },
	{ 0x00009a4f, 0x00005539 },
	{ 0x00009a50, 0x00005540 },
	{ 0x00009a51, 0x00005563 },
	{ 0x00009a52, 0x0000554c },
	{ 0x00009a53, 0x0000552e },
	{ 0x00009a54, 0x0000555c },
	{ 0x00009a55, 0x00005545 },
	{ 0x00009a56, 0x00005556 },
	{ 0x00009a57, 0x00005557 },
	{ 0x00009a58, 0x00005538 },
	{ 0x00009a59, 0x00005533 },
	{ 0x00009a5a, 0x0000555d },
	{ 0x00009a5b, 0x00005599 },
	{ 0x00009a5c, 0x00005580 },
	{ 0x00009a5d, 0x000054af },
	{ 0x00009a5e, 0x0000558a },
	{ 0x00009a5f, 0x0000559f },
	{ 0x00009a60, 0x0000557b },
	{ 0x00009a61, 0x0000557e },
	{ 0x00009a62, 0x00005598 },
	{ 0x00009a63, 0x0000559e },
	{ 0x00009a64, 0x000055ae },
	{ 0x00009a65, 0x0000557c },
	{ 0x00009a66, 0x00005583 },
	{ 0x00009a67, 0x000055a9 },
	{ 0x00009a68, 0x00005587 },
	{ 0x00009a69, 0x000055a8 },
	{ 0x00009a6a, 0x000055da },
	{ 0x00009a6b, 0x000055c5 },
	{ 0x00009a6c, 0x000055df },
	{ 0x00009a6d, 0x000055c4 },
	{ 0x00009a6e, 0x000055dc },
	{ 0x00009a6f, 0x000055e4 },
	{ 0x00009a70, 0x000055d4 },
	{ 0x00009a71, 0x00005614 },
	{ 0x00009a72, 0x000055f7 },
	{ 0x00009a73, 0x00005616 },
	{ 0x00009a74, 0x000055fe },
	{ 0x00009a75, 0x000055fd },
	{ 0x00009a76, 0x0000561b },
	{ 0x00009a77, 0x000055f9 },
	{ 0x00009a78, 0x0000564e },
	{ 0x00009a79, 0x00005650 },
	{ 0x00009a7a, 0x000071df },
	{ 0x00009a7b, 0x00005634 },
	{ 0x00009a7c, 0x00005636 },
	{ 0x00009a7d, 0x00005632 },
	{ 0x00009a7e, 0x00005638 },
	{ 0x00009a80, 0x0000566b },
	{ 0x00009a81, 0x00005664 },
	{ 0x00009a82, 0x0000562f },
	{ 0x00009a83, 0x0000566c },
	{ 0x00009a84, 0x0000566a },
	{ 0x00009a85, 0x00005686 },
	{ 0x00009a86, 0x00005680 },
	{ 0x00009a87, 0x0000568a },
	{ 0x00009a88, 0x000056a0 },
	{ 0x00009a89, 0x00005694 },
	{ 0x00009a8a, 0x0000568f },
	{ 0x00009a8b, 0x000056a5 },
	{ 0x00009a8c, 0x000056ae },
	{ 0x00009a8d, 0x000056b6 },
	{ 0x00009a8e, 0x000056b4 },
	{ 0x00009a8f, 0x000056c2 },
	{ 0x00009a90, 0x000056bc },
	{ 0x00009a91, 0x000056c1 },
	{ 0x00009a92, 0x000056c3 },
	{ 0x00009a93, 0x000056c0 },
	{ 0x00009a94, 0x000056c8 },
	{ 0x00009a95, 0x000056ce },
	{ 0x00009a96, 0x000056d1 },
	{ 0x00009a97, 0x000056d3 },
	{ 0x00009a98, 0x000056d7 },
	{ 0x00009a99, 0x000056ee },
	{ 0x00009a9a, 0x000056f9 },
	{ 0x00009a9b, 0x00005700 },
	{ 0x00009a9c, 0x000056ff },
	{ 0x00009a9d, 0x00005704 },
	{ 0x00009a9e, 0x00005709 },
	{ 0x00009a9f, 0x00005708 },
	{ 0x00009aa0, 0x0000570b },
	{ 0x00009aa1, 0x0000570d },
	{ 0x00009aa2, 0x00005713 },
	{ 0x00009aa3, 0x00005718 },
	{ 0x00009aa4, 0x00005716 },
	{ 0x00009aa5, 0x000055c7 },
	{ 0x00009aa6, 0x0000571c },
	{ 0x00009aa7, 0x00005726 },
	{ 0x00009aa8, 0x00005737 },
	{ 0x00009aa9, 0x00005738 },
	{ 0x00009aaa, 0x0000574e },
	{ 0x00009aab, 0x0000573b },
	{ 0x00009aac, 0x00005740 },
	{ 0x00009aad, 0x0000574f },
	{ 0x00009aae, 0x00005769 },
	{ 0x00009aaf, 0x000057c0 },
	{ 0x00009ab0, 0x00005788 },
	{ 0x00009ab1, 0x00005761 },
	{ 0x00009ab2, 0x0000577f },
	{ 0x00009ab3, 0x00005789 },
	{ 0x00009ab4, 0x00005793 },
	{ 0x00009ab5, 0x000057a0 },
	{ 0x00009ab6, 0x000057b3 },
	{ 0x00009ab7, 0x000057a4 },
	{ 0x00009ab8, 0x000057aa },
	{ 0x00009ab9, 0x000057b0 },
	{ 0x00009aba, 0x000057c3 },
	{ 0x00009abb, 0x000057c6 },
	{ 0x00009abc, 0x000057d4 },
	{ 0x00009abd, 0x000057d2 },
	{ 0x00009abe, 0x000057d3 },
	{ 0x00009abf, 0x0000580a },
	{ 0x00009ac0, 0x000057d6 },
	{ 0x00009ac1, 0x000057e3 },
	{ 0x00009ac2, 0x0000580b },
	{ 0x00009ac3, 0x00005819 },
	{ 0x00009ac4, 0x0000581d },
	{ 0x00009ac5, 0x00005872 },
	{ 0x00009ac6, 0x00005821 },
	{ 0x00009ac7, 0x00005862 },
	{ 0x00009ac8, 0x0000584b },
	{ 0x00009ac9, 0x00005870 },
	{ 0x00009aca, 0x00006bc0 },
	{ 0x00009acb, 0x00005852 },
	{ 0x00009acc, 0x0000583d },
	{ 0x00009acd, 0x00005879 },
	{ 0x00009ace, 0x00005885 },
	{ 0x00009acf, 0x000058b9 },
	{ 0x00009ad0, 0x0000589f },
	{ 0x00009ad1, 0x000058ab },
	{ 0x00009ad2, 0x000058ba },
	{ 0x00009ad3, 0x000058de },
	{ 0x00009ad4, 0x000058bb },
	{ 0x00009ad5, 0x000058b8 },
	{ 0x00009ad6, 0x000058ae },
	{ 0x00009ad7, 0x000058c5 },
	{ 0x00009ad8, 0x000058d3 },
	{ 0x00009ad9, 0x000058d1 },
	{ 0x00009ada, 0x000058d7 },
	{ 0x00009adb, 0x000058d9 },
	{ 0x00009adc, 0x000058d8 },
	{ 0x00009add, 0x000058e5 },
	{ 0x00009ade, 0x000058dc },
	{ 0x00009adf, 0x000058e4 },
	{ 0x00009ae0, 0x000058df },
	{ 0x00009ae1, 0x000058ef },
	{ 0x00009ae2, 0x000058fa },
	{ 0x00009ae3, 0x000058f9 },
	{ 0x00009ae4, 0x000058fb },
	{ 0x00009ae5, 0x000058fc },
	{ 0x00009ae6, 0x000058fd },
	{ 0x00009ae7, 0x00005902 },
	{ 0x00009ae8, 0x0000590a },
	{ 0x00009ae9, 0x00005910 },
	{ 0x00009aea, 0x0000591b },
	{ 0x00009aeb, 0x000068a6 },
	{ 0x00009aec, 0x00005925 },
	{ 0x00009aed, 0x0000592c },
	{ 0x00009aee, 0x0000592d },
	{ 0x00009aef, 0x00005932 },
	{ 0x00009af0, 0x00005938 },
	{ 0x00009af1, 0x0000593e },
	{ 0x00009af2, 0x00007ad2 },
	{ 0x00009af3, 0x00005955 },
	{ 0x00009af4, 0x00005950 },
	{ 0x00009af5, 0x0000594e },
	{ 0x00009af6, 0x0000595a },
	{ 0x00009af7, 0x00005958 },
	{ 0x00009af8, 0x00005962 },
	{ 0x00009af9, 0x00005960 },
	{ 0x00009afa, 0x00005967 },
	{ 0x00009afb, 0x0000596c },
	{ 0x00009afc, 0x00005969 },
	{ 0x00009b40, 0x00005978 },
	{ 0x00009b41, 0x00005981 },
	{ 0x00009b42, 0x0000599d },
	{ 0x00009b43, 0x00004f5e },
	{ 0x00009b44, 0x00004fab },
	{ 0x00009b45, 0x000059a3 },
	{ 0x00009b46, 0x000059b2 },
	{ 0x00009b47, 0x000059c6 },
	{ 0x00009b48, 0x000059e8 },
	{ 0x00009b49, 0x000059dc },
	{ 0x00009b4a, 0x0000598d },
	{ 0x00009b4b, 0x000059d9 },
	{ 0x00009b4c, 0x000059da },
	{ 0x00009b4d, 0x00005a25 },
	{ 0x00009b4e, 0x00005a1f },
	{ 0x00009b4f, 0x00005a11 },
	{ 0x00009b50, 0x00005a1c },
	{ 0x00009b51, 0x00005a09 },
	{ 0x00009b52, 0x00005a1a },
	{ 0x00009b53, 0x00005a40 },
	{ 0x00009b54, 0x00005a6c },
	{ 0x00009b55, 0x00005a49 },
	{ 0x00009b56, 0x00005a35 },
	{ 0x00009b57, 0x00005a36 },
	{ 0x00009b58, 0x00005a62 },
	{ 0x00009b59, 0x00005a6a },
	{ 0x00009b5a, 0x00005a9a },
	{ 0x00009b5b, 0x00005abc },
	{ 0x00009b5c, 0x00005abe },
	{ 0x00009b5d, 0x00005acb },
	{ 0x00009b5e, 0x00005ac2 },
	{ 0x00009b5f, 0x00005abd },
	{ 0x00009b60, 0x00005ae3 },
	{ 0x00009b61, 0x00005ad7 },
	{ 0x00009b62, 0x00005ae6 },
	{ 0x00009b63, 0x00005ae9 },
	{ 0x00009b64, 0x00005ad6 },
	{ 0x00009b65, 0x00005afa },
	{ 0x00009b66, 0x00005afb },
	{ 0x00009b67, 0x00005b0c },
	{ 0x00009b68, 0x00005b0b },
	{ 0x00009b69, 0x00005b16 },
	{ 0x00009b6a, 0x00005b32 },
	{ 0x00009b6b, 0x00005ad0 },
	{ 0x00009b6c, 0x00005b2a },
	{ 0x00009b6d, 0x00005b36 },
	{ 0x00009b6e, 0x00005b3e },
	{ 0x00009b6f, 0x00005b43 },
	{ 0x00009b70, 0x00005b45 },
	{ 0x00009b71, 0x00005b40 },
	{ 0x00009b72, 0x00005b51 },
	{ 0x00009b73, 0x00005b55 },
	{ 0x00009b74, 0x00005b5a },
	{ 0x00009b75, 0x00005b5b },
	{ 0x00009b76, 0x00005b65 },
	{ 0x00009b77, 0x00005b69 },
	{ 0x00009b78, 0x00005b70 },
	{ 0x00009b79, 0x00005b73 },
	{ 0x00009b7a, 0x00005b75 },
	{ 0x00009b7b, 0x00005b78 },
	{ 0x00009b7c, 0x00006588 },
	{ 0x00009b7d, 0x00005b7a },
	{ 0x00009b7e, 0x00005b80 },
	{ 0x00009b80, 0x00005b83 },
	{ 0x00009b81, 0x00005ba6 },
	{ 0x00009b82, 0x00005bb8 },
	{ 0x00009b83, 0x00005bc3 },
	{ 0x00009b84, 0x00005bc7 },
	{ 0x00009b85, 0x00005bc9 },
	{ 0x00009b86, 0x00005bd4 },
	{ 0x00009b87, 0x00005bd0 },
	{ 0x00009b88, 0x00005be4 },
	{ 0x00009b89, 0x00005be6 },
	{ 0x00009b8a, 0x00005be2 },
	{ 0x00009b8b, 0x00005bde },
	{ 0x00009b8c, 0x00005be5 },
	{ 0x00009b8d, 0x00005beb },
	{ 0x00009b8e, 0x00005bf0 },
	{ 0x00009b8f, 0x00005bf6 },
	{ 0x00009b90, 0x00005bf3 },
	{ 0x00009b91, 0x00005c05 },
	{ 0x00009b92, 0x00005c07 },
	{ 0x00009b93, 0x00005c08 },
	{ 0x00009b94, 0x00005c0d },
	{ 0x00009b95, 0x00005c13 },
	{ 0x00009b96, 0x00005c20 },
	{ 0x00009b97, 0x00005c22 },
	{ 0x00009b98, 0x00005c28 },
	{ 0x00009b99, 0x00005c38 },
	{ 0x00009b9a, 0x00005c39 },
	{ 0x00009b9b, 0x00005c41 },
	{ 0x00009b9c, 0x00005c46 },
	{ 0x00009b9d, 0x00005c4e },
	{ 0x00009b9e, 0x00005c53 },
	{ 0x00009b9f, 0x00005c50 },
	{ 0x00009ba0, 0x00005c4f },
	{ 0x00009ba1, 0x00005b71 },
	{ 0x00009ba2, 0x00005c6c },
	{ 0x00009ba3, 0x00005c6e },
	{ 0x00009ba4, 0x00004e62 },
	{ 0x00009ba5, 0x00005c76 },
	{ 0x00009ba6, 0x00005c79 },
	{ 0x00009ba7, 0x00005c8c },
	{ 0x00009ba8, 0x00005c91 },
	{ 0x00009ba9, 0x00005c94 },
	{ 0x00009baa, 0x0000599b },
	{ 0x00009bab, 0x00005cab },
	{ 0x00009bac, 0x00005cbb },
	{ 0x00009bad, 0x00005cb6 },
	{ 0x00009bae, 0x00005cbc },
	{ 0x00009baf, 0x00005cb7 },
	{ 0x00009bb0, 0x00005cc5 },
	{ 0x00009bb1, 0x00005cbe },
	{ 0x00009bb2, 0x00005cc7 },
	{ 0x00009bb3, 0x00005cd9 },
	{ 0x00009bb4, 0x00005ce9 },
	{ 0x00009bb5, 0x00005cfd },
	{ 0x00009bb6, 0x00005cfa },
	{ 0x00009bb7, 0x00005ced },
	{ 0x00009bb8, 0x00005d8c },
	{ 0x00009bb9, 0x00005cea },
	{ 0x00009bba, 0x00005d0b },
	{ 0x00009bbb, 0x00005d15 },
	{ 0x00009bbc, 0x00005d17 },
	{ 0x00009bbd, 0x00005d5c },
	{ 0x00009bbe, 0x00005d1f },
	{ 0x00009bbf, 0x00005d1b },
	{ 0x00009bc0, 0x00005d11 },
	{ 0x00009bc1, 0x00005d14 },
	{ 0x00009bc2, 0x00005d22 },
	{ 0x00009bc3, 0x00005d1a },
	{ 0x00009bc4, 0x00005d19 },
	{ 0x00009bc5, 0x00005d18 },
	{ 0x00009bc6, 0x00005d4c },
	{ 0x00009bc7, 0x00005d52 },
	{ 0x00009bc8, 0x00005d4e },
	{ 0x00009bc9, 0x00005d4b },
	{ 0x00009bca, 0x00005d6c },
	{ 0x00009bcb, 0x00005d73 },
	{ 0x00009bcc, 0x00005d76 },
	{ 0x00009bcd, 0x00005d87 },
	{ 0x00009bce, 0x00005d84 },
	{ 0x00009bcf, 0x00005d82 },
	{ 0x00009bd0, 0x00005da2 },
	{ 0x00009bd1, 0x00005d9d },
	{ 0x00009bd2, 0x00005dac },
	{ 0x00009bd3, 0x00005dae },
	{ 0x00009bd4, 0x00005dbd },
	{ 0x00009bd5, 0x00005d90 },
	{ 0x00009bd6, 0x00005db7 },
	{ 0x00009bd7, 0x00005dbc },
	{ 0x00009bd8, 0x00005dc9 },
	{ 0x00009bd9, 0x00005dcd },
	{ 0x00009bda, 0x00005dd3 },
	{ 0x00009bdb, 0x00005dd2 },
	{ 0x00009bdc, 0x00005dd6 },
	{ 0x00009bdd, 0x00005ddb },
	{ 0x00009bde, 0x00005deb },
	{ 0x00009bdf, 0x00005df2 },
	{ 0x00009be0, 0x00005df5 },
	{ 0x00009be1, 0x00005e0b },
	{ 0x00009be2, 0x00005e1a },
	{ 0x00009be3, 0x00005e19 },
	{ 0x00009be4, 0x00005e11 },
	{ 0x00009be5, 0x00005e1b },
	{ 0x00009be6, 0x00005e36 },
	{ 0x00009be7, 0x00005e37 },
	{ 0x00009be8, 0x00005e44 },
	{ 0x00009be9, 0x00005e43 },
	{ 0x00009bea, 0x00005e40 },
	{ 0x00009beb, 0x00005e4e },
	{ 0x00009bec, 0x00005e57 },
	{ 0x00009bed, 0x00005e54 },
	{ 0x00009bee, 0x00005e5f },
	{ 0x00009bef, 0x00005e62 },
	{ 0x00009bf0, 0x00005e64 },
	{ 0x00009bf1, 0x00005e47 },
	{ 0x00009bf2, 0x00005e75 },
	{ 0x00009bf3, 0x00005e76 },
	{ 0x00009bf4, 0x00005e7a },
	{ 0x00009bf5, 0x00009ebc },
	{ 0x00009bf6, 0x00005e7f },
	{ 0x00009bf7, 0x00005ea0 },
	{ 0x00009bf8, 0x00005ec1 },
	{ 0x00009bf9, 0x00005ec2 },
	{ 0x00009bfa, 0x00005ec8 },
	{ 0x00009bfb, 0x00005ed0 },
	{ 0x00009bfc, 0x00005ecf },
	{ 0x00009c40, 0x00005ed6 },
	{ 0x00009c41, 0x00005ee3 },
	{ 0x00009c42, 0x00005edd },
	{ 0x00009c43, 0x00005eda },
	{ 0x00009c44, 0x00005edb },
	{ 0x00009c45, 0x00005ee2 },
	{ 0x00009c46, 0x00005ee1 },
	{ 0x00009c47, 0x00005ee8 },
	{ 0x00009c48, 0x00005ee9 },
	{ 0x00009c49, 0x00005eec },
	{ 0x00009c4a, 0x00005ef1 },
	{ 0x00009c4b, 0x00005ef3 },
	{ 0x00009c4c, 0x00005ef0 },
	{ 0x00009c4d, 0x00005ef4 },
	{ 0x00009c4e, 0x00005ef8 },
	{ 0x00009c4f, 0x00005efe },
	{ 0x00009c50, 0x00005f03 },
	{ 0x00009c51, 0x00005f09 },
	{ 0x00009c52, 0x00005f5d },
	{ 0x00009c53, 0x00005f5c },
	{ 0x00009c54, 0x00005f0b },
	{ 0x00009c55, 0x00005f11 },
	{ 0x00009c56, 0x00005f16 },
	{ 0x00009c57, 0x00005f29 },
	{ 0x00009c58, 0x00005f2d },
	{ 0x00009c59, 0x00005f38 },
	{ 0x00009c5a, 0x00005f41 },
	{ 0x00009c5b, 0x00005f48 },
	{ 0x00009c5c, 0x00005f4c },
	{ 0x00009c5d, 0x00005f4e },
	{ 0x00009c5e, 0x00005f2f },
	{ 0x00009c5f, 0x00005f51 },
	{ 0x00009c60, 0x00005f56 },
	{ 0x00009c61, 0x00005f57 },
	{ 0x00009c62, 0x00005f59 },
	{ 0x00009c63, 0x00005f61 },
	{ 0x00009c64, 0x00005f6d },
	{ 0x00009c65, 0x00005f73 },
	{ 0x00009c66, 0x00005f77 },
	{ 0x00009c67, 0x00005f83 },
	{ 0x00009c68, 0x00005f82 },
	{ 0x00009c69, 0x00005f7f },
	{ 0x00009c6a, 0x00005f8a },
	{ 0x00009c6b, 0x00005f88 },
	{ 0x00009c6c, 0x00005f91 },
	{ 0x00009c6d, 0x00005f87 },
	{ 0x00009c6e, 0x00005f9e },
	{ 0x00009c6f, 0x00005f99 },
	{ 0x00009c70, 0x00005f98 },
	{ 0x00009c71, 0x00005fa0 },
	{ 0x00009c72, 0x00005fa8 },
	{ 0x00009c73, 0x00005fad },
	{ 0x00009c74, 0x00005fbc },
	{ 0x00009c75, 0x00005fd6 },
	{ 0x00009c76, 0x00005ffb },
	{ 0x00009c77, 0x00005fe4 },
	{ 0x00009c78, 0x00005ff8 },
	{ 0x00009c79, 0x00005ff1 },
	{ 0x00009c7a, 0x00005fdd },
	{ 0x00009c7b, 0x000060b3 },
	{ 0x00009c7c, 0x00005fff },
	{ 0x00009c7d, 0x00006021 },
	{ 0x00009c7e, 0x00006060 },
	{ 0x00009c80, 0x00006019 },
	{ 0x00009c81, 0x00006010 },
	{ 0x00009c82, 0x00006029 },
	{ 0x00009c83, 0x0000600e },
	{ 0x00009c84, 0x00006031 },
	{ 0x00009c85, 0x0000601b },
	{ 0x00009c86, 0x00006015 },
	{ 0x00009c87, 0x0000602b },
	{ 0x00009c88, 0x00006026 },
	{ 0x00009c89, 0x0000600f },
	{ 0x00009c8a, 0x0000603a },
	{ 0x00009c8b, 0x0000605a },
	{ 0x00009c8c, 0x00006041 },
	{ 0x00009c8d, 0x0000606a },
	{ 0x00009c8e, 0x00006077 },
	{ 0x00009c8f, 0x0000605f },
	{ 0x00009c90, 0x0000604a },
	{ 0x00009c91, 0x00006046 },
	{ 0x00009c92, 0x0000604d },
	{ 0x00009c93, 0x00006063 },
	{ 0x00009c94, 0x00006043 },
	{ 0x00009c95, 0x00006064 },
	{ 0x00009c96, 0x00006042 },
	{ 0x00009c97, 0x0000606c },
	{ 0x00009c98, 0x0000606b },
	{ 0x00009c99, 0x00006059 },
	{ 0x00009c9a, 0x00006081 },
	{ 0x00009c9b, 0x0000608d },
	{ 0x00009c9c, 0x000060e7 },
	{ 0x00009c9d, 0x00006083 },
	{ 0x00009c9e, 0x0000609a },
	{ 0x00009c9f, 0x00006084 },
	{ 0x00009ca0, 0x0000609b },
	{ 0x00009ca1, 0x00006096 },
	{ 0x00009ca2, 0x00006097 },
	{ 0x00009ca3, 0x00006092 },
	{ 0x00009ca4, 0x000060a7 },
	{ 0x00009ca5, 0x0000608b },
	{ 0x00009ca6, 0x000060e1 },
	{ 0x00009ca7, 0x000060b8 },
	{ 0x00009ca8, 0x000060e0 },
	{ 0x00009ca9, 0x000060d3 },
	{ 0x00009caa, 0x000060b4 },
	{ 0x00009cab, 0x00005ff0 },
	{ 0x00009cac, 0x000060bd },
	{ 0x00009cad, 0x000060c6 },
	{ 0x00009cae, 0x000060b5 },
	{ 0x00009caf, 0x000060d8 },
	{ 0x00009cb0, 0x0000614d },
	{ 0x00009cb1, 0x00006115 },
	{ 0x00009cb2, 0x00006106 },
	{ 0x00009cb3, 0x000060f6 },
	{ 0x00009cb4, 0x000060f7 },
	{ 0x00009cb5, 0x00006100 },
	{ 0x00009cb6, 0x000060f4 },
	{ 0x00009cb7, 0x000060fa },
	{ 0x00009cb8, 0x00006103 },
	{ 0x00009cb9, 0x00006121 },
	{ 0x00009cba, 0x000060fb },
	{ 0x00009cbb, 0x000060f1 },
	{ 0x00009cbc, 0x0000610d },
	{ 0x00009cbd, 0x0000610e },
	{ 0x00009cbe, 0x00006147 },
	{ 0x00009cbf, 0x0000613e },
	{ 0x00009cc0, 0x00006128 },
	{ 0x00009cc1, 0x00006127 },
	{ 0x00009cc2, 0x0000614a },
	{ 0x00009cc3, 0x0000613f },
	{ 0x00009cc4, 0x0000613c },
	{ 0x00009cc5, 0x0000612c },
	{ 0x00009cc6, 0x00006134 },
	{ 0x00009cc7, 0x0000613d },
	{ 0x00009cc8, 0x00006142 },
	{ 0x00009cc9, 0x00006144 },
	{ 0x00009cca, 0x00006173 },
	{ 0x00009ccb, 0x00006177 },
	{ 0x00009ccc, 0x00006158 },
	{ 0x00009ccd, 0x00006159 },
	{ 0x00009cce, 0x0000615a },
	{ 0x00009ccf, 0x0000616b },
	{ 0x00009cd0, 0x00006174 },
	{ 0x00009cd1, 0x0000616f },
	{ 0x00009cd2, 0x00006165 },
	{ 0x00009cd3, 0x00006171 },
	{ 0x00009cd4, 0x0000615f },
	{ 0x00009cd5, 0x0000615d },
	{ 0x00009cd6, 0x00006153 },
	{ 0x00009cd7, 0x00006175 },
	{ 0x00009cd8, 0x00006199 },
	{ 0x00009cd9, 0x00006196 },
	{ 0x00009cda, 0x00006187 },
	{ 0x00009cdb, 0x000061ac },
	{ 0x00009cdc, 0x00006194 },
	{ 0x00009cdd, 0x0000619a },
	{ 0x00009cde, 0x0000618a },
	{ 0x00009cdf, 0x00006191 },
	{ 0x00009ce0, 0x000061ab },
	{ 0x00009ce1, 0x000061ae },
	{ 0x00009ce2, 0x000061cc },
	{ 0x00009ce3, 0x000061ca },
	{ 0x00009ce4, 0x000061c9 },
	{ 0x00009ce5, 0x000061f7 },
	{ 0x00009ce6, 0x000061c8 },
	{ 0x00009ce7, 0x000061c3 },
	{ 0x00009ce8, 0x000061c6 },
	{ 0x00009ce9, 0x000061ba },
	{ 0x00009cea, 0x000061cb },
	{ 0x00009ceb, 0x00007f79 },
	{ 0x00009cec, 0x000061cd },
	{ 0x00009ced, 0x000061e6 },
	{ 0x00009cee, 0x000061e3 },
	{ 0x00009cef, 0x000061f6 },
	{ 0x00009cf0, 0x000061fa },
	{ 0x00009cf1, 0x000061f4 },
	{ 0x00009cf2, 0x000061ff },
	{ 0x00009cf3, 0x000061fd },
	{ 0x00009cf4, 0x000061fc },
	{ 0x00009cf5, 0x000061fe },
	{ 0x00009cf6, 0x00006200 },
	{ 0x00009cf7, 0x00006208 },
	{ 0x00009cf8, 0x00006209 },
	{ 0x00009cf9, 0x0000620d },
	{ 0x00009cfa, 0x0000620c },
	{ 0x00009cfb, 0x00006214 },
	{ 0x00009cfc, 0x0000621b },
	{ 0x00009d40, 0x0000621e },
	{ 0x00009d41, 0x00006221 },
	{ 0x00009d42, 0x0000622a },
	{ 0x00009d43, 0x0000622e },
	{ 0x00009d44, 0x00006230 },
	{ 0x00009d45, 0x00006232 },
	{ 0x00009d46, 0x00006233 },
	{ 0x00009d47, 0x00006241 },
	{ 0x00009d48, 0x0000624e },
	{ 0x00009d49, 0x0000625e },
	{ 0x00009d4a, 0x00006263 },
	{ 0x00009d4b, 0x0000625b },
	{ 0x00009d4c, 0x00006260 },
	{ 0x00009d4d, 0x00006268 },
	{ 0x00009d4e, 0x0000627c },
	{ 0x00009d4f, 0x00006282 },
	{ 0x00009d50, 0x00006289 },
	{ 0x00009d51, 0x0000627e },
	{ 0x00009d52, 0x00006292 },
	{ 0x00009d53, 0x00006293 },
	{ 0x00009d54, 0x00006296 },
	{ 0x00009d55, 0x000062d4 },
	{ 0x00009d56, 0x00006283 },
	{ 0x00009d57, 0x00006294 },
	{ 0x00009d58, 0x000062d7 },
	{ 0x00009d59, 0x000062d1 },
	{ 0x00009d5a, 0x000062bb },
	{ 0x00009d5b, 0x000062cf },
	{ 0x00009d5c, 0x000062ff },
	{ 0x00009d5d, 0x000062c6 },
	{ 0x00009d5e, 0x000064d4 },
	{ 0x00009d5f, 0x000062c8 },
	{ 0x00009d60, 0x000062dc },
	{ 0x00009d61, 0x000062cc },
	{ 0x00009d62, 0x000062ca },
	{ 0x00009d63, 0x000062c2 },
	{ 0x00009d64, 0x000062c7 },
	{ 0x00009d65, 0x0000629b },
	{ 0x00009d66, 0x000062c9 },
	{ 0x00009d67, 0x0000630c },
	{ 0x00009d68, 0x000062ee },
	{ 0x00009d69, 0x000062f1 },
	{ 0x00009d6a, 0x00006327 },
	{ 0x00009d6b, 0x00006302 },
	{ 0x00009d6c, 0x00006308 },
	{ 0x00009d6d, 0x000062ef },
	{ 0x00009d6e, 0x000062f5 },
	{ 0x00009d6f, 0x00006350 },
	{ 0x00009d70, 0x0000633e },
	{ 0x00009d71, 0x0000634d },
	{ 0x00009d72, 0x0000641c },
	{ 0x00009d73, 0x0000634f },
	{ 0x00009d74, 0x00006396 },
	{ 0x00009d75, 0x0000638e },
	{ 0x00009d76, 0x00006380 },
	{ 0x00009d77, 0x000063ab },
	{ 0x00009d78, 0x00006376 },
	{ 0x00009d79, 0x000063a3 },
	{ 0x00009d7a, 0x0000638f },
	{ 0x00009d7b, 0x00006389 },
	{ 0x00009d7c, 0x0000639f },
	{ 0x00009d7d, 0x000063b5 },
	{ 0x00009d7e, 0x0000636b },
	{ 0x00009d80, 0x00006369 },
	{ 0x00009d81, 0x000063be },
	{ 0x00009d82, 0x000063e9 },
	{ 0x00009d83, 0x000063c0 },
	{ 0x00009d84, 0x000063c6 },
	{ 0x00009d85, 0x000063e3 },
	{ 0x00009d86, 0x000063c9 },
	{ 0x00009d87, 0x000063d2 },
	{ 0x00009d88, 0x000063f6 },
	{ 0x00009d89, 0x000063c4 },
	{ 0x00009d8a, 0x00006416 },
	{ 0x00009d8b, 0x00006434 },
	{ 0x00009d8c, 0x00006406 },
	{ 0x00009d8d, 0x00006413 },
	{ 0x00009d8e, 0x00006426 },
	{ 0x00009d8f, 0x00006436 },
	{ 0x00009d90, 0x0000651d },
	{ 0x00009d91, 0x00006417 },
	{ 0x00009d92, 0x00006428 },
	{ 0x00009d93, 0x0000640f },
	{ 0x00009d94, 0x00006467 },
	{ 0x00009d95, 0x0000646f },
	{ 0x00009d96, 0x00006476 },
	{ 0x00009d97, 0x0000644e },
	{ 0x00009d98, 0x0000652a },
	{ 0x00009d99, 0x00006495 },
	{ 0x00009d9a, 0x00006493 },
	{ 0x00009d9b, 0x000064a5 },
	{ 0x00009d9c, 0x000064a9 },
	{ 0x00009d9d, 0x00006488 },
	{ 0x00009d9e, 0x000064bc },
	{ 0x00009d9f, 0x000064da },
	{ 0x00009da0, 0x000064d2 },
	{ 0x00009da1, 0x000064c5 },
	{ 0x00009da2, 0x000064c7 },
	{ 0x00009da3, 0x000064bb },
	{ 0x00009da4, 0x000064d8 },
	{ 0x00009da5, 0x000064c2 },
	{ 0x00009da6, 0x000064f1 },
	{ 0x00009da7, 0x000064e7 },
	{ 0x00009da8, 0x00008209 },
	{ 0x00009da9, 0x000064e0 },
	{ 0x00009daa, 0x000064e1 },
	{ 0x00009dab, 0x000062ac },
	{ 0x00009dac, 0x000064e3 },
	{ 0x00009dad, 0x000064ef },
	{ 0x00009dae, 0x0000652c },
	{ 0x00009daf, 0x000064f6 },
	{ 0x00009db0, 0x000064f4 },
	{ 0x00009db1, 0x000064f2 },
	{ 0x00009db2, 0x000064fa },
	{ 0x00009db3, 0x00006500 },
	{ 0x00009db4, 0x000064fd },
	{ 0x00009db5, 0x00006518 },
	{ 0x00009db6, 0x0000651c },
	{ 0x00009db7, 0x00006505 },
	{ 0x00009db8, 0x00006524 },
	{ 0x00009db9, 0x00006523 },
	{ 0x00009dba, 0x0000652b },
	{ 0x00009dbb, 0x00006534 },
	{ 0x00009dbc, 0x00006535 },
	{ 0x00009dbd, 0x00006537 },
	{ 0x00009dbe, 0x00006536 },
	{ 0x00009dbf, 0x00006538 },
	{ 0x00009dc0, 0x0000754b },
	{ 0x00009dc1, 0x00006548 },
	{ 0x00009dc2, 0x00006556 },
	{ 0x00009dc3, 0x00006555 },
	{ 0x00009dc4, 0x0000654d },
	{ 0x00009dc5, 0x00006558 },
	{ 0x00009dc6, 0x0000655e },
	{ 0x00009dc7, 0x0000655d },
	{ 0x00009dc8, 0x00006572 },
	{ 0x00009dc9, 0x00006578 },
	{ 0x00009dca, 0x00006582 },
	{ 0x00009dcb, 0x00006583 },
	{ 0x00009dcc, 0x00008b8a },
	{ 0x00009dcd, 0x0000659b },
	{ 0x00009dce, 0x0000659f },
	{ 0x00009dcf, 0x000065ab },
	{ 0x00009dd0, 0x000065b7 },
	{ 0x00009dd1, 0x000065c3 },
	{ 0x00009dd2, 0x000065c6 },
	{ 0x00009dd3, 0x000065c1 },
	{ 0x00009dd4, 0x000065c4 },
	{ 0x00009dd5, 0x000065cc },
	{ 0x00009dd6, 0x000065d2 },
	{ 0x00009dd7, 0x000065db },
	{ 0x00009dd8, 0x000065d9 },
	{ 0x00009dd9, 0x000065e0 },
	{ 0x00009dda, 0x000065e1 },
	{ 0x00009ddb, 0x000065f1 },
	{ 0x00009ddc, 0x00006772 },
	{ 0x00009ddd, 0x0000660a },
	{ 0x00009dde, 0x00006603 },
	{ 0x00009ddf, 0x000065fb },
	{ 0x00009de0, 0x00006773 },
	{ 0x00009de1, 0x00006635 },
	{ 0x00009de2, 0x00006636 },
	{ 0x00009de3, 0x00006634 },
	{ 0x00009de4, 0x0000661c },
	{ 0x00009de5, 0x0000664f },
	{ 0x00009de6, 0x00006644 },
	{ 0x00009de7, 0x00006649 },
	{ 0x00009de8, 0x00006641 },
	{ 0x00009de9, 0x0000665e },
	{ 0x00009dea, 0x0000665d },
	{ 0x00009deb, 0x00006664 },
	{ 0x00009dec, 0x00006667 },
	{ 0x00009ded, 0x00006668 },
	{ 0x00009dee, 0x0000665f },
	{ 0x00009def, 0x00006662 },
	{ 0x00009df0, 0x00006670 },
	{ 0x00009df1, 0x00006683 },
	{ 0x00009df2, 0x00006688 },
	{ 0x00009df3, 0x0000668e },
	{ 0x00009df4, 0x00006689 },
	{ 0x00009df5, 0x00006684 },
	{ 0x00009df6, 0x00006698 },
	{ 0x00009df7, 0x0000669d },
	{ 0x00009df8, 0x000066c1 },
	{ 0x00009df9, 0x000066b9 },
	{ 0x00009dfa, 0x000066c9 },
	{ 0x00009dfb, 0x000066be },
	{ 0x00009dfc, 0x000066bc },
	{ 0x00009e40, 0x000066c4 },
	{ 0x00009e41, 0x000066b8 },
	{ 0x00009e42, 0x000066d6 },
	{ 0x00009e43, 0x000066da },
	{ 0x00009e44, 0x000066e0 },
	{ 0x00009e45, 0x0000663f },
	{ 0x00009e46, 0x000066e6 },
	{ 0x00009e47, 0x000066e9 },
	{ 0x00009e48, 0x000066f0 },
	{ 0x00009e49, 0x000066f5 },
	{ 0x00009e4a, 0x000066f7 },
	{ 0x00009e4b, 0x0000670f },
	{ 0x00009e4c, 0x00006716 },
	{ 0x00009e4d, 0x0000671e },
	{ 0x00009e4e, 0x00006726 },
	{ 0x00009e4f, 0x00006727 },
	{ 0x00009e50, 0x00009738 },
	{ 0x00009e51, 0x0000672e },
	{ 0x00009e52, 0x0000673f },
	{ 0x00009e53, 0x00006736 },
	{ 0x00009e54, 0x00006741 },
	{ 0x00009e55, 0x00006738 },
	{ 0x00009e56, 0x00006737 },
	{ 0x00009e57, 0x00006746 },
	{ 0x00009e58, 0x0000675e },
	{ 0x00009e59, 0x00006760 },
	{ 0x00009e5a, 0x00006759 },
	{ 0x00009e5b, 0x00006763 },
	{ 0x00009e5c, 0x00006764 },
	{ 0x00009e5d, 0x00006789 },
	{ 0x00009e5e, 0x00006770 },
	{ 0x00009e5f, 0x000067a9 },
	{ 0x00009e60, 0x0000677c },
	{ 0x00009e61, 0x0000676a },
	{ 0x00009e62, 0x0000678c },
	{ 0x00009e63, 0x0000678b },
	{ 0x00009e64, 0x000067a6 },
	{ 0x00009e65, 0x000067a1 },
	{ 0x00009e66, 0x00006785 },
	{ 0x00009e67, 0x000067b7 },
	{ 0x00009e68, 0x000067ef },
	{ 0x00009e69, 0x000067b4 },
	{ 0x00009e6a, 0x000067ec },
	{ 0x00009e6b, 0x000067b3 },
	{ 0x00009e6c, 0x000067e9 },
	{ 0x00009e6d, 0x000067b8 },
	{ 0x00009e6e, 0x000067e4 },
	{ 0x00009e6f, 0x000067de },
	{ 0x00009e70, 0x000067dd },
	{ 0x00009e71, 0x000067e2 },
	{ 0x00009e72, 0x000067ee },
	{ 0x00009e73, 0x000067b9 },
	{ 0x00009e74, 0x000067ce },
	{ 0x00009e75, 0x000067c6 },
	{ 0x00009e76, 0x000067e7 },
	{ 0x00009e77, 0x00006a9c },
	{ 0x00009e78, 0x0000681e },
	{ 0x00009e79, 0x00006846 },
	{ 0x00009e7a, 0x00006829 },
	{ 0x00009e7b, 0x00006840 },
	{ 0x00009e7c, 0x0000684d },
	{ 0x00009e7d, 0x00006832 },
	{ 0x00009e7e, 0x0000684e },
	{ 0x00009e80, 0x000068b3 },
	{ 0x00009e81, 0x0000682b },
	{ 0x00009e82, 0x00006859 },
	{ 0x00009e83, 0x00006863 },
	{ 0x00009e84, 0x00006877 },
	{ 0x00009e85, 0x0000687f },
	{ 0x00009e86, 0x0000689f },
	{ 0x00009e87, 0x0000688f },
	{ 0x00009e88, 0x000068ad },
	{ 0x00009e89, 0x00006894 },
	{ 0x00009e8a, 0x0000689d },
	{ 0x00009e8b, 0x0000689b },
	{ 0x00009e8c, 0x00006883 },
	{ 0x00009e8d, 0x00006aae },
	{ 0x00009e8e, 0x000068b9 },
	{ 0x00009e8f, 0x00006874 },
	{ 0x00009e90, 0x000068b5 },
	{ 0x00009e91, 0x000068a0 },
	{ 0x00009e92, 0x000068ba },
	{ 0x00009e93, 0x0000690f },
	{ 0x00009e94, 0x0000688d },
	{ 0x00009e95, 0x0000687e },
	{ 0x00009e96, 0x00006901 },
	{ 0x00009e97, 0x000068ca },
	{ 0x00009e98, 0x00006908 },
	{ 0x00009e99, 0x000068d8 },
	{ 0x00009e9a, 0x00006922 },
	{ 0x00009e9b, 0x00006926 },
	{ 0x00009e9c, 0x000068e1 },
	{ 0x00009e9d, 0x0000690c },
	{ 0x00009e9e, 0x000068cd },
	{ 0x00009e9f, 0x000068d4 },
	{ 0x00009ea0, 0x000068e7 },
	{ 0x00009ea1, 0x000068d5 },
	{ 0x00009ea2, 0x00006936 },
	{ 0x00009ea3, 0x00006912 },
	{ 0x00009ea4, 0x00006904 },
	{ 0x00009ea5, 0x000068d7 },
	{ 0x00009ea6, 0x000068e3 },
	{ 0x00009ea7, 0x00006925 },
	{ 0x00009ea8, 0x000068f9 },
	{ 0x00009ea9, 0x000068e0 },
	{ 0x00009eaa, 0x000068ef },
	{ 0x00009eab, 0x00006928 },
	{ 0x00009eac, 0x0000692a },
	{ 0x00009ead, 0x0000691a },
	{ 0x00009eae, 0x00006923 },
	{ 0x00009eaf, 0x00006921 },
	{ 0x00009eb0, 0x000068c6 },
	{ 0x00009eb1, 0x00006979 },
	{ 0x00009eb2, 0x00006977 },
	{ 0x00009eb3, 0x0000695c },
	{ 0x00009eb4, 0x00006978 },
	{ 0x00009eb5, 0x0000696b },
	{ 0x00009eb6, 0x00006954 },
	{ 0x00009eb7, 0x0000697e },
	{ 0x00009eb8, 0x0000696e },
	{ 0x00009eb9, 0x00006939 },
	{ 0x00009eba, 0x00006974 },
	{ 0x00009ebb, 0x0000693d },
	{ 0x00009ebc, 0x00006959 },
	{ 0x00009ebd, 0x00006930 },
	{ 0x00009ebe, 0x00006961 },
	{ 0x00009ebf, 0x0000695e },
	{ 0x00009ec0, 0x0000695d },
	{ 0x00009ec1, 0x00006981 },
	{ 0x00009ec2, 0x0000696a },
	{ 0x00009ec3, 0x000069b2 },
	{ 0x00009ec4, 0x000069ae },
	{ 0x00009ec5, 0x000069d0 },
	{ 0x00009ec6, 0x000069bf },
	{ 0x00009ec7, 0x000069c1 },
	{ 0x00009ec8, 0x000069d3 },
	{ 0x00009ec9, 0x000069be },
	{ 0x00009eca, 0x000069ce },
	{ 0x00009ecb, 0x00005be8 },
	{ 0x00009ecc, 0x000069ca },
	{ 0x00009ecd, 0x000069dd },
	{ 0x00009ece, 0x000069bb },
	{ 0x00009ecf, 0x000069c3 },
	{ 0x00009ed0, 0x000069a7 },
	{ 0x00009ed1, 0x00006a2e },
	{ 0x00009ed2, 0x00006991 },
	{ 0x00009ed3, 0x000069a0 },
	{ 0x00009ed4, 0x0000699c },
	{ 0x00009ed5, 0x00006995 },
	{ 0x00009ed6, 0x000069b4 },
	{ 0x00009ed7, 0x000069de },
	{ 0x00009ed8, 0x000069e8 },
	{ 0x00009ed9, 0x00006a02 },
	{ 0x00009eda, 0x00006a1b },
	{ 0x00009edb, 0x000069ff },
	{ 0x00009edc, 0x00006b0a },
	{ 0x00009edd, 0x000069f9 },
	{ 0x00009ede, 0x000069f2 },
	{ 0x00009edf, 0x000069e7 },
	{ 0x00009ee0, 0x00006a05 },
	{ 0x00009ee1, 0x000069b1 },
	{ 0x00009ee2, 0x00006a1e },
	{ 0x00009ee3, 0x000069ed },
	{ 0x00009ee4, 0x00006a14 },
	{ 0x00009ee5, 0x000069eb },
	{ 0x00009ee6, 0x00006a0a },
	{ 0x00009ee7, 0x00006a12 },
	{ 0x00009ee8, 0x00006ac1 },
	{ 0x00009ee9, 0x00006a23 },
	{ 0x00009eea, 0x00006a13 },
	{ 0x00009eeb, 0x00006a44 },
	{ 0x00009eec, 0x00006a0c },
	{ 0x00009eed, 0x00006a72 },
	{ 0x00009eee, 0x00006a36 },
	{ 0x00009eef, 0x00006a78 },
	{ 0x00009ef0, 0x00006a47 },
	{ 0x00009ef1, 0x00006a62 },
	{ 0x00009ef2, 0x00006a59 },
	{ 0x00009ef3, 0x00006a66 },
	{ 0x00009ef4, 0x00006a48 },
	{ 0x00009ef5, 0x00006a38 },
	{ 0x00009ef6, 0x00006a22 },
	{ 0x00009ef7, 0x00006a90 },
	{ 0x00009ef8, 0x00006a8d },
	{ 0x00009ef9, 0x00006aa0 },
	{ 0x00009efa, 0x00006a84 },
	{ 0x00009efb, 0x00006aa2 },
	{ 0x00009efc, 0x00006aa3 },
	{ 0x00009f40, 0x00006a97 },
	{ 0x00009f41, 0x00008617 },
	{ 0x00009f42, 0x00006abb },
	{ 0x00009f43, 0x00006ac3 },
	{ 0x00009f44, 0x00006ac2 },
	{ 0x00009f45, 0x00006ab8 },
	{ 0x00009f46, 0x00006ab3 },
	{ 0x00009f47, 0x00006aac },
	{ 0x00009f48, 0x00006ade },
	{ 0x00009f49, 0x00006ad1 },
	{ 0x00009f4a, 0x00006adf },
	{ 0x00009f4b, 0x00006aaa },
	{ 0x00009f4c, 0x00006ada },
	{ 0x00009f4d, 0x00006aea },
	{ 0x00009f4e, 0x00006afb },
	{ 0x00009f4f, 0x00006b05 },
	{ 0x00009f50, 0x00008616 },
	{ 0x00009f51, 0x00006afa },
	{ 0x00009f52, 0x00006b12 },
	{ 0x00009f53, 0x00006b16 },
	{ 0x00009f54, 0x00009b31 },
	{ 0x00009f55, 0x00006b1f },
	{ 0x00009f56, 0x00006b38 },
	{ 0x00009f57, 0x00006b37 },
	{ 0x00009f58, 0x000076dc },
	{ 0x00009f59, 0x00006b39 },
	{ 0x00009f5a, 0x000098ee },
	{ 0x00009f5b, 0x00006b47 },
	{ 0x00009f5c, 0x00006b43 },
	{ 0x00009f5d, 0x00006b49 },
	{ 0x00009f5e, 0x00006b50 },
	{ 0x00009f5f, 0x00006b59 },
	{ 0x00009f60, 0x00006b54 },
	{ 0x00009f61, 0x00006b5b },
	{ 0x00009f62, 0x00006b5f },
	{ 0x00009f63, 0x00006b61 },
	{ 0x00009f64, 0x00006b78 },
	{ 0x00009f65, 0x00006b79 },
	{ 0x00009f66, 0x00006b7f },
	{ 0x00009f67, 0x00006b80 },
	{ 0x00009f68, 0x00006b84 },
	{ 0x00009f69, 0x00006b83 },
	{ 0x00009f6a, 0x00006b8d },
	{ 0x00009f6b, 0x00006b98 },
	{ 0x00009f6c, 0x00006b95 },
	{ 0x00009f6d, 0x00006b9e },
	{ 0x00009f6e, 0x00006ba4 },
	{ 0x00009f6f, 0x00006baa },
	{ 0x00009f70, 0x00006bab },
	{ 0x00009f71, 0x00006baf },
	{ 0x00009f72, 0x00006bb2 },
	{ 0x00009f73, 0x00006bb1 },
	{ 0x00009f74, 0x00006bb3 },
	{ 0x00009f75, 0x00006bb7 },
	{ 0x00009f76, 0x00006bbc },
	{ 0x00009f77, 0x00006bc6 },
	{ 0x00009f78, 0x00006bcb },
	{ 0x00009f79, 0x00006bd3 },
	{ 0x00009f7a, 0x00006bdf },
	{ 0x00009f7b, 0x00006bec },
	{ 0x00009f7c, 0x00006beb },
	{ 0x00009f7d, 0x00006bf3 },
	{ 0x00009f7e, 0x00006bef },
	{ 0x00009f80, 0x00009ebe },
	{ 0x00009f81, 0x00006c08 },
	{ 0x00009f82, 0x00006c13 },
	{ 0x00009f83, 0x00006c14 },
	{ 0x00009f84, 0x00006c1b },
	{ 0x00009f85, 0x00006c24 },
	{ 0x00009f86, 0x00006c23 },
	{ 0x00009f87, 0x00006c5e },
	{ 0x00009f88, 0x00006c55 },
	{ 0x00009f89, 0x00006c62 },
	{ 0x00009f8a, 0x00006c6a },
	{ 0x00009f8b, 0x00006c82 },
	{ 0x00009f8c, 0x00006c8d },
	{ 0x00009f8d, 0x00006c9a },
	{ 0x00009f8e, 0x00006c81 },
	{ 0x00009f8f, 0x00006c9b },
	{ 0x00009f90, 0x00006c7e },
	{ 0x00009f91, 0x00006c68 },
	{ 0x00009f92, 0x00006c73 },
	{ 0x00009f93, 0x00006c92 },
	{ 0x00009f94, 0x00006c90 },
	{ 0x00009f95, 0x00006cc4 },
	{ 0x00009f96, 0x00006cf1 },
	{ 0x00009f97, 0x00006cd3 },
	{ 0x00009f98, 0x00006cbd },
	{ 0x00009f99, 0x00006cd7 },
	{ 0x00009f9a, 0x00006cc5 },
	{ 0x00009f9b, 0x00006cdd },
	{ 0x00009f9c, 0x00006cae },
	{ 0x00009f9d, 0x00006cb1 },
	{ 0x00009f9e, 0x00006cbe },
	{ 0x00009f9f, 0x00006cba },
	{ 0x00009fa0, 0x00006cdb },
	{ 0x00009fa1, 0x00006cef },
	{ 0x00009fa2, 0x00006cd9 },
	{ 0x00009fa3, 0x00006cea },
	{ 0x00009fa4, 0x00006d1f },
	{ 0x00009fa5, 0x0000884d },
	{ 0x00009fa6, 0x00006d36 },
	{ 0x00009fa7, 0x00006d2b },
	{ 0x00009fa8, 0x00006d3d },
	{ 0x00009fa9, 0x00006d38 },
	{ 0x00009faa, 0x00006d19 },
	{ 0x00009fab, 0x00006d35 },
	{ 0x00009fac, 0x00006d33 },
	{ 0x00009fad, 0x00006d12 },
	{ 0x00009fae, 0x00006d0c },
	{ 0x00009faf, 0x00006d63 },
	{ 0x00009fb0, 0x00006d93 },
	{ 0x00009fb1, 0x00006d64 },
	{ 0x00009fb2, 0x00006d5a },
	{ 0x00009fb3, 0x00006d79 },
	{ 0x00009fb4, 0x00006d59 },
	{ 0x00009fb5, 0x00006d8e },
	{ 0x00009fb6, 0x00006d95 },
	{ 0x00009fb7, 0x00006fe4 },
	{ 0x00009fb8, 0x00006d85 },
	{ 0x00009fb9, 0x00006df9 },
	{ 0x00009fba, 0x00006e15 },
	{ 0x00009fbb, 0x00006e0a },
	{ 0x00009fbc, 0x00006db5 },
	{ 0x00009fbd, 0x00006dc7 },
	{ 0x00009fbe, 0x00006de6 },
	{ 0x00009fbf, 0x00006db8 },
	{ 0x00009fc0, 0x00006dc6 },
	{ 0x00009fc1, 0x00006dec },
	{ 0x00009fc2, 0x00006dde },
	{ 0x00009fc3, 0x00006dcc },
	{ 0x00009fc4, 0x00006de8 },
	{ 0x00009fc5, 0x00006dd2 },
	{ 0x00009fc6, 0x00006dc5 },
	{ 0x00009fc7, 0x00006dfa },
	{ 0x00009fc8, 0x00006dd9 },
	{ 0x00009fc9, 0x00006de4 },
	{ 0x00009fca, 0x00006dd5 },
	{ 0x00009fcb, 0x00006dea },
	{ 0x00009fcc, 0x00006dee },
	{ 0x00009fcd, 0x00006e2d },
	{ 0x00009fce, 0x00006e6e },
	{ 0x00009fcf, 0x00006e2e },
	{ 0x00009fd0, 0x00006e19 },
	{ 0x00009fd1, 0x00006e72 },
	{ 0x00009fd2, 0x00006e5f },
	{ 0x00009fd3, 0x00006e3e },
	{ 0x00009fd4, 0x00006e23 },
	{ 0x00009fd5, 0x00006e6b },
	{ 0x00009fd6, 0x00006e2b },
	{ 0x00009fd7, 0x00006e76 },
	{ 0x00009fd8, 0x00006e4d },
	{ 0x00009fd9, 0x00006e1f },
	{ 0x00009fda, 0x00006e43 },
	{ 0x00009fdb, 0x00006e3a },
	{ 0x00009fdc, 0x00006e4e },
	{ 0x00009fdd, 0x00006e24 },
	{ 0x00009fde, 0x00006eff },
	{ 0x00009fdf, 0x00006e1d },
	{ 0x00009fe0, 0x00006e38 },
	{ 0x00009fe1, 0x00006e82 },
	{ 0x00009fe2, 0x00006eaa },
	{ 0x00009fe3, 0x00006e98 },
	{ 0x00009fe4, 0x00006ec9 },
	{ 0x00009fe5, 0x00006eb7 },
	{ 0x00009fe6, 0x00006ed3 },
	{ 0x00009fe7, 0x00006ebd },
	{ 0x00009fe8, 0x00006eaf },
	{ 0x00009fe9, 0x00006ec4 },
	{ 0x00009fea, 0x00006eb2 },
	{ 0x00009feb, 0x00006ed4 },
	{ 0x00009fec, 0x00006ed5 },
	{ 0x00009fed, 0x00006e8f },
	{ 0x00009fee, 0x00006ea5 },
	{ 0x00009fef, 0x00006ec2 },
	{ 0x00009ff0, 0x00006e9f },
	{ 0x00009ff1, 0x00006f41 },
	{ 0x00009ff2, 0x00006f11 },
	{ 0x00009ff3, 0x0000704c },
	{ 0x00009ff4, 0x00006eec },
	{ 0x00009ff5, 0x00006ef8 },
	{ 0x00009ff6, 0x00006efe },
	{ 0x00009ff7, 0x00006f3f },
	{ 0x00009ff8, 0x00006ef2 },
	{ 0x00009ff9, 0x00006f31 },
	{ 0x00009ffa, 0x00006eef },
	{ 0x00009ffb, 0x00006f32 },
	{ 0x00009ffc, 0x00006ecc },
	{ 0x0000e040, 0x00006f3e },
	{ 0x0000e041, 0x00006f13 },
	{ 0x0000e042, 0x00006ef7 },
	{ 0x0000e043, 0x00006f86 },
	{ 0x0000e044, 0x00006f7a },
	{ 0x0000e045, 0x00006f78 },
	{ 0x0000e046, 0x00006f81 },
	{ 0x0000e047, 0x00006f80 },
	{ 0x0000e048, 0x00006f6f },
	{ 0x0000e049, 0x00006f5b },
	{ 0x0000e04a, 0x00006ff3 },
	{ 0x0000e04b, 0x00006f6d },
	{ 0x0000e04c, 0x00006f82 },
	{ 0x0000e04d, 0x00006f7c },
	{ 0x0000e04e, 0x00006f58 },
	{ 0x0000e04f, 0x00006f8e },
	{ 0x0000e050, 0x00006f91 },
	{ 0x0000e051, 0x00006fc2 },
	{ 0x0000e052, 0x00006f66 },
	{ 0x0000e053, 0x00006fb3 },
	{ 0x0000e054, 0x00006fa3 },
	{ 0x0000e055, 0x00006fa1 },
	{ 0x0000e056, 0x00006fa4 },
	{ 0x0000e057, 0x00006fb9 },
	{ 0x0000e058, 0x00006fc6 },
	{ 0x0000e059, 0x00006faa },
	{ 0x0000e05a, 0x00006fdf },
	{ 0x0000e05b, 0x00006fd5 },
	{ 0x0000e05c, 0x00006fec },
	{ 0x0000e05d, 0x00006fd4 },
	{ 0x0000e05e, 0x00006fd8 },
	{ 0x0000e05f, 0x00006ff1 },
	{ 0x0000e060, 0x00006fee },
	{ 0x0000e061, 0x00006fdb },
	{ 0x0000e062, 0x00007009 },
	{ 0x0000e063, 0x0000700b },
	{ 0x0000e064, 0x00006ffa },
	{ 0x0000e065, 0x00007011 },
	{ 0x0000e066, 0x00007001 },
	{ 0x0000e067, 0x0000700f },
	{ 0x0000e068, 0x00006ffe },
	{ 0x0000e069, 0x0000701b },
	{ 0x0000e06a, 0x0000701a },
	{ 0x0000e06b, 0x00006f74 },
	{ 0x0000e06c, 0x0000701d },
	{ 0x0000e06d, 0x00007018 },
	{ 0x0000e06e, 0x0000701f },
	{ 0x0000e06f, 0x00007030 },
	{ 0x0000e070, 0x0000703e },
	{ 0x0000e071, 0x00007032 },
	{ 0x0000e072, 0x00007051 },
	{ 0x0000e073, 0x00007063 },
	{ 0x0000e074, 0x00007099 },
	{ 0x0000e075, 0x00007092 },
	{ 0x0000e076, 0x000070af },
	{ 0x0000e077, 0x000070f1 },
	{ 0x0000e078, 0x000070ac },
	{ 0x0000e079, 0x000070b8 },
	{ 0x0000e07a, 0x000070b3 },
	{ 0x0000e07b, 0x000070ae },
	{ 0x0000e07c, 0x000070df },
	{ 0x0000e07d, 0x000070cb },
	{ 0x0000e07e, 0x000070dd },
	{ 0x0000e080, 0x000070d9 },
	{ 0x0000e081, 0x00007109 },
	{ 0x0000e082, 0x000070fd },
	{ 0x0000e083, 0x0000711c },
	{ 0x0000e084, 0x00007119 },
	{ 0x0000e085, 0x00007165 },
	{ 0x0000e086, 0x00007155 },
	{ 0x0000e087, 0x00007188 },
	{ 0x0000e088, 0x00007166 },
	{ 0x0000e089, 0x00007162 },
	{ 0x0000e08a, 0x0000714c },
	{ 0x0000e08b, 0x00007156 },
	{ 0x0000e08c, 0x0000716c },
	{ 0x0000e08d, 0x0000718f },
	{ 0x0000e08e, 0x000071fb },
	{ 0x0000e08f, 0x00007184 },
	{ 0x0000e090, 0x00007195 },
	{ 0x0000e091, 0x000071a8 },
	{ 0x0000e092, 0x000071ac },
	{ 0x0000e093, 0x000071d7 },
	{ 0x0000e094, 0x000071b9 },
	{ 0x0000e095, 0x000071be },
	{ 0x0000e096, 0x000071d2 },
	{ 0x0000e097, 0x000071c9 },
	{ 0x0000e098, 0x000071d4 },
	{ 0x0000e099, 0x000071ce },
	{ 0x0000e09a, 0x000071e0 },
	{ 0x0000e09b, 0x000071ec },
	{ 0x0000e09c, 0x000071e7 },
	{ 0x0000e09d, 0x000071f5 },
	{ 0x0000e09e, 0x000071fc },
	{ 0x0000e09f, 0x000071f9 },
	{ 0x0000e0a0, 0x000071ff },
	{ 0x0000e0a1, 0x0000720d },
	{ 0x0000e0a2, 0x00007210 },
	{ 0x0000e0a3, 0x0000721b },
	{ 0x0000e0a4, 0x00007228 },
	{ 0x0000e0a5, 0x0000722d },
	{ 0x0000e0a6, 0x0000722c },
	{ 0x0000e0a7, 0x00007230 },
	{ 0x0000e0a8, 0x00007232 },
	{ 0x0000e0a9, 0x0000723b },
	{ 0x0000e0aa, 0x0000723c },
	{ 0x0000e0ab, 0x0000723f },
	{ 0x0000e0ac, 0x00007240 },
	{ 0x0000e0ad, 0x00007246 },
	{ 0x0000e0ae, 0x0000724b },
	{ 0x0000e0af, 0x00007258 },
	{ 0x0000e0b0, 0x00007274 },
	{ 0x0000e0b1, 0x0000727e },
	{ 0x0000e0b2, 0x00007282 },
	{ 0x0000e0b3, 0x00007281 },
	{ 0x0000e0b4, 0x00007287 },
	{ 0x0000e0b5, 0x00007292 },
	{ 0x0000e0b6, 0x00007296 },
	{ 0x0000e0b7, 0x000072a2 },
	{ 0x0000e0b8, 0x000072a7 },
	{ 0x0000e0b9, 0x000072b9 },
	{ 0x0000e0ba, 0x000072b2 },
	{ 0x0000e0bb, 0x000072c3 },
	{ 0x0000e0bc, 0x000072c6 },
	{ 0x0000e0bd, 0x000072c4 },
	{ 0x0000e0be, 0x000072ce },
	{ 0x0000e0bf, 0x000072d2 },
	{ 0x0000e0c0, 0x000072e2 },
	{ 0x0000e0c1, 0x000072e0 },
	{ 0x0000e0c2, 0x000072e1 },
	{ 0x0000e0c3, 0x000072f9 },
	{ 0x0000e0c4, 0x000072f7 },
	{ 0x0000e0c5, 0x0000500f },
	{ 0x0000e0c6, 0x00007317 },
	{ 0x0000e0c7, 0x0000730a },
	{ 0x0000e0c8, 0x0000731c },
	{ 0x0000e0c9, 0x00007316 },
	{ 0x0000e0ca, 0x0000731d },
	{ 0x0000e0cb, 0x00007334 },
	{ 0x0000e0cc, 0x0000732f },
	{ 0x0000e0cd, 0x00007329 },
	{ 0x0000e0ce, 0x00007325 },
	{ 0x0000e0cf, 0x0000733e },
	{ 0x0000e0d0, 0x0000734e },
	{ 0x0000e0d1, 0x0000734f },
	{ 0x0000e0d2, 0x00009ed8 },
	{ 0x0000e0d3, 0x00007357 },
	{ 0x0000e0d4, 0x0000736a },
	{ 0x0000e0d5, 0x00007368 },
	{ 0x0000e0d6, 0x00007370 },
	{ 0x0000e0d7, 0x00007378 },
	{ 0x0000e0d8, 0x00007375 },
	{ 0x0000e0d9, 0x0000737b },
	{ 0x0000e0da, 0x0000737a },
	{ 0x0000e0db, 0x000073c8 },
	{ 0x0000e0dc, 0x000073b3 },
	{ 0x0000e0dd, 0x000073ce },
	{ 0x0000e0de, 0x000073bb },
	{ 0x0000e0df, 0x000073c0 },
	{ 0x0000e0e0, 0x000073e5 },
	{ 0x0000e0e1, 0x000073ee },
	{ 0x0000e0e2, 0x000073de },
	{ 0x0000e0e3, 0x000074a2 },
	{ 0x0000e0e4, 0x00007405 },
	{ 0x0000e0e5, 0x0000746f },
	{ 0x0000e0e6, 0x00007425 },
	{ 0x0000e0e7, 0x000073f8 },
	{ 0x0000e0e8, 0x00007432 },
	{ 0x0000e0e9, 0x0000743a },
	{ 0x0000e0ea, 0x00007455 },
	{ 0x0000e0eb, 0x0000743f },
	{ 0x0000e0ec, 0x0000745f },
	{ 0x0000e0ed, 0x00007459 },
	{ 0x0000e0ee, 0x00007441 },
	{ 0x0000e0ef, 0x0000745c },
	{ 0x0000e0f0, 0x00007469 },
	{ 0x0000e0f1, 0x00007470 },
	{ 0x0000e0f2, 0x00007463 },
	{ 0x0000e0f3, 0x0000746a },
	{ 0x0000e0f4, 0x00007476 },
	{ 0x0000e0f5, 0x0000747e },
	{ 0x0000e0f6, 0x0000748b },
	{ 0x0000e0f7, 0x0000749e },
	{ 0x0000e0f8, 0x000074a7 },
	{ 0x0000e0f9, 0x000074ca },
	{ 0x0000e0fa, 0x000074cf },
	{ 0x0000e0fb, 0x000074d4 },
	{ 0x0000e0fc, 0x000073f1 },
	{ 0x0000e140, 0x000074e0 },
	{ 0x0000e141, 0x000074e3 },
	{ 0x0000e142, 0x000074e7 },
	{ 0x0000e143, 0x000074e9 },
	{ 0x0000e144, 0x000074ee },
	{ 0x0000e145, 0x000074f2 },
	{ 0x0000e146, 0x000074f0 },
	{ 0x0000e147, 0x000074f1 },
	{ 0x0000e148, 0x000074f8 },
	{ 0x0000e149, 0x000074f7 },
	{ 0x0000e14a, 0x00007504 },
	{ 0x0000e14b, 0x00007503 },
	{ 0x0000e14c, 0x00007505 },
	{ 0x0000e14d, 0x0000750c },
	{ 0x0000e14e, 0x0000750e },
	{ 0x0000e14f, 0x0000750d },
	{ 0x0000e150, 0x00007515 },
	{ 0x0000e151, 0x00007513 },
	{ 0x0000e152, 0x0000751e },
	{ 0x0000e153, 0x00007526 },
	{ 0x0000e154, 0x0000752c },
	{ 0x0000e155, 0x0000753c },
	{ 0x0000e156, 0x00007544 },
	{ 0x0000e157, 0x0000754d },
	{ 0x0000e158, 0x0000754a },
	{ 0x0000e159, 0x00007549 },
	{ 0x0000e15a, 0x0000755b },
	{ 0x0000e15b, 0x00007546 },
	{ 0x0000e15c, 0x0000755a },
	{ 0x0000e15d, 0x00007569 },
	{ 0x0000e15e, 0x00007564 },
	{ 0x0000e15f, 0x00007567 },
	{ 0x0000e160, 0x0000756b },
	{ 0x0000e161, 0x0000756d },
	{ 0x0000e162, 0x00007578 },
	{ 0x0000e163, 0x00007576 },
	{ 0x0000e164, 0x00007586 },
	{ 0x0000e165, 0x00007587 },
	{ 0x0000e166, 0x00007574 },
	{ 0x0000e167, 0x0000758a },
	{ 0x0000e168, 0x00007589 },
	{ 0x0000e169, 0x00007582 },
	{ 0x0000e16a, 0x00007594 },
	{ 0x0000e16b, 0x0000759a },
	{ 0x0000e16c, 0x0000759d },
	{ 0x0000e16d, 0x000075a5 },
	{ 0x0000e16e, 0x000075a3 },
	{ 0x0000e16f, 0x000075c2 },
	{ 0x0000e170, 0x000075b3 },
	{ 0x0000e171, 0x000075c3 },
	{ 0x0000e172, 0x000075b5 },
	{ 0x0000e173, 0x000075bd },
	{ 0x0000e174, 0x000075b8 },
	{ 0x0000e175, 0x000075bc },
	{ 0x0000e176, 0x000075b1 },
	{ 0x0000e177, 0x000075cd },
	{ 0x0000e178, 0x000075ca },
	{ 0x0000e179, 0x000075d2 },
	{ 0x0000e17a, 0x000075d9 },
	{ 0x0000e17b, 0x000075e3 },
	{ 0x0000e17c, 0x000075de },
	{ 0x0000e17d, 0x000075fe },
	{ 0x0000e17e, 0x000075ff },
	{ 0x0000e180, 0x000075fc },
	{ 0x0000e181, 0x00007601 },
	{ 0x0000e182, 0x000075f0 },
	{ 0x0000e183, 0x000075fa },
	{ 0x0000e184, 0x000075f2 },
	{ 0x0000e185, 0x000075f3 },
	{ 0x0000e186, 0x0000760b },
	{ 0x0000e187, 0x0000760d },
	{ 0x0000e188, 0x00007609 },
	{ 0x0000e189, 0x0000761f },
	{ 0x0000e18a, 0x00007627 },
	{ 0x0000e18b, 0x00007620 },
	{ 0x0000e18c, 0x00007621 },
	{ 0x0000e18d, 0x00007622 },
	{ 0x0000e18e, 0x00007624 },
	{ 0x0000e18f, 0x00007634 },
	{ 0x0000e190, 0x00007630 },
	{ 0x0000e191, 0x0000763b },
	{ 0x0000e192, 0x00007647 },
	{ 0x0000e193, 0x00007648 },
	{ 0x0000e194, 0x00007646 },
	{ 0x0000e195, 0x0000765c },
	{ 0x0000e196, 0x00007658 },
	{ 0x0000e197, 0x00007661 },
	{ 0x0000e198, 0x00007662 },
	{ 0x0000e199, 0x00007668 },
	{ 0x0000e19a, 0x00007669 },
	{ 0x0000e19b, 0x0000766a },
	{ 0x0000e19c, 0x00007667 },
	{ 0x0000e19d, 0x0000766c },
	{ 0x0000e19e, 0x00007670 },
	{ 0x0000e19f, 0x00007672 },
	{ 0x0000e1a0, 0x00007676 },
	{ 0x0000e1a1, 0x00007678 },
	{ 0x0000e1a2, 0x0000767c },
	{ 0x0000e1a3, 0x00007680 },
	{ 0x0000e1a4, 0x00007683 },
	{ 0x0000e1a5, 0x00007688 },
	{ 0x0000e1a6, 0x0000768b },
	{ 0x0000e1a7, 0x0000768e },
	{ 0x0000e1a8, 0x00007696 },
	{ 0x0000e1a9, 0x00007693 },
	{ 0x0000e1aa, 0x00007699 },
	{ 0x0000e1ab, 0x0000769a },
	{ 0x0000e1ac, 0x000076b0 },
	{ 0x0000e1ad, 0x000076b4 },
	{ 0x0000e1ae, 0x000076b8 },
	{ 0x0000e1af, 0x000076b9 },
	{ 0x0000e1b0, 0x000076ba },
	{ 0x0000e1b1, 0x000076c2 },
	{ 0x0000e1b2, 0x000076cd },
	{ 0x0000e1b3, 0x000076d6 },
	{ 0x0000e1b4, 0x000076d2 },
	{ 0x0000e1b5, 0x000076de },
	{ 0x0000e1b6, 0x000076e1 },
	{ 0x0000e1b7, 0x000076e5 },
	{ 0x0000e1b8, 0x000076e7 },
	{ 0x0000e1b9, 0x000076ea },
	{ 0x0000e1ba, 0x0000862f },
	{ 0x0000e1bb, 0x000076fb },
	{ 0x0000e1bc, 0x00007708 },
	{ 0x0000e1bd, 0x00007707 },
	{ 0x0000e1be, 0x00007704 },
	{ 0x0000e1bf, 0x00007729 },
	{ 0x0000e1c0, 0x00007724 },
	{ 0x0000e1c1, 0x0000771e },
	{ 0x0000e1c2, 0x00007725 },
	{ 0x0000e1c3, 0x00007726 },
	{ 0x0000e1c4, 0x0000771b },
	{ 0x0000e1c5, 0x00007737 },
	{ 0x0000e1c6, 0x00007738 },
	{ 0x0000e1c7, 0x00007747 },
	{ 0x0000e1c8, 0x0000775a },
	{ 0x0000e1c9, 0x00007768 },
	{ 0x0000e1ca, 0x0000776b },
	{ 0x0000e1cb, 0x0000775b },
	{ 0x0000e1cc, 0x00007765 },
	{ 0x0000e1cd, 0x0000777f },
	{ 0x0000e1ce, 0x0000777e },
	{ 0x0000e1cf, 0x00007779 },
	{ 0x0000e1d0, 0x0000778e },
	{ 0x0000e1d1, 0x0000778b },
	{ 0x0000e1d2, 0x00007791 },
	{ 0x0000e1d3, 0x000077a0 },
	{ 0x0000e1d4, 0x0000779e },
	{ 0x0000e1d5, 0x000077b0 },
	{ 0x0000e1d6, 0x000077b6 },
	{ 0x0000e1d7, 0x000077b9 },
	{ 0x0000e1d8, 0x000077bf },
	{ 0x0000e1d9, 0x000077bc },
	{ 0x0000e1da, 0x000077bd },
	{ 0x0000e1db, 0x000077bb },
	{ 0x0000e1dc, 0x000077c7 },
	{ 0x0000e1dd, 0x000077cd },
	{ 0x0000e1de, 0x000077d7 },
	{ 0x0000e1df, 0x000077da },
	{ 0x0000e1e0, 0x000077dc },
	{ 0x0000e1e1, 0x000077e3 },
	{ 0x0000e1e2, 0x000077ee },
	{ 0x0000e1e3, 0x000077fc },
	{ 0x0000e1e4, 0x0000780c },
	{ 0x0000e1e5, 0x00007812 },
	{ 0x0000e1e6, 0x00007926 },
	{ 0x0000e1e7, 0x00007820 },
	{ 0x0000e1e8, 0x0000792a },
	{ 0x0000e1e9, 0x00007845 },
	{ 0x0000e1ea, 0x0000788e },
	{ 0x0000e1eb, 0x00007874 },
	{ 0x0000e1ec, 0x00007886 },
	{ 0x0000e1ed, 0x0000787c },
	{ 0x0000e1ee, 0x0000789a },
	{ 0x0000e1ef, 0x0000788c },
	{ 0x0000e1f0, 0x000078a3 },
	{ 0x0000e1f1, 0x000078b5 },
	{ 0x0000e1f2, 0x000078aa },
	{ 0x0000e1f3, 0x000078af },
	{ 0x0000e1f4, 0x000078d1 },
	{ 0x0000e1f5, 0x000078c6 },
	{ 0x0000e1f6, 0x000078cb },
	{ 0x0000e1f7, 0x000078d4 },
	{ 0x0000e1f8, 0x000078be },
	{ 0x0000e1f9, 0x000078bc },
	{ 0x0000e1fa, 0x000078c5 },
	{ 0x0000e1fb, 0x000078ca },
	{ 0x0000e1fc, 0x000078ec },
	{ 0x0000e240, 0x000078e7 },
	{ 0x0000e241, 0x000078da },
	{ 0x0000e242, 0x000078fd },
	{ 0x0000e243, 0x000078f4 },
	{ 0x0000e244, 0x00007907 },
	{ 0x0000e245, 0x00007912 },
	{ 0x0000e246, 0x00007911 },
	{ 0x0000e247, 0x00007919 },
	{ 0x0000e248, 0x0000792c },
	{ 0x0000e249, 0x0000792b },
	{ 0x0000e24a, 0x00007940 },
	{ 0x0000e24b, 0x00007960 },
	{ 0x0000e24c, 0x00007957 },
	{ 0x0000e24d, 0x0000795f },
	{ 0x0000e24e, 0x0000795a },
	{ 0x0000e24f, 0x00007955 },
	{ 0x0000e250, 0x00007953 },
	{ 0x0000e251, 0x0000797a },
	{ 0x0000e252, 0x0000797f },
	{ 0x0000e253, 0x0000798a },
	{ 0x0000e254, 0x0000799d },
	{ 0x0000e255, 0x000079a7 },
	{ 0x0000e256, 0x00009f4b },
	{ 0x0000e257, 0x000079aa },
	{ 0x0000e258, 0x000079ae },
	{ 0x0000e259, 0x000079b3 },
	{ 0x0000e25a, 0x000079b9 },
	{ 0x0000e25b, 0x000079ba },
	{ 0x0000e25c, 0x000079c9 },
	{ 0x0000e25d, 0x000079d5 },
	{ 0x0000e25e, 0x000079e7 },
	{ 0x0000e25f, 0x000079ec },
	{ 0x0000e260, 0x000079e1 },
	{ 0x0000e261, 0x000079e3 },
	{ 0x0000e262, 0x00007a08 },
	{ 0x0000e263, 0x00007a0d },
	{ 0x0000e264, 0x00007a18 },
	{ 0x0000e265, 0x00007a19 },
	{ 0x0000e266, 0x00007a20 },
	{ 0x0000e267, 0x00007a1f },
	{ 0x0000e268, 0x00007980 },
	{ 0x0000e269, 0x00007a31 },
	{ 0x0000e26a, 0x00007a3b },
	{ 0x0000e26b, 0x00007a3e },
	{ 0x0000e26c, 0x00007a37 },
	{ 0x0000e26d, 0x00007a43 },
	{ 0x0000e26e, 0x00007a57 },
	{ 0x0000e26f, 0x00007a49 },
	{ 0x0000e270, 0x00007a61 },
	{ 0x0000e271, 0x00007a62 },
	{ 0x0000e272, 0x00007a69 },
	{ 0x0000e273, 0x00009f9d },
	{ 0x0000e274, 0x00007a70 },
	{ 0x0000e275, 0x00007a79 },
	{ 0x0000e276, 0x00007a7d },
	{ 0x0000e277, 0x00007a88 },
	{ 0x0000e278, 0x00007a97 },
	{ 0x0000e279, 0x00007a95 },
	{ 0x0000e27a, 0x00007a98 },
	{ 0x0000e27b, 0x00007a96 },
	{ 0x0000e27c, 0x00007aa9 },
	{ 0x0000e27d, 0x00007ac8 },
	{ 0x0000e27e, 0x00007ab0 },
	{ 0x0000e280, 0x00007ab6 },
	{ 0x0000e281, 0x00007ac5 },
	{ 0x0000e282, 0x00007ac4 },
	{ 0x0000e283, 0x00007abf },
	{ 0x0000e284, 0x00009083 },
	{ 0x0000e285, 0x00007ac7 },
	{ 0x0000e286, 0x00007aca },
	{ 0x0000e287, 0x00007acd },
	{ 0x0000e288, 0x00007acf },
	{ 0x0000e289, 0x00007ad5 },
	{ 0x0000e28a, 0x00007ad3 },
	{ 0x0000e28b, 0x00007ad9 },
	{ 0x0000e28c, 0x00007ada },
	{ 0x0000e28d, 0x00007add },
	{ 0x0000e28e, 0x00007ae1 },
	{ 0x0000e28f, 0x00007ae2 },
	{ 0x0000e290, 0x00007ae6 },
	{ 0x0000e291, 0x00007aed },
	{ 0x0000e292, 0x00007af0 },
	{ 0x0000e293, 0x00007b02 },
	{ 0x0000e294, 0x00007b0f },
	{ 0x0000e295, 0x00007b0a },
	{ 0x0000e296, 0x00007b06 },
	{ 0x0000e297, 0x00007b33 },
	{ 0x0000e298, 0x00007b18 },
	{ 0x0000e299, 0x00007b19 },
	{ 0x0000e29a, 0x00007b1e },
	{ 0x0000e29b, 0x00007b35 },
	{ 0x0000e29c, 0x00007b28 },
	{ 0x0000e29d, 0x00007b36 },
	{ 0x0000e29e, 0x00007b50 },
	{ 0x0000e29f, 0x00007b7a },
	{ 0x0000e2a0, 0x00007b04 },
	{ 0x0000e2a1, 0x00007b4d },
	{ 0x0000e2a2, 0x00007b0b },
	{ 0x0000e2a3, 0x00007b4c },
	{ 0x0000e2a4, 0x00007b45 },
	{ 0x0000e2a5, 0x00007b75 },
	{ 0x0000e2a6, 0x00007b65 },
	{ 0x0000e2a7, 0x00007b74 },
	{ 0x0000e2a8, 0x00007b67 },
	{ 0x0000e2a9, 0x00007b70 },
	{ 0x0000e2aa, 0x00007b71 },
	{ 0x0000e2ab, 0x00007b6c },
	{ 0x0000e2ac, 0x00007b6e },
	{ 0x0000e2ad, 0x00007b9d },
	{ 0x0000e2ae, 0x00007b98 },
	{ 0x0000e2af, 0x00007b9f },
	{ 0x0000e2b0, 0x00007b8d },
	{ 0x0000e2b1, 0x00007b9c },
	{ 0x0000e2b2, 0x00007b9a },
	{ 0x0000e2b3, 0x00007b8b },
	{ 0x0000e2b4, 0x00007b92 },
	{ 0x0000e2b5, 0x00007b8f },
	{ 0x0000e2b6, 0x00007b5d },
	{ 0x0000e2b7, 0x00007b99 },
	{ 0x0000e2b8, 0x00007bcb },
	{ 0x0000e2b9, 0x00007bc1 },
	{ 0x0000e2ba, 0x00007bcc },
	{ 0x0000e2bb, 0x00007bcf },
	{ 0x0000e2bc, 0x00007bb4 },
	{ 0x0000e2bd, 0x00007bc6 },
	{ 0x0000e2be, 0x00007bdd },
	{ 0x0000e2bf, 0x00007be9 },
	{ 0x0000e2c0, 0x00007c11 },
	{ 0x0000e2c1, 0x00007c14 },
	{ 0x0000e2c2, 0x00007be6 },
	{ 0x0000e2c3, 0x00007be5 },
	{ 0x0000e2c4, 0x00007c60 },
	{ 0x0000e2c5, 0x00007c00 },
	{ 0x0000e2c6, 0x00007c07 },
	{ 0x0000e2c7, 0x00007c13 },
	{ 0x0000e2c8, 0x00007bf3 },
	{ 0x0000e2c9, 0x00007bf7 },
	{ 0x0000e2ca, 0x00007c17 },
	{ 0x0000e2cb, 0x00007c0d },
	{ 0x0000e2cc, 0x00007bf6 },
	{ 0x0000e2cd, 0x00007c23 },
	{ 0x0000e2ce, 0x00007c27 },
	{ 0x0000e2cf, 0x00007c2a },
	{ 0x0000e2d0, 0x00007c1f },
	{ 0x0000e2d1, 0x00007c37 },
	{ 0x0000e2d2, 0x00007c2b },
	{ 0x0000e2d3, 0x00007c3d },
	{ 0x0000e2d4, 0x00007c4c },
	{ 0x0000e2d5, 0x00007c43 },
	{ 0x0000e2d6, 0x00007c54 },
	{ 0x0000e2d7, 0x00007c4f },
	{ 0x0000e2d8, 0x00007c40 },
	{ 0x0000e2d9, 0x00007c50 },
	{ 0x0000e2da, 0x00007c58 },
	{ 0x0000e2db, 0x00007c5f },
	{ 0x0000e2dc, 0x00007c64 },
	{ 0x0000e2dd, 0x00007c56 },
	{ 0x0000e2de, 0x00007c65 },
	{ 0x0000e2df, 0x00007c6c },
	{ 0x0000e2e0, 0x00007c75 },
	{ 0x0000e2e1, 0x00007c83 },
	{ 0x0000e2e2, 0x00007c90 },
	{ 0x0000e2e3, 0x00007ca4 },
	{ 0x0000e2e4, 0x00007cad },
	{ 0x0000e2e5, 0x00007ca2 },
	{ 0x0000e2e6, 0x00007cab },
	{ 0x0000e2e7, 0x00007ca1 },
	{ 0x0000e2e8, 0x00007ca8 },
	{ 0x0000e2e9, 0x00007cb3 },
	{ 0x0000e2ea, 0x00007cb2 },
	{ 0x0000e2eb, 0x00007cb1 },
	{ 0x0000e2ec, 0x00007cae },
	{ 0x0000e2ed, 0x00007cb9 },
	{ 0x0000e2ee, 0x00007cbd },
	{ 0x0000e2ef, 0x00007cc0 },
	{ 0x0000e2f0, 0x00007cc5 },
	{ 0x0000e2f1, 0x00007cc2 },
	{ 0x0000e2f2, 0x00007cd8 },
	{ 0x0000e2f3, 0x00007cd2 },
	{ 0x0000e2f4, 0x00007cdc },
	{ 0x0000e2f5, 0x00007ce2 },
	{ 0x0000e2f6, 0x00009b3b },
	{ 0x0000e2f7, 0x00007cef },
	{ 0x0000e2f8, 0x00007cf2 },
	{ 0x0000e2f9, 0x00007cf4 },
	{ 0x0000e2fa, 0x00007cf6 },
	{ 0x0000e2fb, 0x00007cfa },
	{ 0x0000e2fc, 0x00007d06 },
	{ 0x0000e340, 0x00007d02 },
	{ 0x0000e341, 0x00007d1c },
	{ 0x0000e342, 0x00007d15 },
	{ 0x0000e343, 0x00007d0a },
	{ 0x0000e344, 0x00007d45 },
	{ 0x0000e345, 0x00007d4b },
	{ 0x0000e346, 0x00007d2e },
	{ 0x0000e347, 0x00007d32 },
	{ 0x0000e348, 0x00007d3f },
	{ 0x0000e349, 0x00007d35 },
	{ 0x0000e34a, 0x00007d46 },
	{ 0x0000e34b, 0x00007d73 },
	{ 0x0000e34c, 0x00007d56 },
	{ 0x0000e34d, 0x00007d4e },
	{ 0x0000e34e, 0x00007d72 },
	{ 0x0000e34f, 0x00007d68 },
	{ 0x0000e350, 0x00007d6e },
	{ 0x0000e351, 0x00007d4f },
	{ 0x0000e352, 0x00007d63 },
	{ 0x0000e353, 0x00007d93 },
	{ 0x0000e354, 0x00007d89 },
	{ 0x0000e355, 0x00007d5b },
	{ 0x0000e356, 0x00007d8f },
	{ 0x0000e357, 0x00007d7d },
	{ 0x0000e358, 0x00007d9b },
	{ 0x0000e359, 0x00007dba },
	{ 0x0000e35a, 0x00007dae },
	{ 0x0000e35b, 0x00007da3 },
	{ 0x0000e35c, 0x00007db5 },
	{ 0x0000e35d, 0x00007dc7 },
	{ 0x0000e35e, 0x00007dbd },
	{ 0x0000e35f, 0x00007dab },
	{ 0x0000e360, 0x00007e3d },
	{ 0x0000e361, 0x00007da2 },
	{ 0x0000e362, 0x00007daf },
	{ 0x0000e363, 0x00007ddc },
	{ 0x0000e364, 0x00007db8 },
	{ 0x0000e365, 0x00007d9f },
	{ 0x0000e366, 0x00007db0 },
	{ 0x0000e367, 0x00007dd8 },
	{ 0x0000e368, 0x00007ddd },
	{ 0x0000e369, 0x00007de4 },
	{ 0x0000e36a, 0x00007dde },
	{ 0x0000e36b, 0x00007dfb },
	{ 0x0000e36c, 0x00007df2 },
	{ 0x0000e36d, 0x00007de1 },
	{ 0x0000e36e, 0x00007e05 },
	{ 0x0000e36f, 0x00007e0a },
	{ 0x0000e370, 0x00007e23 },
	{ 0x0000e371, 0x00007e21 },
	{ 0x0000e372, 0x00007e12 },
	{ 0x0000e373, 0x00007e31 },
	{ 0x0000e374, 0x00007e1f },
	{ 0x0000e375, 0x00007e09 },
	{ 0x0000e376, 0x00007e0b },
	{ 0x0000e377, 0x00007e22 },
	{ 0x0000e378, 0x00007e46 },
	{ 0x0000e379, 0x00007e66 },
	{ 0x0000e37a, 0x00007e3b },
	{ 0x0000e37b, 0x00007e35 },
	{ 0x0000e37c, 0x00007e39 },
	{ 0x0000e37d, 0x00007e43 },
	{ 0x0000e37e, 0x00007e37 },
	{ 0x0000e380, 0x00007e32 },
	{ 0x0000e381, 0x00007e3a },
	{ 0x0000e382, 0x00007e67 },
	{ 0x0000e383, 0x00007e5d },
	{ 0x0000e384, 0x00007e56 },
	{ 0x0000e385, 0x00007e5e },
	{ 0x0000e386, 0x00007e59 },
	{ 0x0000e387, 0x00007e5a },
	{ 0x0000e388, 0x00007e79 },
	{ 0x0000e389, 0x00007e6a },
	{ 0x0000e38a, 0x00007e69 },
	{ 0x0000e38b, 0x00007e7c },
	{ 0x0000e38c, 0x00007e7b },
	{ 0x0000e38d, 0x00007e83 },
	{ 0x0000e38e, 0x00007dd5 },
	{ 0x0000e38f, 0x00007e7d },
	{ 0x0000e390, 0x00008fae },
	{ 0x0000e391, 0x00007e7f },
	{ 0x0000e392, 0x00007e88 },
	{ 0x0000e393, 0x00007e89 },
	{ 0x0000e394, 0x00007e8c },
	{ 0x0000e395, 0x00007e92 },
	{ 0x0000e396, 0x00007e90 },
	{ 0x0000e397, 0x00007e93 },
	{ 0x0000e398, 0x00007e94 },
	{ 0x0000e399, 0x00007e96 },
	{ 0x0000e39a, 0x00007e8e },
	{ 0x0000e39b, 0x00007e9b },
	{ 0x0000e39c, 0x00007e9c },
	{ 0x0000e39d, 0x00007f38 },
	{ 0x0000e39e, 0x00007f3a },
	{ 0x0000e39f, 0x00007f45 },
	{ 0x0000e3a0, 0x00007f4c },
	{ 0x0000e3a1, 0x00007f4d },
	{ 0x0000e3a2, 0x00007f4e },
	{ 0x0000e3a3, 0x00007f50 },
	{ 0x0000e3a4, 0x00007f51 },
	{ 0x0000e3a5, 0x00007f55 },
	{ 0x0000e3a6, 0x00007f54 },
	{ 0x0000e3a7, 0x00007f58 },
	{ 0x0000e3a8, 0x00007f5f },
	{ 0x0000e3a9, 0x00007f60 },
	{ 0x0000e3aa, 0x00007f68 },
	{ 0x0000e3ab, 0x00007f69 },
	{ 0x0000e3ac, 0x00007f67 },
	{ 0x0000e3ad, 0x00007f78 },
	{ 0x0000e3ae, 0x00007f82 },
	{ 0x0000e3af, 0x00007f86 },
	{ 0x0000e3b0, 0x00007f83 },
	{ 0x0000e3b1, 0x00007f88 },
	{ 0x0000e3b2, 0x00007f87 },
	{ 0x0000e3b3, 0x00007f8c },
	{ 0x0000e3b4, 0x00007f94 },
	{ 0x0000e3b5, 0x00007f9e },
	{ 0x0000e3b6, 0x00007f9d },
	{ 0x0000e3b7, 0x00007f9a },
	{ 0x0000e3b8, 0x00007fa3 },
	{ 0x0000e3b9, 0x00007faf },
	{ 0x0000e3ba, 0x00007fb2 },
	{ 0x0000e3bb, 0x00007fb9 },
	{ 0x0000e3bc, 0x00007fae },
	{ 0x0000e3bd, 0x00007fb6 },
	{ 0x0000e3be, 0x00007fb8 },
	{ 0x0000e3bf, 0x00008b71 },
	{ 0x0000e3c0, 0x00007fc5 },
	{ 0x0000e3c1, 0x00007fc6 },
	{ 0x0000e3c2, 0x00007fca },
	{ 0x0000e3c3, 0x00007fd5 },
	{ 0x0000e3c4, 0x00007fd4 },
	{ 0x0000e3c5, 0x00007fe1 },
	{ 0x0000e3c6, 0x00007fe6 },
	{ 0x0000e3c7, 0x00007fe9 },
	{ 0x0000e3c8, 0x00007ff3 },
	{ 0x0000e3c9, 0x00007ff9 },
	{ 0x0000e3ca, 0x000098dc },
	{ 0x0000e3cb, 0x00008006 },
	{ 0x0000e3cc, 0x00008004 },
	{ 0x0000e3cd, 0x0000800b },
	{ 0x0000e3ce, 0x00008012 },
	{ 0x0000e3cf, 0x00008018 },
	{ 0x0000e3d0, 0x00008019 },
	{ 0x0000e3d1, 0x0000801c },
	{ 0x0000e3d2, 0x00008021 },
	{ 0x0000e3d3, 0x00008028 },
	{ 0x0000e3d4, 0x0000803f },
	{ 0x0000e3d5, 0x0000803b },
	{ 0x0000e3d6, 0x0000804a },
	{ 0x0000e3d7, 0x00008046 },
	{ 0x0000e3d8, 0x00008052 },
	{ 0x0000e3d9, 0x00008058 },
	{ 0x0000e3da, 0x0000805a },
	{ 0x0000e3db, 0x0000805f },
	{ 0x0000e3dc, 0x00008062 },
	{ 0x0000e3dd, 0x00008068 },
	{ 0x0000e3de, 0x00008073 },
	{ 0x0000e3df, 0x00008072 },
	{ 0x0000e3e0, 0x00008070 },
	{ 0x0000e3e1, 0x00008076 },
	{ 0x0000e3e2, 0x00008079 },
	{ 0x0000e3e3, 0x0000807d },
	{ 0x0000e3e4, 0x0000807f },
	{ 0x0000e3e5, 0x00008084 },
	{ 0x0000e3e6, 0x00008086 },
	{ 0x0000e3e7, 0x00008085 },
	{ 0x0000e3e8, 0x0000809b },
	{ 0x0000e3e9, 0x00008093 },
	{ 0x0000e3ea, 0x0000809a },
	{ 0x0000e3eb, 0x000080ad },
	{ 0x0000e3ec, 0x00005190 },
	{ 0x0000e3ed, 0x000080ac },
	{ 0x0000e3ee, 0x000080db },
	{ 0x0000e3ef, 0x000080e5 },
	{ 0x0000e3f0, 0x000080d9 },
	{ 0x0000e3f1, 0x000080dd },
	{ 0x0000e3f2, 0x000080c4 },
	{ 0x0000e3f3, 0x000080da },
	{ 0x0000e3f4, 0x000080d6 },
	{ 0x0000e3f5, 0x00008109 },
	{ 0x0000e3f6, 0x000080ef },
	{ 0x0000e3f7, 0x000080f1 },
	{ 0x0000e3f8, 0x0000811b },
	{ 0x0000e3f9, 0x00008129 },
	{ 0x0000e3fa, 0x00008123 },
	{ 0x0000e3fb, 0x0000812f },
	{ 0x0000e3fc, 0x0000814b },
	{ 0x0000e440, 0x0000968b },
	{ 0x0000e441, 0x00008146 },
	{ 0x0000e442, 0x0000813e },
	{ 0x0000e443, 0x00008153 },
	{ 0x0000e444, 0x00008151 },
	{ 0x0000e445, 0x000080fc },
	{ 0x0000e446, 0x00008171 },
	{ 0x0000e447, 0x0000816e },
	{ 0x0000e448, 0x00008165 },
	{ 0x0000e449, 0x00008166 },
	{ 0x0000e44a, 0x00008174 },
	{ 0x0000e44b, 0x00008183 },
	{ 0x0000e44c, 0x00008188 },
	{ 0x0000e44d, 0x0000818a },
	{ 0x0000e44e, 0x00008180 },
	{ 0x0000e44f, 0x00008182 },
	{ 0x0000e450, 0x000081a0 },
	{ 0x0000e451, 0x00008195 },
	{ 0x0000e452, 0x000081a4 },
	{ 0x0000e453, 0x000081a3 },
	{ 0x0000e454, 0x0000815f },
	{ 0x0000e455, 0x00008193 },
	{ 0x0000e456, 0x000081a9 },
	{ 0x0000e457, 0x000081b0 },
	{ 0x0000e458, 0x000081b5 },
	{ 0x0000e459, 0x000081be },
	{ 0x0000e45a, 0x000081b8 },
	{ 0x0000e45b, 0x000081bd },
	{ 0x0000e45c, 0x000081c0 },
	{ 0x0000e45d, 0x000081c2 },
	{ 0x0000e45e, 0x000081ba },
	{ 0x0000e45f, 0x000081c9 },
	{ 0x0000e460, 0x000081cd },
	{ 0x0000e461, 0x000081d1 },
	{ 0x0000e462, 0x000081d9 },
	{ 0x0000e463, 0x000081d8 },
	{ 0x0000e464, 0x000081c8 },
	{ 0x0000e465, 0x000081da },
	{ 0x0000e466, 0x000081df },
	{ 0x0000e467, 0x000081e0 },
	{ 0x0000e468, 0x000081e7 },
	{ 0x0000e469, 0x000081fa },
	{ 0x0000e46a, 0x000081fb },
	{ 0x0000e46b, 0x000081fe },
	{ 0x0000e46c, 0x00008201 },
	{ 0x0000e46d, 0x00008202 },
	{ 0x0000e46e, 0x00008205 },
	{ 0x0000e46f, 0x00008207 },
	{ 0x0000e470, 0x0000820a },
	{ 0x0000e471, 0x0000820d },
	{ 0x0000e472, 0x00008210 },
	{ 0x0000e473, 0x00008216 },
	{ 0x0000e474, 0x00008229 },
	{ 0x0000e475, 0x0000822b },
	{ 0x0000e476, 0x00008238 },
	{ 0x0000e477, 0x00008233 },
	{ 0x0000e478, 0x00008240 },
	{ 0x0000e479, 0x00008259 },
	{ 0x0000e47a, 0x00008258 },
	{ 0x0000e47b, 0x0000825d },
	{ 0x0000e47c, 0x0000825a },
	{ 0x0000e47d, 0x0000825f },
	{ 0x0000e47e, 0x00008264 },
	{ 0x0000e480, 0x00008262 },
	{ 0x0000e481, 0x00008268 },
	{ 0x0000e482, 0x0000826a },
	{ 0x0000e483, 0x0000826b },
	{ 0x0000e484, 0x0000822e },
	{ 0x0000e485, 0x00008271 },
	{ 0x0000e486, 0x00008277 },
	{ 0x0000e487, 0x00008278 },
	{ 0x0000e488, 0x0000827e },
	{ 0x0000e489, 0x0000828d },
	{ 0x0000e48a, 0x00008292 },
	{ 0x0000e48b, 0x000082ab },
	{ 0x0000e48c, 0x0000829f },
	{ 0x0000e48d, 0x000082bb },
	{ 0x0000e48e, 0x000082ac },
	{ 0x0000e48f, 0x000082e1 },
	{ 0x0000e490, 0x000082e3 },
	{ 0x0000e491, 0x000082df },
	{ 0x0000e492, 0x000082d2 },
	{ 0x0000e493, 0x000082f4 },
	{ 0x0000e494, 0x000082f3 },
	{ 0x0000e495, 0x000082fa },
	{ 0x0000e496, 0x00008393 },
	{ 0x0000e497, 0x00008303 },
	{ 0x0000e498, 0x000082fb },
	{ 0x0000e499, 0x000082f9 },
	{ 0x0000e49a, 0x000082de },
	{ 0x0000e49b, 0x00008306 },
	{ 0x0000e49c, 0x000082dc },
	{ 0x0000e49d, 0x00008309 },
	{ 0x0000e49e, 0x000082d9 },
	{ 0x0000e49f, 0x00008335 },
	{ 0x0000e4a0, 0x00008334 },
	{ 0x0000e4a1, 0x00008316 },
	{ 0x0000e4a2, 0x00008332 },
	{ 0x0000e4a3, 0x00008331 },
	{ 0x0000e4a4, 0x00008340 },
	{ 0x0000e4a5, 0x00008339 },
	{ 0x0000e4a6, 0x00008350 },
	{ 0x0000e4a7, 0x00008345 },
	{ 0x0000e4a8, 0x0000832f },
	{ 0x0000e4a9, 0x0000832b },
	{ 0x0000e4aa, 0x00008317 },
	{ 0x0000e4ab, 0x00008318 },
	{ 0x0000e4ac, 0x00008385 },
	{ 0x0000e4ad, 0x0000839a },
	{ 0x0000e4ae, 0x000083aa },
	{ 0x0000e4af, 0x0000839f },
	{ 0x0000e4b0, 0x000083a2 },
	{ 0x0000e4b1, 0x00008396 },
	{ 0x0000e4b2, 0x00008323 },
	{ 0x0000e4b3, 0x0000838e },
	{ 0x0000e4b4, 0x00008387 },
	{ 0x0000e4b5, 0x0000838a },
	{ 0x0000e4b6, 0x0000837c },
	{ 0x0000e4b7, 0x000083b5 },
	{ 0x0000e4b8, 0x00008373 },
	{ 0x0000e4b9, 0x00008375 },
	{ 0x0000e4ba, 0x000083a0 },
	{ 0x0000e4bb, 0x00008389 },
	{ 0x0000e4bc, 0x000083a8 },
	{ 0x0000e4bd, 0x000083f4 },
	{ 0x0000e4be, 0x00008413 },
	{ 0x0000e4bf, 0x000083eb },
	{ 0x0000e4c0, 0x000083ce },
	{ 0x0000e4c1, 0x000083fd },
	{ 0x0000e4c2, 0x00008403 },
	{ 0x0000e4c3, 0x000083d8 },
	{ 0x0000e4c4, 0x0000840b },
	{ 0x0000e4c5, 0x000083c1 },
	{ 0x0000e4c6, 0x000083f7 },
	{ 0x0000e4c7, 0x00008407 },
	{ 0x0000e4c8, 0x000083e0 },
	{ 0x0000e4c9, 0x000083f2 },
	{ 0x0000e4ca, 0x0000840d },
	{ 0x0000e4cb, 0x00008422 },
	{ 0x0000e4cc, 0x00008420 },
	{ 0x0000e4cd, 0x000083bd },
	{ 0x0000e4ce, 0x00008438 },
	{ 0x0000e4cf, 0x00008506 },
	{ 0x0000e4d0, 0x000083fb },
	{ 0x0000e4d1, 0x0000846d },
	{ 0x0000e4d2, 0x0000842a },
	{ 0x0000e4d3, 0x0000843c },
	{ 0x0000e4d4, 0x0000855a },
	{ 0x0000e4d5, 0x00008484 },
	{ 0x0000e4d6, 0x00008477 },
	{ 0x0000e4d7, 0x0000846b },
	{ 0x0000e4d8, 0x000084ad },
	{ 0x0000e4d9, 0x0000846e },
	{ 0x0000e4da, 0x00008482 },
	{ 0x0000e4db, 0x00008469 },
	{ 0x0000e4dc, 0x00008446 },
	{ 0x0000e4dd, 0x0000842c },
	{ 0x0000e4de, 0x0000846f },
	{ 0x0000e4df, 0x00008479 },
	{ 0x0000e4e0, 0x00008435 },
	{ 0x0000e4e1, 0x000084ca },
	{ 0x0000e4e2, 0x00008462 },
	{ 0x0000e4e3, 0x000084b9 },
	{ 0x0000e4e4, 0x000084bf },
	{ 0x0000e4e5, 0x0000849f },
	{ 0x0000e4e6, 0x000084d9 },
	{ 0x0000e4e7, 0x000084cd },
	{ 0x0000e4e8, 0x000084bb },
	{ 0x0000e4e9, 0x000084da },
	{ 0x0000e4ea, 0x000084d0 },
	{ 0x0000e4eb, 0x000084c1 },
	{ 0x0000e4ec, 0x000084c6 },
	{ 0x0000e4ed, 0x000084d6 },
	{ 0x0000e4ee, 0x000084a1 },
	{ 0x0000e4ef, 0x00008521 },
	{ 0x0000e4f0, 0x000084ff },
	{ 0x0000e4f1, 0x000084f4 },
	{ 0x0000e4f2, 0x00008517 },
	{ 0x0000e4f3, 0x00008518 },
	{ 0x0000e4f4, 0x0000852c },
	{ 0x0000e4f5, 0x0000851f },
	{ 0x0000e4f6, 0x00008515 },
	{ 0x0000e4f7, 0x00008514 },
	{ 0x0000e4f8, 0x000084fc },
	{ 0x0000e4f9, 0x00008540 },
	{ 0x0000e4fa, 0x00008563 },
	{ 0x0000e4fb, 0x00008558 },
	{ 0x0000e4fc, 0x00008548 },
	{ 0x0000e540, 0x00008541 },
	{ 0x0000e541, 0x00008602 },
	{ 0x0000e542, 0x0000854b },
	{ 0x0000e543, 0x00008555 },
	{ 0x0000e544, 0x00008580 },
	{ 0x0000e545, 0x000085a4 },
	{ 0x0000e546, 0x00008588 },
	{ 0x0000e547, 0x00008591 },
	{ 0x0000e548, 0x0000858a },
	{ 0x0000e549, 0x000085a8 },
	{ 0x0000e54a, 0x0000856d },
	{ 0x0000e54b, 0x00008594 },
	{ 0x0000e54c, 0x0000859b },
	{ 0x0000e54d, 0x000085ea },
	{ 0x0000e54e, 0x00008587 },
	{ 0x0000e54f, 0x0000859c },
	{ 0x0000e550, 0x00008577 },
	{ 0x0000e551, 0x0000857e },
	{ 0x0000e552, 0x00008590 },
	{ 0x0000e553, 0x000085c9 },
	{ 0x0000e554, 0x000085ba },
	{ 0x0000e555, 0x000085cf },
	{ 0x0000e556, 0x000085b9 },
	{ 0x0000e557, 0x000085d0 },
	{ 0x0000e558, 0x000085d5 },
	{ 0x0000e559, 0x000085dd },
	{ 0x0000e55a, 0x000085e5 },
	{ 0x0000e55b, 0x000085dc },
	{ 0x0000e55c, 0x000085f9 },
	{ 0x0000e55d, 0x0000860a },
	{ 0x0000e55e, 0x00008613 },
	{ 0x0000e55f, 0x0000860b },
	{ 0x0000e560, 0x000085fe },
	{ 0x0000e561, 0x000085fa },
	{ 0x0000e562, 0x00008606 },
	{ 0x0000e563, 0x00008622 },
	{ 0x0000e564, 0x0000861a },
	{ 0x0000e565, 0x00008630 },
	{ 0x0000e566, 0x0000863f },
	{ 0x0000e567, 0x0000864d },
	{ 0x0000e568, 0x00004e55 },
	{ 0x0000e569, 0x00008654 },
	{ 0x0000e56a, 0x0000865f },
	{ 0x0000e56b, 0x00008667 },
	{ 0x0000e56c, 0x00008671 },
	{ 0x0000e56d, 0x00008693 },
	{ 0x0000e56e, 0x000086a3 },
	{ 0x0000e56f, 0x000086a9 },
	{ 0x0000e570, 0x000086aa },
	{ 0x0000e571, 0x0000868b },
	{ 0x0000e572, 0x0000868c },
	{ 0x0000e573, 0x000086b6 },
	{ 0x0000e574, 0x000086af },
	{ 0x0000e575, 0x000086c4 },
	{ 0x0000e576, 0x000086c6 },
	{ 0x0000e577, 0x000086b0 },
	{ 0x0000e578, 0x000086c9 },
	{ 0x0000e579, 0x00008823 },
	{ 0x0000e57a, 0x000086ab },
	{ 0x0000e57b, 0x000086d4 },
	{ 0x0000e57c, 0x000086de },
	{ 0x0000e57d, 0x000086e9 },
	{ 0x0000e57e, 0x000086ec },
	{ 0x0000e580, 0x000086df },
	{ 0x0000e581, 0x000086db },
	{ 0x0000e582, 0x000086ef },
	{ 0x0000e583, 0x00008712 },
	{ 0x0000e584, 0x00008706 },
	{ 0x0000e585, 0x00008708 },
	{ 0x0000e586, 0x00008700 },
	{ 0x0000e587, 0x00008703 },
	{ 0x0000e588, 0x000086fb },
	{ 0x0000e589, 0x00008711 },
	{ 0x0000e58a, 0x00008709 },
	{ 0x0000e58b, 0x0000870d },
	{ 0x0000e58c, 0x000086f9 },
	{ 0x0000e58d, 0x0000870a },
	{ 0x0000e58e, 0x00008734 },
	{ 0x0000e58f, 0x0000873f },
	{ 0x0000e590, 0x00008737 },
	{ 0x0000e591, 0x0000873b },
	{ 0x0000e592, 0x00008725 },
	{ 0x0000e593, 0x00008729 },
	{ 0x0000e594, 0x0000871a },
	{ 0x0000e595, 0x00008760 },
	{ 0x0000e596, 0x0000875f },
	{ 0x0000e597, 0x00008778 },
	{ 0x0000e598, 0x0000874c },
	{ 0x0000e599, 0x0000874e },
	{ 0x0000e59a, 0x00008774 },
	{ 0x0000e59b, 0x00008757 },
	{ 0x0000e59c, 0x00008768 },
	{ 0x0000e59d, 0x0000876e },
	{ 0x0000e59e, 0x00008759 },
	{ 0x0000e59f, 0x00008753 },
	{ 0x0000e5a0, 0x00008763 },
	{ 0x0000e5a1, 0x0000876a },
	{ 0x0000e5a2, 0x00008805 },
	{ 0x0000e5a3, 0x000087a2 },
	{ 0x0000e5a4, 0x0000879f },
	{ 0x0000e5a5, 0x00008782 },
	{ 0x0000e5a6, 0x000087af },
	{ 0x0000e5a7, 0x000087cb },
	{ 0x0000e5a8, 0x000087bd },
	{ 0x0000e5a9, 0x000087c0 },
	{ 0x0000e5aa, 0x000087d0 },
	{ 0x0000e5ab, 0x000096d6 },
	{ 0x0000e5ac, 0x000087ab },
	{ 0x0000e5ad, 0x000087c4 },
	{ 0x0000e5ae, 0x000087b3 },
	{ 0x0000e5af, 0x000087c7 },
	{ 0x0000e5b0, 0x000087c6 },
	{ 0x0000e5b1, 0x000087bb },
	{ 0x0000e5b2, 0x000087ef },
	{ 0x0000e5b3, 0x000087f2 },
	{ 0x0000e5b4, 0x000087e0 },
	{ 0x0000e5b5, 0x0000880f },
	{ 0x0000e5b6, 0x0000880d },
	{ 0x0000e5b7, 0x000087fe },
	{ 0x0000e5b8, 0x000087f6 },
	{ 0x0000e5b9, 0x000087f7 },
	{ 0x0000e5ba, 0x0000880e },
	{ 0x0000e5bb, 0x000087d2 },
	{ 0x0000e5bc, 0x00008811 },
	{ 0x0000e5bd, 0x00008816 },
	{ 0x0000e5be, 0x00008815 },
	{ 0x0000e5bf, 0x00008822 },
	{ 0x0000e5c0, 0x00008821 },
	{ 0x0000e5c1, 0x00008831 },
	{ 0x0000e5c2, 0x00008836 },
	{ 0x0000e5c3, 0x00008839 },
	{ 0x0000e5c4, 0x00008827 },
	{ 0x0000e5c5, 0x0000883b },
	{ 0x0000e5c6, 0x00008844 },
	{ 0x0000e5c7, 0x00008842 },
	{ 0x0000e5c8, 0x00008852 },
	{ 0x0000e5c9, 0x00008859 },
	{ 0x0000e5ca, 0x0000885e },
	{ 0x0000e5cb, 0x00008862 },
	{ 0x0000e5cc, 0x0000886b },
	{ 0x0000e5cd, 0x00008881 },
	{ 0x0000e5ce, 0x0000887e },
	{ 0x0000e5cf, 0x0000889e },
	{ 0x0000e5d0, 0x00008875 },
	{ 0x0000e5d1, 0x0000887d },
	{ 0x0000e5d2, 0x000088b5 },
	{ 0x0000e5d3, 0x00008872 },
	{ 0x0000e5d4, 0x00008882 },
	{ 0x0000e5d5, 0x00008897 },
	{ 0x0000e5d6, 0x00008892 },
	{ 0x0000e5d7, 0x000088ae },
	{ 0x0000e5d8, 0x00008899 },
	{ 0x0000e5d9, 0x000088a2 },
	{ 0x0000e5da, 0x0000888d },
	{ 0x0000e5db, 0x000088a4 },
	{ 0x0000e5dc, 0x000088b0 },
	{ 0x0000e5dd, 0x000088bf },
	{ 0x0000e5de, 0x000088b1 },
	{ 0x0000e5df, 0x000088c3 },
	{ 0x0000e5e0, 0x000088c4 },
	{ 0x0000e5e1, 0x000088d4 },
	{ 0x0000e5e2, 0x000088d8 },
	{ 0x0000e5e3, 0x000088d9 },
	{ 0x0000e5e4, 0x000088dd },
	{ 0x0000e5e5, 0x000088f9 },
	{ 0x0000e5e6, 0x00008902 },
	{ 0x0000e5e7, 0x000088fc },
	{ 0x0000e5e8, 0x000088f4 },
	{ 0x0000e5e9, 0x000088e8 },
	{ 0x0000e5ea, 0x000088f2 },
	{ 0x0000e5eb, 0x00008904 },
	{ 0x0000e5ec, 0x0000890c },
	{ 0x0000e5ed, 0x0000890a },
	{ 0x0000e5ee, 0x00008913 },
	{ 0x0000e5ef, 0x00008943 },
	{ 0x0000e5f0, 0x0000891e },
	{ 0x0000e5f1, 0x00008925 },
	{ 0x0000e5f2, 0x0000892a },
	{ 0x0000e5f3, 0x0000892b },
	{ 0x0000e5f4, 0x00008941 },
	{ 0x0000e5f5, 0x00008944 },
	{ 0x0000e5f6, 0x0000893b },
	{ 0x0000e5f7, 0x00008936 },
	{ 0x0000e5f8, 0x00008938 },
	{ 0x0000e5f9, 0x0000894c },
	{ 0x0000e5fa, 0x0000891d },
	{ 0x0000e5fb, 0x00008960 },
	{ 0x0000e5fc, 0x0000895e },
	{ 0x0000e640, 0x00008966 },
	{ 0x0000e641, 0x00008964 },
	{ 0x0000e642, 0x0000896d },
	{ 0x0000e643, 0x0000896a },
	{ 0x0000e644, 0x0000896f },
	{ 0x0000e645, 0x00008974 },
	{ 0x0000e646, 0x00008977 },
	{ 0x0000e647, 0x0000897e },
	{ 0x0000e648, 0x00008983 },
	{ 0x0000e649, 0x00008988 },
	{ 0x0000e64a, 0x0000898a },
	{ 0x0000e64b, 0x00008993 },
	{ 0x0000e64c, 0x00008998 },
	{ 0x0000e64d, 0x000089a1 },
	{ 0x0000e64e, 0x000089a9 },
	{ 0x0000e64f, 0x000089a6 },
	{ 0x0000e650, 0x000089ac },
	{ 0x0000e651, 0x000089af },
	{ 0x0000e652, 0x000089b2 },
	{ 0x0000e653, 0x000089ba },
	{ 0x0000e654, 0x000089bd },
	{ 0x0000e655, 0x000089bf },
	{ 0x0000e656, 0x000089c0 },
	{ 0x0000e657, 0x000089da },
	{ 0x0000e658, 0x000089dc },
	{ 0x0000e659, 0x000089dd },
	{ 0x0000e65a, 0x000089e7 },
	{ 0x0000e65b, 0x000089f4 },
	{ 0x0000e65c, 0x000089f8 },
	{ 0x0000e65d, 0x00008a03 },
	{ 0x0000e65e, 0x00008a16 },
	{ 0x0000e65f, 0x00008a10 },
	{ 0x0000e660, 0x00008a0c },
	{ 0x0000e661, 0x00008a1b },
	{ 0x0000e662, 0x00008a1d },
	{ 0x0000e663, 0x00008a25 },
	{ 0x0000e664, 0x00008a36 },
	{ 0x0000e665, 0x00008a41 },
	{ 0x0000e666, 0x00008a5b },
	{ 0x0000e667, 0x00008a52 },
	{ 0x0000e668, 0x00008a46 },
	{ 0x0000e669, 0x00008a48 },
	{ 0x0000e66a, 0x00008a7c },
	{ 0x0000e66b, 0x00008a6d },
	{ 0x0000e66c, 0x00008a6c },
	{ 0x0000e66d, 0x00008a62 },
	{ 0x0000e66e, 0x00008a85 },
	{ 0x0000e66f, 0x00008a82 },
	{ 0x0000e670, 0x00008a84 },
	{ 0x0000e671, 0x00008aa8 },
	{ 0x0000e672, 0x00008aa1 },
	{ 0x0000e673, 0x00008a91 },
	{ 0x0000e674, 0x00008aa5 },
	{ 0x0000e675, 0x00008aa6 },
	{ 0x0000e676, 0x00008a9a },
	{ 0x0000e677, 0x00008aa3 },
	{ 0x0000e678, 0x00008ac4 },
	{ 0x0000e679, 0x00008acd },
	{ 0x0000e67a, 0x00008ac2 },
	{ 0x0000e67b, 0x00008ada },
	{ 0x0000e67c, 0x00008aeb },
	{ 0x0000e67d, 0x00008af3 },
	{ 0x0000e67e, 0x00008ae7 },
	{ 0x0000e680, 0x00008ae4 },
	{ 0x0000e681, 0x00008af1 },
	{ 0x0000e682, 0x00008b14 },
	{ 0x0000e683, 0x00008ae0 },
	{ 0x0000e684, 0x00008ae2 },
	{ 0x0000e685, 0x00008af7 },
	{ 0x0000e686, 0x00008ade },
	{ 0x0000e687, 0x00008adb },
	{ 0x0000e688, 0x00008b0c },
	{ 0x0000e689, 0x00008b07 },
	{ 0x0000e68a, 0x00008b1a },
	{ 0x0000e68b, 0x00008ae1 },
	{ 0x0000e68c, 0x00008b16 },
	{ 0x0000e68d, 0x00008b10 },
	{ 0x0000e68e, 0x00008b17 },
	{ 0x0000e68f, 0x00008b20 },
	{ 0x0000e690, 0x00008b33 },
	{ 0x0000e691, 0x000097ab },
	{ 0x0000e692, 0x00008b26 },
	{ 0x0000e693, 0x00008b2b },
	{ 0x0000e694, 0x00008b3e },
	{ 0x0000e695, 0x00008b28 },
	{ 0x0000e696, 0x00008b41 },
	{ 0x0000e697, 0x00008b4c },
	{ 0x0000e698, 0x00008b4f },
	{ 0x0000e699, 0x00008b4e },
	{ 0x0000e69a, 0x00008b49 },
	{ 0x0000e69b, 0x00008b56 },
	{ 0x0000e69c, 0x00008b5b },
	{ 0x0000e69d, 0x00008b5a },
	{ 0x0000e69e, 0x00008b6b },
	{ 0x0000e69f, 0x00008b5f },
	{ 0x0000e6a0, 0x00008b6c },
	{ 0x0000e6a1, 0x00008b6f },
	{ 0x0000e6a2, 0x00008b74 },
	{ 0x0000e6a3, 0x00008b7d },
	{ 0x0000e6a4, 0x00008b80 },
	{ 0x0000e6a5, 0x00008b8c },
	{ 0x0000e6a6, 0x00008b8e },
	{ 0x0000e6a7, 0x00008b92 },
	{ 0x0000e6a8, 0x00008b93 },
	{ 0x0000e6a9, 0x00008b96 },
	{ 0x0000e6aa, 0x00008b99 },
	{ 0x0000e6ab, 0x00008b9a },
	{ 0x0000e6ac, 0x00008c3a },
	{ 0x0000e6ad, 0x00008c41 },
	{ 0x0000e6ae, 0x00008c3f },
	{ 0x0000e6af, 0x00008c48 },
	{ 0x0000e6b0, 0x00008c4c },
	{ 0x0000e6b1, 0x00008c4e },
	{ 0x0000e6b2, 0x00008c50 },
	{ 0x0000e6b3, 0x00008c55 },
	{ 0x0000e6b4, 0x00008c62 },
	{ 0x0000e6b5, 0x00008c6c },
	{ 0x0000e6b6, 0x00008c78 },
	{ 0x0000e6b7, 0x00008c7a },
	{ 0x0000e6b8, 0x00008c82 },
	{ 0x0000e6b9, 0x00008c89 },
	{ 0x0000e6ba, 0x00008c85 },
	{ 0x0000e6bb, 0x00008c8a },
	{ 0x0000e6bc, 0x00008c8d },
	{ 0x0000e6bd, 0x00008c8e },
	{ 0x0000e6be, 0x00008c94 },
	{ 0x0000e6bf, 0x00008c7c },
	{ 0x0000e6c0, 0x00008c98 },
	{ 0x0000e6c1, 0x0000621d },
	{ 0x0000e6c2, 0x00008cad },
	{ 0x0000e6c3, 0x00008caa },
	{ 0x0000e6c4, 0x00008cbd },
	{ 0x0000e6c5, 0x00008cb2 },
	{ 0x0000e6c6, 0x00008cb3 },
	{ 0x0000e6c7, 0x00008cae },
	{ 0x0000e6c8, 0x00008cb6 },
	{ 0x0000e6c9, 0x00008cc8 },
	{ 0x0000e6ca, 0x00008cc1 },
	{ 0x0000e6cb, 0x00008ce4 },
	{ 0x0000e6cc, 0x00008ce3 },
	{ 0x0000e6cd, 0x00008cda },
	{ 0x0000e6ce, 0x00008cfd },
	{ 0x0000e6cf, 0x00008cfa },
	{ 0x0000e6d0, 0x00008cfb },
	{ 0x0000e6d1, 0x00008d04 },
	{ 0x0000e6d2, 0x00008d05 },
	{ 0x0000e6d3, 0x00008d0a },
	{ 0x0000e6d4, 0x00008d07 },
	{ 0x0000e6d5, 0x00008d0f },
	{ 0x0000e6d6, 0x00008d0d },
	{ 0x0000e6d7, 0x00008d10 },
	{ 0x0000e6d8, 0x00009f4e },
	{ 0x0000e6d9, 0x00008d13 },
	{ 0x0000e6da, 0x00008ccd },
	{ 0x0000e6db, 0x00008d14 },
	{ 0x0000e6dc, 0x00008d16 },
	{ 0x0000e6dd, 0x00008d67 },
	{ 0x0000e6de, 0x00008d6d },
	{ 0x0000e6df, 0x00008d71 },
	{ 0x0000e6e0, 0x00008d73 },
	{ 0x0000e6e1, 0x00008d81 },
	{ 0x0000e6e2, 0x00008d99 },
	{ 0x0000e6e3, 0x00008dc2 },
	{ 0x0000e6e4, 0x00008dbe },
	{ 0x0000e6e5, 0x00008dba },
	{ 0x0000e6e6, 0x00008dcf },
	{ 0x0000e6e7, 0x00008dda },
	{ 0x0000e6e8, 0x00008dd6 },
	{ 0x0000e6e9, 0x00008dcc },
	{ 0x0000e6ea, 0x00008ddb },
	{ 0x0000e6eb, 0x00008dcb },
	{ 0x0000e6ec, 0x00008dea },
	{ 0x0000e6ed, 0x00008deb },
	{ 0x0000e6ee, 0x00008ddf },
	{ 0x0000e6ef, 0x00008de3 },
	{ 0x0000e6f0, 0x00008dfc },
	{ 0x0000e6f1, 0x00008e08 },
	{ 0x0000e6f2, 0x00008e09 },
	{ 0x0000e6f3, 0x00008dff },
	{ 0x0000e6f4, 0x00008e1d },
	{ 0x0000e6f5, 0x00008e1e },
	{ 0x0000e6f6, 0x00008e10 },
	{ 0x0000e6f7, 0x00008e1f },
	{ 0x0000e6f8, 0x00008e42 },
	{ 0x0000e6f9, 0x00008e35 },
	{ 0x0000e6fa, 0x00008e30 },
	{ 0x0000e6fb, 0x00008e34 },
	{ 0x0000e6fc, 0x00008e4a },
	{ 0x0000e740, 0x00008e47 },
	{ 0x0000e741, 0x00008e49 },
	{ 0x0000e742, 0x00008e4c },
	{ 0x0000e743, 0x00008e50 },
	{ 0x0000e744, 0x00008e48 },
	{ 0x0000e745, 0x00008e59 },
	{ 0x0000e746, 0x00008e64 },
	{ 0x0000e747, 0x00008e60 },
	{ 0x0000e748, 0x00008e2a },
	{ 0x0000e749, 0x00008e63 },
	{ 0x0000e74a, 0x00008e55 },
	{ 0x0000e74b, 0x00008e76 },
	{ 0x0000e74c, 0x00008e72 },
	{ 0x0000e74d, 0x00008e7c },
	{ 0x0000e74e, 0x00008e81 },
	{ 0x0000e74f, 0x00008e87 },
	{ 0x0000e750, 0x00008e85 },
	{ 0x0000e751, 0x00008e84 },
	{ 0x0000e752, 0x00008e8b },
	{ 0x0000e753, 0x00008e8a },
	{ 0x0000e754, 0x00008e93 },
	{ 0x0000e755, 0x00008e91 },
	{ 0x0000e756, 0x00008e94 },
	{ 0x0000e757, 0x00008e99 },
	{ 0x0000e758, 0x00008eaa },
	{ 0x0000e759, 0x00008ea1 },
	{ 0x0000e75a, 0x00008eac },
	{ 0x0000e75b, 0x00008eb0 },
	{ 0x0000e75c, 0x00008ec6 },
	{ 0x0000e75d, 0x00008eb1 },
	{ 0x0000e75e, 0x00008ebe },
	{ 0x0000e75f, 0x00008ec5 },
	{ 0x0000e760, 0x00008ec8 },
	{ 0x0000e761, 0x00008ecb },
	{ 0x0000e762, 0x00008edb },
	{ 0x0000e763, 0x00008ee3 },
	{ 0x0000e764, 0x00008efc },
	{ 0x0000e765, 0x00008efb },
	{ 0x0000e766, 0x00008eeb },
	{ 0x0000e767, 0x00008efe },
	{ 0x0000e768, 0x00008f0a },
	{ 0x0000e769, 0x00008f05 },
	{ 0x0000e76a, 0x00008f15 },
	{ 0x0000e76b, 0x00008f12 },
	{ 0x0000e76c, 0x00008f19 },
	{ 0x0000e76d, 0x00008f13 },
	{ 0x0000e76e, 0x00008f1c },
	{ 0x0000e76f, 0x00008f1f },
	{ 0x0000e770, 0x00008f1b },
	{ 0x0000e771, 0x00008f0c },
	{ 0x0000e772, 0x00008f26 },
	{ 0x0000e773, 0x00008f33 },
	{ 0x0000e774, 0x00008f3b },
	{ 0x0000e775, 0x00008f39 },
	{ 0x0000e776, 0x00008f45 },
	{ 0x0000e777, 0x00008f42 },
	{ 0x0000e778, 0x00008f3e },
	{ 0x0000e779, 0x00008f4c },
	{ 0x0000e77a, 0x00008f49 },
	{ 0x0000e77b, 0x00008f46 },
	{ 0x0000e77c, 0x00008f4e },
	{ 0x0000e77d, 0x00008f57 },
	{ 0x0000e77e, 0x00008f5c },
	{ 0x0000e780, 0x00008f62 },
	{ 0x0000e781, 0x00008f63 },
	{ 0x0000e782, 0x00008f64 },
	{ 0x0000e783, 0x00008f9c },
	{ 0x0000e784, 0x00008f9f },
	{ 0x0000e785, 0x00008fa3 },
	{ 0x0000e786, 0x00008fad },
	{ 0x0000e787, 0x00008faf },
	{ 0x0000e788, 0x00008fb7 },
	{ 0x0000e789, 0x00008fda },
	{ 0x0000e78a, 0x00008fe5 },
	{ 0x0000e78b, 0x00008fe2 },
	{ 0x0000e78c, 0x00008fea },
	{ 0x0000e78d, 0x00008fef },
	{ 0x0000e78e, 0x00009087 },
	{ 0x0000e78f, 0x00008ff4 },
	{ 0x0000e790, 0x00009005 },
	{ 0x0000e791, 0x00008ff9 },
	{ 0x0000e792, 0x00008ffa },
	{ 0x0000e793, 0x00009011 },
	{ 0x0000e794, 0x00009015 },
	{ 0x0000e795, 0x00009021 },
	{ 0x0000e796, 0x0000900d },
	{ 0x0000e797, 0x0000901e },
	{ 0x0000e798, 0x00009016 },
	{ 0x0000e799, 0x0000900b },
	{ 0x0000e79a, 0x00009027 },
	{ 0x0000e79b, 0x00009036 },
	{ 0x0000e79c, 0x00009035 },
	{ 0x0000e79d, 0x00009039 },
	{ 0x0000e79e, 0x00008ff8 },
	{ 0x0000e79f, 0x0000904f },
	{ 0x0000e7a0, 0x00009050 },
	{ 0x0000e7a1, 0x00009051 },
	{ 0x0000e7a2, 0x00009052 },
	{ 0x0000e7a3, 0x0000900e },
	{ 0x0000e7a4, 0x00009049 },
	{ 0x0000e7a5, 0x0000903e },
	{ 0x0000e7a6, 0x00009056 },
	{ 0x0000e7a7, 0x00009058 },
	{ 0x0000e7a8, 0x0000905e },
	{ 0x0000e7a9, 0x00009068 },
	{ 0x0000e7aa, 0x0000906f },
	{ 0x0000e7ab, 0x00009076 },
	{ 0x0000e7ac, 0x000096a8 },
	{ 0x0000e7ad, 0x00009072 },
	{ 0x0000e7ae, 0x00009082 },
	{ 0x0000e7af, 0x0000907d },
	{ 0x0000e7b0, 0x00009081 },
	{ 0x0000e7b1, 0x00009080 },
	{ 0x0000e7b2, 0x0000908a },
	{ 0x0000e7b3, 0x00009089 },
	{ 0x0000e7b4, 0x0000908f },
	{ 0x0000e7b5, 0x000090a8 },
	{ 0x0000e7b6, 0x000090af },
	{ 0x0000e7b7, 0x000090b1 },
	{ 0x0000e7b8, 0x000090b5 },
	{ 0x0000e7b9, 0x000090e2 },
	{ 0x0000e7ba, 0x000090e4 },
	{ 0x0000e7bb, 0x00006248 },
	{ 0x0000e7bc, 0x000090db },
	{ 0x0000e7bd, 0x00009102 },
	{ 0x0000e7be, 0x00009112 },
	{ 0x0000e7bf, 0x00009119 },
	{ 0x0000e7c0, 0x00009132 },
	{ 0x0000e7c1, 0x00009130 },
	{ 0x0000e7c2, 0x0000914a },
	{ 0x0000e7c3, 0x00009156 },
	{ 0x0000e7c4, 0x00009158 },
	{ 0x0000e7c5, 0x00009163 },
	{ 0x0000e7c6, 0x00009165 },
	{ 0x0000e7c7, 0x00009169 },
	{ 0x0000e7c8, 0x00009173 },
	{ 0x0000e7c9, 0x00009172 },
	{ 0x0000e7ca, 0x0000918b },
	{ 0x0000e7cb, 0x00009189 },
	{ 0x0000e7cc, 0x00009182 },
	{ 0x0000e7cd, 0x000091a2 },
	{ 0x0000e7ce, 0x000091ab },
	{ 0x0000e7cf, 0x000091af },
	{ 0x0000e7d0, 0x000091aa },
	{ 0x0000e7d1, 0x000091b5 },
	{ 0x0000e7d2, 0x000091b4 },
	{ 0x0000e7d3, 0x000091ba },
	{ 0x0000e7d4, 0x000091c0 },
	{ 0x0000e7d5, 0x000091c1 },
	{ 0x0000e7d6, 0x000091c9 },
	{ 0x0000e7d7, 0x000091cb },
	{ 0x0000e7d8, 0x000091d0 },
	{ 0x0000e7d9, 0x000091d6 },
	{ 0x0000e7da, 0x000091df },
	{ 0x0000e7db, 0x000091e1 },
	{ 0x0000e7dc, 0x000091db },
	{ 0x0000e7dd, 0x000091fc },
	{ 0x0000e7de, 0x000091f5 },
	{ 0x0000e7df, 0x000091f6 },
	{ 0x0000e7e0, 0x0000921e },
	{ 0x0000e7e1, 0x000091ff },
	{ 0x0000e7e2, 0x00009214 },
	{ 0x0000e7e3, 0x0000922c },
	{ 0x0000e7e4, 0x00009215 },
	{ 0x0000e7e5, 0x00009211 },
	{ 0x0000e7e6, 0x0000925e },
	{ 0x0000e7e7, 0x00009257 },
	{ 0x0000e7e8, 0x00009245 },
	{ 0x0000e7e9, 0x00009249 },
	{ 0x0000e7ea, 0x00009264 },
	{ 0x0000e7eb, 0x00009248 },
	{ 0x0000e7ec, 0x00009295 },
	{ 0x0000e7ed, 0x0000923f },
	{ 0x0000e7ee, 0x0000924b },
	{ 0x0000e7ef, 0x00009250 },
	{ 0x0000e7f0, 0x0000929c },
	{ 0x0000e7f1, 0x00009296 },
	{ 0x0000e7f2, 0x00009293 },
	{ 0x0000e7f3, 0x0000929b },
	{ 0x0000e7f4, 0x0000925a },
	{ 0x0000e7f5, 0x000092cf },
	{ 0x0000e7f6, 0x000092b9 },
	{ 0x0000e7f7, 0x000092b7 },
	{ 0x0000e7f8, 0x000092e9 },
	{ 0x0000e7f9, 0x0000930f },
	{ 0x0000e7fa, 0x000092fa },
	{ 0x0000e7fb, 0x00009344 },
	{ 0x0000e7fc, 0x0000932e },
	{ 0x0000e840, 0x00009319 },
	{ 0x0000e841, 0x00009322 },
	{ 0x0000e842, 0x0000931a },
	{ 0x0000e843, 0x00009323 },
	{ 0x0000e844, 0x0000933a },
	{ 0x0000e845, 0x00009335 },
	{ 0x0000e846, 0x0000933b },
	{ 0x0000e847, 0x0000935c },
	{ 0x0000e848, 0x00009360 },
	{ 0x0000e849, 0x0000937c },
	{ 0x0000e84a, 0x0000936e },
	{ 0x0000e84b, 0x00009356 },
	{ 0x0000e84c, 0x000093b0 },
	{ 0x0000e84d, 0x000093ac },
	{ 0x0000e84e, 0x000093ad },
	{ 0x0000e84f, 0x00009394 },
	{ 0x0000e850, 0x000093b9 },
	{ 0x0000e851, 0x000093d6 },
	{ 0x0000e852, 0x000093d7 },
	{ 0x0000e853, 0x000093e8 },
	{ 0x0000e854, 0x000093e5 },
	{ 0x0000e855, 0x000093d8 },
	{ 0x0000e856, 0x000093c3 },
	{ 0x0000e857, 0x000093dd },
	{ 0x0000e858, 0x000093d0 },
	{ 0x0000e859, 0x000093c8 },
	{ 0x0000e85a, 0x000093e4 },
	{ 0x0000e85b, 0x0000941a },
	{ 0x0000e85c, 0x00009414 },
	{ 0x0000e85d, 0x00009413 },
	{ 0x0000e85e, 0x00009403 },
	{ 0x0000e85f, 0x00009407 },
	{ 0x0000e860, 0x00009410 },
	{ 0x0000e861, 0x00009436 },
	{ 0x0000e862, 0x0000942b },
	{ 0x0000e863, 0x00009435 },
	{ 0x0000e864, 0x00009421 },
	{ 0x0000e865, 0x0000943a },
	{ 0x0000e866, 0x00009441 },
	{ 0x0000e867, 0x00009452 },
	{ 0x0000e868, 0x00009444 },
	{ 0x0000e869, 0x0000945b },
	{ 0x0000e86a, 0x00009460 },
	{ 0x0000e86b, 0x00009462 },
	{ 0x0000e86c, 0x0000945e },
	{ 0x0000e86d, 0x0000946a },
	{ 0x0000e86e, 0x00009229 },
	{ 0x0000e86f, 0x00009470 },
	{ 0x0000e870, 0x00009475 },
	{ 0x0000e871, 0x00009477 },
	{ 0x0000e872, 0x0000947d },
	{ 0x0000e873, 0x0000945a },
	{ 0x0000e874, 0x0000947c },
	{ 0x0000e875, 0x0000947e },
	{ 0x0000e876, 0x00009481 },
	{ 0x0000e877, 0x0000947f },
	{ 0x0000e878, 0x00009582 },
	{ 0x0000e879, 0x00009587 },
	{ 0x0000e87a, 0x0000958a },
	{ 0x0000e87b, 0x00009594 },
	{ 0x0000e87c, 0x00009596 },
	{ 0x0000e87d, 0x00009598 },
	{ 0x0000e87e, 0x00009599 },
	{ 0x0000e880, 0x000095a0 },
	{ 0x0000e881, 0x000095a8 },
	{ 0x0000e882, 0x000095a7 },
	{ 0x0000e883, 0x000095ad },
	{ 0x0000e884, 0x000095bc },
	{ 0x0000e885, 0x000095bb },
	{ 0x0000e886, 0x000095b9 },
	{ 0x0000e887, 0x000095be },
	{ 0x0000e888, 0x000095ca },
	{ 0x0000e889, 0x00006ff6 },
	{ 0x0000e88a, 0x000095c3 },
	{ 0x0000e88b, 0x000095cd },
	{ 0x0000e88c, 0x000095cc },
	{ 0x0000e88d, 0x000095d5 },
	{ 0x0000e88e, 0x000095d4 },
	{ 0x0000e88f, 0x000095d6 },
	{ 0x0000e890, 0x000095dc },
	{ 0x0000e891, 0x000095e1 },
	{ 0x0000e892, 0x000095e5 },
	{ 0x0000e893, 0x000095e2 },
	{ 0x0000e894, 0x00009621 },
	{ 0x0000e895, 0x00009628 },
	{ 0x0000e896, 0x0000962e },
	{ 0x0000e897, 0x0000962f },
	{ 0x0000e898, 0x00009642 },
	{ 0x0000e899, 0x0000964c },
	{ 0x0000e89a, 0x0000964f },
	{ 0x0000e89b, 0x0000964b },
	{ 0x0000e89c, 0x00009677 },
	{ 0x0000e89d, 0x0000965c },
	{ 0x0000e89e, 0x0000965e },
	{ 0x0000e89f, 0x0000965d },
	{ 0x0000e8a0, 0x0000965f },
	{ 0x0000e8a1, 0x00009666 },
	{ 0x0000e8a2, 0x00009672 },
	{ 0x0000e8a3, 0x0000966c },
	{ 0x0000e8a4, 0x0000968d },
	{ 0x0000e8a5, 0x00009698 },
	{ 0x0000e8a6, 0x00009695 },
	{ 0x0000e8a7, 0x00009697 },
	{ 0x0000e8a8, 0x000096aa },
	{ 0x0000e8a9, 0x000096a7 },
	{ 0x0000e8aa, 0x000096b1 },
	{ 0x0000e8ab, 0x000096b2 },
	{ 0x0000e8ac, 0x000096b0 },
	{ 0x0000e8ad, 0x000096b4 },
	{ 0x0000e8ae, 0x000096b6 },
	{ 0x0000e8af, 0x000096b8 },
	{ 0x0000e8b0, 0x000096b9 },
	{ 0x0000e8b1, 0x000096ce },
	{ 0x0000e8b2, 0x000096cb },
	{ 0x0000e8b3, 0x000096c9 },
	{ 0x0000e8b4, 0x000096cd },
	{ 0x0000e8b5, 0x0000894d },
	{ 0x0000e8b6, 0x000096dc },
	{ 0x0000e8b7, 0x0000970d },
	{ 0x0000e8b8, 0x000096d5 },
	{ 0x0000e8b9, 0x000096f9 },
	{ 0x0000e8ba, 0x00009704 },
	{ 0x0000e8bb, 0x00009706 },
	{ 0x0000e8bc, 0x00009708 },
	{ 0x0000e8bd, 0x00009713 },
	{ 0x0000e8be, 0x0000970e },
	{ 0x0000e8bf, 0x00009711 },
	{ 0x0000e8c0, 0x0000970f },
	{ 0x0000e8c1, 0x00009716 },
	{ 0x0000e8c2, 0x00009719 },
	{ 0x0000e8c3, 0x00009724 },
	{ 0x0000e8c4, 0x0000972a },
	{ 0x0000e8c5, 0x00009730 },
	{ 0x0000e8c6, 0x00009739 },
	{ 0x0000e8c7, 0x0000973d },
	{ 0x0000e8c8, 0x0000973e },
	{ 0x0000e8c9, 0x00009744 },
	{ 0x0000e8ca, 0x00009746 },
	{ 0x0000e8cb, 0x00009748 },
	{ 0x0000e8cc, 0x00009742 },
	{ 0x0000e8cd, 0x00009749 },
	{ 0x0000e8ce, 0x0000975c },
	{ 0x0000e8cf, 0x00009760 },
	{ 0x0000e8d0, 0x00009764 },
	{ 0x0000e8d1, 0x00009766 },
	{ 0x0000e8d2, 0x00009768 },
	{ 0x0000e8d3, 0x000052d2 },
	{ 0x0000e8d4, 0x0000976b },
	{ 0x0000e8d5, 0x00009771 },
	{ 0x0000e8d6, 0x00009779 },
	{ 0x0000e8d7, 0x00009785 },
	{ 0x0000e8d8, 0x0000977c },
	{ 0x0000e8d9, 0x00009781 },
	{ 0x0000e8da, 0x0000977a },
	{ 0x0000e8db, 0x00009786 },
	{ 0x0000e8dc, 0x0000978b },
	{ 0x0000e8dd, 0x0000978f },
	{ 0x0000e8de, 0x00009790 },
	{ 0x0000e8df, 0x0000979c },
	{ 0x0000e8e0, 0x000097a8 },
	{ 0x0000e8e1, 0x000097a6 },
	{ 0x0000e8e2, 0x000097a3 },
	{ 0x0000e8e3, 0x000097b3 },
	{ 0x0000e8e4, 0x000097b4 },
	{ 0x0000e8e5, 0x000097c3 },
	{ 0x0000e8e6, 0x000097c6 },
	{ 0x0000e8e7, 0x000097c8 },
	{ 0x0000e8e8, 0x000097cb },
	{ 0x0000e8e9, 0x000097dc },
	{ 0x0000e8ea, 0x000097ed },
	{ 0x0000e8eb, 0x00009f4f },
	{ 0x0000e8ec, 0x000097f2 },
	{ 0x0000e8ed, 0x00007adf },
	{ 0x0000e8ee, 0x000097f6 },
	{ 0x0000e8ef, 0x000097f5 },
	{ 0x0000e8f0, 0x0000980f },
	{ 0x0000e8f1, 0x0000980c },
	{ 0x0000e8f2, 0x00009838 },
	{ 0x0000e8f3, 0x00009824 },
	{ 0x0000e8f4, 0x00009821 },
	{ 0x0000e8f5, 0x00009837 },
	{ 0x0000e8f6, 0x0000983d },
	{ 0x0000e8f7, 0x00009846 },
	{ 0x0000e8f8, 0x0000984f },
	{ 0x0000e8f9, 0x0000984b },
	{ 0x0000e8fa, 0x0000986b },
	{ 0x0000e8fb, 0x0000986f },
	{ 0x0000e8fc, 0x00009870 },
	{ 0x0000e940, 0x00009871 },
	{ 0x0000e941, 0x00009874 },
	{ 0x0000e942, 0x00009873 },
	{ 0x0000e943, 0x000098aa },
	{ 0x0000e944, 0x000098af },
	{ 0x0000e945, 0x000098b1 },
	{ 0x0000e946, 0x000098b6 },
	{ 0x0000e947, 0x000098c4 },
	{ 0x0000e948, 0x000098c3 },
	{ 0x0000e949, 0x000098c6 },
	{ 0x0000e94a, 0x000098e9 },
	{ 0x0000e94b, 0x000098eb },
	{ 0x0000e94c, 0x00009903 },
	{ 0x0000e94d, 0x00009909 },
	{ 0x0000e94e, 0x00009912 },
	{ 0x0000e94f, 0x00009914 },
	{ 0x0000e950, 0x00009918 },
	{ 0x0000e951, 0x00009921 },
	{ 0x0000e952, 0x0000991d },
	{ 0x0000e953, 0x0000991e },
	{ 0x0000e954, 0x00009924 },
	{ 0x0000e955, 0x00009920 },
	{ 0x0000e956, 0x0000992c },
	{ 0x0000e957, 0x0000992e },
	{ 0x0000e958, 0x0000993d },
	{ 0x0000e959, 0x0000993e },
	{ 0x0000e95a, 0x00009942 },
	{ 0x0000e95b, 0x00009949 },
	{ 0x0000e95c, 0x00009945 },
	{ 0x0000e95d, 0x00009950 },
	{ 0x0000e95e, 0x0000994b },
	{ 0x0000e95f, 0x00009951 },
	{ 0x0000e960, 0x00009952 },
	{ 0x0000e961, 0x0000994c },
	{ 0x0000e962, 0x00009955 },
	{ 0x0000e963, 0x00009997 },
	{ 0x0000e964, 0x00009998 },
	{ 0x0000e965, 0x000099a5 },
	{ 0x0000e966, 0x000099ad },
	{ 0x0000e967, 0x000099ae },
	{ 0x0000e968, 0x000099bc },
	{ 0x0000e969, 0x000099df },
	{ 0x0000e96a, 0x000099db },
	{ 0x0000e96b, 0x000099dd },
	{ 0x0000e96c, 0x000099d8 },
	{ 0x0000e96d, 0x000099d1 },
	{ 0x0000e96e, 0x000099ed },
	{ 0x0000e96f, 0x000099ee },
	{ 0x0000e970, 0x000099f1 },
	{ 0x0000e971, 0x000099f2 },
	{ 0x0000e972, 0x000099fb },
	{ 0x0000e973, 0x000099f8 },
	{ 0x0000e974, 0x00009a01 },
	{ 0x0000e975, 0x00009a0f },
	{ 0x0000e976, 0x00009a05 },
	{ 0x0000e977, 0x000099e2 },
	{ 0x0000e978, 0x00009a19 },
	{ 0x0000e979, 0x00009a2b },
	{ 0x0000e97a, 0x00009a37 },
	{ 0x0000e97b, 0x00009a45 },
	{ 0x0000e97c, 0x00009a42 },
	{ 0x0000e97d, 0x00009a40 },
	{ 0x0000e97e, 0x00009a43 },
	{ 0x0000e980, 0x00009a3e },
	{ 0x0000e981, 0x00009a55 },
	{ 0x0000e982, 0x00009a4d },
	{ 0x0000e983, 0x00009a5b },
	{ 0x0000e984, 0x00009a57 },
	{ 0x0000e985, 0x00009a5f },
	{ 0x0000e986, 0x00009a62 },
	{ 0x0000e987, 0x00009a65 },
	{ 0x0000e988, 0x00009a64 },
	{ 0x0000e989, 0x00009a69 },
	{ 0x0000e98a, 0x00009a6b },
	{ 0x0000e98b, 0x00009a6a },
	{ 0x0000e98c, 0x00009aad },
	{ 0x0000e98d, 0x00009ab0 },
	{ 0x0000e98e, 0x00009abc },
	{ 0x0000e98f, 0x00009ac0 },
	{ 0x0000e990, 0x00009acf },
	{ 0x0000e991, 0x00009ad1 },
	{ 0x0000e992, 0x00009ad3 },
	{ 0x0000e993, 0x00009ad4 },
	{ 0x0000e994, 0x00009ade },
	{ 0x0000e995, 0x00009adf },
	{ 0x0000e996, 0x00009ae2 },
	{ 0x0000e997, 0x00009ae3 },
	{ 0x0000e998, 0x00009ae6 },
	{ 0x0000e999, 0x00009aef },
	{ 0x0000e99a, 0x00009aeb },
	{ 0x0000e99b, 0x00009aee },
	{ 0x0000e99c, 0x00009af4 },
	{ 0x0000e99d, 0x00009af1 },
	{ 0x0000e99e, 0x00009af7 },
	{ 0x0000e99f, 0x00009afb },
	{ 0x0000e9a0, 0x00009b06 },
	{ 0x0000e9a1, 0x00009b18 },
	{ 0x0000e9a2, 0x00009b1a },
	{ 0x0000e9a3, 0x00009b1f },
	{ 0x0000e9a4, 0x00009b22 },
	{ 0x0000e9a5, 0x00009b23 },
	{ 0x0000e9a6, 0x00009b25 },
	{ 0x0000e9a7, 0x00009b27 },
	{ 0x0000e9a8, 0x00009b28 },
	{ 0x0000e9a9, 0x00009b29 },
	{ 0x0000e9aa, 0x00009b2a },
	{ 0x0000e9ab, 0x00009b2e },
	{ 0x0000e9ac, 0x00009b2f },
	{ 0x0000e9ad, 0x00009b32 },
	{ 0x0000e9ae, 0x00009b44 },
	{ 0x0000e9af, 0x00009b43 },
	{ 0x0000e9b0, 0x00009b4f },
	{ 0x0000e9b1, 0x00009b4d },
	{ 0x0000e9b2, 0x00009b4e },
	{ 0x0000e9b3, 0x00009b51 },
	{ 0x0000e9b4, 0x00009b58 },
	{ 0x0000e9b5, 0x00009b74 },
	{ 0x0000e9b6, 0x00009b93 },
	{ 0x0000e9b7, 0x00009b83 },
	{ 0x0000e9b8, 0x00009b91 },
	{ 0x0000e9b9, 0x00009b96 },
	{ 0x0000e9ba, 0x00009b97 },
	{ 0x0000e9bb, 0x00009b9f },
	{ 0x0000e9bc, 0x00009ba0 },
	{ 0x0000e9bd, 0x00009ba8 },
	{ 0x0000e9be, 0x00009bb4 },
	{ 0x0000e9bf, 0x00009bc0 },
	{ 0x0000e9c0, 0x00009bca },
	{ 0x0000e9c1, 0x00009bb9 },
	{ 0x0000e9c2, 0x00009bc6 },
	{ 0x0000e9c3, 0x00009bcf },
	{ 0x0000e9c4, 0x00009bd1 },
	{ 0x0000e9c5, 0x00009bd2 },
	{ 0x0000e9c6, 0x00009be3 },
	{ 0x0000e9c7, 0x00009be2 },
	{ 0x0000e9c8, 0x00009be4 },
	{ 0x0000e9c9, 0x00009bd4 },
	{ 0x0000e9ca, 0x00009be1 },
	{ 0x0000e9cb, 0x00009c3a },
	{ 0x0000e9cc, 0x00009bf2 },
	{ 0x0000e9cd, 0x00009bf1 },
	{ 0x0000e9ce, 0x00009bf0 },
	{ 0x0000e9cf, 0x00009c15 },
	{ 0x0000e9d0, 0x00009c14 },
	{ 0x0000e9d1, 0x00009c09 },
	{ 0x0000e9d2, 0x00009c13 },
	{ 0x0000e9d3, 0x00009c0c },
	{ 0x0000e9d4, 0x00009c06 },
	{ 0x0000e9d5, 0x00009c08 },
	{ 0x0000e9d6, 0x00009c12 },
	{ 0x0000e9d7, 0x00009c0a },
	{ 0x0000e9d8, 0x00009c04 },
	{ 0x0000e9d9, 0x00009c2e },
	{ 0x0000e9da, 0x00009c1b },
	{ 0x0000e9db, 0x00009c25 },
	{ 0x0000e9dc, 0x00009c24 },
	{ 0x0000e9dd, 0x00009c21 },
	{ 0x0000e9de, 0x00009c30 },
	{ 0x0000e9df, 0x00009c47 },
	{ 0x0000e9e0, 0x00009c32 },
	{ 0x0000e9e1, 0x00009c46 },
	{ 0x0000e9e2, 0x00009c3e },
	{ 0x0000e9e3, 0x00009c5a },
	{ 0x0000e9e4, 0x00009c60 },
	{ 0x0000e9e5, 0x00009c67 },
	{ 0x0000e9e6, 0x00009c76 },
	{ 0x0000e9e7, 0x00009c78 },
	{ 0x0000e9e8, 0x00009ce7 },
	{ 0x0000e9e9, 0x00009cec },
	{ 0x0000e9ea, 0x00009cf0 },
	{ 0x0000e9eb, 0x00009d09 },
	{ 0x0000e9ec, 0x00009d08 },
	{ 0x0000e9ed, 0x00009ceb },
	{ 0x0000e9ee, 0x00009d03 },
	{ 0x0000e9ef, 0x00009d06 },
	{ 0x0000e9f0, 0x00009d2a },
	{ 0x0000e9f1, 0x00009d26 },
	{ 0x0000e9f2, 0x00009daf },
	{ 0x0000e9f3, 0x00009d23 },
	{ 0x0000e9f4, 0x00009d1f },
	{ 0x0000e9f5, 0x00009d44 },
	{ 0x0000e9f6, 0x00009d15 },
	{ 0x0000e9f7, 0x00009d12 },
	{ 0x0000e9f8, 0x00009d41 },
	{ 0x0000e9f9, 0x00009d3f },
	{ 0x0000e9fa, 0x00009d3e },
	{ 0x0000e9fb, 0x00009d46 },
	{ 0x0000e9fc, 0x00009d48 },
	{ 0x0000ea40, 0x00009d5d },
	{ 0x0000ea41, 0x00009d5e },
	{ 0x0000ea42, 0x00009d64 },
	{ 0x0000ea43, 0x00009d51 },
	{ 0x0000ea44, 0x00009d50 },
	{ 0x0000ea45, 0x00009d59 },
	{ 0x0000ea46, 0x00009d72 },
	{ 0x0000ea47, 0x00009d89 },
	{ 0x0000ea48, 0x00009d87 },
	{ 0x0000ea49, 0x00009dab },
	{ 0x0000ea4a, 0x00009d6f },
	{ 0x0000ea4b, 0x00009d7a },
	{ 0x0000ea4c, 0x00009d9a },
	{ 0x0000ea4d, 0x00009da4 },
	{ 0x0000ea4e, 0x00009da9 },
	{ 0x0000ea4f, 0x00009db2 },
	{ 0x0000ea50, 0x00009dc4 },
	{ 0x0000ea51, 0x00009dc1 },
	{ 0x0000ea52, 0x00009dbb },
	{ 0x0000ea53, 0x00009db8 },
	{ 0x0000ea54, 0x00009dba },
	{ 0x0000ea55, 0x00009dc6 },
	{ 0x0000ea56, 0x00009dcf },
	{ 0x0000ea57, 0x00009dc2 },
	{ 0x0000ea58, 0x00009dd9 },
	{ 0x0000ea59, 0x00009dd3 },
	{ 0x0000ea5a, 0x00009df8 },
	{ 0x0000ea5b, 0x00009de6 },
	{ 0x0000ea5c, 0x00009ded },
	{ 0x0000ea5d, 0x00009def },
	{ 0x0000ea5e, 0x00009dfd },
	{ 0x0000ea5f, 0x00009e1a },
	{ 0x0000ea60, 0x00009e1b },
	{ 0x0000ea61, 0x00009e1e },
	{ 0x0000ea62, 0x00009e75 },
	{ 0x0000ea63, 0x00009e79 },
	{ 0x0000ea64, 0x00009e7d },
	{ 0x0000ea65, 0x00009e81 },
	{ 0x0000ea66, 0x00009e88 },
	{ 0x0000ea67, 0x00009e8b },
	{ 0x0000ea68, 0x00009e8c },
	{ 0x0000ea69, 0x00009e92 },
	{ 0x0000ea6a, 0x00009e95 },
	{ 0x0000ea6b, 0x00009e91 },
	{ 0x0000ea6c, 0x00009e9d },
	{ 0x0000ea6d, 0x00009ea5 },
	{ 0x0000ea6e, 0x00009ea9 },
	{ 0x0000ea6f, 0x00009eb8 },
	{ 0x0000ea70, 0x00009eaa },
	{ 0x0000ea71, 0x00009ead },
	{ 0x0000ea72, 0x00009761 },
	{ 0x0000ea73, 0x00009ecc },
	{ 0x0000ea74, 0x00009ece },
	{ 0x0000ea75, 0x00009ecf },
	{ 0x0000ea76, 0x00009ed0 },
	{ 0x0000ea77, 0x00009ed4 },
	{ 0x0000ea78, 0x00009edc },
	{ 0x0000ea79, 0x00009ede },
	{ 0x0000ea7a, 0x00009edd },
	{ 0x0000ea7b, 0x00009ee0 },
	{ 0x0000ea7c, 0x00009ee5 },
	{ 0x0000ea7d, 0x00009ee8 },
	{ 0x0000ea7e, 0x00009eef },
	{ 0x0000ea80, 0x00009ef4 },
	{ 0x0000ea81, 0x00009ef6 },
	{ 0x0000ea82, 0x00009ef7 },
	{ 0x0000ea83, 0x00009ef9 },
	{ 0x0000ea84, 0x00009efb },
	{ 0x0000ea85, 0x00009efc },
	{ 0x0000ea86, 0x00009efd },
	{ 0x0000ea87, 0x00009f07 },
	{ 0x0000ea88, 0x00009f08 },
	{ 0x0000ea89, 0x000076b7 },
	{ 0x0000ea8a, 0x00009f15 },
	{ 0x0000ea8b, 0x00009f21 },
	{ 0x0000ea8c, 0x00009f2c },
	{ 0x0000ea8d, 0x00009f3e },
	{ 0x0000ea8e, 0x00009f4a },
	{ 0x0000ea8f, 0x00009f52 },
	{ 0x0000ea90, 0x00009f54 },
	{ 0x0000ea91, 0x00009f63 },
	{ 0x0000ea92, 0x00009f5f },
	{ 0x0000ea93, 0x00009f60 },
	{ 0x0000ea94, 0x00009f61 },
	{ 0x0000ea95, 0x00009f66 },
	{ 0x0000ea96, 0x00009f67 },
	{ 0x0000ea97, 0x00009f6c },
	{ 0x0000ea98, 0x00009f6a },
	{ 0x0000ea99, 0x00009f77 },
	{ 0x0000ea9a, 0x00009f72 },
	{ 0x0000ea9b, 0x00009f76 },
	{ 0x0000ea9c, 0x00009f95 },
	{ 0x0000ea9d, 0x00009f9c },
	{ 0x0000ea9e, 0x00009fa0 },
	{ 0x0000ea9f, 0x0000582f },
	{ 0x0000eaa0, 0x000069c7 },
	{ 0x0000eaa1, 0x00009059 },
	{ 0x0000eaa2, 0x00007464 },
	{ 0x0000eaa3, 0x000051dc },
	{ 0x0000eaa4, 0x00007199 },
};

struct unicode2kuten_lookup __shiftjis_mskanji_table__unicode2kuten_lookup[] = {
	{ 0x000000a2, 0x00008191 },
	{ 0x000000a3, 0x00008192 },
	{ 0x000000a7, 0x00008198 },
	{ 0x000000a8, 0x0000814e },
	{ 0x000000ac, 0x000081ca },
	{ 0x000000b0, 0x0000818b },
	{ 0x000000b1, 0x0000817d },
	{ 0x000000b4, 0x0000814c },
	{ 0x000000b6, 0x000081f7 },
	{ 0x000000d7, 0x0000817e },
	{ 0x000000f7, 0x00008180 },
	{ 0x00000391, 0x0000839f },
	{ 0x00000392, 0x000083a0 },
	{ 0x00000393, 0x000083a1 },
	{ 0x00000394, 0x000083a2 },
	{ 0x00000395, 0x000083a3 },
	{ 0x00000396, 0x000083a4 },
	{ 0x00000397, 0x000083a5 },
	{ 0x00000398, 0x000083a6 },
	{ 0x00000399, 0x000083a7 },
	{ 0x0000039a, 0x000083a8 },
	{ 0x0000039b, 0x000083a9 },
	{ 0x0000039c, 0x000083aa },
	{ 0x0000039d, 0x000083ab },
	{ 0x0000039e, 0x000083ac },
	{ 0x0000039f, 0x000083ad },
	{ 0x000003a0, 0x000083ae },
	{ 0x000003a1, 0x000083af },
	{ 0x000003a3, 0x000083b0 },
	{ 0x000003a4, 0x000083b1 },
	{ 0x000003a5, 0x000083b2 },
	{ 0x000003a6, 0x000083b3 },
	{ 0x000003a7, 0x000083b4 },
	{ 0x000003a8, 0x000083b5 },
	{ 0x000003a9, 0x000083b6 },
	{ 0x000003b1, 0x000083bf },
	{ 0x000003b2, 0x000083c0 },
	{ 0x000003b3, 0x000083c1 },
	{ 0x000003b4, 0x000083c2 },
	{ 0x000003b5, 0x000083c3 },
	{ 0x000003b6, 0x000083c4 },
	{ 0x000003b7, 0x000083c5 },
	{ 0x000003b8, 0x000083c6 },
	{ 0x000003b9, 0x000083c7 },
	{ 0x000003ba, 0x000083c8 },
	{ 0x000003bb, 0x000083c9 },
	{ 0x000003bc, 0x000083ca },
	{ 0x000003bd, 0x000083cb },
	{ 0x000003be, 0x000083cc },
	{ 0x000003bf, 0x000083cd },
	{ 0x000003c0, 0x000083ce },
	{ 0x000003c1, 0x000083cf },
	{ 0x000003c3, 0x000083d0 },
	{ 0x000003c4, 0x000083d1 },
	{ 0x000003c5, 0x000083d2 },
	{ 0x000003c6, 0x000083d3 },
	{ 0x000003c7, 0x000083d4 },
	{ 0x000003c8, 0x000083d5 },
	{ 0x000003c9, 0x000083d6 },
	{ 0x00000401, 0x00008446 },
	{ 0x00000410, 0x00008440 },
	{ 0x00000411, 0x00008441 },
	{ 0x00000412, 0x00008442 },
	{ 0x00000413, 0x00008443 },
	{ 0x00000414, 0x00008444 },
	{ 0x00000415, 0x00008445 },
	{ 0x00000416, 0x00008447 },
	{ 0x00000417, 0x00008448 },
	{ 0x00000418, 0x00008449 },
	{ 0x00000419, 0x0000844a },
	{ 0x0000041a, 0x0000844b },
	{ 0x0000041b, 0x0000844c },
	{ 0x0000041c, 0x0000844d },
	{ 0x0000041d, 0x0000844e },
	{ 0x0000041e, 0x0000844f },
	{ 0x0000041f, 0x00008450 },
	{ 0x00000420, 0x00008451 },
	{ 0x00000421, 0x00008452 },
	{ 0x00000422, 0x00008453 },
	{ 0x00000423, 0x00008454 },
	{ 0x00000424, 0x00008455 },
	{ 0x00000425, 0x00008456 },
	{ 0x00000426, 0x00008457 },
	{ 0x00000427, 0x00008458 },
	{ 0x00000428, 0x00008459 },
	{ 0x00000429, 0x0000845a },
	{ 0x0000042a, 0x0000845b },
	{ 0x0000042b, 0x0000845c },
	{ 0x0000042c, 0x0000845d },
	{ 0x0000042d, 0x0000845e },
	{ 0x0000042e, 0x0000845f },
	{ 0x0000042f, 0x00008460 },
	{ 0x00000430, 0x00008470 },
	{ 0x00000431, 0x00008471 },
	{ 0x00000432, 0x00008472 },
	{ 0x00000433, 0x00008473 },
	{ 0x00000434, 0x00008474 },
	{ 0x00000435, 0x00008475 },
	{ 0x00000436, 0x00008477 },
	{ 0x00000437, 0x00008478 },
	{ 0x00000438, 0x00008479 },
	{ 0x00000439, 0x0000847a },
	{ 0x0000043a, 0x0000847b },
	{ 0x0000043b, 0x0000847c },
	{ 0x0000043c, 0x0000847d },
	{ 0x0000043d, 0x0000847e },
	{ 0x0000043e, 0x00008480 },
	{ 0x0000043f, 0x00008481 },
	{ 0x00000440, 0x00008482 },
	{ 0x00000441, 0x00008483 },
	{ 0x00000442, 0x00008484 },
	{ 0x00000443, 0x00008485 },
	{ 0x00000444, 0x00008486 },
	{ 0x00000445, 0x00008487 },
	{ 0x00000446, 0x00008488 },
	{ 0x00000447, 0x00008489 },
	{ 0x00000448, 0x0000848a },
	{ 0x00000449, 0x0000848b },
	{ 0x0000044a, 0x0000848c },
	{ 0x0000044b, 0x0000848d },
	{ 0x0000044c, 0x0000848e },
	{ 0x0000044d, 0x0000848f },
	{ 0x0000044e, 0x00008490 },
	{ 0x0000044f, 0x00008491 },
	{ 0x00000451, 0x00008476 },
	{ 0x00002010, 0x0000815d },
	{ 0x00002014, 0x0000815c },
	{ 0x00002016, 0x00008161 },
	{ 0x00002018, 0x00008165 },
	{ 0x00002019, 0x00008166 },
	{ 0x0000201c, 0x00008167 },
	{ 0x0000201d, 0x00008168 },
	{ 0x00002020, 0x000081f5 },
	{ 0x00002021, 0x000081f6 },
	{ 0x00002025, 0x00008164 },
	{ 0x00002026, 0x00008163 },
	{ 0x00002030, 0x000081f1 },
	{ 0x00002032, 0x0000818c },
	{ 0x00002033, 0x0000818d },
	{ 0x0000203b, 0x000081a6 },
	{ 0x00002103, 0x0000818e },
	{ 0x0000212b, 0x000081f0 },
	{ 0x00002190, 0x000081a9 },
	{ 0x00002191, 0x000081aa },
	{ 0x00002192, 0x000081a8 },
	{ 0x00002193, 0x000081ab },
	{ 0x000021d2, 0x000081cb },
	{ 0x000021d4, 0x000081cc },
	{ 0x00002200, 0x000081cd },
	{ 0x00002202, 0x000081dd },
	{ 0x00002203, 0x000081ce },
	{ 0x00002207, 0x000081de },
	{ 0x00002208, 0x000081b8 },
	{ 0x0000220b, 0x000081b9 },
	{ 0x00002212, 0x0000817c },
	{ 0x0000221a, 0x000081e3 },
	{ 0x0000221d, 0x000081e5 },
	{ 0x0000221e, 0x00008187 },
	{ 0x00002220, 0x000081da },
	{ 0x00002227, 0x000081c8 },
	{ 0x00002228, 0x000081c9 },
	{ 0x00002229, 0x000081bf },
	{ 0x0000222a, 0x000081be },
	{ 0x0000222b, 0x000081e7 },
	{ 0x0000222c, 0x000081e8 },
	{ 0x00002234, 0x00008188 },
	{ 0x00002235, 0x000081e6 },
	{ 0x0000223d, 0x000081e4 },
	{ 0x00002252, 0x000081e0 },
	{ 0x00002260, 0x00008182 },
	{ 0x00002261, 0x000081df },
	{ 0x00002266, 0x00008185 },
	{ 0x00002267, 0x00008186 },
	{ 0x0000226a, 0x000081e1 },
	{ 0x0000226b, 0x000081e2 },
	{ 0x00002282, 0x000081bc },
	{ 0x00002283, 0x000081bd },
	{ 0x00002286, 0x000081ba },
	{ 0x00002287, 0x000081bb },
	{ 0x000022a5, 0x000081db },
	{ 0x00002312, 0x000081dc },
	{ 0x00002500, 0x0000849f },
	{ 0x00002501, 0x000084aa },
	{ 0x00002502, 0x000084a0 },
	{ 0x00002503, 0x000084ab },
	{ 0x0000250c, 0x000084a1 },
	{ 0x0000250f, 0x000084ac },
	{ 0x00002510, 0x000084a2 },
	{ 0x00002513, 0x000084ad },
	{ 0x00002514, 0x000084a4 },
	{ 0x00002517, 0x000084af },
	{ 0x00002518, 0x000084a3 },
	{ 0x0000251b, 0x000084ae },
	{ 0x0000251c, 0x000084a5 },
	{ 0x0000251d, 0x000084ba },
	{ 0x00002520, 0x000084b5 },
	{ 0x00002523, 0x000084b0 },
	{ 0x00002524, 0x000084a7 },
	{ 0x00002525, 0x000084bc },
	{ 0x00002528, 0x000084b7 },
	{ 0x0000252b, 0x000084b2 },
	{ 0x0000252c, 0x000084a6 },
	{ 0x0000252f, 0x000084b6 },
	{ 0x00002530, 0x000084bb },
	{ 0x00002533, 0x000084b1 },
	{ 0x00002534, 0x000084a8 },
	{ 0x00002537, 0x000084b8 },
	{ 0x00002538, 0x000084bd },
	{ 0x0000253b, 0x000084b3 },
	{ 0x0000253c, 0x000084a9 },
	{ 0x0000253f, 0x000084b9 },
	{ 0x00002542, 0x000084be },
	{ 0x0000254b, 0x000084b4 },
	{ 0x000025a0, 0x000081a1 },
	{ 0x000025a1, 0x000081a0 },
	{ 0x000025b2, 0x000081a3 },
	{ 0x000025b3, 0x000081a2 },
	{ 0x000025bc, 0x000081a5 },
	{ 0x000025bd, 0x000081a4 },
	{ 0x000025c6, 0x0000819f },
	{ 0x000025c7, 0x0000819e },
	{ 0x000025cb, 0x0000819b },
	{ 0x000025ce, 0x0000819d },
	{ 0x000025cf, 0x0000819c },
	{ 0x000025ef, 0x000081fc },
	{ 0x00002605, 0x0000819a },
	{ 0x00002606, 0x00008199 },
	{ 0x00002640, 0x0000818a },
	{ 0x00002642, 0x00008189 },
	{ 0x0000266a, 0x000081f4 },
	{ 0x0000266d, 0x000081f3 },
	{ 0x0000266f, 0x000081f2 },
	{ 0x00003000, 0x00008140 },
	{ 0x00003001, 0x00008141 },
	{ 0x00003002, 0x00008142 },
	{ 0x00003003, 0x00008156 },
	{ 0x00003005, 0x00008158 },
	{ 0x00003006, 0x00008159 },
	{ 0x00003007, 0x0000815a },
	{ 0x00003008, 0x00008171 },
	{ 0x00003009, 0x00008172 },
	{ 0x0000300a, 0x00008173 },
	{ 0x0000300b, 0x00008174 },
	{ 0x0000300c, 0x00008175 },
	{ 0x0000300d, 0x00008176 },
	{ 0x0000300e, 0x00008177 },
	{ 0x0000300f, 0x00008178 },
	{ 0x00003010, 0x00008179 },
	{ 0x00003011, 0x0000817a },
	{ 0x00003012, 0x000081a7 },
	{ 0x00003013, 0x000081ac },
	{ 0x00003014, 0x0000816b },
	{ 0x00003015, 0x0000816c },
	{ 0x0000301c, 0x00008160 },
	{ 0x00003041, 0x0000829f },
	{ 0x00003042, 0x000082a0 },
	{ 0x00003043, 0x000082a1 },
	{ 0x00003044, 0x000082a2 },
	{ 0x00003045, 0x000082a3 },
	{ 0x00003046, 0x000082a4 },
	{ 0x00003047, 0x000082a5 },
	{ 0x00003048, 0x000082a6 },
	{ 0x00003049, 0x000082a7 },
	{ 0x0000304a, 0x000082a8 },
	{ 0x0000304b, 0x000082a9 },
	{ 0x0000304c, 0x000082aa },
	{ 0x0000304d, 0x000082ab },
	{ 0x0000304e, 0x000082ac },
	{ 0x0000304f, 0x000082ad },
	{ 0x00003050, 0x000082ae },
	{ 0x00003051, 0x000082af },
	{ 0x00003052, 0x000082b0 },
	{ 0x00003053, 0x000082b1 },
	{ 0x00003054, 0x000082b2 },
	{ 0x00003055, 0x000082b3 },
	{ 0x00003056, 0x000082b4 },
	{ 0x00003057, 0x000082b5 },
	{ 0x00003058, 0x000082b6 },
	{ 0x00003059, 0x000082b7 },
	{ 0x0000305a, 0x000082b8 },
	{ 0x0000305b, 0x000082b9 },
	{ 0x0000305c, 0x000082ba },
	{ 0x0000305d, 0x000082bb },
	{ 0x0000305e, 0x000082bc },
	{ 0x0000305f, 0x000082bd },
	{ 0x00003060, 0x000082be },
	{ 0x00003061, 0x000082bf },
	{ 0x00003062, 0x000082c0 },
	{ 0x00003063, 0x000082c1 },
	{ 0x00003064, 0x000082c2 },
	{ 0x00003065, 0x000082c3 },
	{ 0x00003066, 0x000082c4 },
	{ 0x00003067, 0x000082c5 },
	{ 0x00003068, 0x000082c6 },
	{ 0x00003069, 0x000082c7 },
	{ 0x0000306a, 0x000082c8 },
	{ 0x0000306b, 0x000082c9 },
	{ 0x0000306c, 0x000082ca },
	{ 0x0000306d, 0x000082cb },
	{ 0x0000306e, 0x000082cc },
	{ 0x0000306f, 0x000082cd },
	{ 0x00003070, 0x000082ce },
	{ 0x00003071, 0x000082cf },
	{ 0x00003072, 0x000082d0 },
	{ 0x00003073, 0x000082d1 },
	{ 0x00003074, 0x000082d2 },
	{ 0x00003075, 0x000082d3 },
	{ 0x00003076, 0x000082d4 },
	{ 0x00003077, 0x000082d5 },
	{ 0x00003078, 0x000082d6 },
	{ 0x00003079, 0x000082d7 },
	{ 0x0000307a, 0x000082d8 },
	{ 0x0000307b, 0x000082d9 },
	{ 0x0000307c, 0x000082da },
	{ 0x0000307d, 0x000082db },
	{ 0x0000307e, 0x000082dc },
	{ 0x0000307f, 0x000082dd },
	{ 0x00003080, 0x000082de },
	{ 0x00003081, 0x000082df },
	{ 0x00003082, 0x000082e0 },
	{ 0x00003083, 0x000082e1 },
	{ 0x00003084, 0x000082e2 },
	{ 0x00003085, 0x000082e3 },
	{ 0x00003086, 0x000082e4 },
	{ 0x00003087, 0x000082e5 },
	{ 0x00003088, 0x000082e6 },
	{ 0x00003089, 0x000082e7 },
	{ 0x0000308a, 0x000082e8 },
	{ 0x0000308b, 0x000082e9 },
	{ 0x0000308c, 0x000082ea },
	{ 0x0000308d, 0x000082eb },
	{ 0x0000308e, 0x000082ec },
	{ 0x0000308f, 0x000082ed },
	{ 0x00003090, 0x000082ee },
	{ 0x00003091, 0x000082ef },
	{ 0x00003092, 0x000082f0 },
	{ 0x00003093, 0x000082f1 },
	{ 0x0000309b, 0x0000814a },
	{ 0x0000309c, 0x0000814b },
	{ 0x0000309d, 0x00008154 },
	{ 0x0000309e, 0x00008155 },
	{ 0x000030a1, 0x00008340 },
	{ 0x000030a2, 0x00008341 },
	{ 0x000030a3, 0x00008342 },
	{ 0x000030a4, 0x00008343 },
	{ 0x000030a5, 0x00008344 },
	{ 0x000030a6, 0x00008345 },
	{ 0x000030a7, 0x00008346 },
	{ 0x000030a8, 0x00008347 },
	{ 0x000030a9, 0x00008348 },
	{ 0x000030aa, 0x00008349 },
	{ 0x000030ab, 0x0000834a },
	{ 0x000030ac, 0x0000834b },
	{ 0x000030ad, 0x0000834c },
	{ 0x000030ae, 0x0000834d },
	{ 0x000030af, 0x0000834e },
	{ 0x000030b0, 0x0000834f },
	{ 0x000030b1, 0x00008350 },
	{ 0x000030b2, 0x00008351 },
	{ 0x000030b3, 0x00008352 },
	{ 0x000030b4, 0x00008353 },
	{ 0x000030b5, 0x00008354 },
	{ 0x000030b6, 0x00008355 },
	{ 0x000030b7, 0x00008356 },
	{ 0x000030b8, 0x00008357 },
	{ 0x000030b9, 0x00008358 },
	{ 0x000030ba, 0x00008359 },
	{ 0x000030bb, 0x0000835a },
	{ 0x000030bc, 0x0000835b },
	{ 0x000030bd, 0x0000835c },
	{ 0x000030be, 0x0000835d },
	{ 0x000030bf, 0x0000835e },
	{ 0x000030c0, 0x0000835f },
	{ 0x000030c1, 0x00008360 },
	{ 0x000030c2, 0x00008361 },
	{ 0x000030c3, 0x00008362 },
	{ 0x000030c4, 0x00008363 },
	{ 0x000030c5, 0x00008364 },
	{ 0x000030c6, 0x00008365 },
	{ 0x000030c7, 0x00008366 },
	{ 0x000030c8, 0x00008367 },
	{ 0x000030c9, 0x00008368 },
	{ 0x000030ca, 0x00008369 },
	{ 0x000030cb, 0x0000836a },
	{ 0x000030cc, 0x0000836b },
	{ 0x000030cd, 0x0000836c },
	{ 0x000030ce, 0x0000836d },
	{ 0x000030cf, 0x0000836e },
	{ 0x000030d0, 0x0000836f },
	{ 0x000030d1, 0x00008370 },
	{ 0x000030d2, 0x00008371 },
	{ 0x000030d3, 0x00008372 },
	{ 0x000030d4, 0x00008373 },
	{ 0x000030d5, 0x00008374 },
	{ 0x000030d6, 0x00008375 },
	{ 0x000030d7, 0x00008376 },
	{ 0x000030d8, 0x00008377 },
	{ 0x000030d9, 0x00008378 },
	{ 0x000030da, 0x00008379 },
	{ 0x000030db, 0x0000837a },
	{ 0x000030dc, 0x0000837b },
	{ 0x000030dd, 0x0000837c },
	{ 0x000030de, 0x0000837d },
	{ 0x000030df, 0x0000837e },
	{ 0x000030e0, 0x00008380 },
	{ 0x000030e1, 0x00008381 },
	{ 0x000030e2, 0x00008382 },
	{ 0x000030e3, 0x00008383 },
	{ 0x000030e4, 0x00008384 },
	{ 0x000030e5, 0x00008385 },
	{ 0x000030e6, 0x00008386 },
	{ 0x000030e7, 0x00008387 },
	{ 0x000030e8, 0x00008388 },
	{ 0x000030e9, 0x00008389 },
	{ 0x000030ea, 0x0000838a },
	{ 0x000030eb, 0x0000838b },
	{ 0x000030ec, 0x0000838c },
	{ 0x000030ed, 0x0000838d },
	{ 0x000030ee, 0x0000838e },
	{ 0x000030ef, 0x0000838f },
	{ 0x000030f0, 0x00008390 },
	{ 0x000030f1, 0x00008391 },
	{ 0x000030f2, 0x00008392 },
	{ 0x000030f3, 0x00008393 },
	{ 0x000030f4, 0x00008394 },
	{ 0x000030f5, 0x00008395 },
	{ 0x000030f6, 0x00008396 },
	{ 0x000030fb, 0x00008145 },
	{ 0x000030fc, 0x0000815b },
	{ 0x000030fd, 0x00008152 },
	{ 0x000030fe, 0x00008153 },
	{ 0x00004e00, 0x000088ea },
	{ 0x00004e01, 0x0000929a },
	{ 0x00004e03, 0x00008eb5 },
	{ 0x00004e07, 0x0000969c },
	{ 0x00004e08, 0x00008fe4 },
	{ 0x00004e09, 0x00008e4f },
	{ 0x00004e0a, 0x00008fe3 },
	{ 0x00004e0b, 0x000089ba },
	{ 0x00004e0d, 0x00009573 },
	{ 0x00004e0e, 0x0000975e },
	{ 0x00004e10, 0x000098a0 },
	{ 0x00004e11, 0x0000894e },
	{ 0x00004e14, 0x00008a8e },
	{ 0x00004e15, 0x000098a1 },
	{ 0x00004e16, 0x000090a2 },
	{ 0x00004e17, 0x000099c0 },
	{ 0x00004e18, 0x00008b75 },
	{ 0x00004e19, 0x000095b8 },
	{ 0x00004e1e, 0x00008fe5 },
	{ 0x00004e21, 0x000097bc },
	{ 0x00004e26, 0x000095c0 },
	{ 0x00004e2a, 0x000098a2 },
	{ 0x00004e2d, 0x00009286 },
	{ 0x00004e31, 0x000098a3 },
	{ 0x00004e32, 0x00008bf8 },
	{ 0x00004e36, 0x000098a4 },
	{ 0x00004e38, 0x00008adb },
	{ 0x00004e39, 0x0000924f },
	{ 0x00004e3b, 0x00008ee5 },
	{ 0x00004e3c, 0x000098a5 },
	{ 0x00004e3f, 0x000098a6 },
	{ 0x00004e42, 0x000098a7 },
	{ 0x00004e43, 0x00009454 },
	{ 0x00004e45, 0x00008b76 },
	{ 0x00004e4b, 0x00009456 },
	{ 0x00004e4d, 0x000093e1 },
	{ 0x00004e4e, 0x00008cc1 },
	{ 0x00004e4f, 0x00009652 },
	{ 0x00004e55, 0x0000e568 },
	{ 0x00004e56, 0x000098a8 },
	{ 0x00004e57, 0x00008fe6 },
	{ 0x00004e58, 0x000098a9 },
	{ 0x00004e59, 0x000089b3 },
	{ 0x00004e5d, 0x00008be3 },
	{ 0x00004e5e, 0x00008cee },
	{ 0x00004e5f, 0x000096e7 },
	{ 0x00004e62, 0x00009ba4 },
	{ 0x00004e71, 0x00009790 },
	{ 0x00004e73, 0x000093fb },
	{ 0x00004e7e, 0x00008aa3 },
	{ 0x00004e80, 0x00008b54 },
	{ 0x00004e82, 0x000098aa },
	{ 0x00004e85, 0x000098ab },
	{ 0x00004e86, 0x000097b9 },
	{ 0x00004e88, 0x0000975c },
	{ 0x00004e89, 0x00009188 },
	{ 0x00004e8a, 0x000098ad },
	{ 0x00004e8b, 0x00008e96 },
	{ 0x00004e8c, 0x000093f1 },
	{ 0x00004e8e, 0x000098b0 },
	{ 0x00004e91, 0x0000895d },
	{ 0x00004e92, 0x00008cdd },
	{ 0x00004e94, 0x00008cdc },
	{ 0x00004e95, 0x000088e4 },
	{ 0x00004e98, 0x0000986a },
	{ 0x00004e99, 0x00009869 },
	{ 0x00004e9b, 0x00008db1 },
	{ 0x00004e9c, 0x0000889f },
	{ 0x00004e9e, 0x000098b1 },
	{ 0x00004e9f, 0x000098b2 },
	{ 0x00004ea0, 0x000098b3 },
	{ 0x00004ea1, 0x00009653 },
	{ 0x00004ea2, 0x000098b4 },
	{ 0x00004ea4, 0x00008cf0 },
	{ 0x00004ea5, 0x000088e5 },
	{ 0x00004ea6, 0x00009692 },
	{ 0x00004ea8, 0x00008b9c },
	{ 0x00004eab, 0x00008b9d },
	{ 0x00004eac, 0x00008b9e },
	{ 0x00004ead, 0x000092e0 },
	{ 0x00004eae, 0x000097ba },
	{ 0x00004eb0, 0x000098b5 },
	{ 0x00004eb3, 0x000098b6 },
	{ 0x00004eb6, 0x000098b7 },
	{ 0x00004eba, 0x0000906c },
	{ 0x00004ec0, 0x00008f59 },
	{ 0x00004ec1, 0x0000906d },
	{ 0x00004ec2, 0x000098bc },
	{ 0x00004ec4, 0x000098ba },
	{ 0x00004ec6, 0x000098bb },
	{ 0x00004ec7, 0x00008b77 },
	{ 0x00004eca, 0x00008da1 },
	{ 0x00004ecb, 0x000089ee },
	{ 0x00004ecd, 0x000098b9 },
	{ 0x00004ece, 0x000098b8 },
	{ 0x00004ecf, 0x000095a7 },
	{ 0x00004ed4, 0x00008e65 },
	{ 0x00004ed5, 0x00008e64 },
	{ 0x00004ed6, 0x000091bc },
	{ 0x00004ed7, 0x000098bd },
	{ 0x00004ed8, 0x00009574 },
	{ 0x00004ed9, 0x000090e5 },
	{ 0x00004edd, 0x00008157 },
	{ 0x00004ede, 0x000098be },
	{ 0x00004edf, 0x000098c0 },
	{ 0x00004ee3, 0x000091e3 },
	{ 0x00004ee4, 0x000097df },
	{ 0x00004ee5, 0x000088c8 },
	{ 0x00004eed, 0x000098bf },
	{ 0x00004eee, 0x000089bc },
	{ 0x00004ef0, 0x00008bc2 },
	{ 0x00004ef2, 0x00009287 },
	{ 0x00004ef6, 0x00008c8f },
	{ 0x00004ef7, 0x000098c1 },
	{ 0x00004efb, 0x00009443 },
	{ 0x00004f01, 0x00008ae9 },
	{ 0x00004f09, 0x000098c2 },
	{ 0x00004f0a, 0x000088c9 },
	{ 0x00004f0d, 0x00008cde },
	{ 0x00004f0e, 0x00008aea },
	{ 0x00004f0f, 0x0000959a },
	{ 0x00004f10, 0x000094b0 },
	{ 0x00004f11, 0x00008b78 },
	{ 0x00004f1a, 0x000089ef },
	{ 0x00004f1c, 0x000098e5 },
	{ 0x00004f1d, 0x00009360 },
	{ 0x00004f2f, 0x0000948c },
	{ 0x00004f30, 0x000098c4 },
	{ 0x00004f34, 0x000094ba },
	{ 0x00004f36, 0x000097e0 },
	{ 0x00004f38, 0x0000904c },
	{ 0x00004f3a, 0x00008e66 },
	{ 0x00004f3c, 0x00008e97 },
	{ 0x00004f3d, 0x000089be },
	{ 0x00004f43, 0x000092cf },
	{ 0x00004f46, 0x00009241 },
	{ 0x00004f47, 0x000098c8 },
	{ 0x00004f4d, 0x000088ca },
	{ 0x00004f4e, 0x000092e1 },
	{ 0x00004f4f, 0x00008f5a },
	{ 0x00004f50, 0x00008db2 },
	{ 0x00004f51, 0x00009743 },
	{ 0x00004f53, 0x000091cc },
	{ 0x00004f55, 0x000089bd },
	{ 0x00004f57, 0x000098c7 },
	{ 0x00004f59, 0x0000975d },
	{ 0x00004f5a, 0x000098c3 },
	{ 0x00004f5b, 0x000098c5 },
	{ 0x00004f5c, 0x00008dec },
	{ 0x00004f5d, 0x000098c6 },
	{ 0x00004f5e, 0x00009b43 },
	{ 0x00004f69, 0x000098ce },
	{ 0x00004f6f, 0x000098d1 },
	{ 0x00004f70, 0x000098cf },
	{ 0x00004f73, 0x000089c0 },
	{ 0x00004f75, 0x000095b9 },
	{ 0x00004f76, 0x000098c9 },
	{ 0x00004f7b, 0x000098cd },
	{ 0x00004f7c, 0x00008cf1 },
	{ 0x00004f7f, 0x00008e67 },
	{ 0x00004f83, 0x00008aa4 },
	{ 0x00004f86, 0x000098d2 },
	{ 0x00004f88, 0x000098ca },
	{ 0x00004f8b, 0x000097e1 },
	{ 0x00004f8d, 0x00008e98 },
	{ 0x00004f8f, 0x000098cb },
	{ 0x00004f91, 0x000098d0 },
	{ 0x00004f96, 0x000098d3 },
	{ 0x00004f98, 0x000098cc },
	{ 0x00004f9b, 0x00008b9f },
	{ 0x00004f9d, 0x000088cb },
	{ 0x00004fa0, 0x00008ba0 },
	{ 0x00004fa1, 0x000089bf },
	{ 0x00004fab, 0x00009b44 },
	{ 0x00004fad, 0x00009699 },
	{ 0x00004fae, 0x0000958e },
	{ 0x00004faf, 0x00008cf2 },
	{ 0x00004fb5, 0x0000904e },
	{ 0x00004fb6, 0x000097b5 },
	{ 0x00004fbf, 0x000095d6 },
	{ 0x00004fc2, 0x00008c57 },
	{ 0x00004fc3, 0x000091a3 },
	{ 0x00004fc4, 0x000089e2 },
	{ 0x00004fca, 0x00008f72 },
	{ 0x00004fce, 0x000098d7 },
	{ 0x00004fd0, 0x000098dc },
	{ 0x00004fd1, 0x000098da },
	{ 0x00004fd4, 0x000098d5 },
	{ 0x00004fd7, 0x000091ad },
	{ 0x00004fd8, 0x000098d8 },
	{ 0x00004fda, 0x000098db },
	{ 0x00004fdb, 0x000098d9 },
	{ 0x00004fdd, 0x000095db },
	{ 0x00004fdf, 0x000098d6 },
	{ 0x00004fe1, 0x0000904d },
	{ 0x00004fe3, 0x00009693 },
	{ 0x00004fe4, 0x000098dd },
	{ 0x00004fe5, 0x000098de },
	{ 0x00004fee, 0x00008f43 },
	{ 0x00004fef, 0x000098eb },
	{ 0x00004ff3, 0x0000946f },
	{ 0x00004ff5, 0x00009555 },
	{ 0x00004ff6, 0x000098e6 },
	{ 0x00004ff8, 0x000095ee },
	{ 0x00004ffa, 0x000089b4 },
	{ 0x00004ffe, 0x000098ea },
	{ 0x00005005, 0x000098e4 },
	{ 0x00005006, 0x000098ed },
	{ 0x00005009, 0x00009171 },
	{ 0x0000500b, 0x00008cc2 },
	{ 0x0000500d, 0x0000947b },
	{ 0x0000500f, 0x0000e0c5 },
	{ 0x00005011, 0x000098ec },
	{ 0x00005012, 0x0000937c },
	{ 0x00005014, 0x000098e1 },
	{ 0x00005016, 0x00008cf4 },
	{ 0x00005019, 0x00008cf3 },
	{ 0x0000501a, 0x000098df },
	{ 0x0000501f, 0x00008ed8 },
	{ 0x00005021, 0x000098e7 },
	{ 0x00005023, 0x000095ed },
	{ 0x00005024, 0x0000926c },
	{ 0x00005025, 0x000098e3 },
	{ 0x00005026, 0x00008c91 },
	{ 0x00005028, 0x000098e0 },
	{ 0x00005029, 0x000098e8 },
	{ 0x0000502a, 0x000098e2 },
	{ 0x0000502b, 0x000097cf },
	{ 0x0000502c, 0x000098e9 },
	{ 0x0000502d, 0x00009860 },
	{ 0x00005036, 0x00008be4 },
	{ 0x00005039, 0x00008c90 },
	{ 0x00005043, 0x000098ee },
	{ 0x00005047, 0x000098ef },
	{ 0x00005048, 0x000098f3 },
	{ 0x00005049, 0x000088cc },
	{ 0x0000504f, 0x000095ce },
	{ 0x00005050, 0x000098f2 },
	{ 0x00005055, 0x000098f1 },
	{ 0x00005056, 0x000098f5 },
	{ 0x0000505a, 0x000098f4 },
	{ 0x0000505c, 0x000092e2 },
	{ 0x00005065, 0x00008c92 },
	{ 0x0000506c, 0x000098f6 },
	{ 0x00005072, 0x00008ec3 },
	{ 0x00005074, 0x000091a4 },
	{ 0x00005075, 0x000092e3 },
	{ 0x00005076, 0x00008bf4 },
	{ 0x00005078, 0x000098f7 },
	{ 0x0000507d, 0x00008b55 },
	{ 0x00005080, 0x000098f8 },
	{ 0x00005085, 0x000098fa },
	{ 0x0000508d, 0x00009654 },
	{ 0x00005091, 0x00008c86 },
	{ 0x00005098, 0x00008e50 },
	{ 0x00005099, 0x000094f5 },
	{ 0x0000509a, 0x000098f9 },
	{ 0x000050ac, 0x00008dc3 },
	{ 0x000050ad, 0x00009762 },
	{ 0x000050b2, 0x000098fc },
	{ 0x000050b3, 0x00009942 },
	{ 0x000050b4, 0x000098fb },
	{ 0x000050b5, 0x00008dc2 },
	{ 0x000050b7, 0x00008f9d },
	{ 0x000050be, 0x00008c58 },
	{ 0x000050c2, 0x00009943 },
	{ 0x000050c5, 0x00008bcd },
	{ 0x000050c9, 0x00009940 },
	{ 0x000050ca, 0x00009941 },
	{ 0x000050cd, 0x000093ad },
	{ 0x000050cf, 0x0000919c },
	{ 0x000050d1, 0x00008ba1 },
	{ 0x000050d5, 0x0000966c },
	{ 0x000050d6, 0x00009944 },
	{ 0x000050da, 0x000097bb },
	{ 0x000050de, 0x00009945 },
	{ 0x000050e3, 0x00009948 },
	{ 0x000050e5, 0x00009946 },
	{ 0x000050e7, 0x0000916d },
	{ 0x000050ed, 0x00009947 },
	{ 0x000050ee, 0x00009949 },
	{ 0x000050f5, 0x0000994b },
	{ 0x000050f9, 0x0000994a },
	{ 0x000050fb, 0x000095c6 },
	{ 0x00005100, 0x00008b56 },
	{ 0x00005101, 0x0000994d },
	{ 0x00005102, 0x0000994e },
	{ 0x00005104, 0x000089ad },
	{ 0x00005109, 0x0000994c },
	{ 0x00005112, 0x00008ef2 },
	{ 0x00005114, 0x00009951 },
	{ 0x00005115, 0x00009950 },
	{ 0x00005116, 0x0000994f },
	{ 0x00005118, 0x000098d4 },
	{ 0x0000511a, 0x00009952 },
	{ 0x0000511f, 0x00008f9e },
	{ 0x00005121, 0x00009953 },
	{ 0x0000512a, 0x00009744 },
	{ 0x00005132, 0x000096d7 },
	{ 0x00005137, 0x00009955 },
	{ 0x0000513a, 0x00009954 },
	{ 0x0000513b, 0x00009957 },
	{ 0x0000513c, 0x00009956 },
	{ 0x0000513f, 0x00009958 },
	{ 0x00005140, 0x00009959 },
	{ 0x00005141, 0x000088f2 },
	{ 0x00005143, 0x00008cb3 },
	{ 0x00005144, 0x00008c5a },
	{ 0x00005145, 0x00008f5b },
	{ 0x00005146, 0x0000929b },
	{ 0x00005147, 0x00008ba2 },
	{ 0x00005148, 0x000090e6 },
	{ 0x00005149, 0x00008cf5 },
	{ 0x0000514b, 0x00008d8e },
	{ 0x0000514c, 0x0000995b },
	{ 0x0000514d, 0x000096c6 },
	{ 0x0000514e, 0x00009365 },
	{ 0x00005150, 0x00008e99 },
	{ 0x00005152, 0x0000995a },
	{ 0x00005154, 0x0000995c },
	{ 0x0000515a, 0x0000937d },
	{ 0x0000515c, 0x00008a95 },
	{ 0x00005162, 0x0000995d },
	{ 0x00005165, 0x000093fc },
	{ 0x00005168, 0x00009153 },
	{ 0x00005169, 0x0000995f },
	{ 0x0000516a, 0x00009960 },
	{ 0x0000516b, 0x000094aa },
	{ 0x0000516c, 0x00008cf6 },
	{ 0x0000516d, 0x0000985a },
	{ 0x0000516e, 0x00009961 },
	{ 0x00005171, 0x00008ba4 },
	{ 0x00005175, 0x000095ba },
	{ 0x00005176, 0x000091b4 },
	{ 0x00005177, 0x00008bef },
	{ 0x00005178, 0x00009354 },
	{ 0x0000517c, 0x00008c93 },
	{ 0x00005180, 0x00009962 },
	{ 0x00005182, 0x00009963 },
	{ 0x00005185, 0x000093e0 },
	{ 0x00005186, 0x0000897e },
	{ 0x00005189, 0x00009966 },
	{ 0x0000518a, 0x00008dfb },
	{ 0x0000518c, 0x00009965 },
	{ 0x0000518d, 0x00008dc4 },
	{ 0x0000518f, 0x00009967 },
	{ 0x00005190, 0x0000e3ec },
	{ 0x00005191, 0x00009968 },
	{ 0x00005192, 0x00009660 },
	{ 0x00005193, 0x00009969 },
	{ 0x00005195, 0x0000996a },
	{ 0x00005196, 0x0000996b },
	{ 0x00005197, 0x00008fe7 },
	{ 0x00005199, 0x00008eca },
	{ 0x000051a0, 0x00008aa5 },
	{ 0x000051a2, 0x0000996e },
	{ 0x000051a4, 0x0000996c },
	{ 0x000051a5, 0x000096bb },
	{ 0x000051a6, 0x0000996d },
	{ 0x000051a8, 0x00009579 },
	{ 0x000051a9, 0x0000996f },
	{ 0x000051aa, 0x00009970 },
	{ 0x000051ab, 0x00009971 },
	{ 0x000051ac, 0x0000937e },
	{ 0x000051b0, 0x00009975 },
	{ 0x000051b1, 0x00009973 },
	{ 0x000051b2, 0x00009974 },
	{ 0x000051b3, 0x00009972 },
	{ 0x000051b4, 0x00008de1 },
	{ 0x000051b5, 0x00009976 },
	{ 0x000051b6, 0x000096e8 },
	{ 0x000051b7, 0x000097e2 },
	{ 0x000051bd, 0x00009977 },
	{ 0x000051c4, 0x000090a6 },
	{ 0x000051c5, 0x00009978 },
	{ 0x000051c6, 0x00008f79 },
	{ 0x000051c9, 0x00009979 },
	{ 0x000051cb, 0x0000929c },
	{ 0x000051cc, 0x000097bd },
	{ 0x000051cd, 0x00009380 },
	{ 0x000051d6, 0x000099c3 },
	{ 0x000051db, 0x0000997a },
	{ 0x000051dc, 0x0000eaa3 },
	{ 0x000051dd, 0x00008bc3 },
	{ 0x000051e0, 0x0000997b },
	{ 0x000051e1, 0x0000967d },
	{ 0x000051e6, 0x00008f88 },
	{ 0x000051e7, 0x000091fa },
	{ 0x000051e9, 0x0000997d },
	{ 0x000051ea, 0x000093e2 },
	{ 0x000051ed, 0x0000997e },
	{ 0x000051f0, 0x00009980 },
	{ 0x000051f1, 0x00008a4d },
	{ 0x000051f5, 0x00009981 },
	{ 0x000051f6, 0x00008ba5 },
	{ 0x000051f8, 0x000093ca },
	{ 0x000051f9, 0x0000899a },
	{ 0x000051fa, 0x00008f6f },
	{ 0x000051fd, 0x0000949f },
	{ 0x000051fe, 0x00009982 },
	{ 0x00005200, 0x00009381 },
	{ 0x00005203, 0x0000906e },
	{ 0x00005204, 0x00009983 },
	{ 0x00005206, 0x000095aa },
	{ 0x00005207, 0x000090d8 },
	{ 0x00005208, 0x00008aa0 },
	{ 0x0000520a, 0x00008aa7 },
	{ 0x0000520b, 0x00009984 },
	{ 0x0000520e, 0x00009986 },
	{ 0x00005211, 0x00008c59 },
	{ 0x00005214, 0x00009985 },
	{ 0x00005217, 0x000097f1 },
	{ 0x0000521d, 0x00008f89 },
	{ 0x00005224, 0x000094bb },
	{ 0x00005225, 0x000095ca },
	{ 0x00005227, 0x00009987 },
	{ 0x00005229, 0x00009798 },
	{ 0x0000522a, 0x00009988 },
	{ 0x0000522e, 0x00009989 },
	{ 0x00005230, 0x0000939e },
	{ 0x00005233, 0x0000998a },
	{ 0x00005236, 0x000090a7 },
	{ 0x00005237, 0x00008dfc },
	{ 0x00005238, 0x00008c94 },
	{ 0x00005239, 0x0000998b },
	{ 0x0000523a, 0x00008e68 },
	{ 0x0000523b, 0x00008d8f },
	{ 0x00005243, 0x000092e4 },
	{ 0x00005244, 0x0000998d },
	{ 0x00005247, 0x000091a5 },
	{ 0x0000524a, 0x00008ded },
	{ 0x0000524b, 0x0000998e },
	{ 0x0000524c, 0x0000998f },
	{ 0x0000524d, 0x0000914f },
	{ 0x0000524f, 0x0000998c },
	{ 0x00005254, 0x00009991 },
	{ 0x00005256, 0x00009655 },
	{ 0x0000525b, 0x00008d84 },
	{ 0x0000525e, 0x00009990 },
	{ 0x00005263, 0x00008c95 },
	{ 0x00005264, 0x00008ddc },
	{ 0x00005265, 0x0000948d },
	{ 0x00005269, 0x00009994 },
	{ 0x0000526a, 0x00009992 },
	{ 0x0000526f, 0x0000959b },
	{ 0x00005270, 0x00008fe8 },
	{ 0x00005271, 0x0000999b },
	{ 0x00005272, 0x00008a84 },
	{ 0x00005273, 0x00009995 },
	{ 0x00005274, 0x00009993 },
	{ 0x00005275, 0x0000916e },
	{ 0x0000527d, 0x00009997 },
	{ 0x0000527f, 0x00009996 },
	{ 0x00005283, 0x00008a63 },
	{ 0x00005287, 0x00008c80 },
	{ 0x00005288, 0x0000999c },
	{ 0x00005289, 0x000097ab },
	{ 0x0000528d, 0x00009998 },
	{ 0x00005291, 0x0000999d },
	{ 0x00005292, 0x0000999a },
	{ 0x00005294, 0x00009999 },
	{ 0x0000529b, 0x000097cd },
	{ 0x0000529f, 0x00008cf7 },
	{ 0x000052a0, 0x000089c1 },
	{ 0x000052a3, 0x000097f2 },
	{ 0x000052a9, 0x00008f95 },
	{ 0x000052aa, 0x00009377 },
	{ 0x000052ab, 0x00008d85 },
	{ 0x000052ac, 0x000099a0 },
	{ 0x000052ad, 0x000099a1 },
	{ 0x000052b1, 0x000097e3 },
	{ 0x000052b4, 0x0000984a },
	{ 0x000052b5, 0x000099a3 },
	{ 0x000052b9, 0x00008cf8 },
	{ 0x000052bc, 0x000099a2 },
	{ 0x000052be, 0x00008a4e },
	{ 0x000052c1, 0x000099a4 },
	{ 0x000052c3, 0x00009675 },
	{ 0x000052c5, 0x000092ba },
	{ 0x000052c7, 0x00009745 },
	{ 0x000052c9, 0x000095d7 },
	{ 0x000052cd, 0x000099a5 },
	{ 0x000052d2, 0x0000e8d3 },
	{ 0x000052d5, 0x000093ae },
	{ 0x000052d7, 0x000099a6 },
	{ 0x000052d8, 0x00008aa8 },
	{ 0x000052d9, 0x000096b1 },
	{ 0x000052dd, 0x00008f9f },
	{ 0x000052de, 0x000099a7 },
	{ 0x000052df, 0x000095e5 },
	{ 0x000052e0, 0x000099ab },
	{ 0x000052e2, 0x000090a8 },
	{ 0x000052e3, 0x000099a8 },
	{ 0x000052e4, 0x00008bce },
	{ 0x000052e6, 0x000099a9 },
	{ 0x000052e7, 0x00008aa9 },
	{ 0x000052f2, 0x00008c4d },
	{ 0x000052f3, 0x000099ac },
	{ 0x000052f5, 0x000099ad },
	{ 0x000052f8, 0x000099ae },
	{ 0x000052f9, 0x000099af },
	{ 0x000052fa, 0x00008ed9 },
	{ 0x000052fe, 0x00008cf9 },
	{ 0x000052ff, 0x000096dc },
	{ 0x00005301, 0x000096e6 },
	{ 0x00005302, 0x000093f5 },
	{ 0x00005305, 0x000095ef },
	{ 0x00005306, 0x000099b0 },
	{ 0x00005308, 0x000099b1 },
	{ 0x0000530d, 0x000099b3 },
	{ 0x0000530f, 0x000099b5 },
	{ 0x00005310, 0x000099b4 },
	{ 0x00005315, 0x000099b6 },
	{ 0x00005316, 0x000089bb },
	{ 0x00005317, 0x0000966b },
	{ 0x00005319, 0x00008dfa },
	{ 0x0000531a, 0x000099b7 },
	{ 0x0000531d, 0x00009178 },
	{ 0x00005320, 0x00008fa0 },
	{ 0x00005321, 0x00008ba7 },
	{ 0x00005323, 0x000099b8 },
	{ 0x0000532a, 0x000094d9 },
	{ 0x0000532f, 0x000099b9 },
	{ 0x00005331, 0x000099ba },
	{ 0x00005333, 0x000099bb },
	{ 0x00005338, 0x000099bc },
	{ 0x00005339, 0x00009543 },
	{ 0x0000533a, 0x00008be6 },
	{ 0x0000533b, 0x000088e3 },
	{ 0x0000533f, 0x000093bd },
	{ 0x00005340, 0x000099bd },
	{ 0x00005341, 0x00008f5c },
	{ 0x00005343, 0x000090e7 },
	{ 0x00005345, 0x000099bf },
	{ 0x00005346, 0x000099be },
	{ 0x00005347, 0x00008fa1 },
	{ 0x00005348, 0x00008cdf },
	{ 0x00005349, 0x000099c1 },
	{ 0x0000534a, 0x000094bc },
	{ 0x0000534d, 0x000099c2 },
	{ 0x00005351, 0x000094da },
	{ 0x00005352, 0x000091b2 },
	{ 0x00005353, 0x000091ec },
	{ 0x00005354, 0x00008ba6 },
	{ 0x00005357, 0x000093ec },
	{ 0x00005358, 0x00009250 },
	{ 0x0000535a, 0x0000948e },
	{ 0x0000535c, 0x0000966d },
	{ 0x0000535e, 0x000099c4 },
	{ 0x00005360, 0x000090e8 },
	{ 0x00005366, 0x00008c54 },
	{ 0x00005369, 0x000099c5 },
	{ 0x0000536e, 0x000099c6 },
	{ 0x0000536f, 0x0000894b },
	{ 0x00005370, 0x000088f3 },
	{ 0x00005371, 0x00008aeb },
	{ 0x00005373, 0x000091a6 },
	{ 0x00005374, 0x00008b70 },
	{ 0x00005375, 0x00009791 },
	{ 0x00005377, 0x000099c9 },
	{ 0x00005378, 0x000089b5 },
	{ 0x0000537b, 0x000099c8 },
	{ 0x0000537f, 0x00008ba8 },
	{ 0x00005382, 0x000099ca },
	{ 0x00005384, 0x000096ef },
	{ 0x00005396, 0x000099cb },
	{ 0x00005398, 0x000097d0 },
	{ 0x0000539a, 0x00008cfa },
	{ 0x0000539f, 0x00008cb4 },
	{ 0x000053a0, 0x000099cc },
	{ 0x000053a5, 0x000099ce },
	{ 0x000053a6, 0x000099cd },
	{ 0x000053a8, 0x0000907e },
	{ 0x000053a9, 0x00008958 },
	{ 0x000053ad, 0x0000897d },
	{ 0x000053ae, 0x000099cf },
	{ 0x000053b0, 0x000099d0 },
	{ 0x000053b3, 0x00008cb5 },
	{ 0x000053b6, 0x000099d1 },
	{ 0x000053bb, 0x00008b8e },
	{ 0x000053c2, 0x00008e51 },
	{ 0x000053c3, 0x000099d2 },
	{ 0x000053c8, 0x00009694 },
	{ 0x000053c9, 0x00008db3 },
	{ 0x000053ca, 0x00008b79 },
	{ 0x000053cb, 0x00009746 },
	{ 0x000053cc, 0x0000916f },
	{ 0x000053cd, 0x000094bd },
	{ 0x000053ce, 0x00008efb },
	{ 0x000053d4, 0x00008f66 },
	{ 0x000053d6, 0x00008ee6 },
	{ 0x000053d7, 0x00008ef3 },
	{ 0x000053d9, 0x00008f96 },
	{ 0x000053db, 0x000094be },
	{ 0x000053df, 0x000099d5 },
	{ 0x000053e1, 0x00008962 },
	{ 0x000053e2, 0x00009170 },
	{ 0x000053e3, 0x00008cfb },
	{ 0x000053e4, 0x00008cc3 },
	{ 0x000053e5, 0x00008be5 },
	{ 0x000053e8, 0x000099d9 },
	{ 0x000053e9, 0x00009240 },
	{ 0x000053ea, 0x000091fc },
	{ 0x000053eb, 0x00008ba9 },
	{ 0x000053ec, 0x00008fa2 },
	{ 0x000053ed, 0x000099da },
	{ 0x000053ee, 0x000099d8 },
	{ 0x000053ef, 0x000089c2 },
	{ 0x000053f0, 0x000091e4 },
	{ 0x000053f1, 0x00008eb6 },
	{ 0x000053f2, 0x00008e6a },
	{ 0x000053f3, 0x00008945 },
	{ 0x000053f6, 0x00008a90 },
	{ 0x000053f7, 0x00008d86 },
	{ 0x000053f8, 0x00008e69 },
	{ 0x000053fa, 0x000099db },
	{ 0x00005401, 0x000099dc },
	{ 0x00005403, 0x00008b68 },
	{ 0x00005404, 0x00008a65 },
	{ 0x00005408, 0x00008d87 },
	{ 0x00005409, 0x00008b67 },
	{ 0x0000540a, 0x000092dd },
	{ 0x0000540b, 0x00008944 },
	{ 0x0000540c, 0x000093af },
	{ 0x0000540d, 0x000096bc },
	{ 0x0000540e, 0x00008d40 },
	{ 0x0000540f, 0x00009799 },
	{ 0x00005410, 0x00009366 },
	{ 0x00005411, 0x00008cfc },
	{ 0x0000541b, 0x00008c4e },
	{ 0x0000541d, 0x000099e5 },
	{ 0x0000541f, 0x00008be1 },
	{ 0x00005420, 0x00009669 },
	{ 0x00005426, 0x000094db },
	{ 0x00005429, 0x000099e4 },
	{ 0x0000542b, 0x00008adc },
	{ 0x0000542c, 0x000099df },
	{ 0x0000542d, 0x000099e0 },
	{ 0x0000542e, 0x000099e2 },
	{ 0x00005436, 0x000099e3 },
	{ 0x00005438, 0x00008b7a },
	{ 0x00005439, 0x00009081 },
	{ 0x0000543b, 0x000095ab },
	{ 0x0000543c, 0x000099e1 },
	{ 0x0000543d, 0x000099dd },
	{ 0x0000543e, 0x00008ce1 },
	{ 0x00005440, 0x000099de },
	{ 0x00005442, 0x00009843 },
	{ 0x00005446, 0x000095f0 },
	{ 0x00005448, 0x000092e6 },
	{ 0x00005449, 0x00008ce0 },
	{ 0x0000544a, 0x00008d90 },
	{ 0x0000544e, 0x000099e6 },
	{ 0x00005451, 0x000093db },
	{ 0x0000545f, 0x000099ea },
	{ 0x00005468, 0x00008efc },
	{ 0x0000546a, 0x00008ef4 },
	{ 0x00005470, 0x000099ed },
	{ 0x00005471, 0x000099eb },
	{ 0x00005473, 0x000096a1 },
	{ 0x00005475, 0x000099e8 },
	{ 0x00005476, 0x000099f1 },
	{ 0x00005477, 0x000099ec },
	{ 0x0000547b, 0x000099ef },
	{ 0x0000547c, 0x00008cc4 },
	{ 0x0000547d, 0x000096bd },
	{ 0x00005480, 0x000099f0 },
	{ 0x00005484, 0x000099f2 },
	{ 0x00005486, 0x000099f4 },
	{ 0x0000548b, 0x00008dee },
	{ 0x0000548c, 0x00009861 },
	{ 0x0000548e, 0x000099e9 },
	{ 0x0000548f, 0x000099e7 },
	{ 0x00005490, 0x000099f3 },
	{ 0x00005492, 0x000099ee },
	{ 0x000054a2, 0x000099f6 },
	{ 0x000054a4, 0x00009a42 },
	{ 0x000054a5, 0x000099f8 },
	{ 0x000054a8, 0x000099fc },
	{ 0x000054ab, 0x00009a40 },
	{ 0x000054ac, 0x000099f9 },
	{ 0x000054af, 0x00009a5d },
	{ 0x000054b2, 0x00008de7 },
	{ 0x000054b3, 0x00008a50 },
	{ 0x000054b8, 0x000099f7 },
	{ 0x000054bc, 0x00009a44 },
	{ 0x000054bd, 0x000088f4 },
	{ 0x000054be, 0x00009a43 },
	{ 0x000054c0, 0x000088a3 },
	{ 0x000054c1, 0x00009569 },
	{ 0x000054c2, 0x00009a41 },
	{ 0x000054c4, 0x000099fa },
	{ 0x000054c7, 0x000099f5 },
	{ 0x000054c8, 0x000099fb },
	{ 0x000054c9, 0x00008dc6 },
	{ 0x000054d8, 0x00009a45 },
	{ 0x000054e1, 0x000088f5 },
	{ 0x000054e2, 0x00009a4e },
	{ 0x000054e5, 0x00009a46 },
	{ 0x000054e6, 0x00009a47 },
	{ 0x000054e8, 0x00008fa3 },
	{ 0x000054e9, 0x00009689 },
	{ 0x000054ed, 0x00009a4c },
	{ 0x000054ee, 0x00009a4b },
	{ 0x000054f2, 0x0000934e },
	{ 0x000054fa, 0x00009a4d },
	{ 0x000054fd, 0x00009a4a },
	{ 0x00005504, 0x00008953 },
	{ 0x00005506, 0x00008db4 },
	{ 0x00005507, 0x0000904f },
	{ 0x0000550f, 0x00009a48 },
	{ 0x00005510, 0x00009382 },
	{ 0x00005514, 0x00009a49 },
	{ 0x00005516, 0x000088a0 },
	{ 0x0000552e, 0x00009a53 },
	{ 0x0000552f, 0x00009742 },
	{ 0x00005531, 0x00008fa5 },
	{ 0x00005533, 0x00009a59 },
	{ 0x00005538, 0x00009a58 },
	{ 0x00005539, 0x00009a4f },
	{ 0x0000553e, 0x000091c1 },
	{ 0x00005540, 0x00009a50 },
	{ 0x00005544, 0x000091ed },
	{ 0x00005545, 0x00009a55 },
	{ 0x00005546, 0x00008fa4 },
	{ 0x0000554c, 0x00009a52 },
	{ 0x0000554f, 0x000096e2 },
	{ 0x00005553, 0x00008c5b },
	{ 0x00005556, 0x00009a56 },
	{ 0x00005557, 0x00009a57 },
	{ 0x0000555c, 0x00009a54 },
	{ 0x0000555d, 0x00009a5a },
	{ 0x00005563, 0x00009a51 },
	{ 0x0000557b, 0x00009a60 },
	{ 0x0000557c, 0x00009a65 },
	{ 0x0000557e, 0x00009a61 },
	{ 0x00005580, 0x00009a5c },
	{ 0x00005583, 0x00009a66 },
	{ 0x00005584, 0x00009150 },
	{ 0x00005587, 0x00009a68 },
	{ 0x00005589, 0x00008d41 },
	{ 0x0000558a, 0x00009a5e },
	{ 0x0000558b, 0x0000929d },
	{ 0x00005598, 0x00009a62 },
	{ 0x00005599, 0x00009a5b },
	{ 0x0000559a, 0x00008aab },
	{ 0x0000559c, 0x00008aec },
	{ 0x0000559d, 0x00008a85 },
	{ 0x0000559e, 0x00009a63 },
	{ 0x0000559f, 0x00009a5f },
	{ 0x000055a7, 0x00008c96 },
	{ 0x000055a8, 0x00009a69 },
	{ 0x000055a9, 0x00009a67 },
	{ 0x000055aa, 0x00009172 },
	{ 0x000055ab, 0x00008b69 },
	{ 0x000055ac, 0x00008baa },
	{ 0x000055ae, 0x00009a64 },
	{ 0x000055b0, 0x00008bf2 },
	{ 0x000055b6, 0x00008963 },
	{ 0x000055c4, 0x00009a6d },
	{ 0x000055c5, 0x00009a6b },
	{ 0x000055c7, 0x00009aa5 },
	{ 0x000055d4, 0x00009a70 },
	{ 0x000055da, 0x00009a6a },
	{ 0x000055dc, 0x00009a6e },
	{ 0x000055df, 0x00009a6c },
	{ 0x000055e3, 0x00008e6b },
	{ 0x000055e4, 0x00009a6f },
	{ 0x000055f7, 0x00009a72 },
	{ 0x000055f9, 0x00009a77 },
	{ 0x000055fd, 0x00009a75 },
	{ 0x000055fe, 0x00009a74 },
	{ 0x00005606, 0x00009251 },
	{ 0x00005609, 0x000089c3 },
	{ 0x00005614, 0x00009a71 },
	{ 0x00005616, 0x00009a73 },
	{ 0x00005617, 0x00008fa6 },
	{ 0x00005618, 0x00008952 },
	{ 0x0000561b, 0x00009a76 },
	{ 0x00005629, 0x000089dc },
	{ 0x0000562f, 0x00009a82 },
	{ 0x00005631, 0x00008ffa },
	{ 0x00005632, 0x00009a7d },
	{ 0x00005634, 0x00009a7b },
	{ 0x00005636, 0x00009a7c },
	{ 0x00005638, 0x00009a7e },
	{ 0x00005642, 0x0000895c },
	{ 0x0000564c, 0x00009158 },
	{ 0x0000564e, 0x00009a78 },
	{ 0x00005650, 0x00009a79 },
	{ 0x0000565b, 0x00008a9a },
	{ 0x00005664, 0x00009a81 },
	{ 0x00005668, 0x00008aed },
	{ 0x0000566a, 0x00009a84 },
	{ 0x0000566b, 0x00009a80 },
	{ 0x0000566c, 0x00009a83 },
	{ 0x00005674, 0x000095ac },
	{ 0x00005678, 0x000093d3 },
	{ 0x0000567a, 0x000094b6 },
	{ 0x00005680, 0x00009a86 },
	{ 0x00005686, 0x00009a85 },
	{ 0x00005687, 0x00008a64 },
	{ 0x0000568a, 0x00009a87 },
	{ 0x0000568f, 0x00009a8a },
	{ 0x00005694, 0x00009a89 },
	{ 0x000056a0, 0x00009a88 },
	{ 0x000056a2, 0x00009458 },
	{ 0x000056a5, 0x00009a8b },
	{ 0x000056ae, 0x00009a8c },
	{ 0x000056b4, 0x00009a8e },
	{ 0x000056b6, 0x00009a8d },
	{ 0x000056bc, 0x00009a90 },
	{ 0x000056c0, 0x00009a93 },
	{ 0x000056c1, 0x00009a91 },
	{ 0x000056c2, 0x00009a8f },
	{ 0x000056c3, 0x00009a92 },
	{ 0x000056c8, 0x00009a94 },
	{ 0x000056ce, 0x00009a95 },
	{ 0x000056d1, 0x00009a96 },
	{ 0x000056d3, 0x00009a97 },
	{ 0x000056d7, 0x00009a98 },
	{ 0x000056d8, 0x00009964 },
	{ 0x000056da, 0x00008efa },
	{ 0x000056db, 0x00008e6c },
	{ 0x000056de, 0x000089f1 },
	{ 0x000056e0, 0x000088f6 },
	{ 0x000056e3, 0x00009263 },
	{ 0x000056ee, 0x00009a99 },
	{ 0x000056f0, 0x00008da2 },
	{ 0x000056f2, 0x000088cd },
	{ 0x000056f3, 0x0000907d },
	{ 0x000056f9, 0x00009a9a },
	{ 0x000056fa, 0x00008cc5 },
	{ 0x000056fd, 0x00008d91 },
	{ 0x000056ff, 0x00009a9c },
	{ 0x00005700, 0x00009a9b },
	{ 0x00005703, 0x000095de },
	{ 0x00005704, 0x00009a9d },
	{ 0x00005708, 0x00009a9f },
	{ 0x00005709, 0x00009a9e },
	{ 0x0000570b, 0x00009aa0 },
	{ 0x0000570d, 0x00009aa1 },
	{ 0x0000570f, 0x00008c97 },
	{ 0x00005712, 0x00008980 },
	{ 0x00005713, 0x00009aa2 },
	{ 0x00005716, 0x00009aa4 },
	{ 0x00005718, 0x00009aa3 },
	{ 0x0000571c, 0x00009aa6 },
	{ 0x0000571f, 0x00009379 },
	{ 0x00005726, 0x00009aa7 },
	{ 0x00005727, 0x000088b3 },
	{ 0x00005728, 0x00008ddd },
	{ 0x0000572d, 0x00008c5c },
	{ 0x00005730, 0x0000926e },
	{ 0x00005737, 0x00009aa8 },
	{ 0x00005738, 0x00009aa9 },
	{ 0x0000573b, 0x00009aab },
	{ 0x00005740, 0x00009aac },
	{ 0x00005742, 0x00008de2 },
	{ 0x00005747, 0x00008bcf },
	{ 0x0000574a, 0x00009656 },
	{ 0x0000574e, 0x00009aaa },
	{ 0x0000574f, 0x00009aad },
	{ 0x00005750, 0x00008dbf },
	{ 0x00005751, 0x00008d42 },
	{ 0x00005761, 0x00009ab1 },
	{ 0x00005764, 0x00008da3 },
	{ 0x00005766, 0x00009252 },
	{ 0x00005769, 0x00009aae },
	{ 0x0000576a, 0x000092d8 },
	{ 0x0000577f, 0x00009ab2 },
	{ 0x00005782, 0x00009082 },
	{ 0x00005788, 0x00009ab0 },
	{ 0x00005789, 0x00009ab3 },
	{ 0x0000578b, 0x00008c5e },
	{ 0x00005793, 0x00009ab4 },
	{ 0x000057a0, 0x00009ab5 },
	{ 0x000057a2, 0x00008d43 },
	{ 0x000057a3, 0x00008a5f },
	{ 0x000057a4, 0x00009ab7 },
	{ 0x000057aa, 0x00009ab8 },
	{ 0x000057b0, 0x00009ab9 },
	{ 0x000057b3, 0x00009ab6 },
	{ 0x000057c0, 0x00009aaf },
	{ 0x000057c3, 0x00009aba },
	{ 0x000057c6, 0x00009abb },
	{ 0x000057cb, 0x00009684 },
	{ 0x000057ce, 0x00008fe9 },
	{ 0x000057d2, 0x00009abd },
	{ 0x000057d3, 0x00009abe },
	{ 0x000057d4, 0x00009abc },
	{ 0x000057d6, 0x00009ac0 },
	{ 0x000057dc, 0x00009457 },
	{ 0x000057df, 0x000088e6 },
	{ 0x000057e0, 0x00009575 },
	{ 0x000057e3, 0x00009ac1 },
	{ 0x000057f4, 0x00008ffb },
	{ 0x000057f7, 0x00008eb7 },
	{ 0x000057f9, 0x0000947c },
	{ 0x000057fa, 0x00008aee },
	{ 0x000057fc, 0x00008de9 },
	{ 0x00005800, 0x00009678 },
	{ 0x00005802, 0x000093b0 },
	{ 0x00005805, 0x00008c98 },
	{ 0x00005806, 0x000091cd },
	{ 0x0000580a, 0x00009abf },
	{ 0x0000580b, 0x00009ac2 },
	{ 0x00005815, 0x000091c2 },
	{ 0x00005819, 0x00009ac3 },
	{ 0x0000581d, 0x00009ac4 },
	{ 0x00005821, 0x00009ac6 },
	{ 0x00005824, 0x000092e7 },
	{ 0x0000582a, 0x00008aac },
	{ 0x0000582f, 0x0000ea9f },
	{ 0x00005830, 0x00008981 },
	{ 0x00005831, 0x000095f1 },
	{ 0x00005834, 0x00008fea },
	{ 0x00005835, 0x00009367 },
	{ 0x0000583a, 0x00008de4 },
	{ 0x0000583d, 0x00009acc },
	{ 0x00005840, 0x000095bb },
	{ 0x00005841, 0x000097db },
	{ 0x0000584a, 0x000089f2 },
	{ 0x0000584b, 0x00009ac8 },
	{ 0x00005851, 0x00009159 },
	{ 0x00005852, 0x00009acb },
	{ 0x00005854, 0x00009383 },
	{ 0x00005857, 0x00009368 },
	{ 0x00005858, 0x00009384 },
	{ 0x00005859, 0x000094b7 },
	{ 0x0000585a, 0x000092cb },
	{ 0x0000585e, 0x00008dc7 },
	{ 0x00005862, 0x00009ac7 },
	{ 0x00005869, 0x00008996 },
	{ 0x0000586b, 0x00009355 },
	{ 0x00005870, 0x00009ac9 },
	{ 0x00005872, 0x00009ac5 },
	{ 0x00005875, 0x0000906f },
	{ 0x00005879, 0x00009acd },
	{ 0x0000587e, 0x00008f6d },
	{ 0x00005883, 0x00008bab },
	{ 0x00005885, 0x00009ace },
	{ 0x00005893, 0x000095e6 },
	{ 0x00005897, 0x0000919d },
	{ 0x0000589c, 0x000092c4 },
	{ 0x0000589f, 0x00009ad0 },
	{ 0x000058a8, 0x0000966e },
	{ 0x000058ab, 0x00009ad1 },
	{ 0x000058ae, 0x00009ad6 },
	{ 0x000058b3, 0x000095ad },
	{ 0x000058b8, 0x00009ad5 },
	{ 0x000058b9, 0x00009acf },
	{ 0x000058ba, 0x00009ad2 },
	{ 0x000058bb, 0x00009ad4 },
	{ 0x000058be, 0x00008da4 },
	{ 0x000058c1, 0x000095c7 },
	{ 0x000058c5, 0x00009ad7 },
	{ 0x000058c7, 0x00009264 },
	{ 0x000058ca, 0x000089f3 },
	{ 0x000058cc, 0x00008feb },
	{ 0x000058d1, 0x00009ad9 },
	{ 0x000058d3, 0x00009ad8 },
	{ 0x000058d5, 0x00008d88 },
	{ 0x000058d7, 0x00009ada },
	{ 0x000058d8, 0x00009adc },
	{ 0x000058d9, 0x00009adb },
	{ 0x000058dc, 0x00009ade },
	{ 0x000058de, 0x00009ad3 },
	{ 0x000058df, 0x00009ae0 },
	{ 0x000058e4, 0x00009adf },
	{ 0x000058e5, 0x00009add },
	{ 0x000058eb, 0x00008e6d },
	{ 0x000058ec, 0x00009070 },
	{ 0x000058ee, 0x00009173 },
	{ 0x000058ef, 0x00009ae1 },
	{ 0x000058f0, 0x000090ba },
	{ 0x000058f1, 0x000088eb },
	{ 0x000058f2, 0x00009484 },
	{ 0x000058f7, 0x000092d9 },
	{ 0x000058f9, 0x00009ae3 },
	{ 0x000058fa, 0x00009ae2 },
	{ 0x000058fb, 0x00009ae4 },
	{ 0x000058fc, 0x00009ae5 },
	{ 0x000058fd, 0x00009ae6 },
	{ 0x00005902, 0x00009ae7 },
	{ 0x00005909, 0x000095cf },
	{ 0x0000590a, 0x00009ae8 },
	{ 0x0000590f, 0x000089c4 },
	{ 0x00005910, 0x00009ae9 },
	{ 0x00005915, 0x0000975b },
	{ 0x00005916, 0x00008a4f },
	{ 0x00005918, 0x000099c7 },
	{ 0x00005919, 0x00008f67 },
	{ 0x0000591a, 0x000091bd },
	{ 0x0000591b, 0x00009aea },
	{ 0x0000591c, 0x000096e9 },
	{ 0x00005922, 0x000096b2 },
	{ 0x00005925, 0x00009aec },
	{ 0x00005927, 0x000091e5 },
	{ 0x00005929, 0x00009356 },
	{ 0x0000592a, 0x000091be },
	{ 0x0000592b, 0x00009576 },
	{ 0x0000592c, 0x00009aed },
	{ 0x0000592d, 0x00009aee },
	{ 0x0000592e, 0x0000899b },
	{ 0x00005931, 0x00008eb8 },
	{ 0x00005932, 0x00009aef },
	{ 0x00005937, 0x000088ce },
	{ 0x00005938, 0x00009af0 },
	{ 0x0000593e, 0x00009af1 },
	{ 0x00005944, 0x00008982 },
	{ 0x00005947, 0x00008aef },
	{ 0x00005948, 0x000093de },
	{ 0x00005949, 0x000095f2 },
	{ 0x0000594e, 0x00009af5 },
	{ 0x0000594f, 0x00009174 },
	{ 0x00005950, 0x00009af4 },
	{ 0x00005951, 0x00008c5f },
	{ 0x00005954, 0x0000967a },
	{ 0x00005955, 0x00009af3 },
	{ 0x00005957, 0x00009385 },
	{ 0x00005958, 0x00009af7 },
	{ 0x0000595a, 0x00009af6 },
	{ 0x00005960, 0x00009af9 },
	{ 0x00005962, 0x00009af8 },
	{ 0x00005965, 0x0000899c },
	{ 0x00005967, 0x00009afa },
	{ 0x00005968, 0x00008fa7 },
	{ 0x00005969, 0x00009afc },
	{ 0x0000596a, 0x00009244 },
	{ 0x0000596c, 0x00009afb },
	{ 0x0000596e, 0x000095b1 },
	{ 0x00005973, 0x00008f97 },
	{ 0x00005974, 0x0000937a },
	{ 0x00005978, 0x00009b40 },
	{ 0x0000597d, 0x00008d44 },
	{ 0x00005981, 0x00009b41 },
	{ 0x00005982, 0x00009440 },
	{ 0x00005983, 0x000094dc },
	{ 0x00005984, 0x000096cf },
	{ 0x0000598a, 0x00009444 },
	{ 0x0000598d, 0x00009b4a },
	{ 0x00005993, 0x00008b57 },
	{ 0x00005996, 0x00009764 },
	{ 0x00005999, 0x000096ad },
	{ 0x0000599b, 0x00009baa },
	{ 0x0000599d, 0x00009b42 },
	{ 0x000059a3, 0x00009b45 },
	{ 0x000059a5, 0x000091c3 },
	{ 0x000059a8, 0x00009657 },
	{ 0x000059ac, 0x00009369 },
	{ 0x000059b2, 0x00009b46 },
	{ 0x000059b9, 0x00009685 },
	{ 0x000059bb, 0x00008dc8 },
	{ 0x000059be, 0x00008fa8 },
	{ 0x000059c6, 0x00009b47 },
	{ 0x000059c9, 0x00008e6f },
	{ 0x000059cb, 0x00008e6e },
	{ 0x000059d0, 0x000088b7 },
	{ 0x000059d1, 0x00008cc6 },
	{ 0x000059d3, 0x000090a9 },
	{ 0x000059d4, 0x000088cf },
	{ 0x000059d9, 0x00009b4b },
	{ 0x000059da, 0x00009b4c },
	{ 0x000059dc, 0x00009b49 },
	{ 0x000059e5, 0x00008957 },
	{ 0x000059e6, 0x00008aad },
	{ 0x000059e8, 0x00009b48 },
	{ 0x000059ea, 0x000096c3 },
	{ 0x000059eb, 0x00009550 },
	{ 0x000059f6, 0x000088a6 },
	{ 0x000059fb, 0x000088f7 },
	{ 0x000059ff, 0x00008e70 },
	{ 0x00005a01, 0x000088d0 },
	{ 0x00005a03, 0x000088a1 },
	{ 0x00005a09, 0x00009b51 },
	{ 0x00005a11, 0x00009b4f },
	{ 0x00005a18, 0x000096ba },
	{ 0x00005a1a, 0x00009b52 },
	{ 0x00005a1c, 0x00009b50 },
	{ 0x00005a1f, 0x00009b4e },
	{ 0x00005a20, 0x00009050 },
	{ 0x00005a25, 0x00009b4d },
	{ 0x00005a29, 0x000095d8 },
	{ 0x00005a2f, 0x00008ce2 },
	{ 0x00005a35, 0x00009b56 },
	{ 0x00005a36, 0x00009b57 },
	{ 0x00005a3c, 0x00008fa9 },
	{ 0x00005a40, 0x00009b53 },
	{ 0x00005a41, 0x0000984b },
	{ 0x00005a46, 0x0000946b },
	{ 0x00005a49, 0x00009b55 },
	{ 0x00005a5a, 0x00008da5 },
	{ 0x00005a62, 0x00009b58 },
	{ 0x00005a66, 0x00009577 },
	{ 0x00005a6a, 0x00009b59 },
	{ 0x00005a6c, 0x00009b54 },
	{ 0x00005a7f, 0x000096b9 },
	{ 0x00005a92, 0x0000947d },
	{ 0x00005a9a, 0x00009b5a },
	{ 0x00005a9b, 0x00009551 },
	{ 0x00005abc, 0x00009b5b },
	{ 0x00005abd, 0x00009b5f },
	{ 0x00005abe, 0x00009b5c },
	{ 0x00005ac1, 0x000089c5 },
	{ 0x00005ac2, 0x00009b5e },
	{ 0x00005ac9, 0x00008eb9 },
	{ 0x00005acb, 0x00009b5d },
	{ 0x00005acc, 0x00008c99 },
	{ 0x00005ad0, 0x00009b6b },
	{ 0x00005ad6, 0x00009b64 },
	{ 0x00005ad7, 0x00009b61 },
	{ 0x00005ae1, 0x00009284 },
	{ 0x00005ae3, 0x00009b60 },
	{ 0x00005ae6, 0x00009b62 },
	{ 0x00005ae9, 0x00009b63 },
	{ 0x00005afa, 0x00009b65 },
	{ 0x00005afb, 0x00009b66 },
	{ 0x00005b09, 0x00008af0 },
	{ 0x00005b0b, 0x00009b68 },
	{ 0x00005b0c, 0x00009b67 },
	{ 0x00005b16, 0x00009b69 },
	{ 0x00005b22, 0x00008fec },
	{ 0x00005b2a, 0x00009b6c },
	{ 0x00005b2c, 0x000092da },
	{ 0x00005b30, 0x00008964 },
	{ 0x00005b32, 0x00009b6a },
	{ 0x00005b36, 0x00009b6d },
	{ 0x00005b3e, 0x00009b6e },
	{ 0x00005b40, 0x00009b71 },
	{ 0x00005b43, 0x00009b6f },
	{ 0x00005b45, 0x00009b70 },
	{ 0x00005b50, 0x00008e71 },
	{ 0x00005b51, 0x00009b72 },
	{ 0x00005b54, 0x00008d45 },
	{ 0x00005b55, 0x00009b73 },
	{ 0x00005b57, 0x00008e9a },
	{ 0x00005b58, 0x000091b6 },
	{ 0x00005b5a, 0x00009b74 },
	{ 0x00005b5b, 0x00009b75 },
	{ 0x00005b5c, 0x00008e79 },
	{ 0x00005b5d, 0x00008d46 },
	{ 0x00005b5f, 0x000096d0 },
	{ 0x00005b63, 0x00008b47 },
	{ 0x00005b64, 0x00008cc7 },
	{ 0x00005b65, 0x00009b76 },
	{ 0x00005b66, 0x00008a77 },
	{ 0x00005b69, 0x00009b77 },
	{ 0x00005b6b, 0x000091b7 },
	{ 0x00005b70, 0x00009b78 },
	{ 0x00005b71, 0x00009ba1 },
	{ 0x00005b73, 0x00009b79 },
	{ 0x00005b75, 0x00009b7a },
	{ 0x00005b78, 0x00009b7b },
	{ 0x00005b7a, 0x00009b7d },
	{ 0x00005b80, 0x00009b7e },
	{ 0x00005b83, 0x00009b80 },
	{ 0x00005b85, 0x000091ee },
	{ 0x00005b87, 0x00008946 },
	{ 0x00005b88, 0x00008ee7 },
	{ 0x00005b89, 0x000088c0 },
	{ 0x00005b8b, 0x00009176 },
	{ 0x00005b8c, 0x00008aae },
	{ 0x00005b8d, 0x00008eb3 },
	{ 0x00005b8f, 0x00008d47 },
	{ 0x00005b95, 0x00009386 },
	{ 0x00005b97, 0x00008f40 },
	{ 0x00005b98, 0x00008aaf },
	{ 0x00005b99, 0x00009288 },
	{ 0x00005b9a, 0x000092e8 },
	{ 0x00005b9b, 0x000088b6 },
	{ 0x00005b9c, 0x00008b58 },
	{ 0x00005b9d, 0x000095f3 },
	{ 0x00005b9f, 0x00008ec0 },
	{ 0x00005ba2, 0x00008b71 },
	{ 0x00005ba3, 0x000090e9 },
	{ 0x00005ba4, 0x00008eba },
	{ 0x00005ba5, 0x00009747 },
	{ 0x00005ba6, 0x00009b81 },
	{ 0x00005bae, 0x00008b7b },
	{ 0x00005bb0, 0x00008dc9 },
	{ 0x00005bb3, 0x00008a51 },
	{ 0x00005bb4, 0x00008983 },
	{ 0x00005bb5, 0x00008faa },
	{ 0x00005bb6, 0x000089c6 },
	{ 0x00005bb8, 0x00009b82 },
	{ 0x00005bb9, 0x00009765 },
	{ 0x00005bbf, 0x00008f68 },
	{ 0x00005bc2, 0x00008ee2 },
	{ 0x00005bc3, 0x00009b83 },
	{ 0x00005bc4, 0x00008af1 },
	{ 0x00005bc5, 0x000093d0 },
	{ 0x00005bc6, 0x000096a7 },
	{ 0x00005bc7, 0x00009b84 },
	{ 0x00005bc9, 0x00009b85 },
	{ 0x00005bcc, 0x00009578 },
	{ 0x00005bd0, 0x00009b87 },
	{ 0x00005bd2, 0x00008aa6 },
	{ 0x00005bd3, 0x00008bf5 },
	{ 0x00005bd4, 0x00009b86 },
	{ 0x00005bdb, 0x00008ab0 },
	{ 0x00005bdd, 0x00009051 },
	{ 0x00005bde, 0x00009b8b },
	{ 0x00005bdf, 0x00008e40 },
	{ 0x00005be1, 0x000089c7 },
	{ 0x00005be2, 0x00009b8a },
	{ 0x00005be4, 0x00009b88 },
	{ 0x00005be5, 0x00009b8c },
	{ 0x00005be6, 0x00009b89 },
	{ 0x00005be7, 0x0000944a },
	{ 0x00005be8, 0x00009ecb },
	{ 0x00005be9, 0x00009052 },
	{ 0x00005beb, 0x00009b8d },
	{ 0x00005bee, 0x000097be },
	{ 0x00005bf0, 0x00009b8e },
	{ 0x00005bf3, 0x00009b90 },
	{ 0x00005bf5, 0x0000929e },
	{ 0x00005bf6, 0x00009b8f },
	{ 0x00005bf8, 0x000090a1 },
	{ 0x00005bfa, 0x00008e9b },
	{ 0x00005bfe, 0x000091ce },
	{ 0x00005bff, 0x00008ef5 },
	{ 0x00005c01, 0x00009595 },
	{ 0x00005c02, 0x000090ea },
	{ 0x00005c04, 0x00008ecb },
	{ 0x00005c05, 0x00009b91 },
	{ 0x00005c06, 0x00008fab },
	{ 0x00005c07, 0x00009b92 },
	{ 0x00005c08, 0x00009b93 },
	{ 0x00005c09, 0x000088d1 },
	{ 0x00005c0a, 0x000091b8 },
	{ 0x00005c0b, 0x00009071 },
	{ 0x00005c0d, 0x00009b94 },
	{ 0x00005c0e, 0x000093b1 },
	{ 0x00005c0f, 0x00008fac },
	{ 0x00005c11, 0x00008fad },
	{ 0x00005c13, 0x00009b95 },
	{ 0x00005c16, 0x000090eb },
	{ 0x00005c1a, 0x00008fae },
	{ 0x00005c20, 0x00009b96 },
	{ 0x00005c22, 0x00009b97 },
	{ 0x00005c24, 0x000096de },
	{ 0x00005c28, 0x00009b98 },
	{ 0x00005c2d, 0x00008bc4 },
	{ 0x00005c31, 0x00008f41 },
	{ 0x00005c38, 0x00009b99 },
	{ 0x00005c39, 0x00009b9a },
	{ 0x00005c3a, 0x00008eda },
	{ 0x00005c3b, 0x0000904b },
	{ 0x00005c3c, 0x000093f2 },
	{ 0x00005c3d, 0x00009073 },
	{ 0x00005c3e, 0x000094f6 },
	{ 0x00005c3f, 0x00009441 },
	{ 0x00005c40, 0x00008bc7 },
	{ 0x00005c41, 0x00009b9b },
	{ 0x00005c45, 0x00008b8f },
	{ 0x00005c46, 0x00009b9c },
	{ 0x00005c48, 0x00008bfc },
	{ 0x00005c4a, 0x000093cd },
	{ 0x00005c4b, 0x000089ae },
	{ 0x00005c4d, 0x00008e72 },
	{ 0x00005c4e, 0x00009b9d },
	{ 0x00005c4f, 0x00009ba0 },
	{ 0x00005c50, 0x00009b9f },
	{ 0x00005c51, 0x00008bfb },
	{ 0x00005c53, 0x00009b9e },
	{ 0x00005c55, 0x00009357 },
	{ 0x00005c5e, 0x000091ae },
	{ 0x00005c60, 0x0000936a },
	{ 0x00005c61, 0x00008ec6 },
	{ 0x00005c64, 0x00009177 },
	{ 0x00005c65, 0x0000979a },
	{ 0x00005c6c, 0x00009ba2 },
	{ 0x00005c6e, 0x00009ba3 },
	{ 0x00005c6f, 0x000093d4 },
	{ 0x00005c71, 0x00008e52 },
	{ 0x00005c76, 0x00009ba5 },
	{ 0x00005c79, 0x00009ba6 },
	{ 0x00005c8c, 0x00009ba7 },
	{ 0x00005c90, 0x00008af2 },
	{ 0x00005c91, 0x00009ba8 },
	{ 0x00005c94, 0x00009ba9 },
	{ 0x00005ca1, 0x000089aa },
	{ 0x00005ca8, 0x0000915a },
	{ 0x00005ca9, 0x00008ae2 },
	{ 0x00005cab, 0x00009bab },
	{ 0x00005cac, 0x000096a6 },
	{ 0x00005cb1, 0x000091d0 },
	{ 0x00005cb3, 0x00008a78 },
	{ 0x00005cb6, 0x00009bad },
	{ 0x00005cb7, 0x00009baf },
	{ 0x00005cb8, 0x00008add },
	{ 0x00005cbb, 0x00009bac },
	{ 0x00005cbc, 0x00009bae },
	{ 0x00005cbe, 0x00009bb1 },
	{ 0x00005cc5, 0x00009bb0 },
	{ 0x00005cc7, 0x00009bb2 },
	{ 0x00005cd9, 0x00009bb3 },
	{ 0x00005ce0, 0x000093bb },
	{ 0x00005ce1, 0x00008bac },
	{ 0x00005ce8, 0x000089e3 },
	{ 0x00005ce9, 0x00009bb4 },
	{ 0x00005cea, 0x00009bb9 },
	{ 0x00005ced, 0x00009bb7 },
	{ 0x00005cef, 0x000095f5 },
	{ 0x00005cf0, 0x000095f4 },
	{ 0x00005cf6, 0x00009387 },
	{ 0x00005cfa, 0x00009bb6 },
	{ 0x00005cfb, 0x00008f73 },
	{ 0x00005cfd, 0x00009bb5 },
	{ 0x00005d07, 0x00009092 },
	{ 0x00005d0b, 0x00009bba },
	{ 0x00005d0e, 0x00008de8 },
	{ 0x00005d11, 0x00009bc0 },
	{ 0x00005d14, 0x00009bc1 },
	{ 0x00005d15, 0x00009bbb },
	{ 0x00005d16, 0x00008a52 },
	{ 0x00005d17, 0x00009bbc },
	{ 0x00005d18, 0x00009bc5 },
	{ 0x00005d19, 0x00009bc4 },
	{ 0x00005d1a, 0x00009bc3 },
	{ 0x00005d1b, 0x00009bbf },
	{ 0x00005d1f, 0x00009bbe },
	{ 0x00005d22, 0x00009bc2 },
	{ 0x00005d29, 0x000095f6 },
	{ 0x00005d4b, 0x00009bc9 },
	{ 0x00005d4c, 0x00009bc6 },
	{ 0x00005d4e, 0x00009bc8 },
	{ 0x00005d50, 0x00009792 },
	{ 0x00005d52, 0x00009bc7 },
	{ 0x00005d5c, 0x00009bbd },
	{ 0x00005d69, 0x00009093 },
	{ 0x00005d6c, 0x00009bca },
	{ 0x00005d6f, 0x00008db5 },
	{ 0x00005d73, 0x00009bcb },
	{ 0x00005d76, 0x00009bcc },
	{ 0x00005d82, 0x00009bcf },
	{ 0x00005d84, 0x00009bce },
	{ 0x00005d87, 0x00009bcd },
	{ 0x00005d8b, 0x00009388 },
	{ 0x00005d8c, 0x00009bb8 },
	{ 0x00005d90, 0x00009bd5 },
	{ 0x00005d9d, 0x00009bd1 },
	{ 0x00005da2, 0x00009bd0 },
	{ 0x00005dac, 0x00009bd2 },
	{ 0x00005dae, 0x00009bd3 },
	{ 0x00005db7, 0x00009bd6 },
	{ 0x00005dba, 0x000097e4 },
	{ 0x00005dbc, 0x00009bd7 },
	{ 0x00005dbd, 0x00009bd4 },
	{ 0x00005dc9, 0x00009bd8 },
	{ 0x00005dcc, 0x00008ade },
	{ 0x00005dcd, 0x00009bd9 },
	{ 0x00005dd2, 0x00009bdb },
	{ 0x00005dd3, 0x00009bda },
	{ 0x00005dd6, 0x00009bdc },
	{ 0x00005ddb, 0x00009bdd },
	{ 0x00005ddd, 0x000090ec },
	{ 0x00005dde, 0x00008f42 },
	{ 0x00005de1, 0x00008f84 },
	{ 0x00005de3, 0x00009183 },
	{ 0x00005de5, 0x00008d48 },
	{ 0x00005de6, 0x00008db6 },
	{ 0x00005de7, 0x00008d49 },
	{ 0x00005de8, 0x00008b90 },
	{ 0x00005deb, 0x00009bde },
	{ 0x00005dee, 0x00008db7 },
	{ 0x00005df1, 0x00008cc8 },
	{ 0x00005df2, 0x00009bdf },
	{ 0x00005df3, 0x000096a4 },
	{ 0x00005df4, 0x00009462 },
	{ 0x00005df5, 0x00009be0 },
	{ 0x00005df7, 0x00008d4a },
	{ 0x00005dfb, 0x00008aaa },
	{ 0x00005dfd, 0x00009246 },
	{ 0x00005dfe, 0x00008bd0 },
	{ 0x00005e02, 0x00008e73 },
	{ 0x00005e03, 0x0000957a },
	{ 0x00005e06, 0x000094bf },
	{ 0x00005e0b, 0x00009be1 },
	{ 0x00005e0c, 0x00008af3 },
	{ 0x00005e11, 0x00009be4 },
	{ 0x00005e16, 0x0000929f },
	{ 0x00005e19, 0x00009be3 },
	{ 0x00005e1a, 0x00009be2 },
	{ 0x00005e1b, 0x00009be5 },
	{ 0x00005e1d, 0x000092e9 },
	{ 0x00005e25, 0x00009083 },
	{ 0x00005e2b, 0x00008e74 },
	{ 0x00005e2d, 0x000090c8 },
	{ 0x00005e2f, 0x000091d1 },
	{ 0x00005e30, 0x00008b41 },
	{ 0x00005e33, 0x000092a0 },
	{ 0x00005e36, 0x00009be6 },
	{ 0x00005e37, 0x00009be7 },
	{ 0x00005e38, 0x00008fed },
	{ 0x00005e3d, 0x00009658 },
	{ 0x00005e40, 0x00009bea },
	{ 0x00005e43, 0x00009be9 },
	{ 0x00005e44, 0x00009be8 },
	{ 0x00005e45, 0x0000959d },
	{ 0x00005e47, 0x00009bf1 },
	{ 0x00005e4c, 0x00009679 },
	{ 0x00005e4e, 0x00009beb },
	{ 0x00005e54, 0x00009bed },
	{ 0x00005e55, 0x0000968b },
	{ 0x00005e57, 0x00009bec },
	{ 0x00005e5f, 0x00009bee },
	{ 0x00005e61, 0x000094a6 },
	{ 0x00005e62, 0x00009bef },
	{ 0x00005e63, 0x000095bc },
	{ 0x00005e64, 0x00009bf0 },
	{ 0x00005e72, 0x00008ab1 },
	{ 0x00005e73, 0x000095bd },
	{ 0x00005e74, 0x0000944e },
	{ 0x00005e75, 0x00009bf2 },
	{ 0x00005e76, 0x00009bf3 },
	{ 0x00005e78, 0x00008d4b },
	{ 0x00005e79, 0x00008ab2 },
	{ 0x00005e7a, 0x00009bf4 },
	{ 0x00005e7b, 0x00008cb6 },
	{ 0x00005e7c, 0x00009763 },
	{ 0x00005e7d, 0x00009748 },
	{ 0x00005e7e, 0x00008af4 },
	{ 0x00005e7f, 0x00009bf6 },
	{ 0x00005e81, 0x000092a1 },
	{ 0x00005e83, 0x00008d4c },
	{ 0x00005e84, 0x00008faf },
	{ 0x00005e87, 0x000094dd },
	{ 0x00005e8a, 0x00008fb0 },
	{ 0x00005e8f, 0x00008f98 },
	{ 0x00005e95, 0x000092ea },
	{ 0x00005e96, 0x000095f7 },
	{ 0x00005e97, 0x00009358 },
	{ 0x00005e9a, 0x00008d4d },
	{ 0x00005e9c, 0x0000957b },
	{ 0x00005ea0, 0x00009bf7 },
	{ 0x00005ea6, 0x00009378 },
	{ 0x00005ea7, 0x00008dc0 },
	{ 0x00005eab, 0x00008cc9 },
	{ 0x00005ead, 0x000092eb },
	{ 0x00005eb5, 0x000088c1 },
	{ 0x00005eb6, 0x00008f8e },
	{ 0x00005eb7, 0x00008d4e },
	{ 0x00005eb8, 0x00009766 },
	{ 0x00005ec1, 0x00009bf8 },
	{ 0x00005ec2, 0x00009bf9 },
	{ 0x00005ec3, 0x00009470 },
	{ 0x00005ec8, 0x00009bfa },
	{ 0x00005ec9, 0x000097f5 },
	{ 0x00005eca, 0x0000984c },
	{ 0x00005ecf, 0x00009bfc },
	{ 0x00005ed0, 0x00009bfb },
	{ 0x00005ed3, 0x00008a66 },
	{ 0x00005ed6, 0x00009c40 },
	{ 0x00005eda, 0x00009c43 },
	{ 0x00005edb, 0x00009c44 },
	{ 0x00005edd, 0x00009c42 },
	{ 0x00005edf, 0x0000955f },
	{ 0x00005ee0, 0x00008fb1 },
	{ 0x00005ee1, 0x00009c46 },
	{ 0x00005ee2, 0x00009c45 },
	{ 0x00005ee3, 0x00009c41 },
	{ 0x00005ee8, 0x00009c47 },
	{ 0x00005ee9, 0x00009c48 },
	{ 0x00005eec, 0x00009c49 },
	{ 0x00005ef0, 0x00009c4c },
	{ 0x00005ef1, 0x00009c4a },
	{ 0x00005ef3, 0x00009c4b },
	{ 0x00005ef4, 0x00009c4d },
	{ 0x00005ef6, 0x00008984 },
	{ 0x00005ef7, 0x000092ec },
	{ 0x00005ef8, 0x00009c4e },
	{ 0x00005efa, 0x00008c9a },
	{ 0x00005efb, 0x000089f4 },
	{ 0x00005efc, 0x00009455 },
	{ 0x00005efe, 0x00009c4f },
	{ 0x00005eff, 0x000093f9 },
	{ 0x00005f01, 0x000095d9 },
	{ 0x00005f03, 0x00009c50 },
	{ 0x00005f04, 0x0000984d },
	{ 0x00005f09, 0x00009c51 },
	{ 0x00005f0a, 0x000095be },
	{ 0x00005f0b, 0x00009c54 },
	{ 0x00005f0c, 0x0000989f },
	{ 0x00005f0d, 0x000098af },
	{ 0x00005f0f, 0x00008eae },
	{ 0x00005f10, 0x000093f3 },
	{ 0x00005f11, 0x00009c55 },
	{ 0x00005f13, 0x00008b7c },
	{ 0x00005f14, 0x000092a2 },
	{ 0x00005f15, 0x000088f8 },
	{ 0x00005f16, 0x00009c56 },
	{ 0x00005f17, 0x000095a4 },
	{ 0x00005f18, 0x00008d4f },
	{ 0x00005f1b, 0x0000926f },
	{ 0x00005f1f, 0x000092ed },
	{ 0x00005f25, 0x000096ed },
	{ 0x00005f26, 0x00008cb7 },
	{ 0x00005f27, 0x00008cca },
	{ 0x00005f29, 0x00009c57 },
	{ 0x00005f2d, 0x00009c58 },
	{ 0x00005f2f, 0x00009c5e },
	{ 0x00005f31, 0x00008ee3 },
	{ 0x00005f35, 0x000092a3 },
	{ 0x00005f37, 0x00008bad },
	{ 0x00005f38, 0x00009c59 },
	{ 0x00005f3c, 0x0000954a },
	{ 0x00005f3e, 0x00009265 },
	{ 0x00005f41, 0x00009c5a },
	{ 0x00005f48, 0x00009c5b },
	{ 0x00005f4a, 0x00008bae },
	{ 0x00005f4c, 0x00009c5c },
	{ 0x00005f4e, 0x00009c5d },
	{ 0x00005f51, 0x00009c5f },
	{ 0x00005f53, 0x00009396 },
	{ 0x00005f56, 0x00009c60 },
	{ 0x00005f57, 0x00009c61 },
	{ 0x00005f59, 0x00009c62 },
	{ 0x00005f5c, 0x00009c53 },
	{ 0x00005f5d, 0x00009c52 },
	{ 0x00005f61, 0x00009c63 },
	{ 0x00005f62, 0x00008c60 },
	{ 0x00005f66, 0x00009546 },
	{ 0x00005f69, 0x00008dca },
	{ 0x00005f6a, 0x00009556 },
	{ 0x00005f6b, 0x000092a4 },
	{ 0x00005f6c, 0x0000956a },
	{ 0x00005f6d, 0x00009c64 },
	{ 0x00005f70, 0x00008fb2 },
	{ 0x00005f71, 0x00008965 },
	{ 0x00005f73, 0x00009c65 },
	{ 0x00005f77, 0x00009c66 },
	{ 0x00005f79, 0x000096f0 },
	{ 0x00005f7c, 0x000094de },
	{ 0x00005f7f, 0x00009c69 },
	{ 0x00005f80, 0x0000899d },
	{ 0x00005f81, 0x000090aa },
	{ 0x00005f82, 0x00009c68 },
	{ 0x00005f83, 0x00009c67 },
	{ 0x00005f84, 0x00008c61 },
	{ 0x00005f85, 0x000091d2 },
	{ 0x00005f87, 0x00009c6d },
	{ 0x00005f88, 0x00009c6b },
	{ 0x00005f8a, 0x00009c6a },
	{ 0x00005f8b, 0x000097a5 },
	{ 0x00005f8c, 0x00008ce3 },
	{ 0x00005f90, 0x00008f99 },
	{ 0x00005f91, 0x00009c6c },
	{ 0x00005f92, 0x0000936b },
	{ 0x00005f93, 0x00008f5d },
	{ 0x00005f97, 0x000093be },
	{ 0x00005f98, 0x00009c70 },
	{ 0x00005f99, 0x00009c6f },
	{ 0x00005f9e, 0x00009c6e },
	{ 0x00005fa0, 0x00009c71 },
	{ 0x00005fa1, 0x00008ce4 },
	{ 0x00005fa8, 0x00009c72 },
	{ 0x00005fa9, 0x0000959c },
	{ 0x00005faa, 0x00008f7a },
	{ 0x00005fad, 0x00009c73 },
	{ 0x00005fae, 0x000094f7 },
	{ 0x00005fb3, 0x000093bf },
	{ 0x00005fb4, 0x000092a5 },
	{ 0x00005fb9, 0x0000934f },
	{ 0x00005fbc, 0x00009c74 },
	{ 0x00005fbd, 0x00008b4a },
	{ 0x00005fc3, 0x00009053 },
	{ 0x00005fc5, 0x0000954b },
	{ 0x00005fcc, 0x00008af5 },
	{ 0x00005fcd, 0x00009445 },
	{ 0x00005fd6, 0x00009c75 },
	{ 0x00005fd7, 0x00008e75 },
	{ 0x00005fd8, 0x00009659 },
	{ 0x00005fd9, 0x0000965a },
	{ 0x00005fdc, 0x0000899e },
	{ 0x00005fdd, 0x00009c7a },
	{ 0x00005fe0, 0x00009289 },
	{ 0x00005fe4, 0x00009c77 },
	{ 0x00005feb, 0x000089f5 },
	{ 0x00005ff0, 0x00009cab },
	{ 0x00005ff1, 0x00009c79 },
	{ 0x00005ff5, 0x0000944f },
	{ 0x00005ff8, 0x00009c78 },
	{ 0x00005ffb, 0x00009c76 },
	{ 0x00005ffd, 0x00008d9a },
	{ 0x00005fff, 0x00009c7c },
	{ 0x0000600e, 0x00009c83 },
	{ 0x0000600f, 0x00009c89 },
	{ 0x00006010, 0x00009c81 },
	{ 0x00006012, 0x0000937b },
	{ 0x00006015, 0x00009c86 },
	{ 0x00006016, 0x0000957c },
	{ 0x00006019, 0x00009c80 },
	{ 0x0000601b, 0x00009c85 },
	{ 0x0000601c, 0x000097e5 },
	{ 0x0000601d, 0x00008e76 },
	{ 0x00006020, 0x000091d3 },
	{ 0x00006021, 0x00009c7d },
	{ 0x00006025, 0x00008b7d },
	{ 0x00006026, 0x00009c88 },
	{ 0x00006027, 0x000090ab },
	{ 0x00006028, 0x00008985 },
	{ 0x00006029, 0x00009c82 },
	{ 0x0000602a, 0x000089f6 },
	{ 0x0000602b, 0x00009c87 },
	{ 0x0000602f, 0x00008baf },
	{ 0x00006031, 0x00009c84 },
	{ 0x0000603a, 0x00009c8a },
	{ 0x00006041, 0x00009c8c },
	{ 0x00006042, 0x00009c96 },
	{ 0x00006043, 0x00009c94 },
	{ 0x00006046, 0x00009c91 },
	{ 0x0000604a, 0x00009c90 },
	{ 0x0000604b, 0x000097f6 },
	{ 0x0000604d, 0x00009c92 },
	{ 0x00006050, 0x00008bb0 },
	{ 0x00006052, 0x00008d50 },
	{ 0x00006055, 0x00008f9a },
	{ 0x00006059, 0x00009c99 },
	{ 0x0000605a, 0x00009c8b },
	{ 0x0000605f, 0x00009c8f },
	{ 0x00006060, 0x00009c7e },
	{ 0x00006062, 0x000089f8 },
	{ 0x00006063, 0x00009c93 },
	{ 0x00006064, 0x00009c95 },
	{ 0x00006065, 0x00009270 },
	{ 0x00006068, 0x00008da6 },
	{ 0x00006069, 0x000089b6 },
	{ 0x0000606a, 0x00009c8d },
	{ 0x0000606b, 0x00009c98 },
	{ 0x0000606c, 0x00009c97 },
	{ 0x0000606d, 0x00008bb1 },
	{ 0x0000606f, 0x000091a7 },
	{ 0x00006070, 0x00008a86 },
	{ 0x00006075, 0x00008c62 },
	{ 0x00006077, 0x00009c8e },
	{ 0x00006081, 0x00009c9a },
	{ 0x00006083, 0x00009c9d },
	{ 0x00006084, 0x00009c9f },
	{ 0x00006089, 0x00008ebb },
	{ 0x0000608b, 0x00009ca5 },
	{ 0x0000608c, 0x000092ee },
	{ 0x0000608d, 0x00009c9b },
	{ 0x00006092, 0x00009ca3 },
	{ 0x00006094, 0x000089f7 },
	{ 0x00006096, 0x00009ca1 },
	{ 0x00006097, 0x00009ca2 },
	{ 0x0000609a, 0x00009c9e },
	{ 0x0000609b, 0x00009ca0 },
	{ 0x0000609f, 0x00008ce5 },
	{ 0x000060a0, 0x00009749 },
	{ 0x000060a3, 0x00008ab3 },
	{ 0x000060a6, 0x00008978 },
	{ 0x000060a7, 0x00009ca4 },
	{ 0x000060a9, 0x00009459 },
	{ 0x000060aa, 0x000088ab },
	{ 0x000060b2, 0x000094df },
	{ 0x000060b3, 0x00009c7b },
	{ 0x000060b4, 0x00009caa },
	{ 0x000060b5, 0x00009cae },
	{ 0x000060b6, 0x000096e3 },
	{ 0x000060b8, 0x00009ca7 },
	{ 0x000060bc, 0x00009389 },
	{ 0x000060bd, 0x00009cac },
	{ 0x000060c5, 0x00008fee },
	{ 0x000060c6, 0x00009cad },
	{ 0x000060c7, 0x000093d5 },
	{ 0x000060d1, 0x00009866 },
	{ 0x000060d3, 0x00009ca9 },
	{ 0x000060d8, 0x00009caf },
	{ 0x000060da, 0x00008d9b },
	{ 0x000060dc, 0x000090c9 },
	{ 0x000060df, 0x000088d2 },
	{ 0x000060e0, 0x00009ca8 },
	{ 0x000060e1, 0x00009ca6 },
	{ 0x000060e3, 0x00009179 },
	{ 0x000060e7, 0x00009c9c },
	{ 0x000060e8, 0x00008e53 },
	{ 0x000060f0, 0x000091c4 },
	{ 0x000060f1, 0x00009cbb },
	{ 0x000060f3, 0x0000917a },
	{ 0x000060f4, 0x00009cb6 },
	{ 0x000060f6, 0x00009cb3 },
	{ 0x000060f7, 0x00009cb4 },
	{ 0x000060f9, 0x00008ee4 },
	{ 0x000060fa, 0x00009cb7 },
	{ 0x000060fb, 0x00009cba },
	{ 0x00006100, 0x00009cb5 },
	{ 0x00006101, 0x00008f44 },
	{ 0x00006103, 0x00009cb8 },
	{ 0x00006106, 0x00009cb2 },
	{ 0x00006108, 0x000096fa },
	{ 0x00006109, 0x000096f9 },
	{ 0x0000610d, 0x00009cbc },
	{ 0x0000610e, 0x00009cbd },
	{ 0x0000610f, 0x000088d3 },
	{ 0x00006115, 0x00009cb1 },
	{ 0x0000611a, 0x00008bf0 },
	{ 0x0000611b, 0x000088a4 },
	{ 0x0000611f, 0x00008ab4 },
	{ 0x00006121, 0x00009cb9 },
	{ 0x00006127, 0x00009cc1 },
	{ 0x00006128, 0x00009cc0 },
	{ 0x0000612c, 0x00009cc5 },
	{ 0x00006134, 0x00009cc6 },
	{ 0x0000613c, 0x00009cc4 },
	{ 0x0000613d, 0x00009cc7 },
	{ 0x0000613e, 0x00009cbf },
	{ 0x0000613f, 0x00009cc3 },
	{ 0x00006142, 0x00009cc8 },
	{ 0x00006144, 0x00009cc9 },
	{ 0x00006147, 0x00009cbe },
	{ 0x00006148, 0x00008e9c },
	{ 0x0000614a, 0x00009cc2 },
	{ 0x0000614b, 0x000091d4 },
	{ 0x0000614c, 0x00008d51 },
	{ 0x0000614d, 0x00009cb0 },
	{ 0x0000614e, 0x00009054 },
	{ 0x00006153, 0x00009cd6 },
	{ 0x00006155, 0x000095e7 },
	{ 0x00006158, 0x00009ccc },
	{ 0x00006159, 0x00009ccd },
	{ 0x0000615a, 0x00009cce },
	{ 0x0000615d, 0x00009cd5 },
	{ 0x0000615f, 0x00009cd4 },
	{ 0x00006162, 0x0000969d },
	{ 0x00006163, 0x00008ab5 },
	{ 0x00006165, 0x00009cd2 },
	{ 0x00006167, 0x00008c64 },
	{ 0x00006168, 0x00008a53 },
	{ 0x0000616b, 0x00009ccf },
	{ 0x0000616e, 0x000097b6 },
	{ 0x0000616f, 0x00009cd1 },
	{ 0x00006170, 0x000088d4 },
	{ 0x00006171, 0x00009cd3 },
	{ 0x00006173, 0x00009cca },
	{ 0x00006174, 0x00009cd0 },
	{ 0x00006175, 0x00009cd7 },
	{ 0x00006176, 0x00008c63 },
	{ 0x00006177, 0x00009ccb },
	{ 0x0000617e, 0x0000977c },
	{ 0x00006182, 0x0000974a },
	{ 0x00006187, 0x00009cda },
	{ 0x0000618a, 0x00009cde },
	{ 0x0000618e, 0x0000919e },
	{ 0x00006190, 0x000097f7 },
	{ 0x00006191, 0x00009cdf },
	{ 0x00006194, 0x00009cdc },
	{ 0x00006196, 0x00009cd9 },
	{ 0x00006199, 0x00009cd8 },
	{ 0x0000619a, 0x00009cdd },
	{ 0x000061a4, 0x000095ae },
	{ 0x000061a7, 0x000093b2 },
	{ 0x000061a9, 0x00008c65 },
	{ 0x000061ab, 0x00009ce0 },
	{ 0x000061ac, 0x00009cdb },
	{ 0x000061ae, 0x00009ce1 },
	{ 0x000061b2, 0x00008c9b },
	{ 0x000061b6, 0x000089af },
	{ 0x000061ba, 0x00009ce9 },
	{ 0x000061be, 0x00008ab6 },
	{ 0x000061c3, 0x00009ce7 },
	{ 0x000061c6, 0x00009ce8 },
	{ 0x000061c7, 0x00008da7 },
	{ 0x000061c8, 0x00009ce6 },
	{ 0x000061c9, 0x00009ce4 },
	{ 0x000061ca, 0x00009ce3 },
	{ 0x000061cb, 0x00009cea },
	{ 0x000061cc, 0x00009ce2 },
	{ 0x000061cd, 0x00009cec },
	{ 0x000061d0, 0x000089f9 },
	{ 0x000061e3, 0x00009cee },
	{ 0x000061e6, 0x00009ced },
	{ 0x000061f2, 0x000092a6 },
	{ 0x000061f4, 0x00009cf1 },
	{ 0x000061f6, 0x00009cef },
	{ 0x000061f7, 0x00009ce5 },
	{ 0x000061f8, 0x00008c9c },
	{ 0x000061fa, 0x00009cf0 },
	{ 0x000061fc, 0x00009cf4 },
	{ 0x000061fd, 0x00009cf3 },
	{ 0x000061fe, 0x00009cf5 },
	{ 0x000061ff, 0x00009cf2 },
	{ 0x00006200, 0x00009cf6 },
	{ 0x00006208, 0x00009cf7 },
	{ 0x00006209, 0x00009cf8 },
	{ 0x0000620a, 0x000095e8 },
	{ 0x0000620c, 0x00009cfa },
	{ 0x0000620d, 0x00009cf9 },
	{ 0x0000620e, 0x00008f5e },
	{ 0x00006210, 0x000090ac },
	{ 0x00006211, 0x000089e4 },
	{ 0x00006212, 0x000089fa },
	{ 0x00006214, 0x00009cfb },
	{ 0x00006216, 0x000088bd },
	{ 0x0000621a, 0x000090ca },
	{ 0x0000621b, 0x00009cfc },
	{ 0x0000621d, 0x0000e6c1 },
	{ 0x0000621e, 0x00009d40 },
	{ 0x0000621f, 0x00008c81 },
	{ 0x00006221, 0x00009d41 },
	{ 0x00006226, 0x000090ed },
	{ 0x0000622a, 0x00009d42 },
	{ 0x0000622e, 0x00009d43 },
	{ 0x0000622f, 0x00008b59 },
	{ 0x00006230, 0x00009d44 },
	{ 0x00006232, 0x00009d45 },
	{ 0x00006233, 0x00009d46 },
	{ 0x00006234, 0x000091d5 },
	{ 0x00006238, 0x00008ccb },
	{ 0x0000623b, 0x000096df },
	{ 0x0000623f, 0x0000965b },
	{ 0x00006240, 0x00008f8a },
	{ 0x00006241, 0x00009d47 },
	{ 0x00006247, 0x000090ee },
	{ 0x00006248, 0x0000e7bb },
	{ 0x00006249, 0x000094e0 },
	{ 0x0000624b, 0x00008ee8 },
	{ 0x0000624d, 0x00008dcb },
	{ 0x0000624e, 0x00009d48 },
	{ 0x00006253, 0x000091c5 },
	{ 0x00006255, 0x000095a5 },
	{ 0x00006258, 0x000091ef },
	{ 0x0000625b, 0x00009d4b },
	{ 0x0000625e, 0x00009d49 },
	{ 0x00006260, 0x00009d4c },
	{ 0x00006263, 0x00009d4a },
	{ 0x00006268, 0x00009d4d },
	{ 0x0000626e, 0x000095af },
	{ 0x00006271, 0x000088b5 },
	{ 0x00006276, 0x0000957d },
	{ 0x00006279, 0x000094e1 },
	{ 0x0000627c, 0x00009d4e },
	{ 0x0000627e, 0x00009d51 },
	{ 0x0000627f, 0x00008fb3 },
	{ 0x00006280, 0x00008b5a },
	{ 0x00006282, 0x00009d4f },
	{ 0x00006283, 0x00009d56 },
	{ 0x00006284, 0x00008fb4 },
	{ 0x00006289, 0x00009d50 },
	{ 0x0000628a, 0x00009463 },
	{ 0x00006291, 0x0000977d },
	{ 0x00006292, 0x00009d52 },
	{ 0x00006293, 0x00009d53 },
	{ 0x00006294, 0x00009d57 },
	{ 0x00006295, 0x0000938a },
	{ 0x00006296, 0x00009d54 },
	{ 0x00006297, 0x00008d52 },
	{ 0x00006298, 0x000090dc },
	{ 0x0000629b, 0x00009d65 },
	{ 0x0000629c, 0x000094b2 },
	{ 0x0000629e, 0x000091f0 },
	{ 0x000062ab, 0x000094e2 },
	{ 0x000062ac, 0x00009dab },
	{ 0x000062b1, 0x000095f8 },
	{ 0x000062b5, 0x000092ef },
	{ 0x000062b9, 0x00009695 },
	{ 0x000062bb, 0x00009d5a },
	{ 0x000062bc, 0x0000899f },
	{ 0x000062bd, 0x0000928a },
	{ 0x000062c2, 0x00009d63 },
	{ 0x000062c5, 0x00009253 },
	{ 0x000062c6, 0x00009d5d },
	{ 0x000062c7, 0x00009d64 },
	{ 0x000062c8, 0x00009d5f },
	{ 0x000062c9, 0x00009d66 },
	{ 0x000062ca, 0x00009d62 },
	{ 0x000062cc, 0x00009d61 },
	{ 0x000062cd, 0x0000948f },
	{ 0x000062cf, 0x00009d5b },
	{ 0x000062d0, 0x000089fb },
	{ 0x000062d1, 0x00009d59 },
	{ 0x000062d2, 0x00008b91 },
	{ 0x000062d3, 0x000091f1 },
	{ 0x000062d4, 0x00009d55 },
	{ 0x000062d7, 0x00009d58 },
	{ 0x000062d8, 0x00008d53 },
	{ 0x000062d9, 0x000090d9 },
	{ 0x000062db, 0x00008fb5 },
	{ 0x000062dc, 0x00009d60 },
	{ 0x000062dd, 0x00009471 },
	{ 0x000062e0, 0x00008b92 },
	{ 0x000062e1, 0x00008a67 },
	{ 0x000062ec, 0x00008a87 },
	{ 0x000062ed, 0x00009040 },
	{ 0x000062ee, 0x00009d68 },
	{ 0x000062ef, 0x00009d6d },
	{ 0x000062f1, 0x00009d69 },
	{ 0x000062f3, 0x00008c9d },
	{ 0x000062f5, 0x00009d6e },
	{ 0x000062f6, 0x00008e41 },
	{ 0x000062f7, 0x00008d89 },
	{ 0x000062fe, 0x00008f45 },
	{ 0x000062ff, 0x00009d5c },
	{ 0x00006301, 0x00008e9d },
	{ 0x00006302, 0x00009d6b },
	{ 0x00006307, 0x00008e77 },
	{ 0x00006308, 0x00009d6c },
	{ 0x00006309, 0x000088c2 },
	{ 0x0000630c, 0x00009d67 },
	{ 0x00006311, 0x000092a7 },
	{ 0x00006319, 0x00008b93 },
	{ 0x0000631f, 0x00008bb2 },
	{ 0x00006327, 0x00009d6a },
	{ 0x00006328, 0x000088a5 },
	{ 0x0000632b, 0x00008dc1 },
	{ 0x0000632f, 0x00009055 },
	{ 0x0000633a, 0x000092f0 },
	{ 0x0000633d, 0x000094d2 },
	{ 0x0000633e, 0x00009d70 },
	{ 0x0000633f, 0x0000917d },
	{ 0x00006349, 0x000091a8 },
	{ 0x0000634c, 0x00008e4a },
	{ 0x0000634d, 0x00009d71 },
	{ 0x0000634f, 0x00009d73 },
	{ 0x00006350, 0x00009d6f },
	{ 0x00006355, 0x000095df },
	{ 0x00006357, 0x000092bb },
	{ 0x0000635c, 0x0000917b },
	{ 0x00006367, 0x000095f9 },
	{ 0x00006368, 0x00008ecc },
	{ 0x00006369, 0x00009d80 },
	{ 0x0000636b, 0x00009d7e },
	{ 0x0000636e, 0x00009098 },
	{ 0x00006372, 0x00008c9e },
	{ 0x00006376, 0x00009d78 },
	{ 0x00006377, 0x00008fb7 },
	{ 0x0000637a, 0x000093e6 },
	{ 0x0000637b, 0x00009450 },
	{ 0x00006380, 0x00009d76 },
	{ 0x00006383, 0x0000917c },
	{ 0x00006388, 0x00008ef6 },
	{ 0x00006389, 0x00009d7b },
	{ 0x0000638c, 0x00008fb6 },
	{ 0x0000638e, 0x00009d75 },
	{ 0x0000638f, 0x00009d7a },
	{ 0x00006392, 0x00009472 },
	{ 0x00006396, 0x00009d74 },
	{ 0x00006398, 0x00008c40 },
	{ 0x0000639b, 0x00008a7c },
	{ 0x0000639f, 0x00009d7c },
	{ 0x000063a0, 0x000097a9 },
	{ 0x000063a1, 0x00008dcc },
	{ 0x000063a2, 0x00009254 },
	{ 0x000063a3, 0x00009d79 },
	{ 0x000063a5, 0x000090da },
	{ 0x000063a7, 0x00008d54 },
	{ 0x000063a8, 0x00009084 },
	{ 0x000063a9, 0x00008986 },
	{ 0x000063aa, 0x0000915b },
	{ 0x000063ab, 0x00009d77 },
	{ 0x000063ac, 0x00008b64 },
	{ 0x000063b2, 0x00008c66 },
	{ 0x000063b4, 0x000092cd },
	{ 0x000063b5, 0x00009d7d },
	{ 0x000063bb, 0x0000917e },
	{ 0x000063be, 0x00009d81 },
	{ 0x000063c0, 0x00009d83 },
	{ 0x000063c3, 0x000091b5 },
	{ 0x000063c4, 0x00009d89 },
	{ 0x000063c6, 0x00009d84 },
	{ 0x000063c9, 0x00009d86 },
	{ 0x000063cf, 0x00009560 },
	{ 0x000063d0, 0x000092f1 },
	{ 0x000063d2, 0x00009d87 },
	{ 0x000063d6, 0x0000974b },
	{ 0x000063da, 0x00009767 },
	{ 0x000063db, 0x00008ab7 },
	{ 0x000063e1, 0x000088ac },
	{ 0x000063e3, 0x00009d85 },
	{ 0x000063e9, 0x00009d82 },
	{ 0x000063ee, 0x00008af6 },
	{ 0x000063f4, 0x00008987 },
	{ 0x000063f6, 0x00009d88 },
	{ 0x000063fa, 0x00009768 },
	{ 0x00006406, 0x00009d8c },
	{ 0x0000640d, 0x000091b9 },
	{ 0x0000640f, 0x00009d93 },
	{ 0x00006413, 0x00009d8d },
	{ 0x00006416, 0x00009d8a },
	{ 0x00006417, 0x00009d91 },
	{ 0x0000641c, 0x00009d72 },
	{ 0x00006426, 0x00009d8e },
	{ 0x00006428, 0x00009d92 },
	{ 0x0000642c, 0x000094c0 },
	{ 0x0000642d, 0x0000938b },
	{ 0x00006434, 0x00009d8b },
	{ 0x00006436, 0x00009d8f },
	{ 0x0000643a, 0x00008c67 },
	{ 0x0000643e, 0x00008def },
	{ 0x00006442, 0x000090db },
	{ 0x0000644e, 0x00009d97 },
	{ 0x00006458, 0x00009345 },
	{ 0x00006467, 0x00009d94 },
	{ 0x00006469, 0x00009680 },
	{ 0x0000646f, 0x00009d95 },
	{ 0x00006476, 0x00009d96 },
	{ 0x00006478, 0x000096cc },
	{ 0x0000647a, 0x000090a0 },
	{ 0x00006483, 0x00008c82 },
	{ 0x00006488, 0x00009d9d },
	{ 0x00006492, 0x00008e54 },
	{ 0x00006493, 0x00009d9a },
	{ 0x00006495, 0x00009d99 },
	{ 0x0000649a, 0x00009451 },
	{ 0x0000649e, 0x000093b3 },
	{ 0x000064a4, 0x00009350 },
	{ 0x000064a5, 0x00009d9b },
	{ 0x000064a9, 0x00009d9c },
	{ 0x000064ab, 0x0000958f },
	{ 0x000064ad, 0x00009464 },
	{ 0x000064ae, 0x00008e42 },
	{ 0x000064b0, 0x000090ef },
	{ 0x000064b2, 0x0000966f },
	{ 0x000064b9, 0x00008a68 },
	{ 0x000064bb, 0x00009da3 },
	{ 0x000064bc, 0x00009d9e },
	{ 0x000064c1, 0x00009769 },
	{ 0x000064c2, 0x00009da5 },
	{ 0x000064c5, 0x00009da1 },
	{ 0x000064c7, 0x00009da2 },
	{ 0x000064cd, 0x00009180 },
	{ 0x000064d2, 0x00009da0 },
	{ 0x000064d4, 0x00009d5e },
	{ 0x000064d8, 0x00009da4 },
	{ 0x000064da, 0x00009d9f },
	{ 0x000064e0, 0x00009da9 },
	{ 0x000064e1, 0x00009daa },
	{ 0x000064e2, 0x00009346 },
	{ 0x000064e3, 0x00009dac },
	{ 0x000064e6, 0x00008e43 },
	{ 0x000064e7, 0x00009da7 },
	{ 0x000064ec, 0x00008b5b },
	{ 0x000064ef, 0x00009dad },
	{ 0x000064f1, 0x00009da6 },
	{ 0x000064f2, 0x00009db1 },
	{ 0x000064f4, 0x00009db0 },
	{ 0x000064f6, 0x00009daf },
	{ 0x000064fa, 0x00009db2 },
	{ 0x000064fd, 0x00009db4 },
	{ 0x000064fe, 0x00008fef },
	{ 0x00006500, 0x00009db3 },
	{ 0x00006505, 0x00009db7 },
	{ 0x00006518, 0x00009db5 },
	{ 0x0000651c, 0x00009db6 },
	{ 0x0000651d, 0x00009d90 },
	{ 0x00006523, 0x00009db9 },
	{ 0x00006524, 0x00009db8 },
	{ 0x0000652a, 0x00009d98 },
	{ 0x0000652b, 0x00009dba },
	{ 0x0000652c, 0x00009dae },
	{ 0x0000652f, 0x00008e78 },
	{ 0x00006534, 0x00009dbb },
	{ 0x00006535, 0x00009dbc },
	{ 0x00006536, 0x00009dbe },
	{ 0x00006537, 0x00009dbd },
	{ 0x00006538, 0x00009dbf },
	{ 0x00006539, 0x000089fc },
	{ 0x0000653b, 0x00008d55 },
	{ 0x0000653e, 0x000095fa },
	{ 0x0000653f, 0x000090ad },
	{ 0x00006545, 0x00008ccc },
	{ 0x00006548, 0x00009dc1 },
	{ 0x0000654d, 0x00009dc4 },
	{ 0x0000654f, 0x00009571 },
	{ 0x00006551, 0x00008b7e },
	{ 0x00006555, 0x00009dc3 },
	{ 0x00006556, 0x00009dc2 },
	{ 0x00006557, 0x00009473 },
	{ 0x00006558, 0x00009dc5 },
	{ 0x00006559, 0x00008bb3 },
	{ 0x0000655d, 0x00009dc7 },
	{ 0x0000655e, 0x00009dc6 },
	{ 0x00006562, 0x00008ab8 },
	{ 0x00006563, 0x00008e55 },
	{ 0x00006566, 0x000093d6 },
	{ 0x0000656c, 0x00008c68 },
	{ 0x00006570, 0x00009094 },
	{ 0x00006572, 0x00009dc8 },
	{ 0x00006574, 0x000090ae },
	{ 0x00006575, 0x00009347 },
	{ 0x00006577, 0x0000957e },
	{ 0x00006578, 0x00009dc9 },
	{ 0x00006582, 0x00009dca },
	{ 0x00006583, 0x00009dcb },
	{ 0x00006587, 0x000095b6 },
	{ 0x00006588, 0x00009b7c },
	{ 0x00006589, 0x000090c4 },
	{ 0x0000658c, 0x0000956b },
	{ 0x0000658e, 0x00008dd6 },
	{ 0x00006590, 0x000094e3 },
	{ 0x00006591, 0x000094c1 },
	{ 0x00006597, 0x0000936c },
	{ 0x00006599, 0x000097bf },
	{ 0x0000659b, 0x00009dcd },
	{ 0x0000659c, 0x00008ece },
	{ 0x0000659f, 0x00009dce },
	{ 0x000065a1, 0x000088b4 },
	{ 0x000065a4, 0x00008bd2 },
	{ 0x000065a5, 0x000090cb },
	{ 0x000065a7, 0x00009580 },
	{ 0x000065ab, 0x00009dcf },
	{ 0x000065ac, 0x00008e61 },
	{ 0x000065ad, 0x00009266 },
	{ 0x000065af, 0x00008e7a },
	{ 0x000065b0, 0x00009056 },
	{ 0x000065b7, 0x00009dd0 },
	{ 0x000065b9, 0x000095fb },
	{ 0x000065bc, 0x00008997 },
	{ 0x000065bd, 0x00008e7b },
	{ 0x000065c1, 0x00009dd3 },
	{ 0x000065c3, 0x00009dd1 },
	{ 0x000065c4, 0x00009dd4 },
	{ 0x000065c5, 0x000097b7 },
	{ 0x000065c6, 0x00009dd2 },
	{ 0x000065cb, 0x000090f9 },
	{ 0x000065cc, 0x00009dd5 },
	{ 0x000065cf, 0x000091b0 },
	{ 0x000065d2, 0x00009dd6 },
	{ 0x000065d7, 0x00008af8 },
	{ 0x000065d9, 0x00009dd8 },
	{ 0x000065db, 0x00009dd7 },
	{ 0x000065e0, 0x00009dd9 },
	{ 0x000065e1, 0x00009dda },
	{ 0x000065e2, 0x00008af9 },
	{ 0x000065e5, 0x000093fa },
	{ 0x000065e6, 0x00009255 },
	{ 0x000065e7, 0x00008b8c },
	{ 0x000065e8, 0x00008e7c },
	{ 0x000065e9, 0x00009181 },
	{ 0x000065ec, 0x00008f7b },
	{ 0x000065ed, 0x000088ae },
	{ 0x000065f1, 0x00009ddb },
	{ 0x000065fa, 0x000089a0 },
	{ 0x000065fb, 0x00009ddf },
	{ 0x00006602, 0x00008d56 },
	{ 0x00006603, 0x00009dde },
	{ 0x00006606, 0x00008da9 },
	{ 0x00006607, 0x00008fb8 },
	{ 0x0000660a, 0x00009ddd },
	{ 0x0000660c, 0x00008fb9 },
	{ 0x0000660e, 0x000096be },
	{ 0x0000660f, 0x00008da8 },
	{ 0x00006613, 0x000088d5 },
	{ 0x00006614, 0x000090cc },
	{ 0x0000661c, 0x00009de4 },
	{ 0x0000661f, 0x000090af },
	{ 0x00006620, 0x00008966 },
	{ 0x00006625, 0x00008f74 },
	{ 0x00006627, 0x00009686 },
	{ 0x00006628, 0x00008df0 },
	{ 0x0000662d, 0x00008fba },
	{ 0x0000662f, 0x000090a5 },
	{ 0x00006634, 0x00009de3 },
	{ 0x00006635, 0x00009de1 },
	{ 0x00006636, 0x00009de2 },
	{ 0x0000663c, 0x0000928b },
	{ 0x0000663f, 0x00009e45 },
	{ 0x00006641, 0x00009de8 },
	{ 0x00006642, 0x00008e9e },
	{ 0x00006643, 0x00008d57 },
	{ 0x00006644, 0x00009de6 },
	{ 0x00006649, 0x00009de7 },
	{ 0x0000664b, 0x00009057 },
	{ 0x0000664f, 0x00009de5 },
	{ 0x00006652, 0x00008e4e },
	{ 0x0000665d, 0x00009dea },
	{ 0x0000665e, 0x00009de9 },
	{ 0x0000665f, 0x00009dee },
	{ 0x00006662, 0x00009def },
	{ 0x00006664, 0x00009deb },
	{ 0x00006666, 0x00008a41 },
	{ 0x00006667, 0x00009dec },
	{ 0x00006668, 0x00009ded },
	{ 0x00006669, 0x000094d3 },
	{ 0x0000666e, 0x00009581 },
	{ 0x0000666f, 0x00008c69 },
	{ 0x00006670, 0x00009df0 },
	{ 0x00006674, 0x000090b0 },
	{ 0x00006676, 0x00008fbb },
	{ 0x0000667a, 0x00009271 },
	{ 0x00006681, 0x00008bc5 },
	{ 0x00006683, 0x00009df1 },
	{ 0x00006684, 0x00009df5 },
	{ 0x00006687, 0x000089c9 },
	{ 0x00006688, 0x00009df2 },
	{ 0x00006689, 0x00009df4 },
	{ 0x0000668e, 0x00009df3 },
	{ 0x00006691, 0x00008f8b },
	{ 0x00006696, 0x00009267 },
	{ 0x00006697, 0x000088c3 },
	{ 0x00006698, 0x00009df6 },
	{ 0x0000669d, 0x00009df7 },
	{ 0x000066a2, 0x000092a8 },
	{ 0x000066a6, 0x000097ef },
	{ 0x000066ab, 0x00008e62 },
	{ 0x000066ae, 0x000095e9 },
	{ 0x000066b4, 0x0000965c },
	{ 0x000066b8, 0x00009e41 },
	{ 0x000066b9, 0x00009df9 },
	{ 0x000066bc, 0x00009dfc },
	{ 0x000066be, 0x00009dfb },
	{ 0x000066c1, 0x00009df8 },
	{ 0x000066c4, 0x00009e40 },
	{ 0x000066c7, 0x000093dc },
	{ 0x000066c9, 0x00009dfa },
	{ 0x000066d6, 0x00009e42 },
	{ 0x000066d9, 0x00008f8c },
	{ 0x000066da, 0x00009e43 },
	{ 0x000066dc, 0x0000976a },
	{ 0x000066dd, 0x00009498 },
	{ 0x000066e0, 0x00009e44 },
	{ 0x000066e6, 0x00009e46 },
	{ 0x000066e9, 0x00009e47 },
	{ 0x000066f0, 0x00009e48 },
	{ 0x000066f2, 0x00008bc8 },
	{ 0x000066f3, 0x00008967 },
	{ 0x000066f4, 0x00008d58 },
	{ 0x000066f5, 0x00009e49 },
	{ 0x000066f7, 0x00009e4a },
	{ 0x000066f8, 0x00008f91 },
	{ 0x000066f9, 0x00009182 },
	{ 0x000066fc, 0x000099d6 },
	{ 0x000066fd, 0x0000915d },
	{ 0x000066fe, 0x0000915c },
	{ 0x000066ff, 0x000091d6 },
	{ 0x00006700, 0x00008dc5 },
	{ 0x00006703, 0x000098f0 },
	{ 0x00006708, 0x00008c8e },
	{ 0x00006709, 0x0000974c },
	{ 0x0000670b, 0x000095fc },
	{ 0x0000670d, 0x0000959e },
	{ 0x0000670f, 0x00009e4b },
	{ 0x00006714, 0x00008df1 },
	{ 0x00006715, 0x000092bd },
	{ 0x00006716, 0x00009e4c },
	{ 0x00006717, 0x0000984e },
	{ 0x0000671b, 0x0000965d },
	{ 0x0000671d, 0x000092a9 },
	{ 0x0000671e, 0x00009e4d },
	{ 0x0000671f, 0x00008afa },
	{ 0x00006726, 0x00009e4e },
	{ 0x00006727, 0x00009e4f },
	{ 0x00006728, 0x000096d8 },
	{ 0x0000672a, 0x000096a2 },
	{ 0x0000672b, 0x00009696 },
	{ 0x0000672c, 0x0000967b },
	{ 0x0000672d, 0x00008e44 },
	{ 0x0000672e, 0x00009e51 },
	{ 0x00006731, 0x00008ee9 },
	{ 0x00006734, 0x00009670 },
	{ 0x00006736, 0x00009e53 },
	{ 0x00006737, 0x00009e56 },
	{ 0x00006738, 0x00009e55 },
	{ 0x0000673a, 0x00008af7 },
	{ 0x0000673d, 0x00008b80 },
	{ 0x0000673f, 0x00009e52 },
	{ 0x00006741, 0x00009e54 },
	{ 0x00006746, 0x00009e57 },
	{ 0x00006749, 0x00009099 },
	{ 0x0000674e, 0x0000979b },
	{ 0x0000674f, 0x000088c7 },
	{ 0x00006750, 0x00008dde },
	{ 0x00006751, 0x000091ba },
	{ 0x00006753, 0x00008edb },
	{ 0x00006756, 0x00008ff1 },
	{ 0x00006759, 0x00009e5a },
	{ 0x0000675c, 0x0000936d },
	{ 0x0000675e, 0x00009e58 },
	{ 0x0000675f, 0x000091a9 },
	{ 0x00006760, 0x00009e59 },
	{ 0x00006761, 0x00008ff0 },
	{ 0x00006762, 0x000096db },
	{ 0x00006763, 0x00009e5b },
	{ 0x00006764, 0x00009e5c },
	{ 0x00006765, 0x00009788 },
	{ 0x0000676a, 0x00009e61 },
	{ 0x0000676d, 0x00008d59 },
	{ 0x0000676f, 0x00009474 },
	{ 0x00006770, 0x00009e5e },
	{ 0x00006771, 0x0000938c },
	{ 0x00006772, 0x00009ddc },
	{ 0x00006773, 0x00009de0 },
	{ 0x00006775, 0x00008b6e },
	{ 0x00006777, 0x00009466 },
	{ 0x0000677c, 0x00009e60 },
	{ 0x0000677e, 0x00008fbc },
	{ 0x0000677f, 0x000094c2 },
	{ 0x00006785, 0x00009e66 },
	{ 0x00006787, 0x000094f8 },
	{ 0x00006789, 0x00009e5d },
	{ 0x0000678b, 0x00009e63 },
	{ 0x0000678c, 0x00009e62 },
	{ 0x00006790, 0x000090cd },
	{ 0x00006795, 0x0000968d },
	{ 0x00006797, 0x000097d1 },
	{ 0x0000679a, 0x00009687 },
	{ 0x0000679c, 0x000089ca },
	{ 0x0000679d, 0x00008e7d },
	{ 0x000067a0, 0x00009867 },
	{ 0x000067a1, 0x00009e65 },
	{ 0x000067a2, 0x00009095 },
	{ 0x000067a6, 0x00009e64 },
	{ 0x000067a9, 0x00009e5f },
	{ 0x000067af, 0x00008ccd },
	{ 0x000067b3, 0x00009e6b },
	{ 0x000067b4, 0x00009e69 },
	{ 0x000067b6, 0x000089cb },
	{ 0x000067b7, 0x00009e67 },
	{ 0x000067b8, 0x00009e6d },
	{ 0x000067b9, 0x00009e73 },
	{ 0x000067c1, 0x000091c6 },
	{ 0x000067c4, 0x000095bf },
	{ 0x000067c6, 0x00009e75 },
	{ 0x000067ca, 0x00009541 },
	{ 0x000067ce, 0x00009e74 },
	{ 0x000067cf, 0x00009490 },
	{ 0x000067d0, 0x0000965e },
	{ 0x000067d1, 0x00008ab9 },
	{ 0x000067d3, 0x000090f5 },
	{ 0x000067d4, 0x00008f5f },
	{ 0x000067d8, 0x000092d1 },
	{ 0x000067da, 0x0000974d },
	{ 0x000067dd, 0x00009e70 },
	{ 0x000067de, 0x00009e6f },
	{ 0x000067e2, 0x00009e71 },
	{ 0x000067e4, 0x00009e6e },
	{ 0x000067e7, 0x00009e76 },
	{ 0x000067e9, 0x00009e6c },
	{ 0x000067ec, 0x00009e6a },
	{ 0x000067ee, 0x00009e72 },
	{ 0x000067ef, 0x00009e68 },
	{ 0x000067f1, 0x0000928c },
	{ 0x000067f3, 0x000096f6 },
	{ 0x000067f4, 0x00008ec4 },
	{ 0x000067f5, 0x00008df2 },
	{ 0x000067fb, 0x00008db8 },
	{ 0x000067fe, 0x0000968f },
	{ 0x000067ff, 0x00008a60 },
	{ 0x00006802, 0x000092cc },
	{ 0x00006803, 0x000093c8 },
	{ 0x00006804, 0x00008968 },
	{ 0x00006813, 0x000090f0 },
	{ 0x00006816, 0x000090b2 },
	{ 0x00006817, 0x00008c49 },
	{ 0x0000681e, 0x00009e78 },
	{ 0x00006821, 0x00008d5a },
	{ 0x00006822, 0x00008a9c },
	{ 0x00006829, 0x00009e7a },
	{ 0x0000682a, 0x00008a94 },
	{ 0x0000682b, 0x00009e81 },
	{ 0x00006832, 0x00009e7d },
	{ 0x00006834, 0x000090f1 },
	{ 0x00006838, 0x00008a6a },
	{ 0x00006839, 0x00008daa },
	{ 0x0000683c, 0x00008a69 },
	{ 0x0000683d, 0x00008dcd },
	{ 0x00006840, 0x00009e7b },
	{ 0x00006841, 0x00008c85 },
	{ 0x00006842, 0x00008c6a },
	{ 0x00006843, 0x0000938d },
	{ 0x00006846, 0x00009e79 },
	{ 0x00006848, 0x000088c4 },
	{ 0x0000684d, 0x00009e7c },
	{ 0x0000684e, 0x00009e7e },
	{ 0x00006850, 0x00008bcb },
	{ 0x00006851, 0x00008c4b },
	{ 0x00006853, 0x00008aba },
	{ 0x00006854, 0x00008b6a },
	{ 0x00006859, 0x00009e82 },
	{ 0x0000685c, 0x00008df7 },
	{ 0x0000685d, 0x00009691 },
	{ 0x0000685f, 0x00008e56 },
	{ 0x00006863, 0x00009e83 },
	{ 0x00006867, 0x0000954f },
	{ 0x00006874, 0x00009e8f },
	{ 0x00006876, 0x000089b1 },
	{ 0x00006877, 0x00009e84 },
	{ 0x0000687e, 0x00009e95 },
	{ 0x0000687f, 0x00009e85 },
	{ 0x00006881, 0x000097c0 },
	{ 0x00006883, 0x00009e8c },
	{ 0x00006885, 0x0000947e },
	{ 0x0000688d, 0x00009e94 },
	{ 0x0000688f, 0x00009e87 },
	{ 0x00006893, 0x000088b2 },
	{ 0x00006894, 0x00009e89 },
	{ 0x00006897, 0x00008d5b },
	{ 0x0000689b, 0x00009e8b },
	{ 0x0000689d, 0x00009e8a },
	{ 0x0000689f, 0x00009e86 },
	{ 0x000068a0, 0x00009e91 },
	{ 0x000068a2, 0x00008fbd },
	{ 0x000068a6, 0x00009aeb },
	{ 0x000068a7, 0x00008ce6 },
	{ 0x000068a8, 0x0000979c },
	{ 0x000068ad, 0x00009e88 },
	{ 0x000068af, 0x000092f2 },
	{ 0x000068b0, 0x00008a42 },
	{ 0x000068b1, 0x00008dab },
	{ 0x000068b3, 0x00009e80 },
	{ 0x000068b5, 0x00009e90 },
	{ 0x000068b6, 0x00008a81 },
	{ 0x000068b9, 0x00009e8e },
	{ 0x000068ba, 0x00009e92 },
	{ 0x000068bc, 0x0000938e },
	{ 0x000068c4, 0x00008afc },
	{ 0x000068c6, 0x00009eb0 },
	{ 0x000068c9, 0x000096c7 },
	{ 0x000068ca, 0x00009e97 },
	{ 0x000068cb, 0x00008afb },
	{ 0x000068cd, 0x00009e9e },
	{ 0x000068d2, 0x0000965f },
	{ 0x000068d4, 0x00009e9f },
	{ 0x000068d5, 0x00009ea1 },
	{ 0x000068d7, 0x00009ea5 },
	{ 0x000068d8, 0x00009e99 },
	{ 0x000068da, 0x00009249 },
	{ 0x000068df, 0x0000938f },
	{ 0x000068e0, 0x00009ea9 },
	{ 0x000068e1, 0x00009e9c },
	{ 0x000068e3, 0x00009ea6 },
	{ 0x000068e7, 0x00009ea0 },
	{ 0x000068ee, 0x00009058 },
	{ 0x000068ef, 0x00009eaa },
	{ 0x000068f2, 0x000090b1 },
	{ 0x000068f9, 0x00009ea8 },
	{ 0x000068fa, 0x00008abb },
	{ 0x00006900, 0x0000986f },
	{ 0x00006901, 0x00009e96 },
	{ 0x00006904, 0x00009ea4 },
	{ 0x00006905, 0x000088d6 },
	{ 0x00006908, 0x00009e98 },
	{ 0x0000690b, 0x000096b8 },
	{ 0x0000690c, 0x00009e9d },
	{ 0x0000690d, 0x00009041 },
	{ 0x0000690e, 0x000092c5 },
	{ 0x0000690f, 0x00009e93 },
	{ 0x00006912, 0x00009ea3 },
	{ 0x00006919, 0x0000909a },
	{ 0x0000691a, 0x00009ead },
	{ 0x0000691b, 0x00008a91 },
	{ 0x0000691c, 0x00008c9f },
	{ 0x00006921, 0x00009eaf },
	{ 0x00006922, 0x00009e9a },
	{ 0x00006923, 0x00009eae },
	{ 0x00006925, 0x00009ea7 },
	{ 0x00006926, 0x00009e9b },
	{ 0x00006928, 0x00009eab },
	{ 0x0000692a, 0x00009eac },
	{ 0x00006930, 0x00009ebd },
	{ 0x00006934, 0x000093cc },
	{ 0x00006936, 0x00009ea2 },
	{ 0x00006939, 0x00009eb9 },
	{ 0x0000693d, 0x00009ebb },
	{ 0x0000693f, 0x000092d6 },
	{ 0x0000694a, 0x0000976b },
	{ 0x00006953, 0x00009596 },
	{ 0x00006954, 0x00009eb6 },
	{ 0x00006955, 0x000091c8 },
	{ 0x00006959, 0x00009ebc },
	{ 0x0000695a, 0x0000915e },
	{ 0x0000695c, 0x00009eb3 },
	{ 0x0000695d, 0x00009ec0 },
	{ 0x0000695e, 0x00009ebf },
	{ 0x00006960, 0x000093ed },
	{ 0x00006961, 0x00009ebe },
	{ 0x00006962, 0x000093e8 },
	{ 0x0000696a, 0x00009ec2 },
	{ 0x0000696b, 0x00009eb5 },
	{ 0x0000696d, 0x00008bc6 },
	{ 0x0000696e, 0x00009eb8 },
	{ 0x0000696f, 0x00008f7c },
	{ 0x00006973, 0x00009480 },
	{ 0x00006974, 0x00009eba },
	{ 0x00006975, 0x00008bc9 },
	{ 0x00006977, 0x00009eb2 },
	{ 0x00006978, 0x00009eb4 },
	{ 0x00006979, 0x00009eb1 },
	{ 0x0000697c, 0x0000984f },
	{ 0x0000697d, 0x00008a79 },
	{ 0x0000697e, 0x00009eb7 },
	{ 0x00006981, 0x00009ec1 },
	{ 0x00006982, 0x00008a54 },
	{ 0x0000698a, 0x00008de5 },
	{ 0x0000698e, 0x0000897c },
	{ 0x00006991, 0x00009ed2 },
	{ 0x00006994, 0x00009850 },
	{ 0x00006995, 0x00009ed5 },
	{ 0x0000699b, 0x00009059 },
	{ 0x0000699c, 0x00009ed4 },
	{ 0x000069a0, 0x00009ed3 },
	{ 0x000069a7, 0x00009ed0 },
	{ 0x000069ae, 0x00009ec4 },
	{ 0x000069b1, 0x00009ee1 },
	{ 0x000069b2, 0x00009ec3 },
	{ 0x000069b4, 0x00009ed6 },
	{ 0x000069bb, 0x00009ece },
	{ 0x000069be, 0x00009ec9 },
	{ 0x000069bf, 0x00009ec6 },
	{ 0x000069c1, 0x00009ec7 },
	{ 0x000069c3, 0x00009ecf },
	{ 0x000069c7, 0x0000eaa0 },
	{ 0x000069ca, 0x00009ecc },
	{ 0x000069cb, 0x00008d5c },
	{ 0x000069cc, 0x000092c6 },
	{ 0x000069cd, 0x00009184 },
	{ 0x000069ce, 0x00009eca },
	{ 0x000069d0, 0x00009ec5 },
	{ 0x000069d3, 0x00009ec8 },
	{ 0x000069d8, 0x0000976c },
	{ 0x000069d9, 0x0000968a },
	{ 0x000069dd, 0x00009ecd },
	{ 0x000069de, 0x00009ed7 },
	{ 0x000069e7, 0x00009edf },
	{ 0x000069e8, 0x00009ed8 },
	{ 0x000069eb, 0x00009ee5 },
	{ 0x000069ed, 0x00009ee3 },
	{ 0x000069f2, 0x00009ede },
	{ 0x000069f9, 0x00009edd },
	{ 0x000069fb, 0x000092ce },
	{ 0x000069fd, 0x00009185 },
	{ 0x000069ff, 0x00009edb },
	{ 0x00006a02, 0x00009ed9 },
	{ 0x00006a05, 0x00009ee0 },
	{ 0x00006a0a, 0x00009ee6 },
	{ 0x00006a0b, 0x000094f3 },
	{ 0x00006a0c, 0x00009eec },
	{ 0x00006a12, 0x00009ee7 },
	{ 0x00006a13, 0x00009eea },
	{ 0x00006a14, 0x00009ee4 },
	{ 0x00006a17, 0x00009294 },
	{ 0x00006a19, 0x00009557 },
	{ 0x00006a1b, 0x00009eda },
	{ 0x00006a1e, 0x00009ee2 },
	{ 0x00006a1f, 0x00008fbe },
	{ 0x00006a21, 0x000096cd },
	{ 0x00006a22, 0x00009ef6 },
	{ 0x00006a23, 0x00009ee9 },
	{ 0x00006a29, 0x00008ca0 },
	{ 0x00006a2a, 0x000089a1 },
	{ 0x00006a2b, 0x00008a7e },
	{ 0x00006a2e, 0x00009ed1 },
	{ 0x00006a35, 0x00008fbf },
	{ 0x00006a36, 0x00009eee },
	{ 0x00006a38, 0x00009ef5 },
	{ 0x00006a39, 0x00008ef7 },
	{ 0x00006a3a, 0x00008a92 },
	{ 0x00006a3d, 0x0000924d },
	{ 0x00006a44, 0x00009eeb },
	{ 0x00006a47, 0x00009ef0 },
	{ 0x00006a48, 0x00009ef4 },
	{ 0x00006a4b, 0x00008bb4 },
	{ 0x00006a58, 0x00008b6b },
	{ 0x00006a59, 0x00009ef2 },
	{ 0x00006a5f, 0x00008b40 },
	{ 0x00006a61, 0x000093c9 },
	{ 0x00006a62, 0x00009ef1 },
	{ 0x00006a66, 0x00009ef3 },
	{ 0x00006a72, 0x00009eed },
	{ 0x00006a78, 0x00009eef },
	{ 0x00006a7f, 0x00008a80 },
	{ 0x00006a80, 0x00009268 },
	{ 0x00006a84, 0x00009efa },
	{ 0x00006a8d, 0x00009ef8 },
	{ 0x00006a8e, 0x00008ce7 },
	{ 0x00006a90, 0x00009ef7 },
	{ 0x00006a97, 0x00009f40 },
	{ 0x00006a9c, 0x00009e77 },
	{ 0x00006aa0, 0x00009ef9 },
	{ 0x00006aa2, 0x00009efb },
	{ 0x00006aa3, 0x00009efc },
	{ 0x00006aaa, 0x00009f4b },
	{ 0x00006aac, 0x00009f47 },
	{ 0x00006aae, 0x00009e8d },
	{ 0x00006ab3, 0x00009f46 },
	{ 0x00006ab8, 0x00009f45 },
	{ 0x00006abb, 0x00009f42 },
	{ 0x00006ac1, 0x00009ee8 },
	{ 0x00006ac2, 0x00009f44 },
	{ 0x00006ac3, 0x00009f43 },
	{ 0x00006ad1, 0x00009f49 },
	{ 0x00006ad3, 0x00009845 },
	{ 0x00006ada, 0x00009f4c },
	{ 0x00006adb, 0x00008bf9 },
	{ 0x00006ade, 0x00009f48 },
	{ 0x00006adf, 0x00009f4a },
	{ 0x00006ae8, 0x000094a5 },
	{ 0x00006aea, 0x00009f4d },
	{ 0x00006afa, 0x00009f51 },
	{ 0x00006afb, 0x00009f4e },
	{ 0x00006b04, 0x00009793 },
	{ 0x00006b05, 0x00009f4f },
	{ 0x00006b0a, 0x00009edc },
	{ 0x00006b12, 0x00009f52 },
	{ 0x00006b16, 0x00009f53 },
	{ 0x00006b1d, 0x00008954 },
	{ 0x00006b1f, 0x00009f55 },
	{ 0x00006b20, 0x00008c87 },
	{ 0x00006b21, 0x00008e9f },
	{ 0x00006b23, 0x00008bd3 },
	{ 0x00006b27, 0x000089a2 },
	{ 0x00006b32, 0x0000977e },
	{ 0x00006b37, 0x00009f57 },
	{ 0x00006b38, 0x00009f56 },
	{ 0x00006b39, 0x00009f59 },
	{ 0x00006b3a, 0x00008b5c },
	{ 0x00006b3d, 0x00008bd4 },
	{ 0x00006b3e, 0x00008abc },
	{ 0x00006b43, 0x00009f5c },
	{ 0x00006b47, 0x00009f5b },
	{ 0x00006b49, 0x00009f5d },
	{ 0x00006b4c, 0x000089cc },
	{ 0x00006b4e, 0x00009256 },
	{ 0x00006b50, 0x00009f5e },
	{ 0x00006b53, 0x00008abd },
	{ 0x00006b54, 0x00009f60 },
	{ 0x00006b59, 0x00009f5f },
	{ 0x00006b5b, 0x00009f61 },
	{ 0x00006b5f, 0x00009f62 },
	{ 0x00006b61, 0x00009f63 },
	{ 0x00006b62, 0x00008e7e },
	{ 0x00006b63, 0x000090b3 },
	{ 0x00006b64, 0x00008d9f },
	{ 0x00006b66, 0x00009590 },
	{ 0x00006b69, 0x000095e0 },
	{ 0x00006b6a, 0x00009863 },
	{ 0x00006b6f, 0x00008e95 },
	{ 0x00006b73, 0x00008dce },
	{ 0x00006b74, 0x000097f0 },
	{ 0x00006b78, 0x00009f64 },
	{ 0x00006b79, 0x00009f65 },
	{ 0x00006b7b, 0x00008e80 },
	{ 0x00006b7f, 0x00009f66 },
	{ 0x00006b80, 0x00009f67 },
	{ 0x00006b83, 0x00009f69 },
	{ 0x00006b84, 0x00009f68 },
	{ 0x00006b86, 0x00009677 },
	{ 0x00006b89, 0x00008f7d },
	{ 0x00006b8a, 0x00008eea },
	{ 0x00006b8b, 0x00008e63 },
	{ 0x00006b8d, 0x00009f6a },
	{ 0x00006b95, 0x00009f6c },
	{ 0x00006b96, 0x00009042 },
	{ 0x00006b98, 0x00009f6b },
	{ 0x00006b9e, 0x00009f6d },
	{ 0x00006ba4, 0x00009f6e },
	{ 0x00006baa, 0x00009f6f },
	{ 0x00006bab, 0x00009f70 },
	{ 0x00006baf, 0x00009f71 },
	{ 0x00006bb1, 0x00009f73 },
	{ 0x00006bb2, 0x00009f72 },
	{ 0x00006bb3, 0x00009f74 },
	{ 0x00006bb4, 0x000089a3 },
	{ 0x00006bb5, 0x00009269 },
	{ 0x00006bb7, 0x00009f75 },
	{ 0x00006bba, 0x00008e45 },
	{ 0x00006bbb, 0x00008a6b },
	{ 0x00006bbc, 0x00009f76 },
	{ 0x00006bbf, 0x00009361 },
	{ 0x00006bc0, 0x00009aca },
	{ 0x00006bc5, 0x00008b42 },
	{ 0x00006bc6, 0x00009f77 },
	{ 0x00006bcb, 0x00009f78 },
	{ 0x00006bcd, 0x000095ea },
	{ 0x00006bce, 0x00009688 },
	{ 0x00006bd2, 0x000093c5 },
	{ 0x00006bd3, 0x00009f79 },
	{ 0x00006bd4, 0x000094e4 },
	{ 0x00006bd8, 0x000094f9 },
	{ 0x00006bdb, 0x000096d1 },
	{ 0x00006bdf, 0x00009f7a },
	{ 0x00006beb, 0x00009f7c },
	{ 0x00006bec, 0x00009f7b },
	{ 0x00006bef, 0x00009f7e },
	{ 0x00006bf3, 0x00009f7d },
	{ 0x00006c08, 0x00009f81 },
	{ 0x00006c0f, 0x00008e81 },
	{ 0x00006c11, 0x000096af },
	{ 0x00006c13, 0x00009f82 },
	{ 0x00006c14, 0x00009f83 },
	{ 0x00006c17, 0x00008b43 },
	{ 0x00006c1b, 0x00009f84 },
	{ 0x00006c23, 0x00009f86 },
	{ 0x00006c24, 0x00009f85 },
	{ 0x00006c34, 0x00009085 },
	{ 0x00006c37, 0x00009558 },
	{ 0x00006c38, 0x00008969 },
	{ 0x00006c3e, 0x000094c3 },
	{ 0x00006c40, 0x000092f3 },
	{ 0x00006c41, 0x00008f60 },
	{ 0x00006c42, 0x00008b81 },
	{ 0x00006c4e, 0x000094c4 },
	{ 0x00006c50, 0x00008eac },
	{ 0x00006c55, 0x00009f88 },
	{ 0x00006c57, 0x00008abe },
	{ 0x00006c5a, 0x00008998 },
	{ 0x00006c5d, 0x000093f0 },
	{ 0x00006c5e, 0x00009f87 },
	{ 0x00006c5f, 0x00008d5d },
	{ 0x00006c60, 0x00009272 },
	{ 0x00006c62, 0x00009f89 },
	{ 0x00006c68, 0x00009f91 },
	{ 0x00006c6a, 0x00009f8a },
	{ 0x00006c70, 0x000091bf },
	{ 0x00006c72, 0x00008b82 },
	{ 0x00006c73, 0x00009f92 },
	{ 0x00006c7a, 0x00008c88 },
	{ 0x00006c7d, 0x00008b44 },
	{ 0x00006c7e, 0x00009f90 },
	{ 0x00006c81, 0x00009f8e },
	{ 0x00006c82, 0x00009f8b },
	{ 0x00006c83, 0x00009780 },
	{ 0x00006c88, 0x000092be },
	{ 0x00006c8c, 0x000093d7 },
	{ 0x00006c8d, 0x00009f8c },
	{ 0x00006c90, 0x00009f94 },
	{ 0x00006c92, 0x00009f93 },
	{ 0x00006c93, 0x00008c42 },
	{ 0x00006c96, 0x000089ab },
	{ 0x00006c99, 0x00008db9 },
	{ 0x00006c9a, 0x00009f8d },
	{ 0x00006c9b, 0x00009f8f },
	{ 0x00006ca1, 0x00009676 },
	{ 0x00006ca2, 0x000091f2 },
	{ 0x00006cab, 0x00009697 },
	{ 0x00006cae, 0x00009f9c },
	{ 0x00006cb1, 0x00009f9d },
	{ 0x00006cb3, 0x000089cd },
	{ 0x00006cb8, 0x000095a6 },
	{ 0x00006cb9, 0x000096fb },
	{ 0x00006cba, 0x00009f9f },
	{ 0x00006cbb, 0x00008ea1 },
	{ 0x00006cbc, 0x00008fc0 },
	{ 0x00006cbd, 0x00009f98 },
	{ 0x00006cbe, 0x00009f9e },
	{ 0x00006cbf, 0x00008988 },
	{ 0x00006cc1, 0x00008bb5 },
	{ 0x00006cc4, 0x00009f95 },
	{ 0x00006cc5, 0x00009f9a },
	{ 0x00006cc9, 0x000090f2 },
	{ 0x00006cca, 0x00009491 },
	{ 0x00006ccc, 0x000094e5 },
	{ 0x00006cd3, 0x00009f97 },
	{ 0x00006cd5, 0x00009640 },
	{ 0x00006cd7, 0x00009f99 },
	{ 0x00006cd9, 0x00009fa2 },
	{ 0x00006cdb, 0x00009fa0 },
	{ 0x00006cdd, 0x00009f9b },
	{ 0x00006ce1, 0x00009641 },
	{ 0x00006ce2, 0x00009467 },
	{ 0x00006ce3, 0x00008b83 },
	{ 0x00006ce5, 0x00009344 },
	{ 0x00006ce8, 0x0000928d },
	{ 0x00006cea, 0x00009fa3 },
	{ 0x00006cef, 0x00009fa1 },
	{ 0x00006cf0, 0x000091d7 },
	{ 0x00006cf1, 0x00009f96 },
	{ 0x00006cf3, 0x0000896a },
	{ 0x00006d0b, 0x0000976d },
	{ 0x00006d0c, 0x00009fae },
	{ 0x00006d12, 0x00009fad },
	{ 0x00006d17, 0x000090f4 },
	{ 0x00006d19, 0x00009faa },
	{ 0x00006d1b, 0x0000978c },
	{ 0x00006d1e, 0x000093b4 },
	{ 0x00006d1f, 0x00009fa4 },
	{ 0x00006d25, 0x000092c3 },
	{ 0x00006d29, 0x0000896b },
	{ 0x00006d2a, 0x00008d5e },
	{ 0x00006d2b, 0x00009fa7 },
	{ 0x00006d32, 0x00008f46 },
	{ 0x00006d33, 0x00009fac },
	{ 0x00006d35, 0x00009fab },
	{ 0x00006d36, 0x00009fa6 },
	{ 0x00006d38, 0x00009fa9 },
	{ 0x00006d3b, 0x00008a88 },
	{ 0x00006d3d, 0x00009fa8 },
	{ 0x00006d3e, 0x00009468 },
	{ 0x00006d41, 0x000097ac },
	{ 0x00006d44, 0x00008ff2 },
	{ 0x00006d45, 0x000090f3 },
	{ 0x00006d59, 0x00009fb4 },
	{ 0x00006d5a, 0x00009fb2 },
	{ 0x00006d5c, 0x0000956c },
	{ 0x00006d63, 0x00009faf },
	{ 0x00006d64, 0x00009fb1 },
	{ 0x00006d66, 0x00008959 },
	{ 0x00006d69, 0x00008d5f },
	{ 0x00006d6a, 0x00009851 },
	{ 0x00006d6c, 0x00008a5c },
	{ 0x00006d6e, 0x00009582 },
	{ 0x00006d74, 0x00009781 },
	{ 0x00006d77, 0x00008a43 },
	{ 0x00006d78, 0x0000905a },
	{ 0x00006d79, 0x00009fb3 },
	{ 0x00006d85, 0x00009fb8 },
	{ 0x00006d88, 0x00008fc1 },
	{ 0x00006d8c, 0x0000974f },
	{ 0x00006d8e, 0x00009fb5 },
	{ 0x00006d93, 0x00009fb0 },
	{ 0x00006d95, 0x00009fb6 },
	{ 0x00006d99, 0x000097dc },
	{ 0x00006d9b, 0x00009393 },
	{ 0x00006d9c, 0x000093c0 },
	{ 0x00006daf, 0x00008a55 },
	{ 0x00006db2, 0x00008974 },
	{ 0x00006db5, 0x00009fbc },
	{ 0x00006db8, 0x00009fbf },
	{ 0x00006dbc, 0x000097c1 },
	{ 0x00006dc0, 0x00009784 },
	{ 0x00006dc5, 0x00009fc6 },
	{ 0x00006dc6, 0x00009fc0 },
	{ 0x00006dc7, 0x00009fbd },
	{ 0x00006dcb, 0x000097d2 },
	{ 0x00006dcc, 0x00009fc3 },
	{ 0x00006dd1, 0x00008f69 },
	{ 0x00006dd2, 0x00009fc5 },
	{ 0x00006dd5, 0x00009fca },
	{ 0x00006dd8, 0x00009391 },
	{ 0x00006dd9, 0x00009fc8 },
	{ 0x00006dde, 0x00009fc2 },
	{ 0x00006de1, 0x00009257 },
	{ 0x00006de4, 0x00009fc9 },
	{ 0x00006de6, 0x00009fbe },
	{ 0x00006de8, 0x00009fc4 },
	{ 0x00006dea, 0x00009fcb },
	{ 0x00006deb, 0x000088fa },
	{ 0x00006dec, 0x00009fc1 },
	{ 0x00006dee, 0x00009fcc },
	{ 0x00006df1, 0x0000905b },
	{ 0x00006df3, 0x00008f7e },
	{ 0x00006df5, 0x000095a3 },
	{ 0x00006df7, 0x00008dac },
	{ 0x00006df9, 0x00009fb9 },
	{ 0x00006dfa, 0x00009fc7 },
	{ 0x00006dfb, 0x00009359 },
	{ 0x00006e05, 0x000090b4 },
	{ 0x00006e07, 0x00008a89 },
	{ 0x00006e08, 0x00008dcf },
	{ 0x00006e09, 0x00008fc2 },
	{ 0x00006e0a, 0x00009fbb },
	{ 0x00006e0b, 0x00008f61 },
	{ 0x00006e13, 0x00008c6b },
	{ 0x00006e15, 0x00009fba },
	{ 0x00006e19, 0x00009fd0 },
	{ 0x00006e1a, 0x00008f8d },
	{ 0x00006e1b, 0x00008cb8 },
	{ 0x00006e1d, 0x00009fdf },
	{ 0x00006e1f, 0x00009fd9 },
	{ 0x00006e20, 0x00008b94 },
	{ 0x00006e21, 0x0000936e },
	{ 0x00006e23, 0x00009fd4 },
	{ 0x00006e24, 0x00009fdd },
	{ 0x00006e25, 0x000088ad },
	{ 0x00006e26, 0x00008951 },
	{ 0x00006e29, 0x000089b7 },
	{ 0x00006e2b, 0x00009fd6 },
	{ 0x00006e2c, 0x000091aa },
	{ 0x00006e2d, 0x00009fcd },
	{ 0x00006e2e, 0x00009fcf },
	{ 0x00006e2f, 0x00008d60 },
	{ 0x00006e38, 0x00009fe0 },
	{ 0x00006e3a, 0x00009fdb },
	{ 0x00006e3e, 0x00009fd3 },
	{ 0x00006e43, 0x00009fda },
	{ 0x00006e4a, 0x000096a9 },
	{ 0x00006e4d, 0x00009fd8 },
	{ 0x00006e4e, 0x00009fdc },
	{ 0x00006e56, 0x00008cce },
	{ 0x00006e58, 0x00008fc3 },
	{ 0x00006e5b, 0x00009258 },
	{ 0x00006e5f, 0x00009fd2 },
	{ 0x00006e67, 0x0000974e },
	{ 0x00006e6b, 0x00009fd5 },
	{ 0x00006e6e, 0x00009fce },
	{ 0x00006e6f, 0x00009392 },
	{ 0x00006e72, 0x00009fd1 },
	{ 0x00006e76, 0x00009fd7 },
	{ 0x00006e7e, 0x00009870 },
	{ 0x00006e7f, 0x00008ebc },
	{ 0x00006e80, 0x0000969e },
	{ 0x00006e82, 0x00009fe1 },
	{ 0x00006e8c, 0x000094ac },
	{ 0x00006e8f, 0x00009fed },
	{ 0x00006e90, 0x00008cb9 },
	{ 0x00006e96, 0x00008f80 },
	{ 0x00006e98, 0x00009fe3 },
	{ 0x00006e9c, 0x000097ad },
	{ 0x00006e9d, 0x00008d61 },
	{ 0x00006e9f, 0x00009ff0 },
	{ 0x00006ea2, 0x000088ec },
	{ 0x00006ea5, 0x00009fee },
	{ 0x00006eaa, 0x00009fe2 },
	{ 0x00006eaf, 0x00009fe8 },
	{ 0x00006eb2, 0x00009fea },
	{ 0x00006eb6, 0x0000976e },
	{ 0x00006eb7, 0x00009fe5 },
	{ 0x00006eba, 0x0000934d },
	{ 0x00006ebd, 0x00009fe7 },
	{ 0x00006ec2, 0x00009fef },
	{ 0x00006ec4, 0x00009fe9 },
	{ 0x00006ec5, 0x000096c5 },
	{ 0x00006ec9, 0x00009fe4 },
	{ 0x00006ecb, 0x00008ea0 },
	{ 0x00006ecc, 0x00009ffc },
	{ 0x00006ed1, 0x00008a8a },
	{ 0x00006ed3, 0x00009fe6 },
	{ 0x00006ed4, 0x00009feb },
	{ 0x00006ed5, 0x00009fec },
	{ 0x00006edd, 0x000091ea },
	{ 0x00006ede, 0x000091d8 },
	{ 0x00006eec, 0x00009ff4 },
	{ 0x00006eef, 0x00009ffa },
	{ 0x00006ef2, 0x00009ff8 },
	{ 0x00006ef4, 0x00009348 },
	{ 0x00006ef7, 0x0000e042 },
	{ 0x00006ef8, 0x00009ff5 },
	{ 0x00006efe, 0x00009ff6 },
	{ 0x00006eff, 0x00009fde },
	{ 0x00006f01, 0x00008b99 },
	{ 0x00006f02, 0x00009559 },
	{ 0x00006f06, 0x00008ebd },
	{ 0x00006f09, 0x00008d97 },
	{ 0x00006f0f, 0x00009852 },
	{ 0x00006f11, 0x00009ff2 },
	{ 0x00006f13, 0x0000e041 },
	{ 0x00006f14, 0x00008989 },
	{ 0x00006f15, 0x00009186 },
	{ 0x00006f20, 0x00009499 },
	{ 0x00006f22, 0x00008abf },
	{ 0x00006f23, 0x000097f8 },
	{ 0x00006f2b, 0x0000969f },
	{ 0x00006f2c, 0x000092d0 },
	{ 0x00006f31, 0x00009ff9 },
	{ 0x00006f32, 0x00009ffb },
	{ 0x00006f38, 0x00009151 },
	{ 0x00006f3e, 0x0000e040 },
	{ 0x00006f3f, 0x00009ff7 },
	{ 0x00006f41, 0x00009ff1 },
	{ 0x00006f45, 0x00008ac1 },
	{ 0x00006f54, 0x00008c89 },
	{ 0x00006f58, 0x0000e04e },
	{ 0x00006f5b, 0x0000e049 },
	{ 0x00006f5c, 0x000090f6 },
	{ 0x00006f5f, 0x00008a83 },
	{ 0x00006f64, 0x00008f81 },
	{ 0x00006f66, 0x0000e052 },
	{ 0x00006f6d, 0x0000e04b },
	{ 0x00006f6e, 0x000092aa },
	{ 0x00006f6f, 0x0000e048 },
	{ 0x00006f70, 0x000092d7 },
	{ 0x00006f74, 0x0000e06b },
	{ 0x00006f78, 0x0000e045 },
	{ 0x00006f7a, 0x0000e044 },
	{ 0x00006f7c, 0x0000e04d },
	{ 0x00006f80, 0x0000e047 },
	{ 0x00006f81, 0x0000e046 },
	{ 0x00006f82, 0x0000e04c },
	{ 0x00006f84, 0x0000909f },
	{ 0x00006f86, 0x0000e043 },
	{ 0x00006f8e, 0x0000e04f },
	{ 0x00006f91, 0x0000e050 },
	{ 0x00006f97, 0x00008ac0 },
	{ 0x00006fa1, 0x0000e055 },
	{ 0x00006fa3, 0x0000e054 },
	{ 0x00006fa4, 0x0000e056 },
	{ 0x00006faa, 0x0000e059 },
	{ 0x00006fb1, 0x00009362 },
	{ 0x00006fb3, 0x0000e053 },
	{ 0x00006fb9, 0x0000e057 },
	{ 0x00006fc0, 0x00008c83 },
	{ 0x00006fc1, 0x000091f7 },
	{ 0x00006fc2, 0x0000e051 },
	{ 0x00006fc3, 0x0000945a },
	{ 0x00006fc6, 0x0000e058 },
	{ 0x00006fd4, 0x0000e05d },
	{ 0x00006fd5, 0x0000e05b },
	{ 0x00006fd8, 0x0000e05e },
	{ 0x00006fdb, 0x0000e061 },
	{ 0x00006fdf, 0x0000e05a },
	{ 0x00006fe0, 0x00008d8a },
	{ 0x00006fe1, 0x00009447 },
	{ 0x00006fe4, 0x00009fb7 },
	{ 0x00006feb, 0x00009794 },
	{ 0x00006fec, 0x0000e05c },
	{ 0x00006fee, 0x0000e060 },
	{ 0x00006fef, 0x000091f3 },
	{ 0x00006ff1, 0x0000e05f },
	{ 0x00006ff3, 0x0000e04a },
	{ 0x00006ff6, 0x0000e889 },
	{ 0x00006ffa, 0x0000e064 },
	{ 0x00006ffe, 0x0000e068 },
	{ 0x00007001, 0x0000e066 },
	{ 0x00007009, 0x0000e062 },
	{ 0x0000700b, 0x0000e063 },
	{ 0x0000700f, 0x0000e067 },
	{ 0x00007011, 0x0000e065 },
	{ 0x00007015, 0x0000956d },
	{ 0x00007018, 0x0000e06d },
	{ 0x0000701a, 0x0000e06a },
	{ 0x0000701b, 0x0000e069 },
	{ 0x0000701d, 0x0000e06c },
	{ 0x0000701e, 0x000093d2 },
	{ 0x0000701f, 0x0000e06e },
	{ 0x00007026, 0x00009295 },
	{ 0x00007027, 0x000091eb },
	{ 0x0000702c, 0x000090a3 },
	{ 0x00007030, 0x0000e06f },
	{ 0x00007032, 0x0000e071 },
	{ 0x0000703e, 0x0000e070 },
	{ 0x0000704c, 0x00009ff3 },
	{ 0x00007051, 0x0000e072 },
	{ 0x00007058, 0x000093e5 },
	{ 0x00007063, 0x0000e073 },
	{ 0x0000706b, 0x000089ce },
	{ 0x0000706f, 0x00009394 },
	{ 0x00007070, 0x00008a44 },
	{ 0x00007078, 0x00008b84 },
	{ 0x0000707c, 0x00008edc },
	{ 0x0000707d, 0x00008dd0 },
	{ 0x00007089, 0x00009846 },
	{ 0x0000708a, 0x00009086 },
	{ 0x0000708e, 0x0000898a },
	{ 0x00007092, 0x0000e075 },
	{ 0x00007099, 0x0000e074 },
	{ 0x000070ac, 0x0000e078 },
	{ 0x000070ad, 0x00009259 },
	{ 0x000070ae, 0x0000e07b },
	{ 0x000070af, 0x0000e076 },
	{ 0x000070b3, 0x0000e07a },
	{ 0x000070b8, 0x0000e079 },
	{ 0x000070b9, 0x0000935f },
	{ 0x000070ba, 0x000088d7 },
	{ 0x000070c8, 0x000097f3 },
	{ 0x000070cb, 0x0000e07d },
	{ 0x000070cf, 0x00008947 },
	{ 0x000070d9, 0x0000e080 },
	{ 0x000070dd, 0x0000e07e },
	{ 0x000070df, 0x0000e07c },
	{ 0x000070f1, 0x0000e077 },
	{ 0x000070f9, 0x00009642 },
	{ 0x000070fd, 0x0000e082 },
	{ 0x00007109, 0x0000e081 },
	{ 0x00007114, 0x0000898b },
	{ 0x00007119, 0x0000e084 },
	{ 0x0000711a, 0x000095b0 },
	{ 0x0000711c, 0x0000e083 },
	{ 0x00007121, 0x000096b3 },
	{ 0x00007126, 0x00008fc5 },
	{ 0x00007136, 0x00009152 },
	{ 0x0000713c, 0x00008fc4 },
	{ 0x00007149, 0x000097f9 },
	{ 0x0000714c, 0x0000e08a },
	{ 0x0000714e, 0x000090f7 },
	{ 0x00007155, 0x0000e086 },
	{ 0x00007156, 0x0000e08b },
	{ 0x00007159, 0x0000898c },
	{ 0x00007162, 0x0000e089 },
	{ 0x00007164, 0x00009481 },
	{ 0x00007165, 0x0000e085 },
	{ 0x00007166, 0x0000e088 },
	{ 0x00007167, 0x00008fc6 },
	{ 0x00007169, 0x000094cf },
	{ 0x0000716c, 0x0000e08c },
	{ 0x0000716e, 0x00008ecf },
	{ 0x0000717d, 0x000090f8 },
	{ 0x00007184, 0x0000e08f },
	{ 0x00007188, 0x0000e087 },
	{ 0x0000718a, 0x00008c46 },
	{ 0x0000718f, 0x0000e08d },
	{ 0x00007194, 0x0000976f },
	{ 0x00007195, 0x0000e090 },
	{ 0x00007199, 0x0000eaa4 },
	{ 0x0000719f, 0x00008f6e },
	{ 0x000071a8, 0x0000e091 },
	{ 0x000071ac, 0x0000e092 },
	{ 0x000071b1, 0x0000944d },
	{ 0x000071b9, 0x0000e094 },
	{ 0x000071be, 0x0000e095 },
	{ 0x000071c3, 0x00009452 },
	{ 0x000071c8, 0x00009395 },
	{ 0x000071c9, 0x0000e097 },
	{ 0x000071ce, 0x0000e099 },
	{ 0x000071d0, 0x000097d3 },
	{ 0x000071d2, 0x0000e096 },
	{ 0x000071d4, 0x0000e098 },
	{ 0x000071d5, 0x0000898d },
	{ 0x000071d7, 0x0000e093 },
	{ 0x000071df, 0x00009a7a },
	{ 0x000071e0, 0x0000e09a },
	{ 0x000071e5, 0x00009187 },
	{ 0x000071e6, 0x00008e57 },
	{ 0x000071e7, 0x0000e09c },
	{ 0x000071ec, 0x0000e09b },
	{ 0x000071ed, 0x00009043 },
	{ 0x000071ee, 0x000099d7 },
	{ 0x000071f5, 0x0000e09d },
	{ 0x000071f9, 0x0000e09f },
	{ 0x000071fb, 0x0000e08e },
	{ 0x000071fc, 0x0000e09e },
	{ 0x000071ff, 0x0000e0a0 },
	{ 0x00007206, 0x0000949a },
	{ 0x0000720d, 0x0000e0a1 },
	{ 0x00007210, 0x0000e0a2 },
	{ 0x0000721b, 0x0000e0a3 },
	{ 0x00007228, 0x0000e0a4 },
	{ 0x0000722a, 0x000092dc },
	{ 0x0000722c, 0x0000e0a6 },
	{ 0x0000722d, 0x0000e0a5 },
	{ 0x00007230, 0x0000e0a7 },
	{ 0x00007232, 0x0000e0a8 },
	{ 0x00007235, 0x00008edd },
	{ 0x00007236, 0x00009583 },
	{ 0x0000723a, 0x000096ea },
	{ 0x0000723b, 0x0000e0a9 },
	{ 0x0000723c, 0x0000e0aa },
	{ 0x0000723d, 0x00009175 },
	{ 0x0000723e, 0x00008ea2 },
	{ 0x0000723f, 0x0000e0ab },
	{ 0x00007240, 0x0000e0ac },
	{ 0x00007246, 0x0000e0ad },
	{ 0x00007247, 0x000095d0 },
	{ 0x00007248, 0x000094c5 },
	{ 0x0000724b, 0x0000e0ae },
	{ 0x0000724c, 0x00009476 },
	{ 0x00007252, 0x000092ab },
	{ 0x00007258, 0x0000e0af },
	{ 0x00007259, 0x000089e5 },
	{ 0x0000725b, 0x00008b8d },
	{ 0x0000725d, 0x000096c4 },
	{ 0x0000725f, 0x000096b4 },
	{ 0x00007261, 0x000089b2 },
	{ 0x00007262, 0x00009853 },
	{ 0x00007267, 0x00009671 },
	{ 0x00007269, 0x000095a8 },
	{ 0x00007272, 0x000090b5 },
	{ 0x00007274, 0x0000e0b0 },
	{ 0x00007279, 0x000093c1 },
	{ 0x0000727d, 0x00008ca1 },
	{ 0x0000727e, 0x0000e0b1 },
	{ 0x00007280, 0x00008dd2 },
	{ 0x00007281, 0x0000e0b3 },
	{ 0x00007282, 0x0000e0b2 },
	{ 0x00007287, 0x0000e0b4 },
	{ 0x00007292, 0x0000e0b5 },
	{ 0x00007296, 0x0000e0b6 },
	{ 0x000072a0, 0x00008b5d },
	{ 0x000072a2, 0x0000e0b7 },
	{ 0x000072a7, 0x0000e0b8 },
	{ 0x000072ac, 0x00008ca2 },
	{ 0x000072af, 0x000094c6 },
	{ 0x000072b2, 0x0000e0ba },
	{ 0x000072b6, 0x00008ff3 },
	{ 0x000072b9, 0x0000e0b9 },
	{ 0x000072c2, 0x00008bb6 },
	{ 0x000072c3, 0x0000e0bb },
	{ 0x000072c4, 0x0000e0bd },
	{ 0x000072c6, 0x0000e0bc },
	{ 0x000072ce, 0x0000e0be },
	{ 0x000072d0, 0x00008ccf },
	{ 0x000072d2, 0x0000e0bf },
	{ 0x000072d7, 0x00008be7 },
	{ 0x000072d9, 0x0000915f },
	{ 0x000072db, 0x00008d9d },
	{ 0x000072e0, 0x0000e0c1 },
	{ 0x000072e1, 0x0000e0c2 },
	{ 0x000072e2, 0x0000e0c0 },
	{ 0x000072e9, 0x00008eeb },
	{ 0x000072ec, 0x000093c6 },
	{ 0x000072ed, 0x00008bb7 },
	{ 0x000072f7, 0x0000e0c4 },
	{ 0x000072f8, 0x0000924b },
	{ 0x000072f9, 0x0000e0c3 },
	{ 0x000072fc, 0x00009854 },
	{ 0x000072fd, 0x00009482 },
	{ 0x0000730a, 0x0000e0c7 },
	{ 0x00007316, 0x0000e0c9 },
	{ 0x00007317, 0x0000e0c6 },
	{ 0x0000731b, 0x000096d2 },
	{ 0x0000731c, 0x0000e0c8 },
	{ 0x0000731d, 0x0000e0ca },
	{ 0x0000731f, 0x000097c2 },
	{ 0x00007325, 0x0000e0ce },
	{ 0x00007329, 0x0000e0cd },
	{ 0x0000732a, 0x00009296 },
	{ 0x0000732b, 0x0000944c },
	{ 0x0000732e, 0x00008ca3 },
	{ 0x0000732f, 0x0000e0cc },
	{ 0x00007334, 0x0000e0cb },
	{ 0x00007336, 0x00009750 },
	{ 0x00007337, 0x00009751 },
	{ 0x0000733e, 0x0000e0cf },
	{ 0x0000733f, 0x0000898e },
	{ 0x00007344, 0x00008d96 },
	{ 0x00007345, 0x00008e82 },
	{ 0x0000734e, 0x0000e0d0 },
	{ 0x0000734f, 0x0000e0d1 },
	{ 0x00007357, 0x0000e0d3 },
	{ 0x00007363, 0x00008f62 },
	{ 0x00007368, 0x0000e0d5 },
	{ 0x0000736a, 0x0000e0d4 },
	{ 0x00007370, 0x0000e0d6 },
	{ 0x00007372, 0x00008a6c },
	{ 0x00007375, 0x0000e0d8 },
	{ 0x00007378, 0x0000e0d7 },
	{ 0x0000737a, 0x0000e0da },
	{ 0x0000737b, 0x0000e0d9 },
	{ 0x00007384, 0x00008cba },
	{ 0x00007387, 0x000097a6 },
	{ 0x00007389, 0x00008bca },
	{ 0x0000738b, 0x000089a4 },
	{ 0x00007396, 0x00008be8 },
	{ 0x000073a9, 0x00008adf },
	{ 0x000073b2, 0x000097e6 },
	{ 0x000073b3, 0x0000e0dc },
	{ 0x000073bb, 0x0000e0de },
	{ 0x000073c0, 0x0000e0df },
	{ 0x000073c2, 0x000089cf },
	{ 0x000073c8, 0x0000e0db },
	{ 0x000073ca, 0x00008e58 },
	{ 0x000073cd, 0x000092bf },
	{ 0x000073ce, 0x0000e0dd },
	{ 0x000073de, 0x0000e0e2 },
	{ 0x000073e0, 0x00008eec },
	{ 0x000073e5, 0x0000e0e0 },
	{ 0x000073ea, 0x00008c5d },
	{ 0x000073ed, 0x000094c7 },
	{ 0x000073ee, 0x0000e0e1 },
	{ 0x000073f1, 0x0000e0fc },
	{ 0x000073f8, 0x0000e0e7 },
	{ 0x000073fe, 0x00008cbb },
	{ 0x00007403, 0x00008b85 },
	{ 0x00007405, 0x0000e0e4 },
	{ 0x00007406, 0x0000979d },
	{ 0x00007409, 0x000097ae },
	{ 0x00007422, 0x000091f4 },
	{ 0x00007425, 0x0000e0e6 },
	{ 0x00007432, 0x0000e0e8 },
	{ 0x00007433, 0x000097d4 },
	{ 0x00007434, 0x00008bd5 },
	{ 0x00007435, 0x000094fa },
	{ 0x00007436, 0x00009469 },
	{ 0x0000743a, 0x0000e0e9 },
	{ 0x0000743f, 0x0000e0eb },
	{ 0x00007441, 0x0000e0ee },
	{ 0x00007455, 0x0000e0ea },
	{ 0x00007459, 0x0000e0ed },
	{ 0x0000745a, 0x00008ce8 },
	{ 0x0000745b, 0x0000896c },
	{ 0x0000745c, 0x0000e0ef },
	{ 0x0000745e, 0x00009090 },
	{ 0x0000745f, 0x0000e0ec },
	{ 0x00007460, 0x000097da },
	{ 0x00007463, 0x0000e0f2 },
	{ 0x00007464, 0x0000eaa2 },
	{ 0x00007469, 0x0000e0f0 },
	{ 0x0000746a, 0x0000e0f3 },
	{ 0x0000746f, 0x0000e0e5 },
	{ 0x00007470, 0x0000e0f1 },
	{ 0x00007473, 0x00008dba },
	{ 0x00007476, 0x0000e0f4 },
	{ 0x0000747e, 0x0000e0f5 },
	{ 0x00007483, 0x0000979e },
	{ 0x0000748b, 0x0000e0f6 },
	{ 0x0000749e, 0x0000e0f7 },
	{ 0x000074a2, 0x0000e0e3 },
	{ 0x000074a7, 0x0000e0f8 },
	{ 0x000074b0, 0x00008ac2 },
	{ 0x000074bd, 0x00008ea3 },
	{ 0x000074ca, 0x0000e0f9 },
	{ 0x000074cf, 0x0000e0fa },
	{ 0x000074d4, 0x0000e0fb },
	{ 0x000074dc, 0x0000895a },
	{ 0x000074e0, 0x0000e140 },
	{ 0x000074e2, 0x0000955a },
	{ 0x000074e3, 0x0000e141 },
	{ 0x000074e6, 0x00008aa2 },
	{ 0x000074e7, 0x0000e142 },
	{ 0x000074e9, 0x0000e143 },
	{ 0x000074ee, 0x0000e144 },
	{ 0x000074f0, 0x0000e146 },
	{ 0x000074f1, 0x0000e147 },
	{ 0x000074f2, 0x0000e145 },
	{ 0x000074f6, 0x00009572 },
	{ 0x000074f7, 0x0000e149 },
	{ 0x000074f8, 0x0000e148 },
	{ 0x00007503, 0x0000e14b },
	{ 0x00007504, 0x0000e14a },
	{ 0x00007505, 0x0000e14c },
	{ 0x0000750c, 0x0000e14d },
	{ 0x0000750d, 0x0000e14f },
	{ 0x0000750e, 0x0000e14e },
	{ 0x00007511, 0x00008d99 },
	{ 0x00007513, 0x0000e151 },
	{ 0x00007515, 0x0000e150 },
	{ 0x00007518, 0x00008ac3 },
	{ 0x0000751a, 0x00009072 },
	{ 0x0000751c, 0x0000935b },
	{ 0x0000751e, 0x0000e152 },
	{ 0x0000751f, 0x000090b6 },
	{ 0x00007523, 0x00008e59 },
	{ 0x00007525, 0x00008999 },
	{ 0x00007526, 0x0000e153 },
	{ 0x00007528, 0x00009770 },
	{ 0x0000752b, 0x000095e1 },
	{ 0x0000752c, 0x0000e154 },
	{ 0x00007530, 0x00009363 },
	{ 0x00007531, 0x00009752 },
	{ 0x00007532, 0x00008d62 },
	{ 0x00007533, 0x0000905c },
	{ 0x00007537, 0x0000926a },
	{ 0x00007538, 0x000099b2 },
	{ 0x0000753a, 0x000092ac },
	{ 0x0000753b, 0x000089e6 },
	{ 0x0000753c, 0x0000e155 },
	{ 0x00007544, 0x0000e156 },
	{ 0x00007546, 0x0000e15b },
	{ 0x00007549, 0x0000e159 },
	{ 0x0000754a, 0x0000e158 },
	{ 0x0000754b, 0x00009dc0 },
	{ 0x0000754c, 0x00008a45 },
	{ 0x0000754d, 0x0000e157 },
	{ 0x0000754f, 0x000088d8 },
	{ 0x00007551, 0x000094a8 },
	{ 0x00007554, 0x000094c8 },
	{ 0x00007559, 0x000097af },
	{ 0x0000755a, 0x0000e15c },
	{ 0x0000755b, 0x0000e15a },
	{ 0x0000755c, 0x0000927b },
	{ 0x0000755d, 0x000090a4 },
	{ 0x00007560, 0x000094a9 },
	{ 0x00007562, 0x0000954c },
	{ 0x00007564, 0x0000e15e },
	{ 0x00007565, 0x000097aa },
	{ 0x00007566, 0x00008c6c },
	{ 0x00007567, 0x0000e15f },
	{ 0x00007569, 0x0000e15d },
	{ 0x0000756a, 0x000094d4 },
	{ 0x0000756b, 0x0000e160 },
	{ 0x0000756d, 0x0000e161 },
	{ 0x00007570, 0x000088d9 },
	{ 0x00007573, 0x00008ff4 },
	{ 0x00007574, 0x0000e166 },
	{ 0x00007576, 0x0000e163 },
	{ 0x00007577, 0x000093eb },
	{ 0x00007578, 0x0000e162 },
	{ 0x0000757f, 0x00008b45 },
	{ 0x00007582, 0x0000e169 },
	{ 0x00007586, 0x0000e164 },
	{ 0x00007587, 0x0000e165 },
	{ 0x00007589, 0x0000e168 },
	{ 0x0000758a, 0x0000e167 },
	{ 0x0000758b, 0x00009544 },
	{ 0x0000758e, 0x00009161 },
	{ 0x0000758f, 0x00009160 },
	{ 0x00007591, 0x00008b5e },
	{ 0x00007594, 0x0000e16a },
	{ 0x0000759a, 0x0000e16b },
	{ 0x0000759d, 0x0000e16c },
	{ 0x000075a3, 0x0000e16e },
	{ 0x000075a5, 0x0000e16d },
	{ 0x000075ab, 0x00008975 },
	{ 0x000075b1, 0x0000e176 },
	{ 0x000075b2, 0x000094e6 },
	{ 0x000075b3, 0x0000e170 },
	{ 0x000075b5, 0x0000e172 },
	{ 0x000075b8, 0x0000e174 },
	{ 0x000075b9, 0x0000905d },
	{ 0x000075bc, 0x0000e175 },
	{ 0x000075bd, 0x0000e173 },
	{ 0x000075be, 0x00008ebe },
	{ 0x000075c2, 0x0000e16f },
	{ 0x000075c3, 0x0000e171 },
	{ 0x000075c5, 0x00009561 },
	{ 0x000075c7, 0x00008fc7 },
	{ 0x000075ca, 0x0000e178 },
	{ 0x000075cd, 0x0000e177 },
	{ 0x000075d2, 0x0000e179 },
	{ 0x000075d4, 0x00008ea4 },
	{ 0x000075d5, 0x00008dad },
	{ 0x000075d8, 0x00009397 },
	{ 0x000075d9, 0x0000e17a },
	{ 0x000075db, 0x000092c9 },
	{ 0x000075de, 0x0000e17c },
	{ 0x000075e2, 0x0000979f },
	{ 0x000075e3, 0x0000e17b },
	{ 0x000075e9, 0x00009189 },
	{ 0x000075f0, 0x0000e182 },
	{ 0x000075f2, 0x0000e184 },
	{ 0x000075f3, 0x0000e185 },
	{ 0x000075f4, 0x00009273 },
	{ 0x000075fa, 0x0000e183 },
	{ 0x000075fc, 0x0000e180 },
	{ 0x000075fe, 0x0000e17d },
	{ 0x000075ff, 0x0000e17e },
	{ 0x00007601, 0x0000e181 },
	{ 0x00007609, 0x0000e188 },
	{ 0x0000760b, 0x0000e186 },
	{ 0x0000760d, 0x0000e187 },
	{ 0x0000761f, 0x0000e189 },
	{ 0x00007620, 0x0000e18b },
	{ 0x00007621, 0x0000e18c },
	{ 0x00007622, 0x0000e18d },
	{ 0x00007624, 0x0000e18e },
	{ 0x00007627, 0x0000e18a },
	{ 0x00007630, 0x0000e190 },
	{ 0x00007634, 0x0000e18f },
	{ 0x0000763b, 0x0000e191 },
	{ 0x00007642, 0x000097c3 },
	{ 0x00007646, 0x0000e194 },
	{ 0x00007647, 0x0000e192 },
	{ 0x00007648, 0x0000e193 },
	{ 0x0000764c, 0x00008ae0 },
	{ 0x00007652, 0x000096fc },
	{ 0x00007656, 0x000095c8 },
	{ 0x00007658, 0x0000e196 },
	{ 0x0000765c, 0x0000e195 },
	{ 0x00007661, 0x0000e197 },
	{ 0x00007662, 0x0000e198 },
	{ 0x00007667, 0x0000e19c },
	{ 0x00007668, 0x0000e199 },
	{ 0x00007669, 0x0000e19a },
	{ 0x0000766a, 0x0000e19b },
	{ 0x0000766c, 0x0000e19d },
	{ 0x00007670, 0x0000e19e },
	{ 0x00007672, 0x0000e19f },
	{ 0x00007676, 0x0000e1a0 },
	{ 0x00007678, 0x0000e1a1 },
	{ 0x0000767a, 0x000094ad },
	{ 0x0000767b, 0x0000936f },
	{ 0x0000767c, 0x0000e1a2 },
	{ 0x0000767d, 0x00009492 },
	{ 0x0000767e, 0x00009553 },
	{ 0x00007680, 0x0000e1a3 },
	{ 0x00007683, 0x0000e1a4 },
	{ 0x00007684, 0x00009349 },
	{ 0x00007686, 0x00008a46 },
	{ 0x00007687, 0x00008d63 },
	{ 0x00007688, 0x0000e1a5 },
	{ 0x0000768b, 0x0000e1a6 },
	{ 0x0000768e, 0x0000e1a7 },
	{ 0x00007690, 0x00008e48 },
	{ 0x00007693, 0x0000e1a9 },
	{ 0x00007696, 0x0000e1a8 },
	{ 0x00007699, 0x0000e1aa },
	{ 0x0000769a, 0x0000e1ab },
	{ 0x000076ae, 0x000094e7 },
	{ 0x000076b0, 0x0000e1ac },
	{ 0x000076b4, 0x0000e1ad },
	{ 0x000076b7, 0x0000ea89 },
	{ 0x000076b8, 0x0000e1ae },
	{ 0x000076b9, 0x0000e1af },
	{ 0x000076ba, 0x0000e1b0 },
	{ 0x000076bf, 0x00008e4d },
	{ 0x000076c2, 0x0000e1b1 },
	{ 0x000076c3, 0x00009475 },
	{ 0x000076c6, 0x0000967e },
	{ 0x000076c8, 0x0000896d },
	{ 0x000076ca, 0x00008976 },
	{ 0x000076cd, 0x0000e1b2 },
	{ 0x000076d2, 0x0000e1b4 },
	{ 0x000076d6, 0x0000e1b3 },
	{ 0x000076d7, 0x00009390 },
	{ 0x000076db, 0x000090b7 },
	{ 0x000076dc, 0x00009f58 },
	{ 0x000076de, 0x0000e1b5 },
	{ 0x000076df, 0x000096bf },
	{ 0x000076e1, 0x0000e1b6 },
	{ 0x000076e3, 0x00008ac4 },
	{ 0x000076e4, 0x000094d5 },
	{ 0x000076e5, 0x0000e1b7 },
	{ 0x000076e7, 0x0000e1b8 },
	{ 0x000076ea, 0x0000e1b9 },
	{ 0x000076ee, 0x000096da },
	{ 0x000076f2, 0x000096d3 },
	{ 0x000076f4, 0x000092bc },
	{ 0x000076f8, 0x0000918a },
	{ 0x000076fb, 0x0000e1bb },
	{ 0x000076fe, 0x00008f82 },
	{ 0x00007701, 0x00008fc8 },
	{ 0x00007704, 0x0000e1be },
	{ 0x00007707, 0x0000e1bd },
	{ 0x00007708, 0x0000e1bc },
	{ 0x00007709, 0x000094fb },
	{ 0x0000770b, 0x00008ac5 },
	{ 0x0000770c, 0x00008ca7 },
	{ 0x0000771b, 0x0000e1c4 },
	{ 0x0000771e, 0x0000e1c1 },
	{ 0x0000771f, 0x0000905e },
	{ 0x00007720, 0x000096b0 },
	{ 0x00007724, 0x0000e1c0 },
	{ 0x00007725, 0x0000e1c2 },
	{ 0x00007726, 0x0000e1c3 },
	{ 0x00007729, 0x0000e1bf },
	{ 0x00007737, 0x0000e1c5 },
	{ 0x00007738, 0x0000e1c6 },
	{ 0x0000773a, 0x000092ad },
	{ 0x0000773c, 0x00008ae1 },
	{ 0x00007740, 0x00009285 },
	{ 0x00007747, 0x0000e1c7 },
	{ 0x0000775a, 0x0000e1c8 },
	{ 0x0000775b, 0x0000e1cb },
	{ 0x00007761, 0x00009087 },
	{ 0x00007763, 0x000093c2 },
	{ 0x00007765, 0x0000e1cc },
	{ 0x00007766, 0x00009672 },
	{ 0x00007768, 0x0000e1c9 },
	{ 0x0000776b, 0x0000e1ca },
	{ 0x00007779, 0x0000e1cf },
	{ 0x0000777e, 0x0000e1ce },
	{ 0x0000777f, 0x0000e1cd },
	{ 0x0000778b, 0x0000e1d1 },
	{ 0x0000778e, 0x0000e1d0 },
	{ 0x00007791, 0x0000e1d2 },
	{ 0x0000779e, 0x0000e1d4 },
	{ 0x000077a0, 0x0000e1d3 },
	{ 0x000077a5, 0x000095cb },
	{ 0x000077ac, 0x00008f75 },
	{ 0x000077ad, 0x000097c4 },
	{ 0x000077b0, 0x0000e1d5 },
	{ 0x000077b3, 0x000093b5 },
	{ 0x000077b6, 0x0000e1d6 },
	{ 0x000077b9, 0x0000e1d7 },
	{ 0x000077bb, 0x0000e1db },
	{ 0x000077bc, 0x0000e1d9 },
	{ 0x000077bd, 0x0000e1da },
	{ 0x000077bf, 0x0000e1d8 },
	{ 0x000077c7, 0x0000e1dc },
	{ 0x000077cd, 0x0000e1dd },
	{ 0x000077d7, 0x0000e1de },
	{ 0x000077da, 0x0000e1df },
	{ 0x000077db, 0x000096b5 },
	{ 0x000077dc, 0x0000e1e0 },
	{ 0x000077e2, 0x000096ee },
	{ 0x000077e3, 0x0000e1e1 },
	{ 0x000077e5, 0x0000926d },
	{ 0x000077e7, 0x0000948a },
	{ 0x000077e9, 0x00008be9 },
	{ 0x000077ed, 0x0000925a },
	{ 0x000077ee, 0x0000e1e2 },
	{ 0x000077ef, 0x00008bb8 },
	{ 0x000077f3, 0x000090ce },
	{ 0x000077fc, 0x0000e1e3 },
	{ 0x00007802, 0x00008dbb },
	{ 0x0000780c, 0x0000e1e4 },
	{ 0x00007812, 0x0000e1e5 },
	{ 0x00007814, 0x00008ca4 },
	{ 0x00007815, 0x00008dd3 },
	{ 0x00007820, 0x0000e1e7 },
	{ 0x00007825, 0x00009375 },
	{ 0x00007826, 0x00008dd4 },
	{ 0x00007827, 0x00008b6d },
	{ 0x00007832, 0x00009643 },
	{ 0x00007834, 0x0000946a },
	{ 0x0000783a, 0x00009376 },
	{ 0x0000783f, 0x00008d7b },
	{ 0x00007845, 0x0000e1e9 },
	{ 0x0000785d, 0x00008fc9 },
	{ 0x0000786b, 0x000097b0 },
	{ 0x0000786c, 0x00008d64 },
	{ 0x0000786f, 0x00008ca5 },
	{ 0x00007872, 0x000094a1 },
	{ 0x00007874, 0x0000e1eb },
	{ 0x0000787c, 0x0000e1ed },
	{ 0x00007881, 0x00008ce9 },
	{ 0x00007886, 0x0000e1ec },
	{ 0x00007887, 0x000092f4 },
	{ 0x0000788c, 0x0000e1ef },
	{ 0x0000788d, 0x00008a56 },
	{ 0x0000788e, 0x0000e1ea },
	{ 0x00007891, 0x000094e8 },
	{ 0x00007893, 0x0000894f },
	{ 0x00007895, 0x00008dea },
	{ 0x00007897, 0x00009871 },
	{ 0x0000789a, 0x0000e1ee },
	{ 0x000078a3, 0x0000e1f0 },
	{ 0x000078a7, 0x000095c9 },
	{ 0x000078a9, 0x000090d7 },
	{ 0x000078aa, 0x0000e1f2 },
	{ 0x000078af, 0x0000e1f3 },
	{ 0x000078b5, 0x0000e1f1 },
	{ 0x000078ba, 0x00008a6d },
	{ 0x000078bc, 0x0000e1f9 },
	{ 0x000078be, 0x0000e1f8 },
	{ 0x000078c1, 0x00008ea5 },
	{ 0x000078c5, 0x0000e1fa },
	{ 0x000078c6, 0x0000e1f5 },
	{ 0x000078ca, 0x0000e1fb },
	{ 0x000078cb, 0x0000e1f6 },
	{ 0x000078d0, 0x000094d6 },
	{ 0x000078d1, 0x0000e1f4 },
	{ 0x000078d4, 0x0000e1f7 },
	{ 0x000078da, 0x0000e241 },
	{ 0x000078e7, 0x0000e240 },
	{ 0x000078e8, 0x00009681 },
	{ 0x000078ec, 0x0000e1fc },
	{ 0x000078ef, 0x000088e9 },
	{ 0x000078f4, 0x0000e243 },
	{ 0x000078fd, 0x0000e242 },
	{ 0x00007901, 0x00008fca },
	{ 0x00007907, 0x0000e244 },
	{ 0x0000790e, 0x00009162 },
	{ 0x00007911, 0x0000e246 },
	{ 0x00007912, 0x0000e245 },
	{ 0x00007919, 0x0000e247 },
	{ 0x00007926, 0x0000e1e6 },
	{ 0x0000792a, 0x0000e1e8 },
	{ 0x0000792b, 0x0000e249 },
	{ 0x0000792c, 0x0000e248 },
	{ 0x0000793a, 0x00008ea6 },
	{ 0x0000793c, 0x000097e7 },
	{ 0x0000793e, 0x00008ed0 },
	{ 0x00007940, 0x0000e24a },
	{ 0x00007941, 0x00008c56 },
	{ 0x00007947, 0x00008b5f },
	{ 0x00007948, 0x00008b46 },
	{ 0x00007949, 0x00008e83 },
	{ 0x00007950, 0x00009753 },
	{ 0x00007953, 0x0000e250 },
	{ 0x00007955, 0x0000e24f },
	{ 0x00007956, 0x00009163 },
	{ 0x00007957, 0x0000e24c },
	{ 0x0000795a, 0x0000e24e },
	{ 0x0000795d, 0x00008f6a },
	{ 0x0000795e, 0x0000905f },
	{ 0x0000795f, 0x0000e24d },
	{ 0x00007960, 0x0000e24b },
	{ 0x00007962, 0x00009449 },
	{ 0x00007965, 0x00008fcb },
	{ 0x00007968, 0x0000955b },
	{ 0x0000796d, 0x00008dd5 },
	{ 0x00007977, 0x00009398 },
	{ 0x0000797a, 0x0000e251 },
	{ 0x0000797f, 0x0000e252 },
	{ 0x00007980, 0x0000e268 },
	{ 0x00007981, 0x00008bd6 },
	{ 0x00007984, 0x0000985c },
	{ 0x00007985, 0x00009154 },
	{ 0x0000798a, 0x0000e253 },
	{ 0x0000798d, 0x000089d0 },
	{ 0x0000798e, 0x000092f5 },
	{ 0x0000798f, 0x0000959f },
	{ 0x0000799d, 0x0000e254 },
	{ 0x000079a6, 0x00008b9a },
	{ 0x000079a7, 0x0000e255 },
	{ 0x000079aa, 0x0000e257 },
	{ 0x000079ae, 0x0000e258 },
	{ 0x000079b0, 0x00009448 },
	{ 0x000079b3, 0x0000e259 },
	{ 0x000079b9, 0x0000e25a },
	{ 0x000079ba, 0x0000e25b },
	{ 0x000079bd, 0x00008bd7 },
	{ 0x000079be, 0x000089d1 },
	{ 0x000079bf, 0x000093c3 },
	{ 0x000079c0, 0x00008f47 },
	{ 0x000079c1, 0x00008e84 },
	{ 0x000079c9, 0x0000e25c },
	{ 0x000079cb, 0x00008f48 },
	{ 0x000079d1, 0x000089c8 },
	{ 0x000079d2, 0x00009562 },
	{ 0x000079d5, 0x0000e25d },
	{ 0x000079d8, 0x000094e9 },
	{ 0x000079df, 0x00009164 },
	{ 0x000079e1, 0x0000e260 },
	{ 0x000079e3, 0x0000e261 },
	{ 0x000079e4, 0x00009489 },
	{ 0x000079e6, 0x00009060 },
	{ 0x000079e7, 0x0000e25e },
	{ 0x000079e9, 0x00009281 },
	{ 0x000079ec, 0x0000e25f },
	{ 0x000079f0, 0x00008fcc },
	{ 0x000079fb, 0x000088da },
	{ 0x00007a00, 0x00008b48 },
	{ 0x00007a08, 0x0000e262 },
	{ 0x00007a0b, 0x000092f6 },
	{ 0x00007a0d, 0x0000e263 },
	{ 0x00007a0e, 0x000090c5 },
	{ 0x00007a14, 0x000096ab },
	{ 0x00007a17, 0x00009542 },
	{ 0x00007a18, 0x0000e264 },
	{ 0x00007a19, 0x0000e265 },
	{ 0x00007a1a, 0x00009274 },
	{ 0x00007a1c, 0x000097c5 },
	{ 0x00007a1f, 0x0000e267 },
	{ 0x00007a20, 0x0000e266 },
	{ 0x00007a2e, 0x00008eed },
	{ 0x00007a31, 0x0000e269 },
	{ 0x00007a32, 0x000088ee },
	{ 0x00007a37, 0x0000e26c },
	{ 0x00007a3b, 0x0000e26a },
	{ 0x00007a3c, 0x000089d2 },
	{ 0x00007a3d, 0x00008c6d },
	{ 0x00007a3e, 0x0000e26b },
	{ 0x00007a3f, 0x00008d65 },
	{ 0x00007a40, 0x00008d92 },
	{ 0x00007a42, 0x000095e4 },
	{ 0x00007a43, 0x0000e26d },
	{ 0x00007a46, 0x00009673 },
	{ 0x00007a49, 0x0000e26f },
	{ 0x00007a4d, 0x000090cf },
	{ 0x00007a4e, 0x0000896e },
	{ 0x00007a4f, 0x000089b8 },
	{ 0x00007a50, 0x000088aa },
	{ 0x00007a57, 0x0000e26e },
	{ 0x00007a61, 0x0000e270 },
	{ 0x00007a62, 0x0000e271 },
	{ 0x00007a63, 0x00008ff5 },
	{ 0x00007a69, 0x0000e272 },
	{ 0x00007a6b, 0x00008a6e },
	{ 0x00007a70, 0x0000e274 },
	{ 0x00007a74, 0x00008c8a },
	{ 0x00007a76, 0x00008b86 },
	{ 0x00007a79, 0x0000e275 },
	{ 0x00007a7a, 0x00008bf3 },
	{ 0x00007a7d, 0x0000e276 },
	{ 0x00007a7f, 0x000090fa },
	{ 0x00007a81, 0x000093cb },
	{ 0x00007a83, 0x000090de },
	{ 0x00007a84, 0x00008df3 },
	{ 0x00007a88, 0x0000e277 },
	{ 0x00007a92, 0x00009282 },
	{ 0x00007a93, 0x0000918b },
	{ 0x00007a95, 0x0000e279 },
	{ 0x00007a96, 0x0000e27b },
	{ 0x00007a97, 0x0000e278 },
	{ 0x00007a98, 0x0000e27a },
	{ 0x00007a9f, 0x00008c41 },
	{ 0x00007aa9, 0x0000e27c },
	{ 0x00007aaa, 0x00008c45 },
	{ 0x00007aae, 0x00008b87 },
	{ 0x00007aaf, 0x00009771 },
	{ 0x00007ab0, 0x0000e27e },
	{ 0x00007ab6, 0x0000e280 },
	{ 0x00007aba, 0x0000894d },
	{ 0x00007abf, 0x0000e283 },
	{ 0x00007ac3, 0x00008a96 },
	{ 0x00007ac4, 0x0000e282 },
	{ 0x00007ac5, 0x0000e281 },
	{ 0x00007ac7, 0x0000e285 },
	{ 0x00007ac8, 0x0000e27d },
	{ 0x00007aca, 0x0000e286 },
	{ 0x00007acb, 0x000097a7 },
	{ 0x00007acd, 0x0000e287 },
	{ 0x00007acf, 0x0000e288 },
	{ 0x00007ad2, 0x00009af2 },
	{ 0x00007ad3, 0x0000e28a },
	{ 0x00007ad5, 0x0000e289 },
	{ 0x00007ad9, 0x0000e28b },
	{ 0x00007ada, 0x0000e28c },
	{ 0x00007adc, 0x000097b3 },
	{ 0x00007add, 0x0000e28d },
	{ 0x00007adf, 0x0000e8ed },
	{ 0x00007ae0, 0x00008fcd },
	{ 0x00007ae1, 0x0000e28e },
	{ 0x00007ae2, 0x0000e28f },
	{ 0x00007ae3, 0x00008f76 },
	{ 0x00007ae5, 0x000093b6 },
	{ 0x00007ae6, 0x0000e290 },
	{ 0x00007aea, 0x00009247 },
	{ 0x00007aed, 0x0000e291 },
	{ 0x00007aef, 0x0000925b },
	{ 0x00007af0, 0x0000e292 },
	{ 0x00007af6, 0x00008ba3 },
	{ 0x00007af8, 0x0000995e },
	{ 0x00007af9, 0x0000927c },
	{ 0x00007afa, 0x00008eb1 },
	{ 0x00007aff, 0x00008ac6 },
	{ 0x00007b02, 0x0000e293 },
	{ 0x00007b04, 0x0000e2a0 },
	{ 0x00007b06, 0x0000e296 },
	{ 0x00007b08, 0x00008b88 },
	{ 0x00007b0a, 0x0000e295 },
	{ 0x00007b0b, 0x0000e2a2 },
	{ 0x00007b0f, 0x0000e294 },
	{ 0x00007b11, 0x00008fce },
	{ 0x00007b18, 0x0000e298 },
	{ 0x00007b19, 0x0000e299 },
	{ 0x00007b1b, 0x0000934a },
	{ 0x00007b1e, 0x0000e29a },
	{ 0x00007b20, 0x00008a7d },
	{ 0x00007b25, 0x00009079 },
	{ 0x00007b26, 0x00009584 },
	{ 0x00007b28, 0x0000e29c },
	{ 0x00007b2c, 0x000091e6 },
	{ 0x00007b33, 0x0000e297 },
	{ 0x00007b35, 0x0000e29b },
	{ 0x00007b36, 0x0000e29d },
	{ 0x00007b39, 0x00008df9 },
	{ 0x00007b45, 0x0000e2a4 },
	{ 0x00007b46, 0x0000954d },
	{ 0x00007b48, 0x000094a4 },
	{ 0x00007b49, 0x00009399 },
	{ 0x00007b4b, 0x00008bd8 },
	{ 0x00007b4c, 0x0000e2a3 },
	{ 0x00007b4d, 0x0000e2a1 },
	{ 0x00007b4f, 0x000094b3 },
	{ 0x00007b50, 0x0000e29e },
	{ 0x00007b51, 0x0000927d },
	{ 0x00007b52, 0x0000939b },
	{ 0x00007b54, 0x0000939a },
	{ 0x00007b56, 0x00008df4 },
	{ 0x00007b5d, 0x0000e2b6 },
	{ 0x00007b65, 0x0000e2a6 },
	{ 0x00007b67, 0x0000e2a8 },
	{ 0x00007b6c, 0x0000e2ab },
	{ 0x00007b6e, 0x0000e2ac },
	{ 0x00007b70, 0x0000e2a9 },
	{ 0x00007b71, 0x0000e2aa },
	{ 0x00007b74, 0x0000e2a7 },
	{ 0x00007b75, 0x0000e2a5 },
	{ 0x00007b7a, 0x0000e29f },
	{ 0x00007b86, 0x000095cd },
	{ 0x00007b87, 0x000089d3 },
	{ 0x00007b8b, 0x0000e2b3 },
	{ 0x00007b8d, 0x0000e2b0 },
	{ 0x00007b8f, 0x0000e2b5 },
	{ 0x00007b92, 0x0000e2b4 },
	{ 0x00007b94, 0x00009493 },
	{ 0x00007b95, 0x000096a5 },
	{ 0x00007b97, 0x00008e5a },
	{ 0x00007b98, 0x0000e2ae },
	{ 0x00007b99, 0x0000e2b7 },
	{ 0x00007b9a, 0x0000e2b2 },
	{ 0x00007b9c, 0x0000e2b1 },
	{ 0x00007b9d, 0x0000e2ad },
	{ 0x00007b9f, 0x0000e2af },
	{ 0x00007ba1, 0x00008ac7 },
	{ 0x00007baa, 0x0000925c },
	{ 0x00007bad, 0x000090fb },
	{ 0x00007bb1, 0x000094a0 },
	{ 0x00007bb4, 0x0000e2bc },
	{ 0x00007bb8, 0x000094a2 },
	{ 0x00007bc0, 0x000090df },
	{ 0x00007bc1, 0x0000e2b9 },
	{ 0x00007bc4, 0x000094cd },
	{ 0x00007bc6, 0x0000e2bd },
	{ 0x00007bc7, 0x000095d1 },
	{ 0x00007bc9, 0x0000927a },
	{ 0x00007bcb, 0x0000e2b8 },
	{ 0x00007bcc, 0x0000e2ba },
	{ 0x00007bcf, 0x0000e2bb },
	{ 0x00007bdd, 0x0000e2be },
	{ 0x00007be0, 0x00008ec2 },
	{ 0x00007be4, 0x000093c4 },
	{ 0x00007be5, 0x0000e2c3 },
	{ 0x00007be6, 0x0000e2c2 },
	{ 0x00007be9, 0x0000e2bf },
	{ 0x00007bed, 0x00009855 },
	{ 0x00007bf3, 0x0000e2c8 },
	{ 0x00007bf6, 0x0000e2cc },
	{ 0x00007bf7, 0x0000e2c9 },
	{ 0x00007c00, 0x0000e2c5 },
	{ 0x00007c07, 0x0000e2c6 },
	{ 0x00007c0d, 0x0000e2cb },
	{ 0x00007c11, 0x0000e2c0 },
	{ 0x00007c12, 0x000099d3 },
	{ 0x00007c13, 0x0000e2c7 },
	{ 0x00007c14, 0x0000e2c1 },
	{ 0x00007c17, 0x0000e2ca },
	{ 0x00007c1f, 0x0000e2d0 },
	{ 0x00007c21, 0x00008ac8 },
	{ 0x00007c23, 0x0000e2cd },
	{ 0x00007c27, 0x0000e2ce },
	{ 0x00007c2a, 0x0000e2cf },
	{ 0x00007c2b, 0x0000e2d2 },
	{ 0x00007c37, 0x0000e2d1 },
	{ 0x00007c38, 0x000094f4 },
	{ 0x00007c3d, 0x0000e2d3 },
	{ 0x00007c3e, 0x000097fa },
	{ 0x00007c3f, 0x000095eb },
	{ 0x00007c40, 0x0000e2d8 },
	{ 0x00007c43, 0x0000e2d5 },
	{ 0x00007c4c, 0x0000e2d4 },
	{ 0x00007c4d, 0x000090d0 },
	{ 0x00007c4f, 0x0000e2d7 },
	{ 0x00007c50, 0x0000e2d9 },
	{ 0x00007c54, 0x0000e2d6 },
	{ 0x00007c56, 0x0000e2dd },
	{ 0x00007c58, 0x0000e2da },
	{ 0x00007c5f, 0x0000e2db },
	{ 0x00007c60, 0x0000e2c4 },
	{ 0x00007c64, 0x0000e2dc },
	{ 0x00007c65, 0x0000e2de },
	{ 0x00007c6c, 0x0000e2df },
	{ 0x00007c73, 0x000095c4 },
	{ 0x00007c75, 0x0000e2e0 },
	{ 0x00007c7e, 0x000096e0 },
	{ 0x00007c81, 0x00008bcc },
	{ 0x00007c82, 0x00008c48 },
	{ 0x00007c83, 0x0000e2e1 },
	{ 0x00007c89, 0x000095b2 },
	{ 0x00007c8b, 0x00009088 },
	{ 0x00007c8d, 0x000096ae },
	{ 0x00007c90, 0x0000e2e2 },
	{ 0x00007c92, 0x000097b1 },
	{ 0x00007c95, 0x00009494 },
	{ 0x00007c97, 0x00009165 },
	{ 0x00007c98, 0x00009453 },
	{ 0x00007c9b, 0x00008f6c },
	{ 0x00007c9f, 0x000088be },
	{ 0x00007ca1, 0x0000e2e7 },
	{ 0x00007ca2, 0x0000e2e5 },
	{ 0x00007ca4, 0x0000e2e3 },
	{ 0x00007ca5, 0x00008a9f },
	{ 0x00007ca7, 0x00008fcf },
	{ 0x00007ca8, 0x0000e2e8 },
	{ 0x00007cab, 0x0000e2e6 },
	{ 0x00007cad, 0x0000e2e4 },
	{ 0x00007cae, 0x0000e2ec },
	{ 0x00007cb1, 0x0000e2eb },
	{ 0x00007cb2, 0x0000e2ea },
	{ 0x00007cb3, 0x0000e2e9 },
	{ 0x00007cb9, 0x0000e2ed },
	{ 0x00007cbd, 0x0000e2ee },
	{ 0x00007cbe, 0x000090b8 },
	{ 0x00007cc0, 0x0000e2ef },
	{ 0x00007cc2, 0x0000e2f1 },
	{ 0x00007cc5, 0x0000e2f0 },
	{ 0x00007cca, 0x00008cd0 },
	{ 0x00007cce, 0x00009157 },
	{ 0x00007cd2, 0x0000e2f3 },
	{ 0x00007cd6, 0x0000939c },
	{ 0x00007cd8, 0x0000e2f2 },
	{ 0x00007cdc, 0x0000e2f4 },
	{ 0x00007cde, 0x000095b3 },
	{ 0x00007cdf, 0x0000918c },
	{ 0x00007ce0, 0x00008d66 },
	{ 0x00007ce2, 0x0000e2f5 },
	{ 0x00007ce7, 0x000097c6 },
	{ 0x00007cef, 0x0000e2f7 },
	{ 0x00007cf2, 0x0000e2f8 },
	{ 0x00007cf4, 0x0000e2f9 },
	{ 0x00007cf6, 0x0000e2fa },
	{ 0x00007cf8, 0x00008e85 },
	{ 0x00007cfa, 0x0000e2fb },
	{ 0x00007cfb, 0x00008c6e },
	{ 0x00007cfe, 0x00008b8a },
	{ 0x00007d00, 0x00008b49 },
	{ 0x00007d02, 0x0000e340 },
	{ 0x00007d04, 0x000096f1 },
	{ 0x00007d05, 0x00008d67 },
	{ 0x00007d06, 0x0000e2fc },
	{ 0x00007d0a, 0x0000e343 },
	{ 0x00007d0b, 0x000096e4 },
	{ 0x00007d0d, 0x0000945b },
	{ 0x00007d10, 0x00009552 },
	{ 0x00007d14, 0x00008f83 },
	{ 0x00007d15, 0x0000e342 },
	{ 0x00007d17, 0x00008ed1 },
	{ 0x00007d18, 0x00008d68 },
	{ 0x00007d19, 0x00008e86 },
	{ 0x00007d1a, 0x00008b89 },
	{ 0x00007d1b, 0x000095b4 },
	{ 0x00007d1c, 0x0000e341 },
	{ 0x00007d20, 0x00009166 },
	{ 0x00007d21, 0x00009661 },
	{ 0x00007d22, 0x00008df5 },
	{ 0x00007d2b, 0x00008e87 },
	{ 0x00007d2c, 0x000092db },
	{ 0x00007d2e, 0x0000e346 },
	{ 0x00007d2f, 0x000097dd },
	{ 0x00007d30, 0x00008dd7 },
	{ 0x00007d32, 0x0000e347 },
	{ 0x00007d33, 0x00009061 },
	{ 0x00007d35, 0x0000e349 },
	{ 0x00007d39, 0x00008fd0 },
	{ 0x00007d3a, 0x00008dae },
	{ 0x00007d3f, 0x0000e348 },
	{ 0x00007d42, 0x00008f49 },
	{ 0x00007d43, 0x00008cbc },
	{ 0x00007d44, 0x00009167 },
	{ 0x00007d45, 0x0000e344 },
	{ 0x00007d46, 0x0000e34a },
	{ 0x00007d4b, 0x0000e345 },
	{ 0x00007d4c, 0x00008c6f },
	{ 0x00007d4e, 0x0000e34d },
	{ 0x00007d4f, 0x0000e351 },
	{ 0x00007d50, 0x00008c8b },
	{ 0x00007d56, 0x0000e34c },
	{ 0x00007d5b, 0x0000e355 },
	{ 0x00007d5e, 0x00008d69 },
	{ 0x00007d61, 0x0000978d },
	{ 0x00007d62, 0x000088ba },
	{ 0x00007d63, 0x0000e352 },
	{ 0x00007d66, 0x00008b8b },
	{ 0x00007d68, 0x0000e34f },
	{ 0x00007d6e, 0x0000e350 },
	{ 0x00007d71, 0x0000939d },
	{ 0x00007d72, 0x0000e34e },
	{ 0x00007d73, 0x0000e34b },
	{ 0x00007d75, 0x00008a47 },
	{ 0x00007d76, 0x000090e2 },
	{ 0x00007d79, 0x00008ca6 },
	{ 0x00007d7d, 0x0000e357 },
	{ 0x00007d89, 0x0000e354 },
	{ 0x00007d8f, 0x0000e356 },
	{ 0x00007d93, 0x0000e353 },
	{ 0x00007d99, 0x00008c70 },
	{ 0x00007d9a, 0x000091b1 },
	{ 0x00007d9b, 0x0000e358 },
	{ 0x00007d9c, 0x0000918e },
	{ 0x00007d9f, 0x0000e365 },
	{ 0x00007da2, 0x0000e361 },
	{ 0x00007da3, 0x0000e35b },
	{ 0x00007dab, 0x0000e35f },
	{ 0x00007dac, 0x00008ef8 },
	{ 0x00007dad, 0x000088db },
	{ 0x00007dae, 0x0000e35a },
	{ 0x00007daf, 0x0000e362 },
	{ 0x00007db0, 0x0000e366 },
	{ 0x00007db1, 0x00008d6a },
	{ 0x00007db2, 0x000096d4 },
	{ 0x00007db4, 0x000092d4 },
	{ 0x00007db5, 0x0000e35c },
	{ 0x00007db8, 0x0000e364 },
	{ 0x00007dba, 0x0000e359 },
	{ 0x00007dbb, 0x0000925d },
	{ 0x00007dbd, 0x0000e35e },
	{ 0x00007dbe, 0x000088bb },
	{ 0x00007dbf, 0x000096c8 },
	{ 0x00007dc7, 0x0000e35d },
	{ 0x00007dca, 0x00008bd9 },
	{ 0x00007dcb, 0x000094ea },
	{ 0x00007dcf, 0x0000918d },
	{ 0x00007dd1, 0x000097ce },
	{ 0x00007dd2, 0x00008f8f },
	{ 0x00007dd5, 0x0000e38e },
	{ 0x00007dd8, 0x0000e367 },
	{ 0x00007dda, 0x000090fc },
	{ 0x00007ddc, 0x0000e363 },
	{ 0x00007ddd, 0x0000e368 },
	{ 0x00007dde, 0x0000e36a },
	{ 0x00007de0, 0x000092f7 },
	{ 0x00007de1, 0x0000e36d },
	{ 0x00007de4, 0x0000e369 },
	{ 0x00007de8, 0x000095d2 },
	{ 0x00007de9, 0x00008ac9 },
	{ 0x00007dec, 0x000096c9 },
	{ 0x00007def, 0x000088dc },
	{ 0x00007df2, 0x0000e36c },
	{ 0x00007df4, 0x000097fb },
	{ 0x00007dfb, 0x0000e36b },
	{ 0x00007e01, 0x0000898f },
	{ 0x00007e04, 0x000093ea },
	{ 0x00007e05, 0x0000e36e },
	{ 0x00007e09, 0x0000e375 },
	{ 0x00007e0a, 0x0000e36f },
	{ 0x00007e0b, 0x0000e376 },
	{ 0x00007e12, 0x0000e372 },
	{ 0x00007e1b, 0x0000949b },
	{ 0x00007e1e, 0x00008ec8 },
	{ 0x00007e1f, 0x0000e374 },
	{ 0x00007e21, 0x0000e371 },
	{ 0x00007e22, 0x0000e377 },
	{ 0x00007e23, 0x0000e370 },
	{ 0x00007e26, 0x00008f63 },
	{ 0x00007e2b, 0x00009644 },
	{ 0x00007e2e, 0x00008f6b },
	{ 0x00007e31, 0x0000e373 },
	{ 0x00007e32, 0x0000e380 },
	{ 0x00007e35, 0x0000e37b },
	{ 0x00007e37, 0x0000e37e },
	{ 0x00007e39, 0x0000e37c },
	{ 0x00007e3a, 0x0000e381 },
	{ 0x00007e3b, 0x0000e37a },
	{ 0x00007e3d, 0x0000e360 },
	{ 0x00007e3e, 0x000090d1 },
	{ 0x00007e41, 0x000094c9 },
	{ 0x00007e43, 0x0000e37d },
	{ 0x00007e46, 0x0000e378 },
	{ 0x00007e4a, 0x00009140 },
	{ 0x00007e4b, 0x00008c71 },
	{ 0x00007e4d, 0x00008f4a },
	{ 0x00007e54, 0x00009044 },
	{ 0x00007e55, 0x00009155 },
	{ 0x00007e56, 0x0000e384 },
	{ 0x00007e59, 0x0000e386 },
	{ 0x00007e5a, 0x0000e387 },
	{ 0x00007e5d, 0x0000e383 },
	{ 0x00007e5e, 0x0000e385 },
	{ 0x00007e66, 0x0000e379 },
	{ 0x00007e67, 0x0000e382 },
	{ 0x00007e69, 0x0000e38a },
	{ 0x00007e6a, 0x0000e389 },
	{ 0x00007e6d, 0x0000969a },
	{ 0x00007e70, 0x00008c4a },
	{ 0x00007e79, 0x0000e388 },
	{ 0x00007e7b, 0x0000e38c },
	{ 0x00007e7c, 0x0000e38b },
	{ 0x00007e7d, 0x0000e38f },
	{ 0x00007e7f, 0x0000e391 },
	{ 0x00007e82, 0x00008e5b },
	{ 0x00007e83, 0x0000e38d },
	{ 0x00007e88, 0x0000e392 },
	{ 0x00007e89, 0x0000e393 },
	{ 0x00007e8c, 0x0000e394 },
	{ 0x00007e8e, 0x0000e39a },
	{ 0x00007e8f, 0x0000935a },
	{ 0x00007e90, 0x0000e396 },
	{ 0x00007e92, 0x0000e395 },
	{ 0x00007e93, 0x0000e397 },
	{ 0x00007e94, 0x0000e398 },
	{ 0x00007e96, 0x0000e399 },
	{ 0x00007e9b, 0x0000e39b },
	{ 0x00007e9c, 0x0000e39c },
	{ 0x00007f36, 0x00008aca },
	{ 0x00007f38, 0x0000e39d },
	{ 0x00007f3a, 0x0000e39e },
	{ 0x00007f45, 0x0000e39f },
	{ 0x00007f4c, 0x0000e3a0 },
	{ 0x00007f4d, 0x0000e3a1 },
	{ 0x00007f4e, 0x0000e3a2 },
	{ 0x00007f50, 0x0000e3a3 },
	{ 0x00007f51, 0x0000e3a4 },
	{ 0x00007f54, 0x0000e3a6 },
	{ 0x00007f55, 0x0000e3a5 },
	{ 0x00007f58, 0x0000e3a7 },
	{ 0x00007f5f, 0x0000e3a8 },
	{ 0x00007f60, 0x0000e3a9 },
	{ 0x00007f67, 0x0000e3ac },
	{ 0x00007f68, 0x0000e3aa },
	{ 0x00007f69, 0x0000e3ab },
	{ 0x00007f6a, 0x00008ddf },
	{ 0x00007f6b, 0x00008c72 },
	{ 0x00007f6e, 0x00009275 },
	{ 0x00007f70, 0x000094b1 },
	{ 0x00007f72, 0x00008f90 },
	{ 0x00007f75, 0x0000946c },
	{ 0x00007f77, 0x000094eb },
	{ 0x00007f78, 0x0000e3ad },
	{ 0x00007f79, 0x00009ceb },
	{ 0x00007f82, 0x0000e3ae },
	{ 0x00007f83, 0x0000e3b0 },
	{ 0x00007f85, 0x00009785 },
	{ 0x00007f86, 0x0000e3af },
	{ 0x00007f87, 0x0000e3b2 },
	{ 0x00007f88, 0x0000e3b1 },
	{ 0x00007f8a, 0x00009772 },
	{ 0x00007f8c, 0x0000e3b3 },
	{ 0x00007f8e, 0x000094fc },
	{ 0x00007f94, 0x0000e3b4 },
	{ 0x00007f9a, 0x0000e3b7 },
	{ 0x00007f9d, 0x0000e3b6 },
	{ 0x00007f9e, 0x0000e3b5 },
	{ 0x00007fa3, 0x0000e3b8 },
	{ 0x00007fa4, 0x00008c51 },
	{ 0x00007fa8, 0x00009141 },
	{ 0x00007fa9, 0x00008b60 },
	{ 0x00007fae, 0x0000e3bc },
	{ 0x00007faf, 0x0000e3b9 },
	{ 0x00007fb2, 0x0000e3ba },
	{ 0x00007fb6, 0x0000e3bd },
	{ 0x00007fb8, 0x0000e3be },
	{ 0x00007fb9, 0x0000e3bb },
	{ 0x00007fbd, 0x00008948 },
	{ 0x00007fc1, 0x000089a5 },
	{ 0x00007fc5, 0x0000e3c0 },
	{ 0x00007fc6, 0x0000e3c1 },
	{ 0x00007fca, 0x0000e3c2 },
	{ 0x00007fcc, 0x00009782 },
	{ 0x00007fd2, 0x00008f4b },
	{ 0x00007fd4, 0x0000e3c4 },
	{ 0x00007fd5, 0x0000e3c3 },
	{ 0x00007fe0, 0x00009089 },
	{ 0x00007fe1, 0x0000e3c5 },
	{ 0x00007fe6, 0x0000e3c6 },
	{ 0x00007fe9, 0x0000e3c7 },
	{ 0x00007feb, 0x00008ae3 },
	{ 0x00007ff0, 0x00008acb },
	{ 0x00007ff3, 0x0000e3c8 },
	{ 0x00007ff9, 0x0000e3c9 },
	{ 0x00007ffb, 0x0000967c },
	{ 0x00007ffc, 0x00009783 },
	{ 0x00008000, 0x00009773 },
	{ 0x00008001, 0x00009856 },
	{ 0x00008003, 0x00008d6c },
	{ 0x00008004, 0x0000e3cc },
	{ 0x00008005, 0x00008ed2 },
	{ 0x00008006, 0x0000e3cb },
	{ 0x0000800b, 0x0000e3cd },
	{ 0x0000800c, 0x00008ea7 },
	{ 0x00008010, 0x000091cf },
	{ 0x00008012, 0x0000e3ce },
	{ 0x00008015, 0x00008d6b },
	{ 0x00008017, 0x000096d5 },
	{ 0x00008018, 0x0000e3cf },
	{ 0x00008019, 0x0000e3d0 },
	{ 0x0000801c, 0x0000e3d1 },
	{ 0x00008021, 0x0000e3d2 },
	{ 0x00008028, 0x0000e3d3 },
	{ 0x00008033, 0x00008ea8 },
	{ 0x00008036, 0x000096eb },
	{ 0x0000803b, 0x0000e3d5 },
	{ 0x0000803d, 0x0000925e },
	{ 0x0000803f, 0x0000e3d4 },
	{ 0x00008046, 0x0000e3d7 },
	{ 0x0000804a, 0x0000e3d6 },
	{ 0x00008052, 0x0000e3d8 },
	{ 0x00008056, 0x000090b9 },
	{ 0x00008058, 0x0000e3d9 },
	{ 0x0000805a, 0x0000e3da },
	{ 0x0000805e, 0x000095b7 },
	{ 0x0000805f, 0x0000e3db },
	{ 0x00008061, 0x0000918f },
	{ 0x00008062, 0x0000e3dc },
	{ 0x00008068, 0x0000e3dd },
	{ 0x0000806f, 0x000097fc },
	{ 0x00008070, 0x0000e3e0 },
	{ 0x00008072, 0x0000e3df },
	{ 0x00008073, 0x0000e3de },
	{ 0x00008074, 0x000092ae },
	{ 0x00008076, 0x0000e3e1 },
	{ 0x00008077, 0x00009045 },
	{ 0x00008079, 0x0000e3e2 },
	{ 0x0000807d, 0x0000e3e3 },
	{ 0x0000807e, 0x00009857 },
	{ 0x0000807f, 0x0000e3e4 },
	{ 0x00008084, 0x0000e3e5 },
	{ 0x00008085, 0x0000e3e7 },
	{ 0x00008086, 0x0000e3e6 },
	{ 0x00008087, 0x000094a3 },
	{ 0x00008089, 0x000093f7 },
	{ 0x0000808b, 0x0000985d },
	{ 0x0000808c, 0x000094a7 },
	{ 0x00008093, 0x0000e3e9 },
	{ 0x00008096, 0x00008fd1 },
	{ 0x00008098, 0x00009549 },
	{ 0x0000809a, 0x0000e3ea },
	{ 0x0000809b, 0x0000e3e8 },
	{ 0x0000809d, 0x00008acc },
	{ 0x000080a1, 0x00008cd2 },
	{ 0x000080a2, 0x00008e88 },
	{ 0x000080a5, 0x000094ec },
	{ 0x000080a9, 0x00008ca8 },
	{ 0x000080aa, 0x00009662 },
	{ 0x000080ac, 0x0000e3ed },
	{ 0x000080ad, 0x0000e3eb },
	{ 0x000080af, 0x00008d6d },
	{ 0x000080b1, 0x00008d6e },
	{ 0x000080b2, 0x000088e7 },
	{ 0x000080b4, 0x00008de6 },
	{ 0x000080ba, 0x00009478 },
	{ 0x000080c3, 0x000088dd },
	{ 0x000080c4, 0x0000e3f2 },
	{ 0x000080c6, 0x0000925f },
	{ 0x000080cc, 0x00009477 },
	{ 0x000080ce, 0x000091d9 },
	{ 0x000080d6, 0x0000e3f4 },
	{ 0x000080d9, 0x0000e3f0 },
	{ 0x000080da, 0x0000e3f3 },
	{ 0x000080db, 0x0000e3ee },
	{ 0x000080dd, 0x0000e3f1 },
	{ 0x000080de, 0x00009645 },
	{ 0x000080e1, 0x00008cd3 },
	{ 0x000080e4, 0x000088fb },
	{ 0x000080e5, 0x0000e3ef },
	{ 0x000080ef, 0x0000e3f6 },
	{ 0x000080f1, 0x0000e3f7 },
	{ 0x000080f4, 0x000093b7 },
	{ 0x000080f8, 0x00008bb9 },
	{ 0x000080fc, 0x0000e445 },
	{ 0x000080fd, 0x0000945c },
	{ 0x00008102, 0x00008e89 },
	{ 0x00008105, 0x00008bba },
	{ 0x00008106, 0x000090c6 },
	{ 0x00008107, 0x00009865 },
	{ 0x00008108, 0x000096ac },
	{ 0x00008109, 0x0000e3f5 },
	{ 0x0000810a, 0x000090d2 },
	{ 0x0000811a, 0x00008b72 },
	{ 0x0000811b, 0x0000e3f8 },
	{ 0x00008123, 0x0000e3fa },
	{ 0x00008129, 0x0000e3f9 },
	{ 0x0000812f, 0x0000e3fb },
	{ 0x00008131, 0x00009245 },
	{ 0x00008133, 0x0000945d },
	{ 0x00008139, 0x000092af },
	{ 0x0000813e, 0x0000e442 },
	{ 0x00008146, 0x0000e441 },
	{ 0x0000814b, 0x0000e3fc },
	{ 0x0000814e, 0x00009074 },
	{ 0x00008150, 0x00009585 },
	{ 0x00008151, 0x0000e444 },
	{ 0x00008153, 0x0000e443 },
	{ 0x00008154, 0x00008d6f },
	{ 0x00008155, 0x00009872 },
	{ 0x0000815f, 0x0000e454 },
	{ 0x00008165, 0x0000e448 },
	{ 0x00008166, 0x0000e449 },
	{ 0x0000816b, 0x00008eee },
	{ 0x0000816e, 0x0000e447 },
	{ 0x00008170, 0x00008d98 },
	{ 0x00008171, 0x0000e446 },
	{ 0x00008174, 0x0000e44a },
	{ 0x00008178, 0x000092b0 },
	{ 0x00008179, 0x000095a0 },
	{ 0x0000817a, 0x00009142 },
	{ 0x0000817f, 0x000091da },
	{ 0x00008180, 0x0000e44e },
	{ 0x00008182, 0x0000e44f },
	{ 0x00008183, 0x0000e44b },
	{ 0x00008188, 0x0000e44c },
	{ 0x0000818a, 0x0000e44d },
	{ 0x0000818f, 0x00008d70 },
	{ 0x00008193, 0x0000e455 },
	{ 0x00008195, 0x0000e451 },
	{ 0x0000819a, 0x00009586 },
	{ 0x0000819c, 0x0000968c },
	{ 0x0000819d, 0x00009547 },
	{ 0x000081a0, 0x0000e450 },
	{ 0x000081a3, 0x0000e453 },
	{ 0x000081a4, 0x0000e452 },
	{ 0x000081a8, 0x00009663 },
	{ 0x000081a9, 0x0000e456 },
	{ 0x000081b0, 0x0000e457 },
	{ 0x000081b3, 0x00009156 },
	{ 0x000081b5, 0x0000e458 },
	{ 0x000081b8, 0x0000e45a },
	{ 0x000081ba, 0x0000e45e },
	{ 0x000081bd, 0x0000e45b },
	{ 0x000081be, 0x0000e459 },
	{ 0x000081bf, 0x0000945e },
	{ 0x000081c0, 0x0000e45c },
	{ 0x000081c2, 0x0000e45d },
	{ 0x000081c6, 0x000089b0 },
	{ 0x000081c8, 0x0000e464 },
	{ 0x000081c9, 0x0000e45f },
	{ 0x000081cd, 0x0000e460 },
	{ 0x000081d1, 0x0000e461 },
	{ 0x000081d3, 0x0000919f },
	{ 0x000081d8, 0x0000e463 },
	{ 0x000081d9, 0x0000e462 },
	{ 0x000081da, 0x0000e465 },
	{ 0x000081df, 0x0000e466 },
	{ 0x000081e0, 0x0000e467 },
	{ 0x000081e3, 0x00009062 },
	{ 0x000081e5, 0x000089e7 },
	{ 0x000081e7, 0x0000e468 },
	{ 0x000081e8, 0x000097d5 },
	{ 0x000081ea, 0x00008ea9 },
	{ 0x000081ed, 0x00008f4c },
	{ 0x000081f3, 0x00008e8a },
	{ 0x000081f4, 0x00009276 },
	{ 0x000081fa, 0x0000e469 },
	{ 0x000081fb, 0x0000e46a },
	{ 0x000081fc, 0x00008950 },
	{ 0x000081fe, 0x0000e46b },
	{ 0x00008201, 0x0000e46c },
	{ 0x00008202, 0x0000e46d },
	{ 0x00008205, 0x0000e46e },
	{ 0x00008207, 0x0000e46f },
	{ 0x00008208, 0x00008bbb },
	{ 0x00008209, 0x00009da8 },
	{ 0x0000820a, 0x0000e470 },
	{ 0x0000820c, 0x000090e3 },
	{ 0x0000820d, 0x0000e471 },
	{ 0x0000820e, 0x00008ec9 },
	{ 0x00008210, 0x0000e472 },
	{ 0x00008212, 0x000098ae },
	{ 0x00008216, 0x0000e473 },
	{ 0x00008217, 0x000095dc },
	{ 0x00008218, 0x00008ada },
	{ 0x0000821b, 0x00009143 },
	{ 0x0000821c, 0x00008f77 },
	{ 0x0000821e, 0x00009591 },
	{ 0x0000821f, 0x00008f4d },
	{ 0x00008229, 0x0000e474 },
	{ 0x0000822a, 0x00008d71 },
	{ 0x0000822b, 0x0000e475 },
	{ 0x0000822c, 0x000094ca },
	{ 0x0000822e, 0x0000e484 },
	{ 0x00008233, 0x0000e477 },
	{ 0x00008235, 0x000091c7 },
	{ 0x00008236, 0x00009495 },
	{ 0x00008237, 0x00008cbd },
	{ 0x00008238, 0x0000e476 },
	{ 0x00008239, 0x00009144 },
	{ 0x00008240, 0x0000e478 },
	{ 0x00008247, 0x000092f8 },
	{ 0x00008258, 0x0000e47a },
	{ 0x00008259, 0x0000e479 },
	{ 0x0000825a, 0x0000e47c },
	{ 0x0000825d, 0x0000e47b },
	{ 0x0000825f, 0x0000e47d },
	{ 0x00008262, 0x0000e480 },
	{ 0x00008264, 0x0000e47e },
	{ 0x00008266, 0x00008acd },
	{ 0x00008268, 0x0000e481 },
	{ 0x0000826a, 0x0000e482 },
	{ 0x0000826b, 0x0000e483 },
	{ 0x0000826e, 0x00008daf },
	{ 0x0000826f, 0x000097c7 },
	{ 0x00008271, 0x0000e485 },
	{ 0x00008272, 0x00009046 },
	{ 0x00008276, 0x00008990 },
	{ 0x00008277, 0x0000e486 },
	{ 0x00008278, 0x0000e487 },
	{ 0x0000827e, 0x0000e488 },
	{ 0x0000828b, 0x000088f0 },
	{ 0x0000828d, 0x0000e489 },
	{ 0x00008292, 0x0000e48a },
	{ 0x00008299, 0x00009587 },
	{ 0x0000829d, 0x00008ec5 },
	{ 0x0000829f, 0x0000e48c },
	{ 0x000082a5, 0x00008a48 },
	{ 0x000082a6, 0x000088b0 },
	{ 0x000082ab, 0x0000e48b },
	{ 0x000082ac, 0x0000e48e },
	{ 0x000082ad, 0x0000946d },
	{ 0x000082af, 0x00009063 },
	{ 0x000082b1, 0x000089d4 },
	{ 0x000082b3, 0x00009646 },
	{ 0x000082b8, 0x00008c7c },
	{ 0x000082b9, 0x00008bda },
	{ 0x000082bb, 0x0000e48d },
	{ 0x000082bd, 0x000089e8 },
	{ 0x000082c5, 0x00008aa1 },
	{ 0x000082d1, 0x00008991 },
	{ 0x000082d2, 0x0000e492 },
	{ 0x000082d3, 0x000097e8 },
	{ 0x000082d4, 0x000091db },
	{ 0x000082d7, 0x00009563 },
	{ 0x000082d9, 0x0000e49e },
	{ 0x000082db, 0x000089d5 },
	{ 0x000082dc, 0x0000e49c },
	{ 0x000082de, 0x0000e49a },
	{ 0x000082df, 0x0000e491 },
	{ 0x000082e1, 0x0000e48f },
	{ 0x000082e3, 0x0000e490 },
	{ 0x000082e5, 0x00008ee1 },
	{ 0x000082e6, 0x00008bea },
	{ 0x000082e7, 0x00009297 },
	{ 0x000082eb, 0x000093cf },
	{ 0x000082f1, 0x00008970 },
	{ 0x000082f3, 0x0000e494 },
	{ 0x000082f4, 0x0000e493 },
	{ 0x000082f9, 0x0000e499 },
	{ 0x000082fa, 0x0000e495 },
	{ 0x000082fb, 0x0000e498 },
	{ 0x00008302, 0x000096ce },
	{ 0x00008303, 0x0000e497 },
	{ 0x00008304, 0x000089d6 },
	{ 0x00008305, 0x00008a9d },
	{ 0x00008306, 0x0000e49b },
	{ 0x00008309, 0x0000e49d },
	{ 0x0000830e, 0x00008c73 },
	{ 0x00008316, 0x0000e4a1 },
	{ 0x00008317, 0x0000e4aa },
	{ 0x00008318, 0x0000e4ab },
	{ 0x0000831c, 0x000088a9 },
	{ 0x00008323, 0x0000e4b2 },
	{ 0x00008328, 0x000088ef },
	{ 0x0000832b, 0x0000e4a9 },
	{ 0x0000832f, 0x0000e4a8 },
	{ 0x00008331, 0x0000e4a3 },
	{ 0x00008332, 0x0000e4a2 },
	{ 0x00008334, 0x0000e4a0 },
	{ 0x00008335, 0x0000e49f },
	{ 0x00008336, 0x00009283 },
	{ 0x00008338, 0x000091f9 },
	{ 0x00008339, 0x0000e4a5 },
	{ 0x00008340, 0x0000e4a4 },
	{ 0x00008345, 0x0000e4a7 },
	{ 0x00008349, 0x00009190 },
	{ 0x0000834a, 0x00008c74 },
	{ 0x0000834f, 0x00008960 },
	{ 0x00008350, 0x0000e4a6 },
	{ 0x00008352, 0x00008d72 },
	{ 0x00008358, 0x00009191 },
	{ 0x00008373, 0x0000e4b8 },
	{ 0x00008375, 0x0000e4b9 },
	{ 0x00008377, 0x000089d7 },
	{ 0x0000837b, 0x000089ac },
	{ 0x0000837c, 0x0000e4b6 },
	{ 0x00008385, 0x0000e4ac },
	{ 0x00008387, 0x0000e4b4 },
	{ 0x00008389, 0x0000e4bb },
	{ 0x0000838a, 0x0000e4b5 },
	{ 0x0000838e, 0x0000e4b3 },
	{ 0x00008393, 0x0000e496 },
	{ 0x00008396, 0x0000e4b1 },
	{ 0x0000839a, 0x0000e4ad },
	{ 0x0000839e, 0x00008ace },
	{ 0x0000839f, 0x0000e4af },
	{ 0x000083a0, 0x0000e4ba },
	{ 0x000083a2, 0x0000e4b0 },
	{ 0x000083a8, 0x0000e4bc },
	{ 0x000083aa, 0x0000e4ae },
	{ 0x000083ab, 0x0000949c },
	{ 0x000083b1, 0x00009789 },
	{ 0x000083b5, 0x0000e4b7 },
	{ 0x000083bd, 0x0000e4cd },
	{ 0x000083c1, 0x0000e4c5 },
	{ 0x000083c5, 0x0000909b },
	{ 0x000083ca, 0x00008b65 },
	{ 0x000083cc, 0x00008bdb },
	{ 0x000083ce, 0x0000e4c0 },
	{ 0x000083d3, 0x000089d9 },
	{ 0x000083d6, 0x00008fd2 },
	{ 0x000083d8, 0x0000e4c3 },
	{ 0x000083dc, 0x00008dd8 },
	{ 0x000083df, 0x00009370 },
	{ 0x000083e0, 0x0000e4c8 },
	{ 0x000083e9, 0x000095ec },
	{ 0x000083eb, 0x0000e4bf },
	{ 0x000083ef, 0x000089d8 },
	{ 0x000083f0, 0x00008cd4 },
	{ 0x000083f1, 0x00009548 },
	{ 0x000083f2, 0x0000e4c9 },
	{ 0x000083f4, 0x0000e4bd },
	{ 0x000083f7, 0x0000e4c6 },
	{ 0x000083fb, 0x0000e4d0 },
	{ 0x000083fd, 0x0000e4c1 },
	{ 0x00008403, 0x0000e4c2 },
	{ 0x00008404, 0x000093b8 },
	{ 0x00008407, 0x0000e4c7 },
	{ 0x0000840b, 0x0000e4c4 },
	{ 0x0000840c, 0x00009647 },
	{ 0x0000840d, 0x0000e4ca },
	{ 0x0000840e, 0x000088de },
	{ 0x00008413, 0x0000e4be },
	{ 0x00008420, 0x0000e4cc },
	{ 0x00008422, 0x0000e4cb },
	{ 0x00008429, 0x0000948b },
	{ 0x0000842a, 0x0000e4d2 },
	{ 0x0000842c, 0x0000e4dd },
	{ 0x00008431, 0x00008a9e },
	{ 0x00008435, 0x0000e4e0 },
	{ 0x00008438, 0x0000e4ce },
	{ 0x0000843c, 0x0000e4d3 },
	{ 0x0000843d, 0x0000978e },
	{ 0x00008446, 0x0000e4dc },
	{ 0x00008449, 0x00009774 },
	{ 0x0000844e, 0x000097a8 },
	{ 0x00008457, 0x00009298 },
	{ 0x0000845b, 0x00008a8b },
	{ 0x00008461, 0x00009592 },
	{ 0x00008462, 0x0000e4e2 },
	{ 0x00008463, 0x0000939f },
	{ 0x00008466, 0x000088af },
	{ 0x00008469, 0x0000e4db },
	{ 0x0000846b, 0x0000e4d7 },
	{ 0x0000846c, 0x00009192 },
	{ 0x0000846d, 0x0000e4d1 },
	{ 0x0000846e, 0x0000e4d9 },
	{ 0x0000846f, 0x0000e4de },
	{ 0x00008471, 0x0000944b },
	{ 0x00008475, 0x000088a8 },
	{ 0x00008477, 0x0000e4d6 },
	{ 0x00008479, 0x0000e4df },
	{ 0x0000847a, 0x00009598 },
	{ 0x00008482, 0x0000e4da },
	{ 0x00008484, 0x0000e4d5 },
	{ 0x0000848b, 0x00008fd3 },
	{ 0x00008490, 0x00008f4e },
	{ 0x00008494, 0x00008eaa },
	{ 0x00008499, 0x000096d6 },
	{ 0x0000849c, 0x00009566 },
	{ 0x0000849f, 0x0000e4e5 },
	{ 0x000084a1, 0x0000e4ee },
	{ 0x000084ad, 0x0000e4d8 },
	{ 0x000084b2, 0x00008a97 },
	{ 0x000084b8, 0x00008ff6 },
	{ 0x000084b9, 0x0000e4e3 },
	{ 0x000084bb, 0x0000e4e8 },
	{ 0x000084bc, 0x00009193 },
	{ 0x000084bf, 0x0000e4e4 },
	{ 0x000084c1, 0x0000e4eb },
	{ 0x000084c4, 0x0000927e },
	{ 0x000084c6, 0x0000e4ec },
	{ 0x000084c9, 0x00009775 },
	{ 0x000084ca, 0x0000e4e1 },
	{ 0x000084cb, 0x00008a57 },
	{ 0x000084cd, 0x0000e4e7 },
	{ 0x000084d0, 0x0000e4ea },
	{ 0x000084d1, 0x000096aa },
	{ 0x000084d6, 0x0000e4ed },
	{ 0x000084d9, 0x0000e4e6 },
	{ 0x000084da, 0x0000e4e9 },
	{ 0x000084ec, 0x00009648 },
	{ 0x000084ee, 0x00009840 },
	{ 0x000084f4, 0x0000e4f1 },
	{ 0x000084fc, 0x0000e4f8 },
	{ 0x000084ff, 0x0000e4f0 },
	{ 0x00008500, 0x00008ec1 },
	{ 0x00008506, 0x0000e4cf },
	{ 0x00008511, 0x000095cc },
	{ 0x00008513, 0x000096a0 },
	{ 0x00008514, 0x0000e4f7 },
	{ 0x00008515, 0x0000e4f6 },
	{ 0x00008517, 0x0000e4f2 },
	{ 0x00008518, 0x0000e4f3 },
	{ 0x0000851a, 0x00008955 },
	{ 0x0000851f, 0x0000e4f5 },
	{ 0x00008521, 0x0000e4ef },
	{ 0x00008526, 0x000092d3 },
	{ 0x0000852c, 0x0000e4f4 },
	{ 0x0000852d, 0x000088fc },
	{ 0x00008535, 0x000091a0 },
	{ 0x0000853d, 0x000095c1 },
	{ 0x00008540, 0x0000e4f9 },
	{ 0x00008541, 0x0000e540 },
	{ 0x00008543, 0x000094d7 },
	{ 0x00008548, 0x0000e4fc },
	{ 0x00008549, 0x00008fd4 },
	{ 0x0000854a, 0x00008ec7 },
	{ 0x0000854b, 0x0000e542 },
	{ 0x0000854e, 0x00008bbc },
	{ 0x00008555, 0x0000e543 },
	{ 0x00008557, 0x00009599 },
	{ 0x00008558, 0x0000e4fb },
	{ 0x0000855a, 0x0000e4d4 },
	{ 0x00008563, 0x0000e4fa },
	{ 0x00008568, 0x0000986e },
	{ 0x00008569, 0x000093a0 },
	{ 0x0000856a, 0x00009593 },
	{ 0x0000856d, 0x0000e54a },
	{ 0x00008577, 0x0000e550 },
	{ 0x0000857e, 0x0000e551 },
	{ 0x00008580, 0x0000e544 },
	{ 0x00008584, 0x00009496 },
	{ 0x00008587, 0x0000e54e },
	{ 0x00008588, 0x0000e546 },
	{ 0x0000858a, 0x0000e548 },
	{ 0x00008590, 0x0000e552 },
	{ 0x00008591, 0x0000e547 },
	{ 0x00008594, 0x0000e54b },
	{ 0x00008597, 0x00008992 },
	{ 0x00008599, 0x000093e3 },
	{ 0x0000859b, 0x0000e54c },
	{ 0x0000859c, 0x0000e54f },
	{ 0x000085a4, 0x0000e545 },
	{ 0x000085a6, 0x00009145 },
	{ 0x000085a8, 0x0000e549 },
	{ 0x000085a9, 0x00008e46 },
	{ 0x000085aa, 0x00009064 },
	{ 0x000085ab, 0x00008c4f },
	{ 0x000085ac, 0x000096f2 },
	{ 0x000085ae, 0x000096f7 },
	{ 0x000085af, 0x00008f92 },
	{ 0x000085b9, 0x0000e556 },
	{ 0x000085ba, 0x0000e554 },
	{ 0x000085c1, 0x0000986d },
	{ 0x000085c9, 0x0000e553 },
	{ 0x000085cd, 0x00009795 },
	{ 0x000085cf, 0x0000e555 },
	{ 0x000085d0, 0x0000e557 },
	{ 0x000085d5, 0x0000e558 },
	{ 0x000085dc, 0x0000e55b },
	{ 0x000085dd, 0x0000e559 },
	{ 0x000085e4, 0x000093a1 },
	{ 0x000085e5, 0x0000e55a },
	{ 0x000085e9, 0x000094cb },
	{ 0x000085ea, 0x0000e54d },
	{ 0x000085f7, 0x00008f93 },
	{ 0x000085f9, 0x0000e55c },
	{ 0x000085fa, 0x0000e561 },
	{ 0x000085fb, 0x00009194 },
	{ 0x000085fe, 0x0000e560 },
	{ 0x00008602, 0x0000e541 },
	{ 0x00008606, 0x0000e562 },
	{ 0x00008607, 0x00009168 },
	{ 0x0000860a, 0x0000e55d },
	{ 0x0000860b, 0x0000e55f },
	{ 0x00008613, 0x0000e55e },
	{ 0x00008616, 0x00009f50 },
	{ 0x00008617, 0x00009f41 },
	{ 0x0000861a, 0x0000e564 },
	{ 0x00008622, 0x0000e563 },
	{ 0x0000862d, 0x00009796 },
	{ 0x0000862f, 0x0000e1ba },
	{ 0x00008630, 0x0000e565 },
	{ 0x0000863f, 0x0000e566 },
	{ 0x0000864d, 0x0000e567 },
	{ 0x0000864e, 0x00008cd5 },
	{ 0x00008650, 0x00008b73 },
	{ 0x00008654, 0x0000e569 },
	{ 0x00008655, 0x0000997c },
	{ 0x0000865a, 0x00008b95 },
	{ 0x0000865c, 0x000097b8 },
	{ 0x0000865e, 0x00008bf1 },
	{ 0x0000865f, 0x0000e56a },
	{ 0x00008667, 0x0000e56b },
	{ 0x0000866b, 0x0000928e },
	{ 0x00008671, 0x0000e56c },
	{ 0x00008679, 0x000093f8 },
	{ 0x0000867b, 0x000088b8 },
	{ 0x0000868a, 0x000089e1 },
	{ 0x0000868b, 0x0000e571 },
	{ 0x0000868c, 0x0000e572 },
	{ 0x00008693, 0x0000e56d },
	{ 0x00008695, 0x00008e5c },
	{ 0x000086a3, 0x0000e56e },
	{ 0x000086a4, 0x00009461 },
	{ 0x000086a9, 0x0000e56f },
	{ 0x000086aa, 0x0000e570 },
	{ 0x000086ab, 0x0000e57a },
	{ 0x000086af, 0x0000e574 },
	{ 0x000086b0, 0x0000e577 },
	{ 0x000086b6, 0x0000e573 },
	{ 0x000086c4, 0x0000e575 },
	{ 0x000086c6, 0x0000e576 },
	{ 0x000086c7, 0x00008ed6 },
	{ 0x000086c9, 0x0000e578 },
	{ 0x000086cb, 0x00009260 },
	{ 0x000086cd, 0x00008c75 },
	{ 0x000086ce, 0x00008a61 },
	{ 0x000086d4, 0x0000e57b },
	{ 0x000086d9, 0x00008a5e },
	{ 0x000086db, 0x0000e581 },
	{ 0x000086de, 0x0000e57c },
	{ 0x000086df, 0x0000e580 },
	{ 0x000086e4, 0x000094b8 },
	{ 0x000086e9, 0x0000e57d },
	{ 0x000086ec, 0x0000e57e },
	{ 0x000086ed, 0x00009567 },
	{ 0x000086ee, 0x000094d8 },
	{ 0x000086ef, 0x0000e582 },
	{ 0x000086f8, 0x000091fb },
	{ 0x000086f9, 0x0000e58c },
	{ 0x000086fb, 0x0000e588 },
	{ 0x000086fe, 0x000089e9 },
	{ 0x00008700, 0x0000e586 },
	{ 0x00008702, 0x00009649 },
	{ 0x00008703, 0x0000e587 },
	{ 0x00008706, 0x0000e584 },
	{ 0x00008708, 0x0000e585 },
	{ 0x00008709, 0x0000e58a },
	{ 0x0000870a, 0x0000e58d },
	{ 0x0000870d, 0x0000e58b },
	{ 0x00008711, 0x0000e589 },
	{ 0x00008712, 0x0000e583 },
	{ 0x00008718, 0x00009277 },
	{ 0x0000871a, 0x0000e594 },
	{ 0x0000871c, 0x000096a8 },
	{ 0x00008725, 0x0000e592 },
	{ 0x00008729, 0x0000e593 },
	{ 0x00008734, 0x0000e58e },
	{ 0x00008737, 0x0000e590 },
	{ 0x0000873b, 0x0000e591 },
	{ 0x0000873f, 0x0000e58f },
	{ 0x00008749, 0x000090e4 },
	{ 0x0000874b, 0x00009858 },
	{ 0x0000874c, 0x0000e598 },
	{ 0x0000874e, 0x0000e599 },
	{ 0x00008753, 0x0000e59f },
	{ 0x00008755, 0x00009049 },
	{ 0x00008757, 0x0000e59b },
	{ 0x00008759, 0x0000e59e },
	{ 0x0000875f, 0x0000e596 },
	{ 0x00008760, 0x0000e595 },
	{ 0x00008763, 0x0000e5a0 },
	{ 0x00008766, 0x000089da },
	{ 0x00008768, 0x0000e59c },
	{ 0x0000876a, 0x0000e5a1 },
	{ 0x0000876e, 0x0000e59d },
	{ 0x00008774, 0x0000e59a },
	{ 0x00008776, 0x000092b1 },
	{ 0x00008778, 0x0000e597 },
	{ 0x0000877f, 0x00009488 },
	{ 0x00008782, 0x0000e5a5 },
	{ 0x0000878d, 0x0000975a },
	{ 0x0000879f, 0x0000e5a4 },
	{ 0x000087a2, 0x0000e5a3 },
	{ 0x000087ab, 0x0000e5ac },
	{ 0x000087af, 0x0000e5a6 },
	{ 0x000087b3, 0x0000e5ae },
	{ 0x000087ba, 0x00009786 },
	{ 0x000087bb, 0x0000e5b1 },
	{ 0x000087bd, 0x0000e5a8 },
	{ 0x000087c0, 0x0000e5a9 },
	{ 0x000087c4, 0x0000e5ad },
	{ 0x000087c6, 0x0000e5b0 },
	{ 0x000087c7, 0x0000e5af },
	{ 0x000087cb, 0x0000e5a7 },
	{ 0x000087d0, 0x0000e5aa },
	{ 0x000087d2, 0x0000e5bb },
	{ 0x000087e0, 0x0000e5b4 },
	{ 0x000087ef, 0x0000e5b2 },
	{ 0x000087f2, 0x0000e5b3 },
	{ 0x000087f6, 0x0000e5b8 },
	{ 0x000087f7, 0x0000e5b9 },
	{ 0x000087f9, 0x00008a49 },
	{ 0x000087fb, 0x00008b61 },
	{ 0x000087fe, 0x0000e5b7 },
	{ 0x00008805, 0x0000e5a2 },
	{ 0x0000880d, 0x0000e5b6 },
	{ 0x0000880e, 0x0000e5ba },
	{ 0x0000880f, 0x0000e5b5 },
	{ 0x00008811, 0x0000e5bc },
	{ 0x00008815, 0x0000e5be },
	{ 0x00008816, 0x0000e5bd },
	{ 0x00008821, 0x0000e5c0 },
	{ 0x00008822, 0x0000e5bf },
	{ 0x00008823, 0x0000e579 },
	{ 0x00008827, 0x0000e5c4 },
	{ 0x00008831, 0x0000e5c1 },
	{ 0x00008836, 0x0000e5c2 },
	{ 0x00008839, 0x0000e5c3 },
	{ 0x0000883b, 0x0000e5c5 },
	{ 0x00008840, 0x00008c8c },
	{ 0x00008842, 0x0000e5c7 },
	{ 0x00008844, 0x0000e5c6 },
	{ 0x00008846, 0x00008f4f },
	{ 0x0000884c, 0x00008d73 },
	{ 0x0000884d, 0x00009fa5 },
	{ 0x00008852, 0x0000e5c8 },
	{ 0x00008853, 0x00008f70 },
	{ 0x00008857, 0x00008a58 },
	{ 0x00008859, 0x0000e5c9 },
	{ 0x0000885b, 0x00008971 },
	{ 0x0000885d, 0x00008fd5 },
	{ 0x0000885e, 0x0000e5ca },
	{ 0x00008861, 0x00008d74 },
	{ 0x00008862, 0x0000e5cb },
	{ 0x00008863, 0x000088df },
	{ 0x00008868, 0x0000955c },
	{ 0x0000886b, 0x0000e5cc },
	{ 0x00008870, 0x0000908a },
	{ 0x00008872, 0x0000e5d3 },
	{ 0x00008875, 0x0000e5d0 },
	{ 0x00008877, 0x0000928f },
	{ 0x0000887d, 0x0000e5d1 },
	{ 0x0000887e, 0x0000e5ce },
	{ 0x0000887f, 0x00008bdc },
	{ 0x00008881, 0x0000e5cd },
	{ 0x00008882, 0x0000e5d4 },
	{ 0x00008888, 0x00008c55 },
	{ 0x0000888b, 0x000091dc },
	{ 0x0000888d, 0x0000e5da },
	{ 0x00008892, 0x0000e5d6 },
	{ 0x00008896, 0x000091b3 },
	{ 0x00008897, 0x0000e5d5 },
	{ 0x00008899, 0x0000e5d8 },
	{ 0x0000889e, 0x0000e5cf },
	{ 0x000088a2, 0x0000e5d9 },
	{ 0x000088a4, 0x0000e5db },
	{ 0x000088ab, 0x000094ed },
	{ 0x000088ae, 0x0000e5d7 },
	{ 0x000088b0, 0x0000e5dc },
	{ 0x000088b1, 0x0000e5de },
	{ 0x000088b4, 0x00008cd1 },
	{ 0x000088b5, 0x0000e5d2 },
	{ 0x000088b7, 0x000088bf },
	{ 0x000088bf, 0x0000e5dd },
	{ 0x000088c1, 0x00008dd9 },
	{ 0x000088c2, 0x000097f4 },
	{ 0x000088c3, 0x0000e5df },
	{ 0x000088c4, 0x0000e5e0 },
	{ 0x000088c5, 0x00009195 },
	{ 0x000088cf, 0x000097a0 },
	{ 0x000088d4, 0x0000e5e1 },
	{ 0x000088d5, 0x00009754 },
	{ 0x000088d8, 0x0000e5e2 },
	{ 0x000088d9, 0x0000e5e3 },
	{ 0x000088dc, 0x000095e2 },
	{ 0x000088dd, 0x0000e5e4 },
	{ 0x000088df, 0x00008dbe },
	{ 0x000088e1, 0x000097a1 },
	{ 0x000088e8, 0x0000e5e9 },
	{ 0x000088f2, 0x0000e5ea },
	{ 0x000088f3, 0x00008fd6 },
	{ 0x000088f4, 0x0000e5e8 },
	{ 0x000088f8, 0x00009787 },
	{ 0x000088f9, 0x0000e5e5 },
	{ 0x000088fc, 0x0000e5e7 },
	{ 0x000088fd, 0x000090bb },
	{ 0x000088fe, 0x0000909e },
	{ 0x00008902, 0x0000e5e6 },
	{ 0x00008904, 0x0000e5eb },
	{ 0x00008907, 0x000095a1 },
	{ 0x0000890a, 0x0000e5ed },
	{ 0x0000890c, 0x0000e5ec },
	{ 0x00008910, 0x00008a8c },
	{ 0x00008912, 0x0000964a },
	{ 0x00008913, 0x0000e5ee },
	{ 0x0000891d, 0x0000e5fa },
	{ 0x0000891e, 0x0000e5f0 },
	{ 0x00008925, 0x0000e5f1 },
	{ 0x0000892a, 0x0000e5f2 },
	{ 0x0000892b, 0x0000e5f3 },
	{ 0x00008936, 0x0000e5f7 },
	{ 0x00008938, 0x0000e5f8 },
	{ 0x0000893b, 0x0000e5f6 },
	{ 0x00008941, 0x0000e5f4 },
	{ 0x00008943, 0x0000e5ef },
	{ 0x00008944, 0x0000e5f5 },
	{ 0x0000894c, 0x0000e5f9 },
	{ 0x0000894d, 0x0000e8b5 },
	{ 0x00008956, 0x000089a6 },
	{ 0x0000895e, 0x0000e5fc },
	{ 0x0000895f, 0x00008bdd },
	{ 0x00008960, 0x0000e5fb },
	{ 0x00008964, 0x0000e641 },
	{ 0x00008966, 0x0000e640 },
	{ 0x0000896a, 0x0000e643 },
	{ 0x0000896d, 0x0000e642 },
	{ 0x0000896f, 0x0000e644 },
	{ 0x00008972, 0x00008f50 },
	{ 0x00008974, 0x0000e645 },
	{ 0x00008977, 0x0000e646 },
	{ 0x0000897e, 0x0000e647 },
	{ 0x0000897f, 0x000090bc },
	{ 0x00008981, 0x00009776 },
	{ 0x00008983, 0x0000e648 },
	{ 0x00008986, 0x000095a2 },
	{ 0x00008987, 0x00009465 },
	{ 0x00008988, 0x0000e649 },
	{ 0x0000898a, 0x0000e64a },
	{ 0x0000898b, 0x00008ca9 },
	{ 0x0000898f, 0x00008b4b },
	{ 0x00008993, 0x0000e64b },
	{ 0x00008996, 0x00008e8b },
	{ 0x00008997, 0x00009460 },
	{ 0x00008998, 0x0000e64c },
	{ 0x0000899a, 0x00008a6f },
	{ 0x000089a1, 0x0000e64d },
	{ 0x000089a6, 0x0000e64f },
	{ 0x000089a7, 0x00009797 },
	{ 0x000089a9, 0x0000e64e },
	{ 0x000089aa, 0x00009065 },
	{ 0x000089ac, 0x0000e650 },
	{ 0x000089af, 0x0000e651 },
	{ 0x000089b2, 0x0000e652 },
	{ 0x000089b3, 0x00008acf },
	{ 0x000089ba, 0x0000e653 },
	{ 0x000089bd, 0x0000e654 },
	{ 0x000089bf, 0x0000e655 },
	{ 0x000089c0, 0x0000e656 },
	{ 0x000089d2, 0x00008a70 },
	{ 0x000089da, 0x0000e657 },
	{ 0x000089dc, 0x0000e658 },
	{ 0x000089dd, 0x0000e659 },
	{ 0x000089e3, 0x000089f0 },
	{ 0x000089e6, 0x00009047 },
	{ 0x000089e7, 0x0000e65a },
	{ 0x000089f4, 0x0000e65b },
	{ 0x000089f8, 0x0000e65c },
	{ 0x00008a00, 0x00008cbe },
	{ 0x00008a02, 0x000092f9 },
	{ 0x00008a03, 0x0000e65d },
	{ 0x00008a08, 0x00008c76 },
	{ 0x00008a0a, 0x00009075 },
	{ 0x00008a0c, 0x0000e660 },
	{ 0x00008a0e, 0x000093a2 },
	{ 0x00008a10, 0x0000e65f },
	{ 0x00008a13, 0x00008c50 },
	{ 0x00008a16, 0x0000e65e },
	{ 0x00008a17, 0x000091f5 },
	{ 0x00008a18, 0x00008b4c },
	{ 0x00008a1b, 0x0000e661 },
	{ 0x00008a1d, 0x0000e662 },
	{ 0x00008a1f, 0x00008fd7 },
	{ 0x00008a23, 0x00008c8d },
	{ 0x00008a25, 0x0000e663 },
	{ 0x00008a2a, 0x0000964b },
	{ 0x00008a2d, 0x000090dd },
	{ 0x00008a31, 0x00008b96 },
	{ 0x00008a33, 0x000096f3 },
	{ 0x00008a34, 0x00009169 },
	{ 0x00008a36, 0x0000e664 },
	{ 0x00008a3a, 0x00009066 },
	{ 0x00008a3b, 0x00009290 },
	{ 0x00008a3c, 0x00008fd8 },
	{ 0x00008a41, 0x0000e665 },
	{ 0x00008a46, 0x0000e668 },
	{ 0x00008a48, 0x0000e669 },
	{ 0x00008a50, 0x00008dbc },
	{ 0x00008a51, 0x000091c0 },
	{ 0x00008a52, 0x0000e667 },
	{ 0x00008a54, 0x00008fd9 },
	{ 0x00008a55, 0x0000955d },
	{ 0x00008a5b, 0x0000e666 },
	{ 0x00008a5e, 0x00008e8c },
	{ 0x00008a60, 0x00008972 },
	{ 0x00008a62, 0x0000e66d },
	{ 0x00008a63, 0x00008c77 },
	{ 0x00008a66, 0x00008e8e },
	{ 0x00008a69, 0x00008e8d },
	{ 0x00008a6b, 0x0000986c },
	{ 0x00008a6c, 0x0000e66c },
	{ 0x00008a6d, 0x0000e66b },
	{ 0x00008a6e, 0x00009146 },
	{ 0x00008a70, 0x00008b6c },
	{ 0x00008a71, 0x00009862 },
	{ 0x00008a72, 0x00008a59 },
	{ 0x00008a73, 0x00008fda },
	{ 0x00008a7c, 0x0000e66a },
	{ 0x00008a82, 0x0000e66f },
	{ 0x00008a84, 0x0000e670 },
	{ 0x00008a85, 0x0000e66e },
	{ 0x00008a87, 0x00008cd6 },
	{ 0x00008a89, 0x0000975f },
	{ 0x00008a8c, 0x00008e8f },
	{ 0x00008a8d, 0x00009446 },
	{ 0x00008a91, 0x0000e673 },
	{ 0x00008a93, 0x000090be },
	{ 0x00008a95, 0x00009261 },
	{ 0x00008a98, 0x00009755 },
	{ 0x00008a9a, 0x0000e676 },
	{ 0x00008a9e, 0x00008cea },
	{ 0x00008aa0, 0x000090bd },
	{ 0x00008aa1, 0x0000e672 },
	{ 0x00008aa3, 0x0000e677 },
	{ 0x00008aa4, 0x00008ceb },
	{ 0x00008aa5, 0x0000e674 },
	{ 0x00008aa6, 0x0000e675 },
	{ 0x00008aa8, 0x0000e671 },
	{ 0x00008aac, 0x000090e0 },
	{ 0x00008aad, 0x000093c7 },
	{ 0x00008ab0, 0x0000924e },
	{ 0x00008ab2, 0x000089db },
	{ 0x00008ab9, 0x000094ee },
	{ 0x00008abc, 0x00008b62 },
	{ 0x00008abf, 0x000092b2 },
	{ 0x00008ac2, 0x0000e67a },
	{ 0x00008ac4, 0x0000e678 },
	{ 0x00008ac7, 0x0000926b },
	{ 0x00008acb, 0x000090bf },
	{ 0x00008acc, 0x00008ad0 },
	{ 0x00008acd, 0x0000e679 },
	{ 0x00008acf, 0x0000907a },
	{ 0x00008ad2, 0x000097c8 },
	{ 0x00008ad6, 0x0000985f },
	{ 0x00008ada, 0x0000e67b },
	{ 0x00008adb, 0x0000e687 },
	{ 0x00008adc, 0x000092b3 },
	{ 0x00008ade, 0x0000e686 },
	{ 0x00008ae0, 0x0000e683 },
	{ 0x00008ae1, 0x0000e68b },
	{ 0x00008ae2, 0x0000e684 },
	{ 0x00008ae4, 0x0000e680 },
	{ 0x00008ae6, 0x000092fa },
	{ 0x00008ae7, 0x0000e67e },
	{ 0x00008aeb, 0x0000e67c },
	{ 0x00008aed, 0x00009740 },
	{ 0x00008aee, 0x00008e90 },
	{ 0x00008af1, 0x0000e681 },
	{ 0x00008af3, 0x0000e67d },
	{ 0x00008af7, 0x0000e685 },
	{ 0x00008af8, 0x00008f94 },
	{ 0x00008afa, 0x00008cbf },
	{ 0x00008afe, 0x000091f8 },
	{ 0x00008b00, 0x00009664 },
	{ 0x00008b01, 0x00008979 },
	{ 0x00008b02, 0x000088e0 },
	{ 0x00008b04, 0x000093a3 },
	{ 0x00008b07, 0x0000e689 },
	{ 0x00008b0c, 0x0000e688 },
	{ 0x00008b0e, 0x000093e4 },
	{ 0x00008b10, 0x0000e68d },
	{ 0x00008b14, 0x0000e682 },
	{ 0x00008b16, 0x0000e68c },
	{ 0x00008b17, 0x0000e68e },
	{ 0x00008b19, 0x00008caa },
	{ 0x00008b1a, 0x0000e68a },
	{ 0x00008b1b, 0x00008d75 },
	{ 0x00008b1d, 0x00008ed3 },
	{ 0x00008b20, 0x0000e68f },
	{ 0x00008b21, 0x00009777 },
	{ 0x00008b26, 0x0000e692 },
	{ 0x00008b28, 0x0000e695 },
	{ 0x00008b2b, 0x0000e693 },
	{ 0x00008b2c, 0x00009554 },
	{ 0x00008b33, 0x0000e690 },
	{ 0x00008b39, 0x00008bde },
	{ 0x00008b3e, 0x0000e694 },
	{ 0x00008b41, 0x0000e696 },
	{ 0x00008b49, 0x0000e69a },
	{ 0x00008b4c, 0x0000e697 },
	{ 0x00008b4e, 0x0000e699 },
	{ 0x00008b4f, 0x0000e698 },
	{ 0x00008b56, 0x0000e69b },
	{ 0x00008b58, 0x00008eaf },
	{ 0x00008b5a, 0x0000e69d },
	{ 0x00008b5b, 0x0000e69c },
	{ 0x00008b5c, 0x00009588 },
	{ 0x00008b5f, 0x0000e69f },
	{ 0x00008b66, 0x00008c78 },
	{ 0x00008b6b, 0x0000e69e },
	{ 0x00008b6c, 0x0000e6a0 },
	{ 0x00008b6f, 0x0000e6a1 },
	{ 0x00008b70, 0x00008b63 },
	{ 0x00008b71, 0x0000e3bf },
	{ 0x00008b72, 0x00008ff7 },
	{ 0x00008b74, 0x0000e6a2 },
	{ 0x00008b77, 0x00008cec },
	{ 0x00008b7d, 0x0000e6a3 },
	{ 0x00008b80, 0x0000e6a4 },
	{ 0x00008b83, 0x00008e5d },
	{ 0x00008b8a, 0x00009dcc },
	{ 0x00008b8c, 0x0000e6a5 },
	{ 0x00008b8e, 0x0000e6a6 },
	{ 0x00008b90, 0x00008f51 },
	{ 0x00008b92, 0x0000e6a7 },
	{ 0x00008b93, 0x0000e6a8 },
	{ 0x00008b96, 0x0000e6a9 },
	{ 0x00008b99, 0x0000e6aa },
	{ 0x00008b9a, 0x0000e6ab },
	{ 0x00008c37, 0x0000924a },
	{ 0x00008c3a, 0x0000e6ac },
	{ 0x00008c3f, 0x0000e6ae },
	{ 0x00008c41, 0x0000e6ad },
	{ 0x00008c46, 0x000093a4 },
	{ 0x00008c48, 0x0000e6af },
	{ 0x00008c4a, 0x0000964c },
	{ 0x00008c4c, 0x0000e6b0 },
	{ 0x00008c4e, 0x0000e6b1 },
	{ 0x00008c50, 0x0000e6b2 },
	{ 0x00008c55, 0x0000e6b3 },
	{ 0x00008c5a, 0x000093d8 },
	{ 0x00008c61, 0x00008fdb },
	{ 0x00008c62, 0x0000e6b4 },
	{ 0x00008c6a, 0x00008d8b },
	{ 0x00008c6b, 0x000098ac },
	{ 0x00008c6c, 0x0000e6b5 },
	{ 0x00008c78, 0x0000e6b6 },
	{ 0x00008c79, 0x0000955e },
	{ 0x00008c7a, 0x0000e6b7 },
	{ 0x00008c7c, 0x0000e6bf },
	{ 0x00008c82, 0x0000e6b8 },
	{ 0x00008c85, 0x0000e6ba },
	{ 0x00008c89, 0x0000e6b9 },
	{ 0x00008c8a, 0x0000e6bb },
	{ 0x00008c8c, 0x00009665 },
	{ 0x00008c8d, 0x0000e6bc },
	{ 0x00008c8e, 0x0000e6bd },
	{ 0x00008c94, 0x0000e6be },
	{ 0x00008c98, 0x0000e6c0 },
	{ 0x00008c9d, 0x00008a4c },
	{ 0x00008c9e, 0x000092e5 },
	{ 0x00008ca0, 0x00009589 },
	{ 0x00008ca1, 0x00008de0 },
	{ 0x00008ca2, 0x00008d76 },
	{ 0x00008ca7, 0x0000956e },
	{ 0x00008ca8, 0x000089dd },
	{ 0x00008ca9, 0x000094cc },
	{ 0x00008caa, 0x0000e6c3 },
	{ 0x00008cab, 0x00008ad1 },
	{ 0x00008cac, 0x000090d3 },
	{ 0x00008cad, 0x0000e6c2 },
	{ 0x00008cae, 0x0000e6c7 },
	{ 0x00008caf, 0x00009299 },
	{ 0x00008cb0, 0x000096e1 },
	{ 0x00008cb2, 0x0000e6c5 },
	{ 0x00008cb3, 0x0000e6c6 },
	{ 0x00008cb4, 0x00008b4d },
	{ 0x00008cb6, 0x0000e6c8 },
	{ 0x00008cb7, 0x00009483 },
	{ 0x00008cb8, 0x000091dd },
	{ 0x00008cbb, 0x000094ef },
	{ 0x00008cbc, 0x0000935c },
	{ 0x00008cbd, 0x0000e6c4 },
	{ 0x00008cbf, 0x00009666 },
	{ 0x00008cc0, 0x000089ea },
	{ 0x00008cc1, 0x0000e6ca },
	{ 0x00008cc2, 0x00009847 },
	{ 0x00008cc3, 0x000092c0 },
	{ 0x00008cc4, 0x00009864 },
	{ 0x00008cc7, 0x00008e91 },
	{ 0x00008cc8, 0x0000e6c9 },
	{ 0x00008cca, 0x000091af },
	{ 0x00008ccd, 0x0000e6da },
	{ 0x00008cce, 0x00009147 },
	{ 0x00008cd1, 0x000093f6 },
	{ 0x00008cd3, 0x0000956f },
	{ 0x00008cda, 0x0000e6cd },
	{ 0x00008cdb, 0x00008e5e },
	{ 0x00008cdc, 0x00008e92 },
	{ 0x00008cde, 0x00008fdc },
	{ 0x00008ce0, 0x00009485 },
	{ 0x00008ce2, 0x00008cab },
	{ 0x00008ce3, 0x0000e6cc },
	{ 0x00008ce4, 0x0000e6cb },
	{ 0x00008ce6, 0x0000958a },
	{ 0x00008cea, 0x00008ebf },
	{ 0x00008ced, 0x00009371 },
	{ 0x00008cfa, 0x0000e6cf },
	{ 0x00008cfb, 0x0000e6d0 },
	{ 0x00008cfc, 0x00008d77 },
	{ 0x00008cfd, 0x0000e6ce },
	{ 0x00008d04, 0x0000e6d1 },
	{ 0x00008d05, 0x0000e6d2 },
	{ 0x00008d07, 0x0000e6d4 },
	{ 0x00008d08, 0x000091a1 },
	{ 0x00008d0a, 0x0000e6d3 },
	{ 0x00008d0b, 0x00008ae4 },
	{ 0x00008d0d, 0x0000e6d6 },
	{ 0x00008d0f, 0x0000e6d5 },
	{ 0x00008d10, 0x0000e6d7 },
	{ 0x00008d13, 0x0000e6d9 },
	{ 0x00008d14, 0x0000e6db },
	{ 0x00008d16, 0x0000e6dc },
	{ 0x00008d64, 0x000090d4 },
	{ 0x00008d66, 0x00008ecd },
	{ 0x00008d67, 0x0000e6dd },
	{ 0x00008d6b, 0x00008a71 },
	{ 0x00008d6d, 0x0000e6de },
	{ 0x00008d70, 0x00009196 },
	{ 0x00008d71, 0x0000e6df },
	{ 0x00008d73, 0x0000e6e0 },
	{ 0x00008d74, 0x0000958b },
	{ 0x00008d77, 0x00008b4e },
	{ 0x00008d81, 0x0000e6e1 },
	{ 0x00008d85, 0x000092b4 },
	{ 0x00008d8a, 0x0000897a },
	{ 0x00008d99, 0x0000e6e2 },
	{ 0x00008da3, 0x00008eef },
	{ 0x00008da8, 0x00009096 },
	{ 0x00008db3, 0x000091ab },
	{ 0x00008dba, 0x0000e6e5 },
	{ 0x00008dbe, 0x0000e6e4 },
	{ 0x00008dc2, 0x0000e6e3 },
	{ 0x00008dcb, 0x0000e6eb },
	{ 0x00008dcc, 0x0000e6e9 },
	{ 0x00008dcf, 0x0000e6e6 },
	{ 0x00008dd6, 0x0000e6e8 },
	{ 0x00008dda, 0x0000e6e7 },
	{ 0x00008ddb, 0x0000e6ea },
	{ 0x00008ddd, 0x00008b97 },
	{ 0x00008ddf, 0x0000e6ee },
	{ 0x00008de1, 0x000090d5 },
	{ 0x00008de3, 0x0000e6ef },
	{ 0x00008de8, 0x00008cd7 },
	{ 0x00008dea, 0x0000e6ec },
	{ 0x00008deb, 0x0000e6ed },
	{ 0x00008def, 0x00009848 },
	{ 0x00008df3, 0x000092b5 },
	{ 0x00008df5, 0x00009148 },
	{ 0x00008dfc, 0x0000e6f0 },
	{ 0x00008dff, 0x0000e6f3 },
	{ 0x00008e08, 0x0000e6f1 },
	{ 0x00008e09, 0x0000e6f2 },
	{ 0x00008e0a, 0x00009778 },
	{ 0x00008e0f, 0x000093a5 },
	{ 0x00008e10, 0x0000e6f6 },
	{ 0x00008e1d, 0x0000e6f4 },
	{ 0x00008e1e, 0x0000e6f5 },
	{ 0x00008e1f, 0x0000e6f7 },
	{ 0x00008e2a, 0x0000e748 },
	{ 0x00008e30, 0x0000e6fa },
	{ 0x00008e34, 0x0000e6fb },
	{ 0x00008e35, 0x0000e6f9 },
	{ 0x00008e42, 0x0000e6f8 },
	{ 0x00008e44, 0x000092fb },
	{ 0x00008e47, 0x0000e740 },
	{ 0x00008e48, 0x0000e744 },
	{ 0x00008e49, 0x0000e741 },
	{ 0x00008e4a, 0x0000e6fc },
	{ 0x00008e4c, 0x0000e742 },
	{ 0x00008e50, 0x0000e743 },
	{ 0x00008e55, 0x0000e74a },
	{ 0x00008e59, 0x0000e745 },
	{ 0x00008e5f, 0x000090d6 },
	{ 0x00008e60, 0x0000e747 },
	{ 0x00008e63, 0x0000e749 },
	{ 0x00008e64, 0x0000e746 },
	{ 0x00008e72, 0x0000e74c },
	{ 0x00008e74, 0x00008f52 },
	{ 0x00008e76, 0x0000e74b },
	{ 0x00008e7c, 0x0000e74d },
	{ 0x00008e81, 0x0000e74e },
	{ 0x00008e84, 0x0000e751 },
	{ 0x00008e85, 0x0000e750 },
	{ 0x00008e87, 0x0000e74f },
	{ 0x00008e8a, 0x0000e753 },
	{ 0x00008e8b, 0x0000e752 },
	{ 0x00008e8d, 0x000096f4 },
	{ 0x00008e91, 0x0000e755 },
	{ 0x00008e93, 0x0000e754 },
	{ 0x00008e94, 0x0000e756 },
	{ 0x00008e99, 0x0000e757 },
	{ 0x00008ea1, 0x0000e759 },
	{ 0x00008eaa, 0x0000e758 },
	{ 0x00008eab, 0x00009067 },
	{ 0x00008eac, 0x0000e75a },
	{ 0x00008eaf, 0x00008beb },
	{ 0x00008eb0, 0x0000e75b },
	{ 0x00008eb1, 0x0000e75d },
	{ 0x00008ebe, 0x0000e75e },
	{ 0x00008ec5, 0x0000e75f },
	{ 0x00008ec6, 0x0000e75c },
	{ 0x00008ec8, 0x0000e760 },
	{ 0x00008eca, 0x00008ed4 },
	{ 0x00008ecb, 0x0000e761 },
	{ 0x00008ecc, 0x00008b4f },
	{ 0x00008ecd, 0x00008c52 },
	{ 0x00008ed2, 0x00008cac },
	{ 0x00008edb, 0x0000e762 },
	{ 0x00008edf, 0x000093ee },
	{ 0x00008ee2, 0x0000935d },
	{ 0x00008ee3, 0x0000e763 },
	{ 0x00008eeb, 0x0000e766 },
	{ 0x00008ef8, 0x00008eb2 },
	{ 0x00008efb, 0x0000e765 },
	{ 0x00008efc, 0x0000e764 },
	{ 0x00008efd, 0x00008c79 },
	{ 0x00008efe, 0x0000e767 },
	{ 0x00008f03, 0x00008a72 },
	{ 0x00008f05, 0x0000e769 },
	{ 0x00008f09, 0x00008dda },
	{ 0x00008f0a, 0x0000e768 },
	{ 0x00008f0c, 0x0000e771 },
	{ 0x00008f12, 0x0000e76b },
	{ 0x00008f13, 0x0000e76d },
	{ 0x00008f14, 0x000095e3 },
	{ 0x00008f15, 0x0000e76a },
	{ 0x00008f19, 0x0000e76c },
	{ 0x00008f1b, 0x0000e770 },
	{ 0x00008f1c, 0x0000e76e },
	{ 0x00008f1d, 0x00008b50 },
	{ 0x00008f1f, 0x0000e76f },
	{ 0x00008f26, 0x0000e772 },
	{ 0x00008f29, 0x00009479 },
	{ 0x00008f2a, 0x000097d6 },
	{ 0x00008f2f, 0x00008f53 },
	{ 0x00008f33, 0x0000e773 },
	{ 0x00008f38, 0x00009741 },
	{ 0x00008f39, 0x0000e775 },
	{ 0x00008f3b, 0x0000e774 },
	{ 0x00008f3e, 0x0000e778 },
	{ 0x00008f3f, 0x00009760 },
	{ 0x00008f42, 0x0000e777 },
	{ 0x00008f44, 0x00008a8d },
	{ 0x00008f45, 0x0000e776 },
	{ 0x00008f46, 0x0000e77b },
	{ 0x00008f49, 0x0000e77a },
	{ 0x00008f4c, 0x0000e779 },
	{ 0x00008f4d, 0x00009351 },
	{ 0x00008f4e, 0x0000e77c },
	{ 0x00008f57, 0x0000e77d },
	{ 0x00008f5c, 0x0000e77e },
	{ 0x00008f5f, 0x00008d8c },
	{ 0x00008f61, 0x00008c44 },
	{ 0x00008f62, 0x0000e780 },
	{ 0x00008f63, 0x0000e781 },
	{ 0x00008f64, 0x0000e782 },
	{ 0x00008f9b, 0x00009068 },
	{ 0x00008f9c, 0x0000e783 },
	{ 0x00008f9e, 0x00008eab },
	{ 0x00008f9f, 0x0000e784 },
	{ 0x00008fa3, 0x0000e785 },
	{ 0x00008fa7, 0x0000999f },
	{ 0x00008fa8, 0x0000999e },
	{ 0x00008fad, 0x0000e786 },
	{ 0x00008fae, 0x0000e390 },
	{ 0x00008faf, 0x0000e787 },
	{ 0x00008fb0, 0x00009243 },
	{ 0x00008fb1, 0x0000904a },
	{ 0x00008fb2, 0x0000945f },
	{ 0x00008fb7, 0x0000e788 },
	{ 0x00008fba, 0x000095d3 },
	{ 0x00008fbb, 0x000092d2 },
	{ 0x00008fbc, 0x00008d9e },
	{ 0x00008fbf, 0x00009248 },
	{ 0x00008fc2, 0x00008949 },
	{ 0x00008fc4, 0x00009698 },
	{ 0x00008fc5, 0x00009076 },
	{ 0x00008fce, 0x00008c7d },
	{ 0x00008fd1, 0x00008bdf },
	{ 0x00008fd4, 0x000095d4 },
	{ 0x00008fda, 0x0000e789 },
	{ 0x00008fe2, 0x0000e78b },
	{ 0x00008fe5, 0x0000e78a },
	{ 0x00008fe6, 0x000089de },
	{ 0x00008fe9, 0x000093f4 },
	{ 0x00008fea, 0x0000e78c },
	{ 0x00008feb, 0x00009497 },
	{ 0x00008fed, 0x00009352 },
	{ 0x00008fef, 0x0000e78d },
	{ 0x00008ff0, 0x00008f71 },
	{ 0x00008ff4, 0x0000e78f },
	{ 0x00008ff7, 0x000096c0 },
	{ 0x00008ff8, 0x0000e79e },
	{ 0x00008ff9, 0x0000e791 },
	{ 0x00008ffa, 0x0000e792 },
	{ 0x00008ffd, 0x000092c7 },
	{ 0x00009000, 0x000091de },
	{ 0x00009001, 0x00009197 },
	{ 0x00009003, 0x000093a6 },
	{ 0x00009005, 0x0000e790 },
	{ 0x00009006, 0x00008b74 },
	{ 0x0000900b, 0x0000e799 },
	{ 0x0000900d, 0x0000e796 },
	{ 0x0000900e, 0x0000e7a3 },
	{ 0x0000900f, 0x000093a7 },
	{ 0x00009010, 0x00009280 },
	{ 0x00009011, 0x0000e793 },
	{ 0x00009013, 0x000092fc },
	{ 0x00009014, 0x00009372 },
	{ 0x00009015, 0x0000e794 },
	{ 0x00009016, 0x0000e798 },
	{ 0x00009017, 0x00009080 },
	{ 0x00009019, 0x00009487 },
	{ 0x0000901a, 0x000092ca },
	{ 0x0000901d, 0x000090c0 },
	{ 0x0000901e, 0x0000e797 },
	{ 0x0000901f, 0x000091ac },
	{ 0x00009020, 0x000091a2 },
	{ 0x00009021, 0x0000e795 },
	{ 0x00009022, 0x000088a7 },
	{ 0x00009023, 0x00009841 },
	{ 0x00009027, 0x0000e79a },
	{ 0x0000902e, 0x000091df },
	{ 0x00009031, 0x00008f54 },
	{ 0x00009032, 0x00009069 },
	{ 0x00009035, 0x0000e79c },
	{ 0x00009036, 0x0000e79b },
	{ 0x00009038, 0x000088ed },
	{ 0x00009039, 0x0000e79d },
	{ 0x0000903c, 0x0000954e },
	{ 0x0000903e, 0x0000e7a5 },
	{ 0x00009041, 0x000093d9 },
	{ 0x00009042, 0x0000908b },
	{ 0x00009045, 0x00009278 },
	{ 0x00009047, 0x00008bf6 },
	{ 0x00009049, 0x0000e7a4 },
	{ 0x0000904a, 0x00009756 },
	{ 0x0000904b, 0x0000895e },
	{ 0x0000904d, 0x000095d5 },
	{ 0x0000904e, 0x000089df },
	{ 0x0000904f, 0x0000e79f },
	{ 0x00009050, 0x0000e7a0 },
	{ 0x00009051, 0x0000e7a1 },
	{ 0x00009052, 0x0000e7a2 },
	{ 0x00009053, 0x000093b9 },
	{ 0x00009054, 0x00009242 },
	{ 0x00009055, 0x000088e1 },
	{ 0x00009056, 0x0000e7a6 },
	{ 0x00009058, 0x0000e7a7 },
	{ 0x00009059, 0x0000eaa1 },
	{ 0x0000905c, 0x000091bb },
	{ 0x0000905e, 0x0000e7a8 },
	{ 0x00009060, 0x00008993 },
	{ 0x00009061, 0x0000916b },
	{ 0x00009063, 0x00008cad },
	{ 0x00009065, 0x00009779 },
	{ 0x00009068, 0x0000e7a9 },
	{ 0x00009069, 0x0000934b },
	{ 0x0000906d, 0x00009198 },
	{ 0x0000906e, 0x00008ed5 },
	{ 0x0000906f, 0x0000e7aa },
	{ 0x00009072, 0x0000e7ad },
	{ 0x00009075, 0x00008f85 },
	{ 0x00009076, 0x0000e7ab },
	{ 0x00009077, 0x0000914a },
	{ 0x00009078, 0x00009149 },
	{ 0x0000907a, 0x000088e2 },
	{ 0x0000907c, 0x000097c9 },
	{ 0x0000907d, 0x0000e7af },
	{ 0x0000907f, 0x000094f0 },
	{ 0x00009080, 0x0000e7b1 },
	{ 0x00009081, 0x0000e7b0 },
	{ 0x00009082, 0x0000e7ae },
	{ 0x00009083, 0x0000e284 },
	{ 0x00009084, 0x00008ad2 },
	{ 0x00009087, 0x0000e78e },
	{ 0x00009089, 0x0000e7b3 },
	{ 0x0000908a, 0x0000e7b2 },
	{ 0x0000908f, 0x0000e7b4 },
	{ 0x00009091, 0x00009757 },
	{ 0x000090a3, 0x000093df },
	{ 0x000090a6, 0x0000964d },
	{ 0x000090a8, 0x0000e7b5 },
	{ 0x000090aa, 0x00008ed7 },
	{ 0x000090af, 0x0000e7b6 },
	{ 0x000090b1, 0x0000e7b7 },
	{ 0x000090b5, 0x0000e7b8 },
	{ 0x000090b8, 0x00009340 },
	{ 0x000090c1, 0x000088e8 },
	{ 0x000090ca, 0x00008d78 },
	{ 0x000090ce, 0x00009859 },
	{ 0x000090db, 0x0000e7bc },
	{ 0x000090e1, 0x00008c53 },
	{ 0x000090e2, 0x0000e7b9 },
	{ 0x000090e4, 0x0000e7ba },
	{ 0x000090e8, 0x00009594 },
	{ 0x000090ed, 0x00008a73 },
	{ 0x000090f5, 0x00009758 },
	{ 0x000090f7, 0x00008bbd },
	{ 0x000090fd, 0x00009373 },
	{ 0x00009102, 0x0000e7bd },
	{ 0x00009112, 0x0000e7be },
	{ 0x00009119, 0x0000e7bf },
	{ 0x0000912d, 0x00009341 },
	{ 0x00009130, 0x0000e7c1 },
	{ 0x00009132, 0x0000e7c0 },
	{ 0x00009149, 0x000093d1 },
	{ 0x0000914a, 0x0000e7c2 },
	{ 0x0000914b, 0x00008f55 },
	{ 0x0000914c, 0x00008ede },
	{ 0x0000914d, 0x0000947a },
	{ 0x0000914e, 0x00009291 },
	{ 0x00009152, 0x00008ef0 },
	{ 0x00009154, 0x0000908c },
	{ 0x00009156, 0x0000e7c3 },
	{ 0x00009158, 0x0000e7c4 },
	{ 0x00009162, 0x0000907c },
	{ 0x00009163, 0x0000e7c5 },
	{ 0x00009165, 0x0000e7c6 },
	{ 0x00009169, 0x0000e7c7 },
	{ 0x0000916a, 0x0000978f },
	{ 0x0000916c, 0x00008f56 },
	{ 0x00009172, 0x0000e7c9 },
	{ 0x00009173, 0x0000e7c8 },
	{ 0x00009175, 0x00008d79 },
	{ 0x00009177, 0x00008d93 },
	{ 0x00009178, 0x00008e5f },
	{ 0x00009182, 0x0000e7cc },
	{ 0x00009187, 0x00008f86 },
	{ 0x00009189, 0x0000e7cb },
	{ 0x0000918b, 0x0000e7ca },
	{ 0x0000918d, 0x000091e7 },
	{ 0x00009190, 0x00008ced },
	{ 0x00009192, 0x000090c1 },
	{ 0x00009197, 0x000094ae },
	{ 0x0000919c, 0x00008f58 },
	{ 0x000091a2, 0x0000e7cd },
	{ 0x000091a4, 0x00008fdd },
	{ 0x000091aa, 0x0000e7d0 },
	{ 0x000091ab, 0x0000e7ce },
	{ 0x000091af, 0x0000e7cf },
	{ 0x000091b4, 0x0000e7d2 },
	{ 0x000091b5, 0x0000e7d1 },
	{ 0x000091b8, 0x00008ff8 },
	{ 0x000091ba, 0x0000e7d3 },
	{ 0x000091c0, 0x0000e7d4 },
	{ 0x000091c1, 0x0000e7d5 },
	{ 0x000091c6, 0x000094ce },
	{ 0x000091c7, 0x00008dd1 },
	{ 0x000091c8, 0x00008edf },
	{ 0x000091c9, 0x0000e7d6 },
	{ 0x000091cb, 0x0000e7d7 },
	{ 0x000091cc, 0x000097a2 },
	{ 0x000091cd, 0x00008f64 },
	{ 0x000091ce, 0x000096ec },
	{ 0x000091cf, 0x000097ca },
	{ 0x000091d0, 0x0000e7d8 },
	{ 0x000091d1, 0x00008be0 },
	{ 0x000091d6, 0x0000e7d9 },
	{ 0x000091d8, 0x00009342 },
	{ 0x000091db, 0x0000e7dc },
	{ 0x000091dc, 0x00008a98 },
	{ 0x000091dd, 0x0000906a },
	{ 0x000091df, 0x0000e7da },
	{ 0x000091e1, 0x0000e7db },
	{ 0x000091e3, 0x000092de },
	{ 0x000091e6, 0x00009674 },
	{ 0x000091e7, 0x00008bfa },
	{ 0x000091f5, 0x0000e7de },
	{ 0x000091f6, 0x0000e7df },
	{ 0x000091fc, 0x0000e7dd },
	{ 0x000091ff, 0x0000e7e1 },
	{ 0x0000920d, 0x000093dd },
	{ 0x0000920e, 0x00008a62 },
	{ 0x00009211, 0x0000e7e5 },
	{ 0x00009214, 0x0000e7e2 },
	{ 0x00009215, 0x0000e7e4 },
	{ 0x0000921e, 0x0000e7e0 },
	{ 0x00009229, 0x0000e86e },
	{ 0x0000922c, 0x0000e7e3 },
	{ 0x00009234, 0x000097e9 },
	{ 0x00009237, 0x00008cd8 },
	{ 0x0000923f, 0x0000e7ed },
	{ 0x00009244, 0x00009353 },
	{ 0x00009245, 0x0000e7e8 },
	{ 0x00009248, 0x0000e7eb },
	{ 0x00009249, 0x0000e7e9 },
	{ 0x0000924b, 0x0000e7ee },
	{ 0x00009250, 0x0000e7ef },
	{ 0x00009257, 0x0000e7e7 },
	{ 0x0000925a, 0x0000e7f4 },
	{ 0x0000925b, 0x00008994 },
	{ 0x0000925e, 0x0000e7e6 },
	{ 0x00009262, 0x000094ab },
	{ 0x00009264, 0x0000e7ea },
	{ 0x00009266, 0x00008fde },
	{ 0x00009271, 0x00008d7a },
	{ 0x0000927e, 0x00009667 },
	{ 0x00009280, 0x00008be2 },
	{ 0x00009283, 0x00008f65 },
	{ 0x00009285, 0x000093ba },
	{ 0x00009291, 0x0000914c },
	{ 0x00009293, 0x0000e7f2 },
	{ 0x00009295, 0x0000e7ec },
	{ 0x00009296, 0x0000e7f1 },
	{ 0x00009298, 0x000096c1 },
	{ 0x0000929a, 0x000092b6 },
	{ 0x0000929b, 0x0000e7f3 },
	{ 0x0000929c, 0x0000e7f0 },
	{ 0x000092ad, 0x0000914b },
	{ 0x000092b7, 0x0000e7f7 },
	{ 0x000092b9, 0x0000e7f6 },
	{ 0x000092cf, 0x0000e7f5 },
	{ 0x000092d2, 0x0000964e },
	{ 0x000092e4, 0x00008f9b },
	{ 0x000092e9, 0x0000e7f8 },
	{ 0x000092ea, 0x000095dd },
	{ 0x000092ed, 0x00008973 },
	{ 0x000092f2, 0x00009565 },
	{ 0x000092f3, 0x00009292 },
	{ 0x000092f8, 0x00008b98 },
	{ 0x000092fa, 0x0000e7fa },
	{ 0x000092fc, 0x00008d7c },
	{ 0x00009306, 0x00008e4b },
	{ 0x0000930f, 0x0000e7f9 },
	{ 0x00009310, 0x0000908d },
	{ 0x00009318, 0x0000908e },
	{ 0x00009319, 0x0000e840 },
	{ 0x0000931a, 0x0000e842 },
	{ 0x00009320, 0x00008ff9 },
	{ 0x00009322, 0x0000e841 },
	{ 0x00009323, 0x0000e843 },
	{ 0x00009326, 0x00008bd1 },
	{ 0x00009328, 0x00009564 },
	{ 0x0000932b, 0x00008ee0 },
	{ 0x0000932c, 0x00009842 },
	{ 0x0000932e, 0x0000e7fc },
	{ 0x0000932f, 0x00008df6 },
	{ 0x00009332, 0x0000985e },
	{ 0x00009335, 0x0000e845 },
	{ 0x0000933a, 0x0000e844 },
	{ 0x0000933b, 0x0000e846 },
	{ 0x00009344, 0x0000e7fb },
	{ 0x0000934b, 0x000093e7 },
	{ 0x0000934d, 0x00009374 },
	{ 0x00009354, 0x000092d5 },
	{ 0x00009356, 0x0000e84b },
	{ 0x0000935b, 0x00009262 },
	{ 0x0000935c, 0x0000e847 },
	{ 0x00009360, 0x0000e848 },
	{ 0x0000936c, 0x00008c4c },
	{ 0x0000936e, 0x0000e84a },
	{ 0x00009375, 0x00008cae },
	{ 0x0000937c, 0x0000e849 },
	{ 0x0000937e, 0x00008fdf },
	{ 0x0000938c, 0x00008a99 },
	{ 0x00009394, 0x0000e84f },
	{ 0x00009396, 0x00008dbd },
	{ 0x00009397, 0x00009199 },
	{ 0x0000939a, 0x000092c8 },
	{ 0x000093a7, 0x00008a5a },
	{ 0x000093ac, 0x0000e84d },
	{ 0x000093ad, 0x0000e84e },
	{ 0x000093ae, 0x000092c1 },
	{ 0x000093b0, 0x0000e84c },
	{ 0x000093b9, 0x0000e850 },
	{ 0x000093c3, 0x0000e856 },
	{ 0x000093c8, 0x0000e859 },
	{ 0x000093d0, 0x0000e858 },
	{ 0x000093d1, 0x0000934c },
	{ 0x000093d6, 0x0000e851 },
	{ 0x000093d7, 0x0000e852 },
	{ 0x000093d8, 0x0000e855 },
	{ 0x000093dd, 0x0000e857 },
	{ 0x000093e1, 0x00008bbe },
	{ 0x000093e4, 0x0000e85a },
	{ 0x000093e5, 0x0000e854 },
	{ 0x000093e8, 0x0000e853 },
	{ 0x00009403, 0x0000e85e },
	{ 0x00009407, 0x0000e85f },
	{ 0x00009410, 0x0000e860 },
	{ 0x00009413, 0x0000e85d },
	{ 0x00009414, 0x0000e85c },
	{ 0x00009418, 0x00008fe0 },
	{ 0x00009419, 0x000093a8 },
	{ 0x0000941a, 0x0000e85b },
	{ 0x00009421, 0x0000e864 },
	{ 0x0000942b, 0x0000e862 },
	{ 0x00009435, 0x0000e863 },
	{ 0x00009436, 0x0000e861 },
	{ 0x00009438, 0x000091f6 },
	{ 0x0000943a, 0x0000e865 },
	{ 0x00009441, 0x0000e866 },
	{ 0x00009444, 0x0000e868 },
	{ 0x00009451, 0x00008ad3 },
	{ 0x00009452, 0x0000e867 },
	{ 0x00009453, 0x000096f8 },
	{ 0x0000945a, 0x0000e873 },
	{ 0x0000945b, 0x0000e869 },
	{ 0x0000945e, 0x0000e86c },
	{ 0x00009460, 0x0000e86a },
	{ 0x00009462, 0x0000e86b },
	{ 0x0000946a, 0x0000e86d },
	{ 0x00009470, 0x0000e86f },
	{ 0x00009475, 0x0000e870 },
	{ 0x00009477, 0x0000e871 },
	{ 0x0000947c, 0x0000e874 },
	{ 0x0000947d, 0x0000e872 },
	{ 0x0000947e, 0x0000e875 },
	{ 0x0000947f, 0x0000e877 },
	{ 0x00009481, 0x0000e876 },
	{ 0x00009577, 0x000092b7 },
	{ 0x00009580, 0x000096e5 },
	{ 0x00009582, 0x0000e878 },
	{ 0x00009583, 0x0000914d },
	{ 0x00009587, 0x0000e879 },
	{ 0x00009589, 0x000095c2 },
	{ 0x0000958a, 0x0000e87a },
	{ 0x0000958b, 0x00008a4a },
	{ 0x0000958f, 0x0000895b },
	{ 0x00009591, 0x00008ad5 },
	{ 0x00009593, 0x00008ad4 },
	{ 0x00009594, 0x0000e87b },
	{ 0x00009596, 0x0000e87c },
	{ 0x00009598, 0x0000e87d },
	{ 0x00009599, 0x0000e87e },
	{ 0x000095a0, 0x0000e880 },
	{ 0x000095a2, 0x00008ad6 },
	{ 0x000095a3, 0x00008a74 },
	{ 0x000095a4, 0x00008d7d },
	{ 0x000095a5, 0x000094b4 },
	{ 0x000095a7, 0x0000e882 },
	{ 0x000095a8, 0x0000e881 },
	{ 0x000095ad, 0x0000e883 },
	{ 0x000095b2, 0x0000897b },
	{ 0x000095b9, 0x0000e886 },
	{ 0x000095bb, 0x0000e885 },
	{ 0x000095bc, 0x0000e884 },
	{ 0x000095be, 0x0000e887 },
	{ 0x000095c3, 0x0000e88a },
	{ 0x000095c7, 0x000088c5 },
	{ 0x000095ca, 0x0000e888 },
	{ 0x000095cc, 0x0000e88c },
	{ 0x000095cd, 0x0000e88b },
	{ 0x000095d4, 0x0000e88e },
	{ 0x000095d5, 0x0000e88d },
	{ 0x000095d6, 0x0000e88f },
	{ 0x000095d8, 0x000093ac },
	{ 0x000095dc, 0x0000e890 },
	{ 0x000095e1, 0x0000e891 },
	{ 0x000095e2, 0x0000e893 },
	{ 0x000095e5, 0x0000e892 },
	{ 0x0000961c, 0x0000958c },
	{ 0x00009621, 0x0000e894 },
	{ 0x00009628, 0x0000e895 },
	{ 0x0000962a, 0x00008de3 },
	{ 0x0000962e, 0x0000e896 },
	{ 0x0000962f, 0x0000e897 },
	{ 0x00009632, 0x00009668 },
	{ 0x0000963b, 0x0000916a },
	{ 0x0000963f, 0x000088a2 },
	{ 0x00009640, 0x000091c9 },
	{ 0x00009642, 0x0000e898 },
	{ 0x00009644, 0x0000958d },
	{ 0x0000964b, 0x0000e89b },
	{ 0x0000964c, 0x0000e899 },
	{ 0x0000964d, 0x00008d7e },
	{ 0x0000964f, 0x0000e89a },
	{ 0x00009650, 0x00008cc0 },
	{ 0x0000965b, 0x000095c3 },
	{ 0x0000965c, 0x0000e89d },
	{ 0x0000965d, 0x0000e89f },
	{ 0x0000965e, 0x0000e89e },
	{ 0x0000965f, 0x0000e8a0 },
	{ 0x00009662, 0x00008940 },
	{ 0x00009663, 0x00009077 },
	{ 0x00009664, 0x00008f9c },
	{ 0x00009665, 0x00008ad7 },
	{ 0x00009666, 0x0000e8a1 },
	{ 0x0000966a, 0x00009486 },
	{ 0x0000966c, 0x0000e8a3 },
	{ 0x00009670, 0x00008941 },
	{ 0x00009672, 0x0000e8a2 },
	{ 0x00009673, 0x000092c2 },
	{ 0x00009675, 0x000097cb },
	{ 0x00009676, 0x000093a9 },
	{ 0x00009677, 0x0000e89c },
	{ 0x00009678, 0x000097a4 },
	{ 0x0000967a, 0x00008caf },
	{ 0x0000967d, 0x0000977a },
	{ 0x00009685, 0x00008bf7 },
	{ 0x00009686, 0x000097b2 },
	{ 0x00009688, 0x00008c47 },
	{ 0x0000968a, 0x000091e0 },
	{ 0x0000968b, 0x0000e440 },
	{ 0x0000968d, 0x0000e8a4 },
	{ 0x0000968e, 0x00008a4b },
	{ 0x0000968f, 0x0000908f },
	{ 0x00009694, 0x00008a75 },
	{ 0x00009695, 0x0000e8a6 },
	{ 0x00009697, 0x0000e8a7 },
	{ 0x00009698, 0x0000e8a5 },
	{ 0x00009699, 0x00008c84 },
	{ 0x0000969b, 0x00008ddb },
	{ 0x0000969c, 0x00008fe1 },
	{ 0x000096a0, 0x00008942 },
	{ 0x000096a3, 0x000097d7 },
	{ 0x000096a7, 0x0000e8a9 },
	{ 0x000096a8, 0x0000e7ac },
	{ 0x000096aa, 0x0000e8a8 },
	{ 0x000096b0, 0x0000e8ac },
	{ 0x000096b1, 0x0000e8aa },
	{ 0x000096b2, 0x0000e8ab },
	{ 0x000096b4, 0x0000e8ad },
	{ 0x000096b6, 0x0000e8ae },
	{ 0x000096b7, 0x000097ea },
	{ 0x000096b8, 0x0000e8af },
	{ 0x000096b9, 0x0000e8b0 },
	{ 0x000096bb, 0x000090c7 },
	{ 0x000096bc, 0x000094b9 },
	{ 0x000096c0, 0x0000909d },
	{ 0x000096c1, 0x00008ae5 },
	{ 0x000096c4, 0x00009759 },
	{ 0x000096c5, 0x000089eb },
	{ 0x000096c6, 0x00008f57 },
	{ 0x000096c7, 0x00008cd9 },
	{ 0x000096c9, 0x0000e8b3 },
	{ 0x000096cb, 0x0000e8b2 },
	{ 0x000096cc, 0x00008e93 },
	{ 0x000096cd, 0x0000e8b4 },
	{ 0x000096ce, 0x0000e8b1 },
	{ 0x000096d1, 0x00008e47 },
	{ 0x000096d5, 0x0000e8b8 },
	{ 0x000096d6, 0x0000e5ab },
	{ 0x000096d9, 0x000099d4 },
	{ 0x000096db, 0x00009097 },
	{ 0x000096dc, 0x0000e8b6 },
	{ 0x000096e2, 0x000097a3 },
	{ 0x000096e3, 0x000093ef },
	{ 0x000096e8, 0x0000894a },
	{ 0x000096ea, 0x000090e1 },
	{ 0x000096eb, 0x00008eb4 },
	{ 0x000096f0, 0x000095b5 },
	{ 0x000096f2, 0x0000895f },
	{ 0x000096f6, 0x000097eb },
	{ 0x000096f7, 0x0000978b },
	{ 0x000096f9, 0x0000e8b9 },
	{ 0x000096fb, 0x00009364 },
	{ 0x00009700, 0x00008ef9 },
	{ 0x00009704, 0x0000e8ba },
	{ 0x00009706, 0x0000e8bb },
	{ 0x00009707, 0x0000906b },
	{ 0x00009708, 0x0000e8bc },
	{ 0x0000970a, 0x000097ec },
	{ 0x0000970d, 0x0000e8b7 },
	{ 0x0000970e, 0x0000e8be },
	{ 0x0000970f, 0x0000e8c0 },
	{ 0x00009711, 0x0000e8bf },
	{ 0x00009713, 0x0000e8bd },
	{ 0x00009716, 0x0000e8c1 },
	{ 0x00009719, 0x0000e8c2 },
	{ 0x0000971c, 0x0000919a },
	{ 0x0000971e, 0x000089e0 },
	{ 0x00009724, 0x0000e8c3 },
	{ 0x00009727, 0x000096b6 },
	{ 0x0000972a, 0x0000e8c4 },
	{ 0x00009730, 0x0000e8c5 },
	{ 0x00009732, 0x00009849 },
	{ 0x00009738, 0x00009e50 },
	{ 0x00009739, 0x0000e8c6 },
	{ 0x0000973d, 0x0000e8c7 },
	{ 0x0000973e, 0x0000e8c8 },
	{ 0x00009742, 0x0000e8cc },
	{ 0x00009744, 0x0000e8c9 },
	{ 0x00009746, 0x0000e8ca },
	{ 0x00009748, 0x0000e8cb },
	{ 0x00009749, 0x0000e8cd },
	{ 0x00009752, 0x000090c2 },
	{ 0x00009756, 0x000096f5 },
	{ 0x00009759, 0x000090c3 },
	{ 0x0000975c, 0x0000e8ce },
	{ 0x0000975e, 0x000094f1 },
	{ 0x00009760, 0x0000e8cf },
	{ 0x00009761, 0x0000ea72 },
	{ 0x00009762, 0x000096ca },
	{ 0x00009764, 0x0000e8d0 },
	{ 0x00009766, 0x0000e8d1 },
	{ 0x00009768, 0x0000e8d2 },
	{ 0x00009769, 0x00008a76 },
	{ 0x0000976b, 0x0000e8d4 },
	{ 0x0000976d, 0x00009078 },
	{ 0x00009771, 0x0000e8d5 },
	{ 0x00009774, 0x00008c43 },
	{ 0x00009779, 0x0000e8d6 },
	{ 0x0000977a, 0x0000e8da },
	{ 0x0000977c, 0x0000e8d8 },
	{ 0x00009781, 0x0000e8d9 },
	{ 0x00009784, 0x00008a93 },
	{ 0x00009785, 0x0000e8d7 },
	{ 0x00009786, 0x0000e8db },
	{ 0x0000978b, 0x0000e8dc },
	{ 0x0000978d, 0x000088c6 },
	{ 0x0000978f, 0x0000e8dd },
	{ 0x00009790, 0x0000e8de },
	{ 0x00009798, 0x00008fe2 },
	{ 0x0000979c, 0x0000e8df },
	{ 0x000097a0, 0x00008b66 },
	{ 0x000097a3, 0x0000e8e2 },
	{ 0x000097a6, 0x0000e8e1 },
	{ 0x000097a8, 0x0000e8e0 },
	{ 0x000097ab, 0x0000e691 },
	{ 0x000097ad, 0x000095da },
	{ 0x000097b3, 0x0000e8e3 },
	{ 0x000097b4, 0x0000e8e4 },
	{ 0x000097c3, 0x0000e8e5 },
	{ 0x000097c6, 0x0000e8e6 },
	{ 0x000097c8, 0x0000e8e7 },
	{ 0x000097cb, 0x0000e8e8 },
	{ 0x000097d3, 0x00008ad8 },
	{ 0x000097dc, 0x0000e8e9 },
	{ 0x000097ed, 0x0000e8ea },
	{ 0x000097ee, 0x00009442 },
	{ 0x000097f2, 0x0000e8ec },
	{ 0x000097f3, 0x000089b9 },
	{ 0x000097f5, 0x0000e8ef },
	{ 0x000097f6, 0x0000e8ee },
	{ 0x000097fb, 0x00008943 },
	{ 0x000097ff, 0x00008bbf },
	{ 0x00009801, 0x000095c5 },
	{ 0x00009802, 0x000092b8 },
	{ 0x00009803, 0x00008da0 },
	{ 0x00009805, 0x00008d80 },
	{ 0x00009806, 0x00008f87 },
	{ 0x00009808, 0x0000907b },
	{ 0x0000980c, 0x0000e8f1 },
	{ 0x0000980f, 0x0000e8f0 },
	{ 0x00009810, 0x00009761 },
	{ 0x00009811, 0x00008ae6 },
	{ 0x00009812, 0x000094d0 },
	{ 0x00009813, 0x000093da },
	{ 0x00009817, 0x0000909c },
	{ 0x00009818, 0x000097cc },
	{ 0x0000981a, 0x00008c7a },
	{ 0x00009821, 0x0000e8f4 },
	{ 0x00009824, 0x0000e8f3 },
	{ 0x0000982c, 0x0000966a },
	{ 0x0000982d, 0x000093aa },
	{ 0x00009834, 0x0000896f },
	{ 0x00009837, 0x0000e8f5 },
	{ 0x00009838, 0x0000e8f2 },
	{ 0x0000983b, 0x00009570 },
	{ 0x0000983c, 0x0000978a },
	{ 0x0000983d, 0x0000e8f6 },
	{ 0x00009846, 0x0000e8f7 },
	{ 0x0000984b, 0x0000e8f9 },
	{ 0x0000984c, 0x000091e8 },
	{ 0x0000984d, 0x00008a7a },
	{ 0x0000984e, 0x00008a7b },
	{ 0x0000984f, 0x0000e8f8 },
	{ 0x00009854, 0x00008ae7 },
	{ 0x00009855, 0x00008cb0 },
	{ 0x00009858, 0x00008ae8 },
	{ 0x0000985b, 0x0000935e },
	{ 0x0000985e, 0x000097de },
	{ 0x00009867, 0x00008cda },
	{ 0x0000986b, 0x0000e8fa },
	{ 0x0000986f, 0x0000e8fb },
	{ 0x00009870, 0x0000e8fc },
	{ 0x00009871, 0x0000e940 },
	{ 0x00009873, 0x0000e942 },
	{ 0x00009874, 0x0000e941 },
	{ 0x000098a8, 0x00009597 },
	{ 0x000098aa, 0x0000e943 },
	{ 0x000098af, 0x0000e944 },
	{ 0x000098b1, 0x0000e945 },
	{ 0x000098b6, 0x0000e946 },
	{ 0x000098c3, 0x0000e948 },
	{ 0x000098c4, 0x0000e947 },
	{ 0x000098c6, 0x0000e949 },
	{ 0x000098db, 0x000094f2 },
	{ 0x000098dc, 0x0000e3ca },
	{ 0x000098df, 0x00009048 },
	{ 0x000098e2, 0x00008b51 },
	{ 0x000098e9, 0x0000e94a },
	{ 0x000098eb, 0x0000e94b },
	{ 0x000098ed, 0x000099aa },
	{ 0x000098ee, 0x00009f5a },
	{ 0x000098ef, 0x000094d1 },
	{ 0x000098f2, 0x000088f9 },
	{ 0x000098f4, 0x000088b9 },
	{ 0x000098fc, 0x00008e94 },
	{ 0x000098fd, 0x0000964f },
	{ 0x000098fe, 0x00008ffc },
	{ 0x00009903, 0x0000e94c },
	{ 0x00009905, 0x000096dd },
	{ 0x00009909, 0x0000e94d },
	{ 0x0000990a, 0x0000977b },
	{ 0x0000990c, 0x00008961 },
	{ 0x00009910, 0x00008e60 },
	{ 0x00009912, 0x0000e94e },
	{ 0x00009913, 0x000089ec },
	{ 0x00009914, 0x0000e94f },
	{ 0x00009918, 0x0000e950 },
	{ 0x0000991d, 0x0000e952 },
	{ 0x0000991e, 0x0000e953 },
	{ 0x00009920, 0x0000e955 },
	{ 0x00009921, 0x0000e951 },
	{ 0x00009924, 0x0000e954 },
	{ 0x00009928, 0x00008ad9 },
	{ 0x0000992c, 0x0000e956 },
	{ 0x0000992e, 0x0000e957 },
	{ 0x0000993d, 0x0000e958 },
	{ 0x0000993e, 0x0000e959 },
	{ 0x00009942, 0x0000e95a },
	{ 0x00009945, 0x0000e95c },
	{ 0x00009949, 0x0000e95b },
	{ 0x0000994b, 0x0000e95e },
	{ 0x0000994c, 0x0000e961 },
	{ 0x00009950, 0x0000e95d },
	{ 0x00009951, 0x0000e95f },
	{ 0x00009952, 0x0000e960 },
	{ 0x00009955, 0x0000e962 },
	{ 0x00009957, 0x00008bc0 },
	{ 0x00009996, 0x00008ef1 },
	{ 0x00009997, 0x0000e963 },
	{ 0x00009998, 0x0000e964 },
	{ 0x00009999, 0x00008d81 },
	{ 0x000099a5, 0x0000e965 },
	{ 0x000099a8, 0x00008a5d },
	{ 0x000099ac, 0x0000946e },
	{ 0x000099ad, 0x0000e966 },
	{ 0x000099ae, 0x0000e967 },
	{ 0x000099b3, 0x00009279 },
	{ 0x000099b4, 0x000093e9 },
	{ 0x000099bc, 0x0000e968 },
	{ 0x000099c1, 0x0000949d },
	{ 0x000099c4, 0x000091ca },
	{ 0x000099c5, 0x00008977 },
	{ 0x000099c6, 0x00008bec },
	{ 0x000099c8, 0x00008bed },
	{ 0x000099d0, 0x00009293 },
	{ 0x000099d1, 0x0000e96d },
	{ 0x000099d2, 0x00008bee },
	{ 0x000099d5, 0x000089ed },
	{ 0x000099d8, 0x0000e96c },
	{ 0x000099db, 0x0000e96a },
	{ 0x000099dd, 0x0000e96b },
	{ 0x000099df, 0x0000e969 },
	{ 0x000099e2, 0x0000e977 },
	{ 0x000099ed, 0x0000e96e },
	{ 0x000099ee, 0x0000e96f },
	{ 0x000099f1, 0x0000e970 },
	{ 0x000099f2, 0x0000e971 },
	{ 0x000099f8, 0x0000e973 },
	{ 0x000099fb, 0x0000e972 },
	{ 0x000099ff, 0x00008f78 },
	{ 0x00009a01, 0x0000e974 },
	{ 0x00009a05, 0x0000e976 },
	{ 0x00009a0e, 0x00008b52 },
	{ 0x00009a0f, 0x0000e975 },
	{ 0x00009a12, 0x0000919b },
	{ 0x00009a13, 0x00008cb1 },
	{ 0x00009a19, 0x0000e978 },
	{ 0x00009a28, 0x000091cb },
	{ 0x00009a2b, 0x0000e979 },
	{ 0x00009a30, 0x000093ab },
	{ 0x00009a37, 0x0000e97a },
	{ 0x00009a3e, 0x0000e980 },
	{ 0x00009a40, 0x0000e97d },
	{ 0x00009a42, 0x0000e97c },
	{ 0x00009a43, 0x0000e97e },
	{ 0x00009a45, 0x0000e97b },
	{ 0x00009a4d, 0x0000e982 },
	{ 0x00009a55, 0x0000e981 },
	{ 0x00009a57, 0x0000e984 },
	{ 0x00009a5a, 0x00008bc1 },
	{ 0x00009a5b, 0x0000e983 },
	{ 0x00009a5f, 0x0000e985 },
	{ 0x00009a62, 0x0000e986 },
	{ 0x00009a64, 0x0000e988 },
	{ 0x00009a65, 0x0000e987 },
	{ 0x00009a69, 0x0000e989 },
	{ 0x00009a6a, 0x0000e98b },
	{ 0x00009a6b, 0x0000e98a },
	{ 0x00009aa8, 0x00008d9c },
	{ 0x00009aad, 0x0000e98c },
	{ 0x00009ab0, 0x0000e98d },
	{ 0x00009ab8, 0x00008a5b },
	{ 0x00009abc, 0x0000e98e },
	{ 0x00009ac0, 0x0000e98f },
	{ 0x00009ac4, 0x00009091 },
	{ 0x00009acf, 0x0000e990 },
	{ 0x00009ad1, 0x0000e991 },
	{ 0x00009ad3, 0x0000e992 },
	{ 0x00009ad4, 0x0000e993 },
	{ 0x00009ad8, 0x00008d82 },
	{ 0x00009ade, 0x0000e994 },
	{ 0x00009adf, 0x0000e995 },
	{ 0x00009ae2, 0x0000e996 },
	{ 0x00009ae3, 0x0000e997 },
	{ 0x00009ae6, 0x0000e998 },
	{ 0x00009aea, 0x000094af },
	{ 0x00009aeb, 0x0000e99a },
	{ 0x00009aed, 0x00009545 },
	{ 0x00009aee, 0x0000e99b },
	{ 0x00009aef, 0x0000e999 },
	{ 0x00009af1, 0x0000e99d },
	{ 0x00009af4, 0x0000e99c },
	{ 0x00009af7, 0x0000e99e },
	{ 0x00009afb, 0x0000e99f },
	{ 0x00009b06, 0x0000e9a0 },
	{ 0x00009b18, 0x0000e9a1 },
	{ 0x00009b1a, 0x0000e9a2 },
	{ 0x00009b1f, 0x0000e9a3 },
	{ 0x00009b22, 0x0000e9a4 },
	{ 0x00009b23, 0x0000e9a5 },
	{ 0x00009b25, 0x0000e9a6 },
	{ 0x00009b27, 0x0000e9a7 },
	{ 0x00009b28, 0x0000e9a8 },
	{ 0x00009b29, 0x0000e9a9 },
	{ 0x00009b2a, 0x0000e9aa },
	{ 0x00009b2e, 0x0000e9ab },
	{ 0x00009b2f, 0x0000e9ac },
	{ 0x00009b31, 0x00009f54 },
	{ 0x00009b32, 0x0000e9ad },
	{ 0x00009b3b, 0x0000e2f6 },
	{ 0x00009b3c, 0x00008b53 },
	{ 0x00009b41, 0x00008a40 },
	{ 0x00009b42, 0x00008db0 },
	{ 0x00009b43, 0x0000e9af },
	{ 0x00009b44, 0x0000e9ae },
	{ 0x00009b45, 0x000096a3 },
	{ 0x00009b4d, 0x0000e9b1 },
	{ 0x00009b4e, 0x0000e9b2 },
	{ 0x00009b4f, 0x0000e9b0 },
	{ 0x00009b51, 0x0000e9b3 },
	{ 0x00009b54, 0x00009682 },
	{ 0x00009b58, 0x0000e9b4 },
	{ 0x00009b5a, 0x00008b9b },
	{ 0x00009b6f, 0x00009844 },
	{ 0x00009b74, 0x0000e9b5 },
	{ 0x00009b83, 0x0000e9b7 },
	{ 0x00009b8e, 0x000088bc },
	{ 0x00009b91, 0x0000e9b8 },
	{ 0x00009b92, 0x000095a9 },
	{ 0x00009b93, 0x0000e9b6 },
	{ 0x00009b96, 0x0000e9b9 },
	{ 0x00009b97, 0x0000e9ba },
	{ 0x00009b9f, 0x0000e9bb },
	{ 0x00009ba0, 0x0000e9bc },
	{ 0x00009ba8, 0x0000e9bd },
	{ 0x00009baa, 0x0000968e },
	{ 0x00009bab, 0x00008e4c },
	{ 0x00009bad, 0x00008df8 },
	{ 0x00009bae, 0x0000914e },
	{ 0x00009bb4, 0x0000e9be },
	{ 0x00009bb9, 0x0000e9c1 },
	{ 0x00009bc0, 0x0000e9bf },
	{ 0x00009bc6, 0x0000e9c2 },
	{ 0x00009bc9, 0x00008cef },
	{ 0x00009bca, 0x0000e9c0 },
	{ 0x00009bcf, 0x0000e9c3 },
	{ 0x00009bd1, 0x0000e9c4 },
	{ 0x00009bd2, 0x0000e9c5 },
	{ 0x00009bd4, 0x0000e9c9 },
	{ 0x00009bd6, 0x00008e49 },
	{ 0x00009bdb, 0x000091e2 },
	{ 0x00009be1, 0x0000e9ca },
	{ 0x00009be2, 0x0000e9c7 },
	{ 0x00009be3, 0x0000e9c6 },
	{ 0x00009be4, 0x0000e9c8 },
	{ 0x00009be8, 0x00008c7e },
	{ 0x00009bf0, 0x0000e9ce },
	{ 0x00009bf1, 0x0000e9cd },
	{ 0x00009bf2, 0x0000e9cc },
	{ 0x00009bf5, 0x000088b1 },
	{ 0x00009c04, 0x0000e9d8 },
	{ 0x00009c06, 0x0000e9d4 },
	{ 0x00009c08, 0x0000e9d5 },
	{ 0x00009c09, 0x0000e9d1 },
	{ 0x00009c0a, 0x0000e9d7 },
	{ 0x00009c0c, 0x0000e9d3 },
	{ 0x00009c0d, 0x00008a82 },
	{ 0x00009c10, 0x0000986b },
	{ 0x00009c12, 0x0000e9d6 },
	{ 0x00009c13, 0x0000e9d2 },
	{ 0x00009c14, 0x0000e9d0 },
	{ 0x00009c15, 0x0000e9cf },
	{ 0x00009c1b, 0x0000e9da },
	{ 0x00009c21, 0x0000e9dd },
	{ 0x00009c24, 0x0000e9dc },
	{ 0x00009c25, 0x0000e9db },
	{ 0x00009c2d, 0x00009568 },
	{ 0x00009c2e, 0x0000e9d9 },
	{ 0x00009c2f, 0x000088f1 },
	{ 0x00009c30, 0x0000e9de },
	{ 0x00009c32, 0x0000e9e0 },
	{ 0x00009c39, 0x00008a8f },
	{ 0x00009c3a, 0x0000e9cb },
	{ 0x00009c3b, 0x00008956 },
	{ 0x00009c3e, 0x0000e9e2 },
	{ 0x00009c46, 0x0000e9e1 },
	{ 0x00009c47, 0x0000e9df },
	{ 0x00009c48, 0x0000924c },
	{ 0x00009c52, 0x00009690 },
	{ 0x00009c57, 0x000097d8 },
	{ 0x00009c5a, 0x0000e9e3 },
	{ 0x00009c60, 0x0000e9e4 },
	{ 0x00009c67, 0x0000e9e5 },
	{ 0x00009c76, 0x0000e9e6 },
	{ 0x00009c78, 0x0000e9e7 },
	{ 0x00009ce5, 0x000092b9 },
	{ 0x00009ce7, 0x0000e9e8 },
	{ 0x00009ce9, 0x000094b5 },
	{ 0x00009ceb, 0x0000e9ed },
	{ 0x00009cec, 0x0000e9e9 },
	{ 0x00009cf0, 0x0000e9ea },
	{ 0x00009cf3, 0x00009650 },
	{ 0x00009cf4, 0x000096c2 },
	{ 0x00009cf6, 0x000093ce },
	{ 0x00009d03, 0x0000e9ee },
	{ 0x00009d06, 0x0000e9ef },
	{ 0x00009d07, 0x000093bc },
	{ 0x00009d08, 0x0000e9ec },
	{ 0x00009d09, 0x0000e9eb },
	{ 0x00009d0e, 0x000089a8 },
	{ 0x00009d12, 0x0000e9f7 },
	{ 0x00009d15, 0x0000e9f6 },
	{ 0x00009d1b, 0x00008995 },
	{ 0x00009d1f, 0x0000e9f4 },
	{ 0x00009d23, 0x0000e9f3 },
	{ 0x00009d26, 0x0000e9f1 },
	{ 0x00009d28, 0x00008a9b },
	{ 0x00009d2a, 0x0000e9f0 },
	{ 0x00009d2b, 0x00008eb0 },
	{ 0x00009d2c, 0x000089a7 },
	{ 0x00009d3b, 0x00008d83 },
	{ 0x00009d3e, 0x0000e9fa },
	{ 0x00009d3f, 0x0000e9f9 },
	{ 0x00009d41, 0x0000e9f8 },
	{ 0x00009d44, 0x0000e9f5 },
	{ 0x00009d46, 0x0000e9fb },
	{ 0x00009d48, 0x0000e9fc },
	{ 0x00009d50, 0x0000ea44 },
	{ 0x00009d51, 0x0000ea43 },
	{ 0x00009d59, 0x0000ea45 },
	{ 0x00009d5c, 0x0000894c },
	{ 0x00009d5d, 0x0000ea40 },
	{ 0x00009d5e, 0x0000ea41 },
	{ 0x00009d60, 0x00008d94 },
	{ 0x00009d61, 0x000096b7 },
	{ 0x00009d64, 0x0000ea42 },
	{ 0x00009d6c, 0x00009651 },
	{ 0x00009d6f, 0x0000ea4a },
	{ 0x00009d72, 0x0000ea46 },
	{ 0x00009d7a, 0x0000ea4b },
	{ 0x00009d87, 0x0000ea48 },
	{ 0x00009d89, 0x0000ea47 },
	{ 0x00009d8f, 0x00008c7b },
	{ 0x00009d9a, 0x0000ea4c },
	{ 0x00009da4, 0x0000ea4d },
	{ 0x00009da9, 0x0000ea4e },
	{ 0x00009dab, 0x0000ea49 },
	{ 0x00009daf, 0x0000e9f2 },
	{ 0x00009db2, 0x0000ea4f },
	{ 0x00009db4, 0x000092df },
	{ 0x00009db8, 0x0000ea53 },
	{ 0x00009dba, 0x0000ea54 },
	{ 0x00009dbb, 0x0000ea52 },
	{ 0x00009dc1, 0x0000ea51 },
	{ 0x00009dc2, 0x0000ea57 },
	{ 0x00009dc4, 0x0000ea50 },
	{ 0x00009dc6, 0x0000ea55 },
	{ 0x00009dcf, 0x0000ea56 },
	{ 0x00009dd3, 0x0000ea59 },
	{ 0x00009dd9, 0x0000ea58 },
	{ 0x00009de6, 0x0000ea5b },
	{ 0x00009ded, 0x0000ea5c },
	{ 0x00009def, 0x0000ea5d },
	{ 0x00009df2, 0x00009868 },
	{ 0x00009df8, 0x0000ea5a },
	{ 0x00009df9, 0x000091e9 },
	{ 0x00009dfa, 0x00008deb },
	{ 0x00009dfd, 0x0000ea5e },
	{ 0x00009e1a, 0x0000ea5f },
	{ 0x00009e1b, 0x0000ea60 },
	{ 0x00009e1e, 0x0000ea61 },
	{ 0x00009e75, 0x0000ea62 },
	{ 0x00009e78, 0x00008cb2 },
	{ 0x00009e79, 0x0000ea63 },
	{ 0x00009e7d, 0x0000ea64 },
	{ 0x00009e7f, 0x00008ead },
	{ 0x00009e81, 0x0000ea65 },
	{ 0x00009e88, 0x0000ea66 },
	{ 0x00009e8b, 0x0000ea67 },
	{ 0x00009e8c, 0x0000ea68 },
	{ 0x00009e91, 0x0000ea6b },
	{ 0x00009e92, 0x0000ea69 },
	{ 0x00009e93, 0x0000985b },
	{ 0x00009e95, 0x0000ea6a },
	{ 0x00009e97, 0x000097ed },
	{ 0x00009e9d, 0x0000ea6c },
	{ 0x00009e9f, 0x000097d9 },
	{ 0x00009ea5, 0x0000ea6d },
	{ 0x00009ea6, 0x0000949e },
	{ 0x00009ea9, 0x0000ea6e },
	{ 0x00009eaa, 0x0000ea70 },
	{ 0x00009ead, 0x0000ea71 },
	{ 0x00009eb8, 0x0000ea6f },
	{ 0x00009eb9, 0x00008d8d },
	{ 0x00009eba, 0x000096cb },
	{ 0x00009ebb, 0x00009683 },
	{ 0x00009ebc, 0x00009bf5 },
	{ 0x00009ebe, 0x00009f80 },
	{ 0x00009ebf, 0x0000969b },
	{ 0x00009ec4, 0x000089a9 },
	{ 0x00009ecc, 0x0000ea73 },
	{ 0x00009ecd, 0x00008b6f },
	{ 0x00009ece, 0x0000ea74 },
	{ 0x00009ecf, 0x0000ea75 },
	{ 0x00009ed0, 0x0000ea76 },
	{ 0x00009ed2, 0x00008d95 },
	{ 0x00009ed4, 0x0000ea77 },
	{ 0x00009ed8, 0x0000e0d2 },
	{ 0x00009ed9, 0x000096d9 },
	{ 0x00009edb, 0x000091e1 },
	{ 0x00009edc, 0x0000ea78 },
	{ 0x00009edd, 0x0000ea7a },
	{ 0x00009ede, 0x0000ea79 },
	{ 0x00009ee0, 0x0000ea7b },
	{ 0x00009ee5, 0x0000ea7c },
	{ 0x00009ee8, 0x0000ea7d },
	{ 0x00009eef, 0x0000ea7e },
	{ 0x00009ef4, 0x0000ea80 },
	{ 0x00009ef6, 0x0000ea81 },
	{ 0x00009ef7, 0x0000ea82 },
	{ 0x00009ef9, 0x0000ea83 },
	{ 0x00009efb, 0x0000ea84 },
	{ 0x00009efc, 0x0000ea85 },
	{ 0x00009efd, 0x0000ea86 },
	{ 0x00009f07, 0x0000ea87 },
	{ 0x00009f08, 0x0000ea88 },
	{ 0x00009f0e, 0x00009343 },
	{ 0x00009f13, 0x00008cdb },
	{ 0x00009f15, 0x0000ea8a },
	{ 0x00009f20, 0x0000916c },
	{ 0x00009f21, 0x0000ea8b },
	{ 0x00009f2c, 0x0000ea8c },
	{ 0x00009f3b, 0x00009540 },
	{ 0x00009f3e, 0x0000ea8d },
	{ 0x00009f4a, 0x0000ea8e },
	{ 0x00009f4b, 0x0000e256 },
	{ 0x00009f4e, 0x0000e6d8 },
	{ 0x00009f4f, 0x0000e8eb },
	{ 0x00009f52, 0x0000ea8f },
	{ 0x00009f54, 0x0000ea90 },
	{ 0x00009f5f, 0x0000ea92 },
	{ 0x00009f60, 0x0000ea93 },
	{ 0x00009f61, 0x0000ea94 },
	{ 0x00009f62, 0x000097ee },
	{ 0x00009f63, 0x0000ea91 },
	{ 0x00009f66, 0x0000ea95 },
	{ 0x00009f67, 0x0000ea96 },
	{ 0x00009f6a, 0x0000ea98 },
	{ 0x00009f6c, 0x0000ea97 },
	{ 0x00009f72, 0x0000ea9a },
	{ 0x00009f76, 0x0000ea9b },
	{ 0x00009f77, 0x0000ea99 },
	{ 0x00009f8d, 0x000097b4 },
	{ 0x00009f95, 0x0000ea9c },
	{ 0x00009f9c, 0x0000ea9d },
	{ 0x00009f9d, 0x0000e273 },
	{ 0x00009fa0, 0x0000ea9e },
	{ 0x0000ff01, 0x00008149 },
	{ 0x0000ff03, 0x00008194 },
	{ 0x0000ff04, 0x00008190 },
	{ 0x0000ff05, 0x00008193 },
	{ 0x0000ff06, 0x00008195 },
	{ 0x0000ff08, 0x00008169 },
	{ 0x0000ff09, 0x0000816a },
	{ 0x0000ff0a, 0x00008196 },
	{ 0x0000ff0b, 0x0000817b },
	{ 0x0000ff0c, 0x00008143 },
	{ 0x0000ff0e, 0x00008144 },
	{ 0x0000ff0f, 0x0000815e },
	{ 0x0000ff10, 0x0000824f },
	{ 0x0000ff11, 0x00008250 },
	{ 0x0000ff12, 0x00008251 },
	{ 0x0000ff13, 0x00008252 },
	{ 0x0000ff14, 0x00008253 },
	{ 0x0000ff15, 0x00008254 },
	{ 0x0000ff16, 0x00008255 },
	{ 0x0000ff17, 0x00008256 },
	{ 0x0000ff18, 0x00008257 },
	{ 0x0000ff19, 0x00008258 },
	{ 0x0000ff1a, 0x00008146 },
	{ 0x0000ff1b, 0x00008147 },
	{ 0x0000ff1c, 0x00008183 },
	{ 0x0000ff1d, 0x00008181 },
	{ 0x0000ff1e, 0x00008184 },
	{ 0x0000ff1f, 0x00008148 },
	{ 0x0000ff20, 0x00008197 },
	{ 0x0000ff21, 0x00008260 },
	{ 0x0000ff22, 0x00008261 },
	{ 0x0000ff23, 0x00008262 },
	{ 0x0000ff24, 0x00008263 },
	{ 0x0000ff25, 0x00008264 },
	{ 0x0000ff26, 0x00008265 },
	{ 0x0000ff27, 0x00008266 },
	{ 0x0000ff28, 0x00008267 },
	{ 0x0000ff29, 0x00008268 },
	{ 0x0000ff2a, 0x00008269 },
	{ 0x0000ff2b, 0x0000826a },
	{ 0x0000ff2c, 0x0000826b },
	{ 0x0000ff2d, 0x0000826c },
	{ 0x0000ff2e, 0x0000826d },
	{ 0x0000ff2f, 0x0000826e },
	{ 0x0000ff30, 0x0000826f },
	{ 0x0000ff31, 0x00008270 },
	{ 0x0000ff32, 0x00008271 },
	{ 0x0000ff33, 0x00008272 },
	{ 0x0000ff34, 0x00008273 },
	{ 0x0000ff35, 0x00008274 },
	{ 0x0000ff36, 0x00008275 },
	{ 0x0000ff37, 0x00008276 },
	{ 0x0000ff38, 0x00008277 },
	{ 0x0000ff39, 0x00008278 },
	{ 0x0000ff3a, 0x00008279 },
	{ 0x0000ff3b, 0x0000816d },
	{ 0x0000ff3c, 0x0000815f },
	{ 0x0000ff3d, 0x0000816e },
	{ 0x0000ff3e, 0x0000814f },
	{ 0x0000ff3f, 0x00008151 },
	{ 0x0000ff40, 0x0000814d },
	{ 0x0000ff41, 0x00008281 },
	{ 0x0000ff42, 0x00008282 },
	{ 0x0000ff43, 0x00008283 },
	{ 0x0000ff44, 0x00008284 },
	{ 0x0000ff45, 0x00008285 },
	{ 0x0000ff46, 0x00008286 },
	{ 0x0000ff47, 0x00008287 },
	{ 0x0000ff48, 0x00008288 },
	{ 0x0000ff49, 0x00008289 },
	{ 0x0000ff4a, 0x0000828a },
	{ 0x0000ff4b, 0x0000828b },
	{ 0x0000ff4c, 0x0000828c },
	{ 0x0000ff4d, 0x0000828d },
	{ 0x0000ff4e, 0x0000828e },
	{ 0x0000ff4f, 0x0000828f },
	{ 0x0000ff50, 0x00008290 },
	{ 0x0000ff51, 0x00008291 },
	{ 0x0000ff52, 0x00008292 },
	{ 0x0000ff53, 0x00008293 },
	{ 0x0000ff54, 0x00008294 },
	{ 0x0000ff55, 0x00008295 },
	{ 0x0000ff56, 0x00008296 },
	{ 0x0000ff57, 0x00008297 },
	{ 0x0000ff58, 0x00008298 },
	{ 0x0000ff59, 0x00008299 },
	{ 0x0000ff5a, 0x0000829a },
	{ 0x0000ff5b, 0x0000816f },
	{ 0x0000ff5c, 0x00008162 },
	{ 0x0000ff5d, 0x00008170 },
	{ 0x0000ffe3, 0x00008150 },
	{ 0x0000ffe5, 0x0000818f },
};
