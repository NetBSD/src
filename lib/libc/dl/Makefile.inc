#	$Id: Makefile.inc,v 1.2 1993/12/04 02:34:47 cgd Exp $

.PATH: ${.CURDIR}/arch/${MACHINE_ARCH}/dl ${.CURDIR}/dl

SRCS+=	dl.c

