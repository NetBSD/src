# $NetBSD: Makefile.inc,v 1.1.4.2 2014/08/20 00:02:08 tls Exp $

SRCS+=	strtof.c
SRCS+=	strtold_pQ.c
SRCS+=	strtopQ.c
