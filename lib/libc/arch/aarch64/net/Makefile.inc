# $NetBSD: Makefile.inc,v 1.1.4.2 2014/08/20 00:02:08 tls Exp $

# hton* and nto* functions provided by ../gen/byte_swap_*.S
