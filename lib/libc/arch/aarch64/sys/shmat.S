/* $NetBSD: shmat.S,v 1.1.4.2 2014/08/20 00:02:09 tls Exp $ */

#include "SYS.h"

RSYSCALL(shmat)
