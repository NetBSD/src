#	$NetBSD: Makefile.inc,v 1.2 2006/03/22 22:03:58 drochner Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c

SRCS+=	erand48_ieee754.c
