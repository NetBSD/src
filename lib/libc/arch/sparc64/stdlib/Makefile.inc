#	$NetBSD: Makefile.inc,v 1.4.6.2 2008/08/04 21:29:29 matt Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c imaxabs.c

SRCS+=	erand48_ieee754.c
