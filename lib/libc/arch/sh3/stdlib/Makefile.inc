#	$NetBSD: Makefile.inc,v 1.1 2000/01/05 14:07:37 msaitoh Exp $

SRCS+=	abs.c div.c labs.c ldiv.c
