/*	$NetBSD: bzero.S,v 1.1.2.2 2002/12/10 06:25:45 thorpej Exp $	*/

#define BZERO
#include "memset.S"

