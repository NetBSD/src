/*	$NetBSD: memcpy.S,v 1.1.2.2 2002/12/10 06:25:45 thorpej Exp $	*/

#define MEMCOPY
#include "bcopy.S"
