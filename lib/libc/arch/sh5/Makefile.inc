#	$NetBSD: Makefile.inc,v 1.4 2006/04/05 12:23:51 skrll Exp $

KMINCLUDES=
KMSRCS=

SRCS+=	__sigaction14_sigtramp.c __sigtramp2.S
