#	$NetBSD: Makefile.inc,v 1.2 2006/03/22 22:03:58 drochner Exp $

SRCS+=	abs.S llabs.S div.c ldiv.c

SRCS+=	erand48_ieee754.c
