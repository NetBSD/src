/*	$NetBSD: rindex.S,v 1.1.2.2 2002/12/10 06:25:46 thorpej Exp $	*/

#define _RINDEX
#include "strrchr.S"
