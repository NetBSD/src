/* $NetBSD: rindex.S,v 1.3 2004/07/19 20:04:41 drochner Exp $ */

#define RINDEX
#include "strrchr.S"
