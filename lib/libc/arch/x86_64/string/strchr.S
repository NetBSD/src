/*	$NetBSD: strchr.S,v 1.1 2001/06/19 00:25:05 fvdl Exp $	*/

#define STRCHR
#include "index.S"
