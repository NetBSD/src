/*	$NetBSD: strrchr.S,v 1.1 2001/06/19 00:25:05 fvdl Exp $	*/

#define STRRCHR
#include "rindex.S"
