/*	$NetBSD: memmove.S,v 1.1 2000/10/10 21:51:54 jeffs Exp $	*/


#define MEMMOVE
#include "bcopy.S"
