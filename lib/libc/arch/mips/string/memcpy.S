/*	$NetBSD: memcpy.S,v 1.1 2000/10/10 21:51:54 jeffs Exp $	*/


#define MEMCOPY
#include "bcopy.S"
