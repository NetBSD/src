#	$NetBSD: Makefile.inc,v 1.1.2.2 1997/11/08 21:56:39 veego Exp $

SRCS+=	abs.c div.c labs.c ldiv.c
