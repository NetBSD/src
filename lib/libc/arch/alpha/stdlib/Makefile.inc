#	$NetBSD: Makefile.inc,v 1.4 2008/08/04 21:29:28 matt Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c imaxabs.c imaxdiv.c

SRCS+=	erand48_ieee754.c
