#	$NetBSD: Makefile.inc,v 1.5 2009/07/18 09:44:30 dsl Exp $

SRCS+=	bcmp.c bcopy.S bzero.S ffs.S memchr.c memcmp.c memset.c \
	strcat.c strcmp.c strcpy.c strcspn.c strlen.c \
	strncat.c strncmp.c strncpy.c strpbrk.c strsep.c \
	strspn.c strstr.c swab.c
SRCS+=	memcpy.S memmove.S
