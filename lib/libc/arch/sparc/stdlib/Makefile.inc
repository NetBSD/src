#	$NetBSD: Makefile.inc,v 1.4 2009/07/31 20:40:00 dsl Exp $

SRCS+=	llabs.S
NO_SRCS+= imaxabs.c
