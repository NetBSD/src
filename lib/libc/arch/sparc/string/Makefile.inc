#	$NetBSD: Makefile.inc,v 1.3 2009/07/18 09:44:30 dsl Exp $

SRCS+=	bcmp.c bcopy.c bzero.S ffs.S memchr.c memcmp.c memset.S \
	strcat.c strcmp.c strcpy.c strcspn.c strlen.S \
	strncat.c strncmp.c strncpy.c strpbrk.c strsep.c \
	strspn.c strstr.c swab.c
