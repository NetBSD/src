/*	$NetBSD: memset.S,v 1.1.2.2 2001/10/08 20:18:20 nathanw Exp $	*/

#define MEMSET
#include "bzero.S"
