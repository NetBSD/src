#	$NetBSD: Makefile.inc,v 1.1.16.1 2019/06/10 22:05:17 christos Exp $

SRCS+=	strtof.c strtold_pQ.c
SRCS+=	strtopQ.c

