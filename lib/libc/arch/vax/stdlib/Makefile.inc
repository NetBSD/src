#	$NetBSD: Makefile.inc,v 1.3.20.1 2008/09/18 04:39:20 wrstuden Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c imaxabs.c

SRCS+=	erand48.c
