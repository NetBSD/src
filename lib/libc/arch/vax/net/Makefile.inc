#	$NetBSD: Makefile.inc,v 1.3 2004/06/06 13:26:01 he Exp $

# ntoh* and htn* are in ../gen/byte_swap_*
SRCS+=	

CPPFLAGS.nslexer.c+= -I.
