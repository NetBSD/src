#       $NetBSD: Makefile.inc,v 1.4 2009/07/30 20:57:17 dsl Exp $

SRCS+=  bcmp.S bcopy.S bzero.S ffs.S memcmp.S memset.S
SRCS+=	memcpy.S memmove.S
