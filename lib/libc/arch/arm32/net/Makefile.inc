# $NetBSD: Makefile.inc,v 1.3 1999/01/15 13:31:17 bouyer Exp $

# hton* and nto* functions provided by ../gen/byte_swap_*.S
SRCS+= 
