#include "SYS.h"

#if defined(LIBC_SCCS)
	RCSID("$NetBSD: __syscall.S,v 1.1 2000/12/29 23:16:18 matthias Exp $")
#endif

RSYSCALL(__syscall)
