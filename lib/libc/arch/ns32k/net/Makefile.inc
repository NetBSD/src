#	$NetBSD: Makefile.inc,v 1.3 1999/01/15 13:31:19 bouyer Exp $

# objects built from assembler sources (need lint stubs)
# hton* and nto* functions provided by ../gen/byte_swap_*.S
ASSRCS+=

