#	$NetBSD: Makefile.inc,v 1.6 2009/07/31 20:40:00 dsl Exp $

SRCS+=	abs.S llabs.S
NO_SRCS+= labs.c imaxabs.c 
