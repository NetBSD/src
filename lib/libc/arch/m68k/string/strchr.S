/*	$NetBSD: strchr.S,v 1.2 1998/01/09 03:45:11 perry Exp $	*/

#define STRCHR
#include "index.S"
