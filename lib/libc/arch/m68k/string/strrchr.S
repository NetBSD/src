/*	$NetBSD: strrchr.S,v 1.2 1998/01/09 03:45:12 perry Exp $	*/

#define STRRCHR
#include "rindex.S"
