/*	$NetBSD: memcpy.S,v 1.3 1998/01/09 03:45:10 perry Exp $	*/

#define MEMCOPY
#include "bcopy.S"
