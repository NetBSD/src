#	$NetBSD: Makefile.inc,v 1.4 2009/07/17 19:37:55 dsl Exp $

SRCS+=	bcmp.S bcopy.S bzero.S ffs.S memchr.c memcmp.S memset.S \
	strcat.S strcmp.S strcpy.S strcspn.c strlen.S \
	strncat.c strncmp.S strncpy.S strpbrk.c strsep.c \
	strspn.c strstr.c swab.S
SRCS+=	memcpy.S memccpy.S memmove.S strchr.S strrchr.S
