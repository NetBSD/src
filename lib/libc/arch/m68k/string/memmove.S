/*	$NetBSD: memmove.S,v 1.3 1998/01/09 03:45:11 perry Exp $	*/

#define MEMMOVE
#include "bcopy.S"
