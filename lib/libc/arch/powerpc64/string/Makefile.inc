#	$NetBSD: Makefile.inc,v 1.5 2009/08/03 06:26:41 dsl Exp $

SRCS+=	bzero.S ffs.S strlen.S
NO_SRCS+= memset.c
