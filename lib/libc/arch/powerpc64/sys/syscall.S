/*	$NetBSD: syscall.S,v 1.1.64.1 2015/02/04 22:00:24 martin Exp $	*/

/* aliased to __syscall */
