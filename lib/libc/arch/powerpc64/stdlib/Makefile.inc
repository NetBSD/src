#	$NetBSD: Makefile.inc,v 1.1 2006/07/01 16:37:20 ross Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c

SRCS+=	erand48_ieee754.c
