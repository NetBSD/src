#	$NetBSD: Makefile.inc,v 1.2 2006/09/23 17:39:34 cherry Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c

SRCS+=	erand48_ieee754.c

