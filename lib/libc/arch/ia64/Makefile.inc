#	$NetBSD: Makefile.inc,v 1.4 2021/10/31 22:24:35 thorpej Exp $

SRCS+=	__sigtramp2.S
