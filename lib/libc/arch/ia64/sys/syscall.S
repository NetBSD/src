/* $NetBSD: syscall.S,v 1.2.84.1 2020/04/21 18:41:58 martin Exp $ */
	
#include "SYS.h"

	
WSYSCALL(syscall,_syscall)

