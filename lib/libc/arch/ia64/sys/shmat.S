/*	$NetBSD: shmat.S,v 1.2 2016/06/30 09:14:30 mrg Exp $	*/

#include "SYS.h"

RSYSCALL(shmat)
