/*	$NetBSD: __syscall.S,v 1.1 2006/07/07 07:49:19 cherry Exp $	*/

/* XXX:	 Stub */