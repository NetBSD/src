/* $NetBSD: rindex.S,v 1.12 2005/02/04 18:12:52 drochner Exp $ */

#define RINDEX
#include "strrchr.S"
