/*	$NetBSD: strchr.S,v 1.7 2005/02/07 05:22:52 christos Exp $	*/

#define STRCHR
#include "index.S"
