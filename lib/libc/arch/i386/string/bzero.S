/*	$NetBSD: bzero.S,v 1.10 2005/02/03 22:05:01 dsl Exp $	*/

#define BZERO
#include "memset.S"
