/*	$NetBSD: strrchr.S,v 1.8 2005/02/07 05:22:52 christos Exp $	*/

#define STRRCHR
#include "rindex.S"
