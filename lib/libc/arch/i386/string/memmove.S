/*	$NetBSD: memmove.S,v 1.7 2005/02/09 18:15:16 christos Exp $	*/

#define MEMMOVE
#include "memcpy.S"
