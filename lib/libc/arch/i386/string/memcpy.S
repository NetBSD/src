/*	$NetBSD: memcpy.S,v 1.4 2005/02/07 05:22:51 christos Exp $	*/

#define MEMCOPY
#include "bcopy.S"
