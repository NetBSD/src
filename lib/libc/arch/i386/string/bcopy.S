/*	$NetBSD: bcopy.S,v 1.13 2005/02/03 22:35:11 dsl Exp $	*/

#define BCOPY
#include "memcpy.S"
