#	$NetBSD: Makefile.inc,v 1.8 2009/07/31 20:54:35 dsl Exp $

# objects built from assembler sources
SRCS+=	abs.S div.S labs.S ldiv.S llabs.S
NO_SRCS+= imaxabs.c
