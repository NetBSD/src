#	$NetBSD: Makefile.inc,v 1.1 2000/05/09 21:55:49 bjh21 Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c
