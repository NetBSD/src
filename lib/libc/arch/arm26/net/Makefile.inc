# $NetBSD: Makefile.inc,v 1.1 2000/05/09 21:55:49 bjh21 Exp $

# hton* and nto* functions provided by ../gen/byte_swap_*.S
SRCS+= 
