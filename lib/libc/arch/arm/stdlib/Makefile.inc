#	$NetBSD: Makefile.inc,v 1.2.20.1 2008/09/18 04:39:19 wrstuden Exp $

SRCS+=	abs.c div.c labs.c ldiv.c llabs.c imaxabs.c imaxdiv.c

SRCS+=	erand48_ieee754.c
