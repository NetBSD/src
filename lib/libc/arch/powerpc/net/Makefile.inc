#	$NetBSD: Makefile.inc,v 1.1.16.1 2003/06/19 00:29:15 grant Exp $

SRCS+=	htonl.c htons.c ntohl.c ntohs.c
