/*	$NetBSD: syscall.S,v 1.2.76.1 2014/08/20 00:02:11 tls Exp $	*/

/* aliased to __syscall */
