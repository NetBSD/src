/*	$NetBSD: __sigreturn14.S,v 1.2 2004/03/26 20:35:37 drochner Exp $	*/

#include "SYS.h"

PSEUDO(__sigreturn14,compat_16___sigreturn14)
