#	$NetBSD: Makefile.inc,v 1.1 1997/11/05 23:00:09 cgd Exp $

SRCS+=	abs.c div.c labs.c ldiv.c
