#	$NetBSD: Makefile.inc,v 1.1.2.1 2008/11/08 21:49:35 christos Exp $

.PATH: ${COMPATDIR}/rpc

SRCS+=compat_pmap_rmtcall.c compat_rpcb.c
