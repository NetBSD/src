#	$NetBSD: Makefile.inc,v 1.1 2005/09/13 01:44:09 christos Exp $
.include "${.CURDIR}/compat/db/hash/Makefile.inc"
