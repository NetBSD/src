#	$NetBSD: Makefile.inc,v 1.1 2005/10/15 22:11:22 uwe Exp $

SRCS+=	compat_setjmp.S compat_sigsetjmp.S
