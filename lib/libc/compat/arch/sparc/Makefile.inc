#	$NetBSD: Makefile.inc,v 1.1 2005/10/15 22:11:22 uwe Exp $

.include "${.CURDIR}/compat/arch/sparc/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/sparc/sys/Makefile.inc"
