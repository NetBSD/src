#	$NetBSD: Makefile.inc,v 1.2 2005/10/15 16:00:42 uwe Exp $

SRCS+=	compat_setjmp.S compat_sigsetjmp.S
