#	$NetBSD: Makefile.inc,v 1.2 2005/09/15 22:44:58 uwe Exp $

.include "${.CURDIR}/compat/arch/sh3/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/sh3/sys/Makefile.inc"
