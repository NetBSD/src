# $NetBSD: Makefile.inc,v 1.1 2005/09/16 18:21:19 drochner Exp $

SRCS+=  compat_setjmp.S compat__setjmp.S compat_sigsetjmp.S
