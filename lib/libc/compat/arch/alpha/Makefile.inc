# $NetBSD: Makefile.inc,v 1.1 2005/09/16 18:21:19 drochner Exp $

.include "${.CURDIR}/compat/arch/alpha/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/alpha/sys/Makefile.inc"
