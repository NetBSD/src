#	$NetBSD: Makefile.inc,v 1.2 2006/03/11 23:04:03 christos Exp $

.include "${COMPATARCHDIR}/sys/Makefile.inc"
