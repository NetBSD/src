#	$NetBSD: Makefile.inc,v 1.1 2006/03/11 19:26:29 christos Exp $

.include "${.CURDIR}/compat/arch/ns32k/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/ns32k/sys/Makefile.inc"
