#	$NetBSD: Makefile.inc,v 1.1 2006/02/18 22:54:51 matt Exp $

.include "${.CURDIR}/compat/arch/${MACHINE_ARCH}/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/${MACHINE_ARCH}/sys/Makefile.inc"
