#	$NetBSD: Makefile.inc,v 1.1.24.1 2018/05/02 07:20:01 pgoyette Exp $

.include "${COMPATARCHDIR}/sys/Makefile.inc"
