#	$NetBSD: Makefile.inc,v 1.1 2006/02/18 00:21:28 matt Exp $

.include "${.CURDIR}/compat/arch/${MACHINE_ARCH}/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/${MACHINE_ARCH}/sys/Makefile.inc"
