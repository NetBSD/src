#	$NetBSD: Makefile.inc,v 1.2 2006/03/11 19:26:29 christos Exp $

.include "${.CURDIR}/compat/arch/x86_64/sys/Makefile.inc"
