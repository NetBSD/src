#	$NetBSD: Makefile.inc,v 1.4 2006/06/28 14:46:33 drochner Exp $

.include "${COMPATARCHDIR}/gen/Makefile.inc"
.include "${COMPATARCHDIR}/sys/Makefile.inc"
