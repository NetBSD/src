# $NetBSD: Makefile.inc,v 1.2 2023/05/19 06:50:07 skrll Exp $

.include "${COMPATARCHDIR}/sys/Makefile.inc"
