#	$NetBSD: Makefile.inc,v 1.1 2023/05/19 06:50:07 skrll Exp $

SRCS+= \
    compat_Ovfork.S \
    compat_msgctl.S \
    compat_quotactl.S \
    compat_shmctl.S \
    compat_sigaction.S \
    compat_sigpending.S \
    compat_sigprocmask.S \
    compat_sigreturn.S \
    compat_sigsuspend.S \
