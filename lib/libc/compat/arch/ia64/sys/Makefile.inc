# $NetBSD: Makefile.inc,v 1.4 2025/04/07 20:21:10 riastradh Exp $

SRCS+=	compat_Ovfork.S
SRCS+=	compat___semctl.S
SRCS+=	compat_quotactl.S
SRCS+=	compat_sigprocmask.S
SRCS+=	compat_sigsuspend.S
