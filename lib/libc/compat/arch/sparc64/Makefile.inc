#	$NetBSD: Makefile.inc,v 1.1 2005/10/16 04:41:34 christos Exp $

.include "${.CURDIR}/compat/arch/sparc/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/sparc/sys/Makefile.inc"
