#	$NetBSD: Makefile.inc,v 1.1 2005/10/16 04:41:34 christos Exp $

SRCS+=	compat_setjmp.S compat_sigsetjmp.S
