#	$NetBSD: Makefile.inc,v 1.1 2006/03/09 16:20:55 christos Exp $

# objects built from assembler sources (need lint stubs)
SRCS+=	compat_setjmp.S compat_sigsetjmp.S
