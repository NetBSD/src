#	$NetBSD: Makefile.inc,v 1.1 2006/03/09 16:20:55 christos Exp $

.include "${.CURDIR}/compat/arch/m68k/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/m68k/sys/Makefile.inc"
