#	$NetBSD: Makefile.inc,v 1.2 2005/10/05 20:16:43 christos Exp $

# objects built from assembler sources (need lint stubs)
SRCS+=	compat_setjmp.S compat_sigsetjmp.S
