#	$NetBSD: Makefile.inc,v 1.1 2005/09/13 01:44:08 christos Exp $

.include "${.CURDIR}/compat/arch/i386/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/i386/sys/Makefile.inc"
