#	$NetBSD: Makefile.inc,v 1.1 2005/10/16 17:27:50 christos Exp $

SRCS+=	compat_setjmp.S compat_sigsetjmp.S
