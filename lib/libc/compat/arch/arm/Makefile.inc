#	$NetBSD: Makefile.inc,v 1.1 2005/10/16 17:27:49 christos Exp $

.include "${.CURDIR}/compat/arch/sparc/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/sparc/sys/Makefile.inc"
