#	$NetBSD: Makefile.inc,v 1.1 2005/09/17 11:49:39 tsutsui Exp $

.include "${.CURDIR}/compat/arch/mips/gen/Makefile.inc"
.include "${.CURDIR}/compat/arch/mips/sys/Makefile.inc"
