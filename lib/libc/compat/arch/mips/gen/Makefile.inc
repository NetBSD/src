#	$NetBSD: Makefile.inc,v 1.2 2005/10/07 17:16:39 tsutsui Exp $

# objects built from assembler sources (need lint stubs)
SRCS+=	compat_setjmp.S compat_sigsetjmp.S
