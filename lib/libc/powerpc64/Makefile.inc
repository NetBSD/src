#	$NetBSD: Makefile.inc,v 1.1 2006/06/30 23:25:18 ross Exp $
