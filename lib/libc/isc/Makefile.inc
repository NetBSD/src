#	$NetBSD: Makefile.inc,v 1.3 2026/04/18 21:52:21 rillig Exp $

# net sources
.PATH: ${.CURDIR}/isc

SRCS+=	assertions.c ev_timers.c ev_streams.c
