#	from: @(#)Makefile.inc	8.1 (Berkeley) 6/4/93
#	$Id: Makefile.inc,v 1.2 1993/08/01 05:41:07 mycroft Exp $

.PATH: ${.CURDIR}/db/mpool

SRCS+=	mpool.c
