#	$NetBSD: Makefile.inc,v 1.5.38.1 2026/11/04 23:19:16 perseant Exp $
#       @(#)Makefile.inc	8.1 (Berkeley) 6/4/93

.PATH: ${.PARSEDIR}

SRCS+=	db.c dbfile.c
