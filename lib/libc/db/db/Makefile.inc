#	$NetBSD: Makefile.inc,v 1.4.80.1 2014/05/22 11:36:51 yamt Exp $
#       @(#)Makefile.inc	8.1 (Berkeley) 6/4/93

.PATH: ${.CURDIR}/db/db

SRCS+=	db.c dbfile.c
