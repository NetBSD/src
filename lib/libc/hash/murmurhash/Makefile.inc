# $NetBSD: Makefile.inc,v 1.1.4.2 2012/10/30 18:58:50 yamt Exp $

.PATH: ${.CURDIR}/hash/murmurhash

SRCS+=	murmurhash.c
