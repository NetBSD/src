#       @(#)Makefile.inc	5.1 (Berkeley) 9/12/91

.PATH: ${.CURDIR}/DB/db

SRCS+=	db.c
