#	@(#)Makefile.inc	5.3 (Berkeley) 9/4/91
#
.include "${.CURDIR}/DB/btree/Makefile.inc"
.include "${.CURDIR}/DB/db/Makefile.inc"
.include "${.CURDIR}/DB/hash/Makefile.inc"
.include "${.CURDIR}/DB/man/Makefile.inc"
.include "${.CURDIR}/DB/mpool/Makefile.inc"
.include "${.CURDIR}/DB/recno/Makefile.inc"
