#	@(#)Makefile.inc	5.1 (Berkeley) 9/4/91

.PATH: ${.CURDIR}/DB/mpool

SRCS+=	mpool.c
