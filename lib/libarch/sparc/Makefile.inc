#	$NetBSD: Makefile.inc,v 1.1 2002/11/26 14:30:53 pk Exp $

.if (${MACHINE_ARCH} == "sparc")
SUBDIR=sparc/v8
.endif

