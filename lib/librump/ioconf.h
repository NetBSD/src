void ksymsattach(int);
