/* $NetBSD: crtn.S,v 1.1.16.1 2019/06/10 22:05:14 christos Exp $ */

/* no need for anything here since RISC-V for NetBSD uses .init_array/.fini_array */
