/* $NetBSD: crtn.S,v 1.1.4.2 2014/08/20 00:02:05 tls Exp $ */

/* no need for anything here since AAPCS64 uses .init_array/.fini_array */
