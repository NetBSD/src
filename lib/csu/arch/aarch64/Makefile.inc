# $NetBSD: Makefile.inc,v 1.1.26.1 2019/06/10 22:05:13 christos Exp $

CPPFLAGS+=	-I${ARCHDIR}
CPPFLAGS+=	-DHAVE_INITFINI_ARRAY
#CPPFLAGS+=	-DELF_NOTE_MARCH_DESC=\"${CSU_MACHINE_ARCH}\"
