#	$NetBSD: Makefile.inc,v 1.3 2016/01/24 16:47:32 christos Exp $

CPPFLAGS+=	-I${ARCHDIR} -DELFSIZE=64
