# $NetBSD: Makefile.inc,v 1.1.10.2 2014/08/20 00:02:06 tls Exp $

CPPFLAGS+=	-DELFSIZE=64 -I${ARCHDIR}


