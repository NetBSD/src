# $NetBSD: Makefile.inc,v 1.1.12.2 2014/08/20 00:02:06 tls Exp $

CPPFLAGS+=	-I${ARCHDIR}
