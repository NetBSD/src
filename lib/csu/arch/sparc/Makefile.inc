# $NetBSD: Makefile.inc,v 1.1.6.1 2014/05/22 11:36:44 yamt Exp $

CPPFLAGS+=	-DELFSIZE=32 -I${ARCHDIR}


