# $NetBSD: Makefile.inc,v 1.1.16.1 2019/06/10 22:05:14 christos Exp $

CPPFLAGS+=	-I${ARCHDIR}
CPPFLAGS+=	-DHAVE_INITFINI_ARRAY
#CPPFLAGS+=	-DELF_NOTE_MARCH_DESC=\"${CSU_MACHINE_ARCH}\"
