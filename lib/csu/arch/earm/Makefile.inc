# $NetBSD: Makefile.inc,v 1.4 2018/12/27 18:57:15 christos Exp $

CPPFLAGS+=	-I${ARCHDIR}
CPPFLAGS+=	-DELF_NOTE_MARCH_DESC=\"${CSU_MACHINE_ARCH}\"
