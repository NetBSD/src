/* $NetBSD: crtn.S,v 1.1.4.2 2012/10/30 18:58:36 yamt Exp $ */

/* no need for anything here since ARM EABI uses .init_array/.fini_array */
