/* $NetBSD: k_tanf.S,v 1.8 2024/05/07 22:51:19 riastradh Exp $ */

/*
 * Dummy file. Real code is elsewhere.
 *
 * DO NOT EDIT - this file is automatically generated by;
 *
 *	NetBSD: makeas.sh,v 1.16 2024/05/07 22:30:16 riastradh Exp
 *
 */
