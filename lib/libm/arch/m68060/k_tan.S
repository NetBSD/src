/* $NetBSD: k_tan.S,v 1.5 2000/05/16 19:07:36 is Exp $ */

/*
 * Dummy file. Real code is elsewhere.
 *
 * DO NOT EDIT - this file is automatically generated.
 *
 */
