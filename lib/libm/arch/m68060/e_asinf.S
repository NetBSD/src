/* $NetBSD: e_asinf.S,v 1.4 2000/05/12 20:11:12 is Exp $ */

/*
 * FPLSP wrapper for __ieee754_asinf
 * DO NOT EDIT - this file is automatically generated.
 */

#include <machine/asm.h>

ENTRY(__ieee754_asinf)
#ifdef __SVR4_ABI__
	jbra _ASM_LABEL(___060FPLSP0018)
#else
	movel %sp@(4),%sp@-
	jbsr _ASM_LABEL(___060FPLSP0018)
	fmoves %fp0,%sp@
	movel %sp@+,%d0
	rts
#endif
