/* $NetBSD: s_sin.S,v 1.5 2000/05/16 19:07:36 is Exp $ */

/*
 * FPLSP wrapper for sin
 * DO NOT EDIT - this file is automatically generated.
 */

#include <machine/asm.h>

ENTRY(sin)
#ifdef __SVR4_ABI__
	jbra _C_LABEL(__fplsp060_01a0)
#else
	movel %sp@(8),%sp@-
	movel %sp@(8),%sp@-
	jbsr _C_LABEL(__fplsp060_01a0)
	fmoved %fp0,%sp@
	movel %sp@+,%d0
	movel %sp@+,%d1
	rts
#endif
