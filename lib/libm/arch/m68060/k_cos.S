/* $NetBSD: k_cos.S,v 1.2 1999/08/21 21:04:18 is Exp $ */

/*
 * Dummy file. Real code is in fplsp_wrap.S.
 *
 * DO NOT EDIT - this file is automatically generated.
 *
 */
