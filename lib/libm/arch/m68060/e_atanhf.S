/* $NetBSD: e_atanhf.S,v 1.7 2024/05/07 21:18:47 riastradh Exp $ */

/*
 * FPLSP wrapper for __ieee754_atanhf
 * DO NOT EDIT - this file is automatically generated by:
 *
 *	NetBSD: makeas.sh,v 1.10 2024/05/07 21:14:12 riastradh Exp
 */

#include <machine/asm.h>

ENTRY(__ieee754_atanhf)
#ifdef __SVR4_ABI__
	bral PIC_PLT(_C_LABEL(__fplsp060_0048))
#else
	movel %sp@(4),%sp@-
	bsrl PIC_PLT(_C_LABEL(__fplsp060_0048))
	fmoves %fp0,%sp@
	movel %sp@+,%d0
	rts
#endif
