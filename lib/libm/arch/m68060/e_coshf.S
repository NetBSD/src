/* $NetBSD: e_coshf.S,v 1.5 2000/05/16 19:07:35 is Exp $ */

/*
 * FPLSP wrapper for __ieee754_coshf
 * DO NOT EDIT - this file is automatically generated.
 */

#include <machine/asm.h>

ENTRY(__ieee754_coshf)
#ifdef __SVR4_ABI__
	jbra _C_LABEL(__fplsp060_0078)
#else
	movel %sp@(4),%sp@-
	jbsr _C_LABEL(__fplsp060_0078)
	fmoves %fp0,%sp@
	movel %sp@+,%d0
	rts
#endif
