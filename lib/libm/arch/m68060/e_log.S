/* $NetBSD: e_log.S,v 1.4 2000/05/12 20:11:13 is Exp $ */

/*
 * FPLSP wrapper for __ieee754_log
 * DO NOT EDIT - this file is automatically generated.
 */

#include <machine/asm.h>

ENTRY(__ieee754_log)
#ifdef __SVR4_ABI__
	jbra _ASM_LABEL(___060FPLSP0128)
#else
	movel %sp@(8),%sp@-
	movel %sp@(8),%sp@-
	jbsr _ASM_LABEL(___060FPLSP0128)
	fmoved %fp0,%sp@
	movel %sp@+,%d0
	movel %sp@+,%d1
	rts
#endif
