/* $NetBSD: e_log10.S,v 1.5 2000/05/16 19:07:35 is Exp $ */

/*
 * FPLSP wrapper for __ieee754_log10
 * DO NOT EDIT - this file is automatically generated.
 */

#include <machine/asm.h>

ENTRY(__ieee754_log10)
#ifdef __SVR4_ABI__
	jbra _C_LABEL(__fplsp060_00f8)
#else
	movel %sp@(8),%sp@-
	movel %sp@(8),%sp@-
	jbsr _C_LABEL(__fplsp060_00f8)
	fmoved %fp0,%sp@
	movel %sp@+,%d0
	movel %sp@+,%d1
	rts
#endif
