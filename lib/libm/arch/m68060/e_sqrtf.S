/* $NetBSD: e_sqrtf.S,v 1.5 2000/05/16 19:07:35 is Exp $ */

/*
 * FPLSP wrapper for __ieee754_sqrtf
 * DO NOT EDIT - this file is automatically generated.
 */

#include <machine/asm.h>

ENTRY(__ieee754_sqrtf)
#ifdef __SVR4_ABI__
	jbra _C_LABEL(__fplsp060_02e8)
#else
	movel %sp@(4),%sp@-
	jbsr _C_LABEL(__fplsp060_02e8)
	fmoves %fp0,%sp@
	movel %sp@+,%d0
	rts
#endif
