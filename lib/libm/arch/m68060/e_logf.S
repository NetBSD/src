/* $NetBSD: e_logf.S,v 1.7 2024/05/07 21:18:47 riastradh Exp $ */

/*
 * FPLSP wrapper for __ieee754_logf
 * DO NOT EDIT - this file is automatically generated by:
 *
 *	NetBSD: makeas.sh,v 1.10 2024/05/07 21:14:12 riastradh Exp
 */

#include <machine/asm.h>

ENTRY(__ieee754_logf)
#ifdef __SVR4_ABI__
	bral PIC_PLT(_C_LABEL(__fplsp060_0120))
#else
	movel %sp@(4),%sp@-
	bsrl PIC_PLT(_C_LABEL(__fplsp060_0120))
	fmoves %fp0,%sp@
	movel %sp@+,%d0
	rts
#endif
