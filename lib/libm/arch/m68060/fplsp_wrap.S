/* $NetBSD: fplsp_wrap.S,v 1.9 2024/05/07 22:51:19 riastradh Exp $ */

/*
 * FPLSP wrapper.
 *
 * DO NOT EDIT - this file is automatically generated by:
 *
 *	NetBSD: makeas.sh,v 1.16 2024/05/07 22:30:16 riastradh Exp
 */

#include <machine/asm.h>


L060FPLSP_BASE:
#include "fplsp.hex"
