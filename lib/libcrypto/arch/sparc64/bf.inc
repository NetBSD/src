#	$NetBSD: bf.inc,v 1.1 2005/12/13 09:52:20 martin Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
