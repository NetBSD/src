.PATH.S: ${.PARSEDIR}
AES_SRCS = aes-586.S
.include "../../aes.inc"
