#	$NetBSD: bf.inc,v 1.1.4.2 2002/08/29 16:49:33 he Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
