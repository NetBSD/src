.PATH.S: ${.PARSEDIR}
AES_SRCS = aes-x86_64.S
.include "../../aes.inc"
