#	$NetBSD: bf.inc,v 1.1 2001/09/10 02:56:58 thorpej Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
