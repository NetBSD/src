#	$NetBSD: Makefile.inc,v 1.6.40.1 2012/04/17 00:05:11 yamt Exp $

WARNS?=		5
