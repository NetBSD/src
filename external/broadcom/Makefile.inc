# $NetBSD: Makefile.inc,v 1.1 2017/08/10 15:15:48 nat Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
