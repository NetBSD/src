# $NetBSD: Makefile.inc,v 1.1 2009/09/29 23:56:28 tsarna Exp $

.include <bsd.own.mk>

.include "${.PARSEDIR}/../Makefile.inc"

BINDIR?=	/usr/bin
