#	$NetBSD: Makefile.inc,v 1.1 2019/11/11 22:45:02 joerg Exp $

.include "${.PARSEDIR}/../Makefile.inc"
