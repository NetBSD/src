#	$NetBSD: Makefile.inc,v 1.1 2019/11/11 22:44:58 joerg Exp $

BINDIR=	/usr/bin

.include "${.PARSEDIR}/../Makefile.inc"
