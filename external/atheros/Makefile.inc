# $NetBSD: Makefile.inc,v 1.1.6.1 2012/10/30 18:49:10 yamt Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
