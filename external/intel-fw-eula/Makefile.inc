# $NetBSD: Makefile.inc,v 1.1.72.1 2025/08/02 05:50:21 perseant Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
