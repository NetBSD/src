# $NetBSD: Makefile.inc,v 1.2 2025/05/17 19:00:56 andvar Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
