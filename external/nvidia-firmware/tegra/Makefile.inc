# $NetBSD: Makefile.inc,v 1.1 2018/01/07 20:59:25 jmcneill Exp $

includes:
clean:
cleandir:
