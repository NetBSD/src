# $NetBSD: Makefile.inc,v 1.1 2021/12/13 23:59:41 maya Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
