# $NetBSD: Makefile.inc,v 1.1.6.2 2020/04/13 08:03:04 martin Exp $

includes:
clean:
cleandir:
