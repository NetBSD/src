#	$NetBSD: Makefile.inc,v 1.1.4.2 2010/04/21 05:24:28 matt Exp $

.include "${.CURDIR}/../../Makefile.inc"

BINDIR=	${PFIX_LIBEXECDIR}
