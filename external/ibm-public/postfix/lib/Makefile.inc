#	$NetBSD: Makefile.inc,v 1.1.4.2 2010/04/21 05:24:27 matt Exp $

.include "${.CURDIR}/../../Makefile.inc"
