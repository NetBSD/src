#	$NetBSD: Makefile.inc,v 1.1 2009/06/25 18:22:01 tron Exp $

.include "${.CURDIR}/../../Makefile.inc"
