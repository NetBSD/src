# $NetBSD: Makefile.inc,v 1.1 2011/05/20 08:40:04 tsutsui Exp $

XORGCONF_FILES=	etc.${MACHINE}/xorg.conf
