# $NetBSD: Makefile.inc,v 1.1 2018/05/01 17:42:00 christos Exp $

NOINFO=		# defined
NOLINT=		# defined
NOMAN=		# defined
MKREPRO=no	# Native toolchain might be unable to do it
