#	$NetBSD: Makefile.inc,v 1.1.2.2 2008/10/19 22:41:03 haad Exp $

X11EXTRAMANDEFS+=	-e 's,__mansuffix__,1,g'
