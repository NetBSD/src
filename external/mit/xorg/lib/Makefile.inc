#	$NetBSD: Makefile.inc,v 1.1.1.1.2.2 2008/09/18 05:18:34 wrstuden Exp $

.include <bsd.own.mk>
.include <bsd.obj.mk>
