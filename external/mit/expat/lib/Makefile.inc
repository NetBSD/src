#	$NetBSD: Makefile.inc,v 1.1.2.2 2012/03/02 18:27:47 riz Exp $

.include "../Makefile.inc"
