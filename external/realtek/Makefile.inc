# $NetBSD: Makefile.inc,v 1.1.6.2 2012/10/30 18:58:15 yamt Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
