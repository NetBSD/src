#	$NetBSD: Makefile.inc,v 1.1 2021/04/25 23:57:47 christos Exp $

COPTS+=		-Wno-error

GMP_LIMB_BITS=64

.include "srcs.mk"
