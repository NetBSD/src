#	$NetBSD: Makefile.inc,v 1.5 2020/09/27 00:31:52 mrg Exp $

GMP_LIMB_BITS=64

.include "srcs.mk"
