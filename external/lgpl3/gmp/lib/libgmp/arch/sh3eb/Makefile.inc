#	$NetBSD: Makefile.inc,v 1.6 2020/09/27 00:31:53 mrg Exp $

GMP_LIMB_BITS=32

.include "srcs.mk"
