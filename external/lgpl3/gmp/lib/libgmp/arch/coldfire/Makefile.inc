#	$NetBSD: Makefile.inc,v 1.4 2020/09/27 00:31:52 mrg Exp $

GMP_LIMB_BITS=32

.include "srcs.mk"
