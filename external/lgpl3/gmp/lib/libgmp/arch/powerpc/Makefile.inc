#	$NetBSD: Makefile.inc,v 1.8 2020/09/27 00:31:53 mrg Exp $

GMP_LIMB_BITS=32

M4FLAGS= -DPIC

.include "srcs.mk"
