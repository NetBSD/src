#	$NetBSD: Makefile.inc,v 1.1.2.2 2018/07/28 04:37:20 pgoyette Exp $

GMP_LIMB_BITS=64

C_SRCS_LIST= \
	add.c	mpn/generic/add.c \
	add_1.c	mpn/generic/add_1.c \
	add_err1_n.c	mpn/generic/add_err1_n.c \
	add_err2_n.c	mpn/generic/add_err2_n.c \
	add_err3_n.c	mpn/generic/add_err3_n.c \
	add_n_sub_n.c	mpn/generic/add_n_sub_n.c \
	bdiv_q.c	mpn/generic/bdiv_q.c \
	bdiv_q_1.c	mpn/generic/bdiv_q_1.c \
	bdiv_qr.c	mpn/generic/bdiv_qr.c \
	binvert.c	mpn/generic/binvert.c \
	broot.c	mpn/generic/broot.c \
	brootinv.c	mpn/generic/brootinv.c \
	bsqrt.c	mpn/generic/bsqrt.c \
	bsqrtinv.c	mpn/generic/bsqrtinv.c \
	cmp.c	mpn/generic/cmp.c \
	cnd_swap.c	mpn/generic/cnd_swap.c \
	comb_tables.c	mpn/generic/comb_tables.c \
	dcpi1_bdiv_q.c	mpn/generic/dcpi1_bdiv_q.c \
	dcpi1_bdiv_qr.c	mpn/generic/dcpi1_bdiv_qr.c \
	dcpi1_div_q.c	mpn/generic/dcpi1_div_q.c \
	dcpi1_div_qr.c	mpn/generic/dcpi1_div_qr.c \
	dcpi1_divappr_q.c	mpn/generic/dcpi1_divappr_q.c \
	div_q.c	mpn/generic/div_q.c \
	div_qr_1.c	mpn/generic/div_qr_1.c \
	div_qr_1n_pi1.c	mpn/generic/div_qr_1n_pi1.c \
	div_qr_2.c	mpn/generic/div_qr_2.c \
	div_qr_2n_pi1.c	mpn/generic/div_qr_2n_pi1.c \
	div_qr_2u_pi1.c	mpn/generic/div_qr_2u_pi1.c \
	dive_1.c	mpn/generic/dive_1.c \
	diveby3.c	mpn/generic/diveby3.c \
	divexact.c	mpn/generic/divexact.c \
	divis.c	mpn/generic/divis.c \
	divrem.c	mpn/generic/divrem.c \
	divrem_1.c	mpn/generic/divrem_1.c \
	divrem_2.c	mpn/generic/divrem_2.c \
	dump.c	mpn/generic/dump.c \
	fib2_ui.c	mpn/generic/fib2_ui.c \
	gcd.c	mpn/generic/gcd.c \
	gcd_subdiv_step.c	mpn/generic/gcd_subdiv_step.c \
	gcdext.c	mpn/generic/gcdext.c \
	gcdext_1.c	mpn/generic/gcdext_1.c \
	gcdext_lehmer.c	mpn/generic/gcdext_lehmer.c \
	get_d.c	mpn/generic/get_d.c \
	get_str.c	mpn/generic/get_str.c \
	hgcd.c	mpn/generic/hgcd.c \
	hgcd2.c	mpn/generic/hgcd2.c \
	hgcd2_jacobi.c	mpn/generic/hgcd2_jacobi.c \
	hgcd_appr.c	mpn/generic/hgcd_appr.c \
	hgcd_jacobi.c	mpn/generic/hgcd_jacobi.c \
	hgcd_matrix.c	mpn/generic/hgcd_matrix.c \
	hgcd_reduce.c	mpn/generic/hgcd_reduce.c \
	hgcd_step.c	mpn/generic/hgcd_step.c \
	invert.c	mpn/generic/invert.c \
	invertappr.c	mpn/generic/invertappr.c \
	jacbase.c	mpn/generic/jacbase.c \
	jacobi.c	mpn/generic/jacobi.c \
	jacobi_2.c	mpn/generic/jacobi_2.c \
	lshiftc.c	mpn/generic/lshiftc.c \
	matrix22_mul.c	mpn/generic/matrix22_mul.c \
	matrix22_mul1_inverse_vector.c	mpn/generic/matrix22_mul1_inverse_vector.c \
	mod_1.c	mpn/generic/mod_1.c \
	mod_1_1.c	mpn/generic/mod_1_1.c \
	mod_1_2.c	mpn/generic/mod_1_2.c \
	mod_1_3.c	mpn/generic/mod_1_3.c \
	mod_1_4.c	mpn/generic/mod_1_4.c \
	mode1o.c	mpn/generic/mode1o.c \
	mu_bdiv_q.c	mpn/generic/mu_bdiv_q.c \
	mu_bdiv_qr.c	mpn/generic/mu_bdiv_qr.c \
	mu_div_q.c	mpn/generic/mu_div_q.c \
	mu_div_qr.c	mpn/generic/mu_div_qr.c \
	mu_divappr_q.c	mpn/generic/mu_divappr_q.c \
	mul.c	mpn/generic/mul.c \
	mul_basecase.c	mpn/generic/mul_basecase.c \
	mul_fft.c	mpn/generic/mul_fft.c \
	mul_n.c	mpn/generic/mul_n.c \
	mullo_basecase.c	mpn/generic/mullo_basecase.c \
	mullo_n.c	mpn/generic/mullo_n.c \
	mulmid.c	mpn/generic/mulmid.c \
	mulmid_basecase.c	mpn/generic/mulmid_basecase.c \
	mulmid_n.c	mpn/generic/mulmid_n.c \
	mulmod_bnm1.c	mpn/generic/mulmod_bnm1.c \
	neg.c	mpn/generic/neg.c \
	nussbaumer_mul.c	mpn/generic/nussbaumer_mul.c \
	perfpow.c	mpn/generic/perfpow.c \
	perfsqr.c	mpn/generic/perfsqr.c \
	pow_1.c	mpn/generic/pow_1.c \
	powlo.c	mpn/generic/powlo.c \
	powm.c	mpn/generic/powm.c \
	pre_divrem_1.c	mpn/generic/pre_divrem_1.c \
	pre_mod_1.c	mpn/generic/pre_mod_1.c \
	random.c	mpn/generic/random.c \
	random2.c	mpn/generic/random2.c \
	redc_1.c	mpn/generic/redc_1.c \
	redc_2.c	mpn/generic/redc_2.c \
	redc_n.c	mpn/generic/redc_n.c \
	remove.c	mpn/generic/remove.c \
	rootrem.c	mpn/generic/rootrem.c \
	sbpi1_bdiv_q.c	mpn/generic/sbpi1_bdiv_q.c \
	sbpi1_bdiv_qr.c	mpn/generic/sbpi1_bdiv_qr.c \
	sbpi1_div_q.c	mpn/generic/sbpi1_div_q.c \
	sbpi1_div_qr.c	mpn/generic/sbpi1_div_qr.c \
	sbpi1_divappr_q.c	mpn/generic/sbpi1_divappr_q.c \
	scan0.c	mpn/generic/scan0.c \
	scan1.c	mpn/generic/scan1.c \
	sec_add_1.c	mpn/generic/sec_aors_1.c \
	sec_div_qr.c	mpn/generic/sec_div.c \
	sec_div_r.c	mpn/generic/sec_div.c \
	sec_invert.c	mpn/generic/sec_invert.c \
	sec_mul.c	mpn/generic/sec_mul.c \
	sec_pi1_div_qr.c	mpn/generic/sec_pi1_div.c \
	sec_pi1_div_r.c	mpn/generic/sec_pi1_div.c \
	sec_powm.c	mpn/generic/sec_powm.c \
	sec_sqr.c	mpn/generic/sec_sqr.c \
	sec_sub_1.c	mpn/generic/sec_aors_1.c \
	set_str.c	mpn/generic/set_str.c \
	sizeinbase.c	mpn/generic/sizeinbase.c \
	sqr.c	mpn/generic/sqr.c \
	sqr_basecase.c	mpn/generic/sqr_basecase.c \
	sqrlo.c	mpn/generic/sqrlo.c \
	sqrlo_basecase.c	mpn/generic/sqrlo_basecase.c \
	sqrmod_bnm1.c	mpn/generic/sqrmod_bnm1.c \
	sqrtrem.c	mpn/generic/sqrtrem.c \
	sub.c	mpn/generic/sub.c \
	sub_1.c	mpn/generic/sub_1.c \
	sub_err1_n.c	mpn/generic/sub_err1_n.c \
	sub_err2_n.c	mpn/generic/sub_err2_n.c \
	sub_err3_n.c	mpn/generic/sub_err3_n.c \
	tdiv_qr.c	mpn/generic/tdiv_qr.c \
	toom22_mul.c	mpn/generic/toom22_mul.c \
	toom2_sqr.c	mpn/generic/toom2_sqr.c \
	toom32_mul.c	mpn/generic/toom32_mul.c \
	toom33_mul.c	mpn/generic/toom33_mul.c \
	toom3_sqr.c	mpn/generic/toom3_sqr.c \
	toom42_mul.c	mpn/generic/toom42_mul.c \
	toom42_mulmid.c	mpn/generic/toom42_mulmid.c \
	toom43_mul.c	mpn/generic/toom43_mul.c \
	toom44_mul.c	mpn/generic/toom44_mul.c \
	toom4_sqr.c	mpn/generic/toom4_sqr.c \
	toom52_mul.c	mpn/generic/toom52_mul.c \
	toom53_mul.c	mpn/generic/toom53_mul.c \
	toom54_mul.c	mpn/generic/toom54_mul.c \
	toom62_mul.c	mpn/generic/toom62_mul.c \
	toom63_mul.c	mpn/generic/toom63_mul.c \
	toom6_sqr.c	mpn/generic/toom6_sqr.c \
	toom6h_mul.c	mpn/generic/toom6h_mul.c \
	toom8_sqr.c	mpn/generic/toom8_sqr.c \
	toom8h_mul.c	mpn/generic/toom8h_mul.c \
	toom_couple_handling.c	mpn/generic/toom_couple_handling.c \
	toom_eval_dgr3_pm1.c	mpn/generic/toom_eval_dgr3_pm1.c \
	toom_eval_dgr3_pm2.c	mpn/generic/toom_eval_dgr3_pm2.c \
	toom_eval_pm1.c	mpn/generic/toom_eval_pm1.c \
	toom_eval_pm2.c	mpn/generic/toom_eval_pm2.c \
	toom_eval_pm2exp.c	mpn/generic/toom_eval_pm2exp.c \
	toom_eval_pm2rexp.c	mpn/generic/toom_eval_pm2rexp.c \
	toom_interpolate_12pts.c	mpn/generic/toom_interpolate_12pts.c \
	toom_interpolate_16pts.c	mpn/generic/toom_interpolate_16pts.c \
	toom_interpolate_5pts.c	mpn/generic/toom_interpolate_5pts.c \
	toom_interpolate_6pts.c	mpn/generic/toom_interpolate_6pts.c \
	toom_interpolate_7pts.c	mpn/generic/toom_interpolate_7pts.c \
	toom_interpolate_8pts.c	mpn/generic/toom_interpolate_8pts.c \
	trialdiv.c	mpn/generic/trialdiv.c \
	zero.c	mpn/generic/zero.c \
	zero_p.c	mpn/generic/zero_p.c

ASM_SRCS_LIST= \
	add_n.asm	mpn/arm64/aors_n.asm \
	addmul_1.asm	mpn/arm64/aorsmul_1.asm \
	and_n.asm	mpn/arm64/logops_n.asm \
	andn_n.asm	mpn/arm64/logops_n.asm \
	bdiv_dbm1c.asm	mpn/arm64/bdiv_dbm1c.asm \
	cnd_add_n.asm	mpn/arm64/cnd_aors_n.asm \
	cnd_sub_n.asm	mpn/arm64/cnd_aors_n.asm \
	com.asm	mpn/arm64/com.asm \
	copyd.asm	mpn/arm64/copyd.asm \
	copyi.asm	mpn/arm64/copyi.asm \
	gcd_1.asm	mpn/arm64/gcd_1.asm \
	hamdist.asm	mpn/arm64/hamdist.asm \
	invert_limb.asm	mpn/arm64/invert_limb.asm \
	ior_n.asm	mpn/arm64/logops_n.asm \
	iorn_n.asm	mpn/arm64/logops_n.asm \
	lshift.asm	mpn/arm64/lshift.asm \
	mod_34lsub1.asm	mpn/arm64/mod_34lsub1.asm \
	mul_1.asm	mpn/arm64/mul_1.asm \
	nand_n.asm	mpn/arm64/logops_n.asm \
	nior_n.asm	mpn/arm64/logops_n.asm \
	popcount.asm	mpn/arm64/popcount.asm \
	rshift.asm	mpn/arm64/rshift.asm \
	sec_tabselect.asm	mpn/arm64/sec_tabselect.asm \
	sub_n.asm	mpn/arm64/aors_n.asm \
	submul_1.asm	mpn/arm64/aorsmul_1.asm \
	xnor_n.asm	mpn/arm64/logops_n.asm \
	xor_n.asm	mpn/arm64/logops_n.asm
