#	$NetBSD: Makefile.inc,v 1.7 2020/09/27 00:31:54 mrg Exp $

GMP_LIMB_BITS=64

.include "srcs.mk"
