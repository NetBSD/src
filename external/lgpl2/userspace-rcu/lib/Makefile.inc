# $NetBSD: Makefile.inc,v 1.1 2025/01/17 16:07:26 christos Exp $
.include "${.PARSEDIR}/../Makefile.inc"
