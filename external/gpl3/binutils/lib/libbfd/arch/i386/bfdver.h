/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-binutils,v 1.5 2006/02/02 20:06:04 skrll Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

#define BFD_VERSION_DATE 20090202
#define BFD_VERSION 219010000
#define BFD_VERSION_STRING  "(GNU Binutils) " "2.19.1"
#define REPORT_BUGS_TO "<http://www.sourceware.org/bugzilla/>"
