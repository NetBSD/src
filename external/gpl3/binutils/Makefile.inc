# $NetBSD: Makefile.inc,v 1.1 2016/01/26 19:37:46 christos Exp $
.include <bsd.own.mk>
TOP=	${NETBSDSRCDIR}/external/gpl3/${EXTERNAL_BINUTILS_SUBDIR}
DIST=	${TOP}/dist
