# Long Instructions

	.text
foo:
.byte 0xf2
.byte 0xf0
.byte 0xf0
.byte 0xf0
.byte 0xf2
.byte 0xf2
.byte 0xf2
.byte 0xf2
.byte 0xf2
.byte 0xf2
.byte 0xf0
.byte 0xf0
movapd	(%eax), %xmm0
.byte 0xf2
.byte 0xf0
.byte 0xf0
.byte 0xf0
.byte 0xf2
.byte 0xf2
.byte 0xf2
.byte 0xf2
.byte 0xf0
.byte 0xf0
.byte 0xf0
.byte 0xf0
movapd	(%eax), %xmm0
