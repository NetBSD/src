
#line 2 "ldlex.c"

#define  YY_INT_ALIGNED short int

/* A lexical scanner generated by flex */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 6
#define YY_FLEX_SUBMINOR_VERSION 4
#if YY_FLEX_SUBMINOR_VERSION > 0
#define FLEX_BETA
#endif

/* First, we deal with  platform-specific or compiler-specific issues. */

/* begin standard C headers. */
#include <stdio.h>
#include <string.h>
#include <errno.h>
#include <stdlib.h>

/* end standard C headers. */

/* flex integer type definitions */

#ifndef FLEXINT_H
#define FLEXINT_H

/* C99 systems have <inttypes.h>. Non-C99 systems may or may not. */

#if defined (__STDC_VERSION__) && __STDC_VERSION__ >= 199901L

/* C99 says to define __STDC_LIMIT_MACROS before including stdint.h,
 * if you want the limit (max/min) macros for int types. 
 */
#ifndef __STDC_LIMIT_MACROS
#define __STDC_LIMIT_MACROS 1
#endif

#include <inttypes.h>
typedef int8_t flex_int8_t;
typedef uint8_t flex_uint8_t;
typedef int16_t flex_int16_t;
typedef uint16_t flex_uint16_t;
typedef int32_t flex_int32_t;
typedef uint32_t flex_uint32_t;
#else
typedef signed char flex_int8_t;
typedef short int flex_int16_t;
typedef int flex_int32_t;
typedef unsigned char flex_uint8_t; 
typedef unsigned short int flex_uint16_t;
typedef unsigned int flex_uint32_t;

/* Limits of integral types. */
#ifndef INT8_MIN
#define INT8_MIN               (-128)
#endif
#ifndef INT16_MIN
#define INT16_MIN              (-32767-1)
#endif
#ifndef INT32_MIN
#define INT32_MIN              (-2147483647-1)
#endif
#ifndef INT8_MAX
#define INT8_MAX               (127)
#endif
#ifndef INT16_MAX
#define INT16_MAX              (32767)
#endif
#ifndef INT32_MAX
#define INT32_MAX              (2147483647)
#endif
#ifndef UINT8_MAX
#define UINT8_MAX              (255U)
#endif
#ifndef UINT16_MAX
#define UINT16_MAX             (65535U)
#endif
#ifndef UINT32_MAX
#define UINT32_MAX             (4294967295U)
#endif

#ifndef SIZE_MAX
#define SIZE_MAX               (~(size_t)0)
#endif

#endif /* ! C99 */

#endif /* ! FLEXINT_H */

/* begin standard C++ headers. */

/* TODO: this is always defined, so inline it */
#define yyconst const

#if defined(__GNUC__) && __GNUC__ >= 3
#define yynoreturn __attribute__((__noreturn__))
#else
#define yynoreturn
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an
 *   integer in range [0..255] for use as an array index.
 */
#define YY_SC_TO_UI(c) ((YY_CHAR) (c))

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN (yy_start) = 1 + 2 *
/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START (((yy_start) - 1) / 2)
#define YYSTATE YY_START
/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)
/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( yyin  )
#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#ifndef YY_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k.
 * Moreover, YY_BUF_SIZE is 2*YY_READ_BUF_SIZE in the general case.
 * Ditto for the __ia64__ case accordingly.
 */
#define YY_BUF_SIZE 32768
#else
#define YY_BUF_SIZE 16384
#endif /* __ia64__ */
#endif

/* The state buf must be large enough to hold one state per character in the main buffer.
 */
#define YY_STATE_BUF_SIZE   ((YY_BUF_SIZE + 2) * sizeof(yy_state_type))

#ifndef YY_TYPEDEF_YY_BUFFER_STATE
#define YY_TYPEDEF_YY_BUFFER_STATE
typedef struct yy_buffer_state *YY_BUFFER_STATE;
#endif

#ifndef YY_TYPEDEF_YY_SIZE_T
#define YY_TYPEDEF_YY_SIZE_T
typedef size_t yy_size_t;
#endif

extern int yyleng;

extern FILE *yyin, *yyout;

#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2
    
    #define YY_LESS_LINENO(n)
    #define YY_LINENO_REWIND_TO(ptr)
    
/* Return all but the first "n" matched characters back to the input stream. */
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		*yy_cp = (yy_hold_char); \
		YY_RESTORE_YY_MORE_OFFSET \
		(yy_c_buf_p) = yy_cp = yy_bp + yyless_macro_arg - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )
#define unput(c) yyunput( c, (yytext_ptr)  )

#ifndef YY_STRUCT_YY_BUFFER_STATE
#define YY_STRUCT_YY_BUFFER_STATE
struct yy_buffer_state
	{
	FILE *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	int yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	int yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether this is an "interactive" input source; if so, and
	 * if we're using stdio for input, then we want to use getc()
	 * instead of fread(), to make sure we stop fetching input after
	 * each newline.
	 */
	int yy_is_interactive;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

    int yy_bs_lineno; /**< The line count. */
    int yy_bs_column; /**< The column count. */

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;

#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2

	};
#endif /* !YY_STRUCT_YY_BUFFER_STATE */

/* Stack of input buffers. */
static size_t yy_buffer_stack_top = 0; /**< index of top of stack. */
static size_t yy_buffer_stack_max = 0; /**< capacity of stack. */
static YY_BUFFER_STATE * yy_buffer_stack = NULL; /**< Stack as an array. */

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 *
 * Returns the top of the stack, or NULL.
 */
#define YY_CURRENT_BUFFER ( (yy_buffer_stack) \
                          ? (yy_buffer_stack)[(yy_buffer_stack_top)] \
                          : NULL)
/* Same as previous macro, but useful when we know that the buffer stack is not
 * NULL or when we need an lvalue. For internal use only.
 */
#define YY_CURRENT_BUFFER_LVALUE (yy_buffer_stack)[(yy_buffer_stack_top)]

/* yy_hold_char holds the character lost when yytext is formed. */
static char yy_hold_char;
static int yy_n_chars;		/* number of characters read into yy_ch_buf */
int yyleng;

/* Points to current character in buffer. */
static char *yy_c_buf_p = NULL;
static int yy_init = 0;		/* whether we need to initialize */
static int yy_start = 0;	/* start state number */

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
static int yy_did_buffer_switch_on_eof;

void yyrestart ( FILE *input_file  );
void yy_switch_to_buffer ( YY_BUFFER_STATE new_buffer  );
YY_BUFFER_STATE yy_create_buffer ( FILE *file, int size  );
void yy_delete_buffer ( YY_BUFFER_STATE b  );
void yy_flush_buffer ( YY_BUFFER_STATE b  );
void yypush_buffer_state ( YY_BUFFER_STATE new_buffer  );
void yypop_buffer_state ( void );

static void yyensure_buffer_stack ( void );
static void yy_load_buffer_state ( void );
static void yy_init_buffer ( YY_BUFFER_STATE b, FILE *file  );
#define YY_FLUSH_BUFFER yy_flush_buffer( YY_CURRENT_BUFFER )

YY_BUFFER_STATE yy_scan_buffer ( char *base, yy_size_t size  );
YY_BUFFER_STATE yy_scan_string ( const char *yy_str  );
YY_BUFFER_STATE yy_scan_bytes ( const char *bytes, int len  );

void *yyalloc ( yy_size_t  );
void *yyrealloc ( void *, yy_size_t  );
void yyfree ( void *  );

#define yy_new_buffer yy_create_buffer
#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){ \
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_is_interactive = is_interactive; \
	}
#define yy_set_bol(at_bol) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){\
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_at_bol = at_bol; \
	}
#define YY_AT_BOL() (YY_CURRENT_BUFFER_LVALUE->yy_at_bol)

/* Begin user sect3 */

#define yywrap() (/*CONSTCOND*/1)
#define YY_SKIP_YYWRAP
typedef flex_uint8_t YY_CHAR;

FILE *yyin = NULL, *yyout = NULL;

typedef int yy_state_type;

extern int yylineno;
int yylineno = 1;

extern char *yytext;
#ifdef yytext_ptr
#undef yytext_ptr
#endif
#define yytext_ptr yytext

static yy_state_type yy_get_previous_state ( void );
static yy_state_type yy_try_NUL_trans ( yy_state_type current_state  );
static int yy_get_next_buffer ( void );
static void yynoreturn yy_fatal_error ( const char* msg  );

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	(yytext_ptr) = yy_bp; \
	yyleng = (int) (yy_cp - yy_bp); \
	(yy_hold_char) = *yy_cp; \
	*yy_cp = '\0'; \
	(yy_c_buf_p) = yy_cp;
#define YY_NUM_RULES 200
#define YY_END_OF_BUFFER 201
/* This struct is not used in this scanner,
   but its presence is necessary. */
struct yy_trans_info
	{
	flex_int32_t yy_verify;
	flex_int32_t yy_nxt;
	};
static const flex_int16_t yy_accept[1242] =
    {   0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
      182,  182,    0,    0,    0,    0,    0,    0,  201,  200,
      198,  185,  184,   29,  198,  186,  177,  198,   42,   41,
      198,   32,   25,   33,  177,  177,    4,    4,   43,   44,
      198,   38,   24,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  198,  123,  121,   40,  198,   39,   28,  185,  200,
      177,   42,   41,   25,  200,  177,  200,  177,  199,  185,
       29,  199,  186,  180,   35,   26,   42,   41,   31,   32,
       25,   33,  180,   34,    4,    4,    4,    4,   43,   44,

       36,   38,   24,   30,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,   37,
       40,   27,   39,   28,  138,   29,  137,  176,   35,   26,
       31,  176,   34,    4,    4,    4,    4,   44,   36,   38,
       24,   30,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,    6,    5,   37,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,   27,
       28,  182,   26,  182,  182,  182,  182,   38,  198,  182,
      182,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      182,  182,    6,    5,  182,  198,  193,  192,  187,  194,

      195,  191,  191,  191,  191,  196,  197,  185,    0,  183,
      186,  177,    4,   20,   18,   16,   17,    1,   19,    4,
        4,    0,    0,    0,  177,  177,  177,  177,  177,  128,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,   22,  177,  177,
       21,    0,  178,  177,   11,  180,    2,   23,   19,    0,
        4,    4,    4,    0,    3,    3,    3,    3,    3,   14,
       13,   10,   12,   15,  180,  180,  180,    3,  180,  180,

      128,  180,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,    9,  137,  137,  176,    2,
      139,   18,  140,  176,  176,    3,  176,  176,  176,    3,
      176,    3,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,    3,  176,    3,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  182,   18,
       16,   17,   19,  182,  128,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      182,   22,  192,  191,    0,  191,  191,  191,    4,    4,

        7,    8,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,   92,
      177,  177,  177,  177,  177,  177,  177,  177,   70,   61,
      177,   62,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  124,  122,  179,  178,  177,    4,    0,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,   61,   62,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
      180,    4,  176,  176,  176,  176,  176,  141,  176,  176,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  158,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  191,  191,  191,  177,   57,  177,
      177,  177,  177,   51,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,   67,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,    0,  180,   57,  180,  180,   51,

      180,  180,  115,  180,  180,  180,  180,  180,  116,  180,
      180,  180,   67,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  117,  176,  176,  176,  146,  154,
      145,  176,  176,  176,  156,  149,  152,  176,  176,  157,
      176,  176,  176,  176,  176,  163,  171,  162,  176,  176,
      174,  166,  169,  176,  176,  175,  176,  176,  182,  182,
       99,  182,  182,  182,   88,  182,  182,  182,  134,  182,
       97,  182,   95,  182,  182,  108,  182,  191,  191,  191,
      177,   86,   53,  177,  177,   50,  177,  177,  177,   65,
      177,   94,  177,   76,  177,  177,  177,   75,  177,  177,

      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      127,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,    0,  180,   53,  180,   50,  180,
      180,  180,  114,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,  176,
      147,  144,  176,  176,  176,  156,  156,  151,  176,  155,
      176,  176,  164,  161,  176,  176,  174,  174,  168,  176,
      173,  176,  100,  182,  182,  182,  182,  182,  182,  182,
      182,  182,  182,   98,  182,   96,  191,  191,  189,  177,
      177,  177,   64,   87,  177,  177,  177,   66,  177,  131,

      177,  177,   85,  177,   52,  177,  177,   45,  177,  177,
      177,   48,   74,  177,  177,  177,  177,  177,  177,   71,
      177,  177,  177,   93,   72,  177,  177,    0,  180,  180,
      180,   64,  180,  180,  180,  131,  180,   52,  180,  180,
      180,  112,  180,   48,  180,  180,  180,  180,   71,  180,
      180,  176,  176,   66,  153,  176,  150,  176,  176,  176,
      172,  170,  167,  176,   64,  182,  182,  182,  131,  182,
      182,  182,  182,  182,  182,  182,  190,  188,  177,   59,
      177,  177,  177,   78,  177,  177,  126,  177,  177,  177,
      177,  177,  102,  177,  177,  105,  132,  177,  177,  177,

      177,  177,  120,   89,  177,   49,  177,    0,  180,   59,
      180,  180,  180,   78,  126,  180,  180,  180,  180,  105,
      132,  180,  180,  180,  120,  180,  176,  176,  126,  176,
      176,  176,  176,  182,  182,  182,  126,  182,  182,  132,
      111,  182,  182,   60,  177,  136,  177,  177,  177,  177,
      177,   58,   63,  177,  177,  177,  177,  177,  177,  177,
       84,  177,  177,  130,  177,    0,   60,  180,  136,  180,
       58,   63,  180,  180,  180,  113,  180,  180,  130,  142,
      143,  148,  159,  160,  165,  182,  182,  182,  182,  182,
      182,  182,  182,  177,  177,  177,  177,  177,  177,  177,

      177,  177,  177,  177,  177,  177,  177,  177,   77,  181,
      180,  180,  180,  180,  180,  180,  180,  182,  182,  182,
      182,  182,  182,  182,  182,  182,  110,  177,  177,  177,
      177,  177,   47,  177,  118,  119,  177,  177,  177,  177,
       73,  177,  177,  180,  180,  180,  118,  119,  180,  180,
      180,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      177,  177,  177,  177,  177,  103,   91,  177,  177,  177,
      177,  177,  180,  180,  103,  180,  180,  180,  182,  182,
      182,  182,  182,  182,  182,  182,  182,  177,  177,  177,
      177,  177,  177,  177,  177,   46,  177,  177,  180,  180,

      180,  180,  180,  180,   80,  182,  135,  182,  182,  182,
      182,  182,  106,  177,  177,  177,  177,  177,  177,   90,
      177,   69,  177,  180,  180,  180,  180,   69,  180,  182,
      182,  182,  182,  182,  182,  177,  177,  177,  177,  177,
      177,  177,  104,  133,   68,  180,  180,  180,  180,  104,
      133,   68,  182,  182,  101,  133,  182,  182,  177,  177,
      177,  177,  177,  177,  177,  180,  180,  180,  180,  182,
      182,  182,  182,  129,  177,   56,  177,  177,  177,  177,
      129,  180,   56,  180,  182,  182,  182,  182,  177,  177,
      177,  177,  177,  180,  180,  182,  182,  107,  182,   54,

      177,  177,  177,  177,   54,  180,  182,  182,  182,  177,
      177,  177,  177,  180,  182,  125,  182,  177,  177,  177,
      177,  180,  182,  182,  177,  177,  177,  177,  180,   79,
      109,   55,  177,   82,  177,   55,   81,  177,  177,   83,
        0
    } ;

static const YY_CHAR yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    2,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    2,    4,    5,    6,    7,    8,    9,    1,   10,
       11,   12,   13,   14,   15,   16,   17,   18,   19,   20,
       21,   21,   21,   21,   21,   22,   22,   23,   24,   25,
       26,   27,   28,    1,   29,   30,   31,   32,   33,   34,
       35,   36,   37,   38,   39,   40,   41,   42,   43,   44,
       45,   46,   47,   48,   49,   50,   51,   52,   53,   54,
       55,   56,   57,   58,   59,    1,   60,   61,   62,   63,

       64,   65,   66,   67,   68,   16,   69,   70,   71,   72,
       73,   74,   16,   75,   76,   77,   78,   16,   16,   79,
       16,   16,   80,   81,   82,   83,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,

        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1
    } ;

static const YY_CHAR yy_meta[84] =
    {   0,
        1,    1,    2,    3,    1,    1,    4,    1,    1,    1,
        1,    3,    5,    6,    7,    8,    9,   10,   10,   10,
       10,   10,    7,    1,    1,    6,    1,    3,   11,   11,
       11,   11,   11,   11,    8,   12,    8,    8,    8,    8,
        8,    8,    8,    8,    8,    8,    8,    8,    8,    8,
        8,   12,    8,    8,    7,    4,    7,    3,    8,   11,
       11,   11,   11,   11,   11,    8,   12,    8,    8,    8,
        8,    8,    8,    8,    8,    8,    8,    8,   12,    1,
        1,    1,    9
    } ;

static const flex_int16_t yy_base[1266] =
    {   0,
        0,    0,    0,    0,   83,  165,  247,    0,  330,    0,
      413,    0,  115,  117,  496,    0,  579,  662, 2221, 2222,
     2222, 2218, 2222, 2222, 2214,    0,  728, 2192, 2222, 2222,
     2191, 2190, 2222, 2189,    0,   87,  684,  696, 2222, 2222,
     2189, 2222, 2186,   95,   91, 2169,   93,   94,   90, 2165,
      107, 2168,  116,  121,  112,  111,  116, 2176,  163, 2179,
     2174, 2180, 2141, 2129, 2222, 2177, 2222,    0, 2200, 2196,
        0, 2222, 2222, 2222, 2130, 2187,    0, 2151, 2222, 2195,
     2170, 2190,    0,  776, 2222,  130, 2222, 2222, 2168, 2167,
     2222, 2166,    0,  187,  824,  129,  590,  593, 2222, 2222,

       89, 2165,  175, 2222,  886,  194,  185,  586,  591, 2153,
     2147,  171,  169,  194,  193, 2142, 2154,  591, 2133, 2159,
     2222,  560, 2222, 2222, 2222, 2158, 2180,  948, 2222,  212,
     2156,    0, 2155,    0,  151,    0,    0,    0,  184, 2154,
      568, 2222,  996,  617,  661,  577,  668,  669, 2137,  607,
     2149, 2131, 2127,  196, 2129, 2222, 2222, 2148,  711,  592,
      744,  694,  681,  557, 2113, 2097, 2093,  141, 2095,  611,
        0,    0, 2143, 2142, 2141, 2140, 2139,    0, 2137,  606,
     2110,  612, 2110, 2124, 2123, 2117, 2125,  657, 2111, 2107,
     2122,  686,    0,    0, 2128, 2141, 2222,    0, 2222, 2222,

     2222, 2129,   93,   67,  604, 2222, 2222, 2149, 2145, 2222,
        0,    0, 1058, 2222, 2222, 2222, 2222, 2222,    0,  781,
     2222,    0, 2123, 2122, 2100, 2114, 2097, 2107, 2096,    0,
     2108, 2099, 2097, 2097, 2090, 2103, 2088, 2087, 2091, 2087,
     2089, 2099, 2090,  733, 2070, 2086,  678,  539, 2086, 2084,
     2073,  662, 2084, 2086, 2074, 2088, 2088, 2076, 2083,  747,
     2063, 2083, 2086, 2084, 2066, 2066, 2065, 2222, 2038, 2043,
     2222,    0,    0, 2049, 2222,    0, 1112, 2222, 2222, 2070,
      577,    0,    0,  704,  780,  782, 2222, 2222,    0, 2080,
     2222, 2222, 2222, 2079,  783,  832,  862,    0, 2067, 2056,

        0, 2060, 2058,  726,  881,  924, 2067, 2067,  696, 2056,
      704, 2045, 2054, 2043,  781, 2054, 2056, 2059, 2048, 2061,
     2054, 2034, 2054, 2056, 2041, 2222, 2081, 2222,    0, 1166,
        0,    0,    0,  745,  843,    0, 2046,  884,  895, 2045,
     2049, 2032, 2033, 2047, 2030, 2047, 2034, 2042, 2043, 2041,
     2042, 2021,  795, 2001,  897,  900, 2000, 2004, 1989, 1990,
     1988, 2003, 1991, 1998, 1999, 1997, 1998, 1979,    0,    0,
        0,    0,    0,  786,    0, 2008, 2013, 2021, 2022, 2012,
     2019,  783, 2017, 2007, 2006, 2004, 2017, 1995, 2001, 1997,
     1993,    0,    0, 2018, 2017,  801,  756,  764,    0,  827,

     2222, 2222, 1996, 1992, 2004, 2001, 2002, 1991, 2001, 2001,
     1984, 2001, 1992, 1982, 1994, 1997, 1994, 1975, 1991,    0,
     1982, 1984, 1971, 1986, 1984, 1982, 1984, 1995,    0,    0,
     1971,    0, 1965, 1966, 1971, 1957, 1974, 1964, 1961, 1960,
     1955, 1967, 1957, 1954, 1960, 1967, 1968, 1952, 1968, 1956,
     1960, 1947,    0,    0,    0,    0, 1951,    0, 1945, 1948,
      953, 1955, 1956, 1956, 1956, 1939, 1932, 1955,  957, 1952,
     1950, 1941, 1937, 1944, 1946, 1957,    0,    0, 1928, 1929,
     1931, 1920, 1937, 1925, 1920, 1937, 1927, 1934, 1935, 1936,
     1931,    0, 1920,  840, 1929, 1928, 1916,    0, 1926, 1917,

     1917, 1908, 1923, 1921, 1920, 1912, 1903, 1904, 1907, 1875,
      879, 1883, 1882, 1871,    0, 1880, 1872, 1865, 1878, 1876,
     1875, 1868, 1860, 1861, 1863, 1897, 1900, 1899, 1884, 1901,
     1889, 1888, 1895, 1886, 1876, 1880, 1884, 1887, 1871, 1888,
     1886, 1872, 1869, 1887,  655,  587,  876, 1875,    0, 1868,
     1871, 1866, 1865,    0, 1871, 1861, 1849, 1865, 1853, 1859,
     1856, 1870, 1858, 1868, 1851, 1869, 1850, 1851, 1863, 1847,
     1865, 1862, 1846,    0, 1848, 1847, 1830, 1851, 1838, 1846,
     1838, 1847, 1840, 1851, 1844, 1847, 1836, 1841, 1829, 1836,
     1838, 1841, 1836, 1839, 1840, 1830,    0, 1827, 1822,    0,

     1828, 1818,    0, 1806, 1822, 1815, 1829, 1812,    0, 1812,
     1830, 1827,    0, 1814, 1827, 1796, 1817, 1813, 1815, 1808,
     1817, 1806, 1811, 1807,    0, 1806, 1798, 1802,    0,    0,
        0, 1797, 1813, 1792, 1237,    0,    0, 1794, 1802,    0,
     1790, 1806, 1766, 1759, 1762,    0,    0,    0, 1758, 1772,
     1319,    0,    0, 1756, 1762,    0, 1752, 1766, 1773, 1780,
        0, 1777, 1776, 1774,    0, 1789, 1772, 1772,    0, 1786,
        0, 1781,    0, 1771, 1768, 1756, 1782,  825,  900,  889,
     1764,    0,  898, 1764, 1778,    0, 1781, 1762, 1775,    0,
     1765,    0, 1747,    0, 1753, 1751, 1734,    0, 1711, 1702,

     1692, 1695, 1688, 1646, 1640, 1650, 1622, 1616, 1609, 1624,
        0, 1618, 1607, 1612, 1584, 1520, 1527, 1531, 1510, 1521,
     1527, 1508, 1512, 1521, 1524, 1503,  931, 1503,    0, 1521,
     1502, 1515,    0, 1505, 1514, 1509, 1512, 1510, 1495, 1508,
     1502, 1496, 1508, 1504, 1493, 1492, 1499, 1503, 1494, 1481,
        0, 1488, 1486, 1479, 1494,    0, 1401,    0, 1494,    0,
     1495, 1445,    0, 1451, 1449, 1443,    0, 1483,    0, 1457,
        0, 1458,    0, 1469, 1470, 1482, 1482, 1471, 1480, 1447,
     1459, 1472, 1456,    0,  840,    0,  805,  921, 1479, 1453,
     1466, 1448,    0,    0, 1456, 1463, 1458,    0,  205,    0,

     1453, 1432,    0, 1431,    0,  119,  637,    0,  648,  690,
      718,    0,  727,  766,  818,  815,  822,  859,  884,  884,
      912,  911,  926,    0,    0,  920,  931,  929,  936,  952,
      937,    0,  950,  962,  964,    0,  965,    0,  970,  966,
      959,    0,  973,    0,  966,  987,  981,  974,  964,  984,
      996,  985,  991,    0,    0, 1002,    0,  989,  961,  966,
        0,    0,    0,  963,    0,  992,  983, 1010,    0, 1011,
      998,  987, 1014, 1016,  997, 1008, 1029, 1030, 1021,    0,
     1018, 1014, 1029,    0, 1022, 1020,    0, 1008, 1019, 1023,
     1030, 1025,    0, 1013, 1052,    0, 1014, 1045, 1050, 1036,

     1025, 1049,    0,    0, 1051,    0, 1061, 1063, 1063,    0,
     1061, 1052, 1066,    0,    0, 1056, 1063, 1058, 1046,    0,
     1047, 1054, 1049, 1073,    0, 1068, 1078, 1080,    0, 1080,
     1050, 1052, 1052, 1086, 1081, 1066,    0, 1093, 1078, 1076,
        0, 1077, 1095,    0, 1090,    0, 1098, 1099, 1104, 1117,
     1103,    0,    0, 1117, 1106, 1108, 1112, 1120, 1117, 1121,
        0, 1112, 1127,    0, 1129, 1145,    0, 1115,    0, 1123,
        0,    0, 1132, 1120, 1131,    0, 1121, 1136,    0,    0,
        0,    0,    0,    0,    0, 1122, 1141, 1144, 1148, 1147,
     1146, 1164, 1156, 1154, 1158, 1151, 1145, 1159, 1170, 1170,

     1165, 1178, 1164, 1174, 1175, 1167, 1166, 1186,    0, 2222,
     1181, 1185, 1185, 1181, 1183, 1173, 1193, 1180, 1187, 1196,
     1186, 1190, 1203, 1204, 1208, 1223,    0, 1194, 1212, 1212,
     1212, 1216,    0, 1211,    0,    0, 1223, 1219, 1234, 1238,
        0, 1239, 1237, 1211, 1229, 1225,    0,    0, 1241, 1245,
     1243, 1230, 1244, 1238, 1242, 1233, 1249, 1245, 1246, 1243,
     1248, 1238, 1245, 1229, 1248, 1231,    0, 1262, 1260, 1246,
     1248, 1263, 1260, 1250, 1240, 1268, 1255, 1269, 1256, 1273,
     1272, 1263, 1270, 1276, 1274, 1262, 1278, 1270, 1254, 1255,
     1286, 1273, 1274, 1278, 1299,    0, 1286, 1289, 1294, 1278,

     1290, 1306, 1292, 1295,    0, 1294,    0, 1306, 1306, 1317,
     1309, 1293,    0, 1309, 1325, 1326, 1316, 1315, 1316,    0,
     1318,    0, 1314, 1318, 1334, 1321, 1323,    0, 1319, 1309,
     1310, 1328, 1330, 1332, 1330, 1326, 1336, 1336, 1346, 1341,
     1342, 1324,    0,    0,    0, 1335, 1345, 1344, 1354,    0,
        0,    0, 1341, 1355,    0,    0, 1357, 1345, 1344, 1356,
     1362, 1355, 1356, 1354, 1369, 1356, 1371, 1382, 1376, 1364,
     1378, 1377, 1383,    0, 1386,    0, 1376, 1380, 1393, 1390,
        0, 1396,    0, 1386, 1392, 1405, 1387, 1393, 1395, 1395,
     1408, 1411, 1401, 1400, 1400, 1414, 1410,    0, 1400,    0,

     1388, 1419, 1401, 1407,    0, 1392, 1409, 1406, 1417, 1422,
     1408, 1420, 1427, 1427, 1421,    0, 1414, 1421, 1427, 1422,
     1437, 1425, 1421, 1416, 1438, 1428, 1430, 1425, 1442,    0,
        0,    0, 1433,    0, 1439,    0,    0, 1434, 1436,    0,
     2222, 1565, 1577, 1589, 1601, 1613, 1625, 1634, 1643, 1652,
     1664, 1673, 1685, 1697, 1707, 1712, 1722, 1725, 1733, 1742,
     1745, 1757, 1769, 1781, 1793
    } ;

static const flex_int16_t yy_def[1266] =
    {   0,
     1242, 1242, 1241,    3, 1243, 1243, 1241,    7, 1241,    9,
     1241,   11, 1244, 1244, 1241,   15, 1245, 1245, 1241, 1241,
     1241, 1241, 1241, 1241, 1246, 1247, 1248, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1248, 1248, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1241, 1248, 1248, 1241, 1241, 1241, 1248, 1241, 1246,
     1248, 1241, 1241, 1241, 1241, 1248, 1249, 1248, 1241, 1241,
     1241, 1246, 1247, 1250, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1250, 1241, 1241,   95,   95,   97, 1241, 1241,

     1241, 1241, 1241, 1241, 1250,  105,  105,  105,  105, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1251, 1252, 1241, 1241,
     1253, 1252, 1252,   95,   95,   97,   98, 1254, 1241, 1241,
     1241, 1241, 1252,  143,  143,  143,  143,  143, 1252, 1252,
     1252, 1252, 1252, 1252, 1252, 1241, 1241, 1241,  143,  143,
      143,  143,  143, 1252, 1252, 1252, 1252, 1252, 1252, 1241,
     1252, 1255, 1241, 1255, 1255, 1255, 1255, 1255, 1241, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1241, 1241, 1256, 1241, 1241,

     1241, 1257, 1257, 1257, 1257, 1241, 1241, 1241, 1246, 1241,
     1247, 1248, 1248, 1241, 1241, 1241, 1241, 1241, 1248, 1241,
     1241, 1258, 1241, 1241, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1241, 1248, 1248,
     1241, 1259, 1260, 1248, 1241, 1250, 1250, 1241, 1241, 1241,
       95,   97,   98, 1261, 1261, 1261, 1241, 1241, 1258, 1241,
     1241, 1241, 1241, 1241,  105,  105,  105, 1250, 1250, 1250,

     1250, 1250, 1250, 1250,  105,  105, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1241, 1251, 1241, 1252, 1252,
     1253, 1253, 1254,  143,  143, 1252, 1252,  143,  143, 1252,
     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1252, 1252,  143, 1252,  143,  143, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1256, 1257, 1241, 1257, 1257, 1257, 1248, 1258,

     1241, 1241, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1259, 1260, 1248, 1250, 1241, 1250,
      105, 1250, 1250, 1250, 1250, 1250, 1250, 1250,  105, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,

     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1252, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1257, 1257, 1257, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1241, 1250, 1250, 1250, 1250, 1250,

     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1252, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1262, 1252, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1263, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1257, 1257, 1257,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,

     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1241, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1252,
     1252, 1252, 1252, 1252, 1252, 1264, 1262, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1252, 1252, 1265, 1263, 1252, 1252,
     1252, 1252, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1257, 1257, 1257, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,

     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1241, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1252, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1257, 1257, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,

     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1241, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1252, 1252, 1252, 1252,
     1252, 1252, 1252, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1241, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1252,
     1252, 1252, 1252, 1252, 1252, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1248, 1248, 1248, 1248, 1248, 1248, 1248,

     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1241,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1250, 1250, 1250, 1250, 1250, 1250, 1255, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1250, 1250,

     1250, 1250, 1250, 1250, 1255, 1255, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1250, 1250, 1250, 1250, 1250, 1250, 1255,
     1255, 1255, 1255, 1255, 1255, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1255, 1255, 1255, 1255, 1255, 1255, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1250, 1250, 1250, 1250, 1255,
     1255, 1255, 1255, 1248, 1248, 1248, 1248, 1248, 1248, 1248,
     1250, 1250, 1250, 1250, 1255, 1255, 1255, 1255, 1248, 1248,
     1248, 1248, 1248, 1250, 1250, 1255, 1255, 1255, 1255, 1248,

     1248, 1248, 1248, 1248, 1250, 1250, 1255, 1255, 1255, 1248,
     1248, 1248, 1248, 1250, 1255, 1255, 1255, 1248, 1248, 1248,
     1248, 1250, 1255, 1255, 1248, 1248, 1248, 1248, 1250, 1255,
     1255, 1248, 1248, 1248, 1248, 1250, 1248, 1248, 1248, 1248,
        0, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241
    } ;

static const flex_int16_t yy_nxt[2306] =
    {   0,
       21,   22,   23,   24,   25,   26,   27,   21,   28,   29,
       30,   31,   32,   33,   34,   35,   36,   37,   38,   38,
       38,   38,   39,   40,   41,   42,   43,   21,   44,   45,
       46,   47,   48,   49,   50,   51,   52,   35,   35,   53,
       54,   55,   56,   57,   35,   58,   59,   60,   35,   61,
       35,   35,   35,   35,   21,   35,   21,   62,   35,   35,
       35,   35,   35,   35,   35,   35,   35,   35,   35,   63,
       35,   35,   64,   35,   35,   35,   35,   35,   35,   65,
       66,   67,   68,   20,   69,   23,   20,   70,   20,  395,
       20,   20,   72,   73,   20,   20,   74,   75,  218,   76,

       20,   20,   20,   20,   20,   20,   20,   20,   77,   20,
       20,   78,  219,  290,  291,  395,   22,   23,   22,   23,
       26,  235,   26,  231,  225,  236,  226,  232,  227,  239,
      233,  196,  240,  196,  228,  237,  397,   20,  278,   20,
       20,  229,  230,  242,  251,  238,  243,  245,  246,  248,
      890,  257,  253,  249,  252,  214,  254,  250,  247,  255,
      256,  258,   20,   20,   20,   20,   69,   23,   20,   70,
       20,  396,   20,   20,   72,   73,   20,   20,   74,   75,
      287,   76,   20,   20,   20,   20,   20,   20,   20,   20,
       77,   20,   20,   78,  197,  260,  197,  312,  218,  261,

      293,  294,  287,  310,  366,  313,  262,  287,  290,  291,
      263,  264,  279,  311,  295,  265,  295,  367,  280,   20,
      278,   20,   20,  295,  276,  295,  314,  304,  350,  287,
      302,  276,  276,  303,  316,  885,  315,  214,  317,  886,
      276,  276,  318,  351,   20,   20,   20,   79,   80,   23,
       81,   82,   83,   84,   85,   86,   87,   88,   89,   90,
       91,   92,   93,   94,   95,   96,   97,   97,   98,   99,
      100,  101,  102,  103,  104,  105,  106,  107,  108,  109,
      109,   93,  110,  111,   93,   93,  112,  113,  114,  115,
      116,   93,  117,  118,  119,   93,   93,   93,   93,   93,

       93,   79,   93,   79,  120,   93,  109,  109,  109,  109,
      109,  109,   93,   93,   93,   93,   93,   93,   93,   93,
       93,   93,   93,   93,   93,   93,  121,  122,  123,  124,
       21,   22,  125,  126,   21,  127,  128,  129,  130,   29,
       30,  131,   32,   33,   34,  132,  133,  134,  135,  136,
      136,  137,   39,  138,  139,  140,  141,  142,  143,  144,
      145,  146,  147,  148,  132,  132,  149,  132,  132,  150,
      132,  151,  152,  153,  132,  132,  154,  155,  132,  132,
      132,  132,  132,  132,  156,  132,  157,  158,  132,  159,
      160,  161,  146,  162,  163,  132,  132,  132,  132,  164,

      132,  165,  166,  167,  132,  168,  169,  132,  132,   65,
      170,   67,  171,   21,   22,   23,  172,   25,   26,  172,
       21,  173,   29,   30,  174,  175,  172,  176,  172,  177,
      172,  172,  172,  172,  172,  172,   40,   41,  178,  179,
      172,  180,  181,  182,  172,  183,  184,  172,  185,  186,
      172,  187,  188,  172,  172,  172,  189,  190,  191,  192,
      172,  172,  172,  172,  172,  172,  172,  193,  172,  194,
      195,  172,  172,  172,  172,  172,  172,  172,  172,  172,
      172,  172,  172,  172,  172,  172,  172,  172,  172,  172,
      172,  172,   65,   66,   67,  172,   21,   22,   23,   21,

       21,   26,  198,   21,   21,   21,   21,   21,   21,  199,
       21,  198,  196,   21,   21,   21,   21,   21,  199,  199,
       21,   21,   21,   21,  198,  198,  198,  198,  198,  198,
      198,  198,  198,  198,  198,  198,  198,  198,  198,  198,
      198,  198,  198,  198,  198,  198,  198,  198,  198,  198,
       21,   21,   21,   21,  198,  198,  198,  198,  198,  198,
      198,  198,  198,  198,  198,  198,  198,  198,  198,  198,
      198,  198,  198,  198,  198,  200,   21,  201,   21,   21,
       22,   23,  429,   25,   26,  271,   21,   21,   21,   21,
      430,   21,  199,  293,  294,  196,   21,   21,   21,   21,

       21,  199,  199,   21,   21,   21,  334,  282,  282,  395,
      283,  283,  283,  283,  305,  295,  329,  295,  306,  284,
      295,  334,  295,  321,  361,  276,  395,  322,  287,  362,
      276,  329,  307,  276,  323, 1241,  271,  276,  276,  324,
      326,  287,  203,  345,  204,  338,  334,  679,  205,  346,
      284,  355,  374,  375,  377,  287,  329,  378,  206,   21,
      207,   21,   21,   22,   23, 1241,   25,   26,  287,   21,
       21,   21,   21,  891,   21,  199,  398,  395,  196,   21,
       21,   21,   21,   21,  199,  199,   21,   21,   21,  339,
      334,  326,  434,  384,  892,  435,  340,  334,  334,  385,

      329,  220,  220,  220,  220,  220,  427,  329,  329,  341,
      334,  343,  428,  220,  220,  220,  220,  220,  678,  342,
      329,  389,  221,  334,  221,  203,  472,  204,  390,  473,
      391,  205,  475,  329,  221,  222,  221,  893,  476,  287,
      334,  206,   21,  207,   21,  213,  213,  213,  213,  213,
      329,  894,  221,  360,  221,  287,  213,  213,  213,  213,
      213,  213,  222,  421,  221,  358,  221,  466,  422,  467,
      287,  353,  359,  334,  334,  443,  423,  444,  395,  424,
      354,  445,  287,  329,  329,  895,  395,  213,  213,  213,
      213,  213,  213,  277,  277,  277,  277,  277,  220,  220,

      220,  220,  220,  356,  277,  277,  277,  277,  277,  277,
      357,  480,  295,  534,  295,  287,  526,  287,  896,  221,
      481,  221,  276,  395,  334,  547,  535,  395,  546,  276,
      276,  287,  527,  287,  329,  277,  277,  277,  277,  277,
      277,  281,  281,  282,  282,  283,  287,  395,  287,  221,
      897,  221,  284,  285,  284,  286,  284,  284,  287,  287,
      287,  295,  221,  295,  221,  221,  288,  221,  627,  875,
      510,  276,  334,  898,  628,  289,  877,  545,  460,  276,
      899,  876,  329,  284,  285,  284,  286,  284,  284,  493,
      287,  295,  221,  461,  221,  221,  288,  221,  395,  787,

      900,  276,  289,  295,  295,  295,  295,  295,  276,  276,
      295,  395,  295,  334,  295,  296,  295,  297,  295,  295,
      276,  298,  395,  329,  334,  299,  334,  276,  468,  334,
      495,  901,  300,  301,  329,  680,  329,  298,  644,  329,
      791,  496,  902,  395,  645,  295,  295,  295,  295,  295,
      295,  903,  298,  295,  904,  295,  792,  469,  789,  788,
      905,  906,  907,  276,  298,  330,  330,  330,  330,  330,
      276,  276,  512,  830,  908,  513,  330,  330,  330,  330,
      330,  330,  295,  909,  295,  910,  295,  911,  295,  831,
      878,  912,  276,  605,  913,  914,  276,  915,  597,  276,

      276,  916,  917,  276,  276,  918,  919,  330,  330,  330,
      330,  330,  330,  334,  334,  334,  334,  334,  920,  921,
      922,  923,  924,  925,  334,  335,  334,  334,  334,  334,
      926,  336,  927,  928,  929,  337,  930,  931,  932,  933,
      934,  935,  936,  937,  938,  939,  940,  336,  941,  942,
      943,  395,  395,  944,  945,  334,  334,  334,  334,  334,
      334,  946,  336,  947,  948,  949,  950,  951,  952,  953,
      954,  955,  958,  959,  336,  213,  213,  213,  213,  213,
      956,  960,  961,  962,  963,  957,  213,  213,  213,  213,
      213,  213,  964,  965,  966,  967,  399,  968,  399,  969,

      970,  971,  972,  973,  974,  975,  976,  977,  978,  979,
      980,  981,  982,  983,  984,  985,  986,  213,  213,  213,
      213,  213,  213,  987,  988,  989,  399,  990,  399,  277,
      277,  277,  277,  277,  991,  992,  993,  994,  995,  996,
      277,  277,  277,  277,  277,  277,  997,  998,  999, 1000,
      458, 1001,  458, 1002, 1003, 1004, 1005, 1006, 1007, 1008,
     1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018,
     1019,  277,  277,  277,  277,  277,  277, 1020, 1021, 1022,
      458, 1023,  458,  330,  330,  330,  330,  330, 1027, 1028,
     1029, 1030, 1024, 1031,  330,  330,  330,  330,  330,  330,

     1025, 1032, 1033, 1034,  492, 1026,  492, 1035, 1037, 1038,
     1039, 1040, 1041, 1042, 1043, 1036, 1044, 1045, 1046, 1049,
     1050, 1051, 1052, 1047, 1053,  330,  330,  330,  330,  330,
      330, 1048, 1054, 1055,  492, 1056,  492,  756,  756, 1057,
      756,  756,  756, 1058,  756,  756,  756,  756,  756, 1059,
      756, 1060, 1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068,
      756,  756,  756,  756,  756, 1069, 1070, 1071, 1072, 1073,
     1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083,
     1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093,
     1094, 1095, 1096, 1097,  756, 1098, 1099, 1100, 1101, 1102,

     1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112,
     1113, 1114, 1115, 1116, 1117, 1118,  756,  756,  756,  767,
      767, 1119,  767,  767,  767, 1120,  767,  767,  767,  767,
      767, 1121,  767, 1122, 1123, 1124, 1125, 1126, 1127, 1128,
     1129, 1130,  767,  767,  767,  767,  767, 1131, 1132, 1133,
     1134, 1135, 1136, 1137, 1140, 1141, 1142, 1138, 1143, 1144,
     1145, 1146, 1147, 1150, 1151, 1152, 1148, 1153, 1154, 1155,
     1139, 1156, 1157, 1158, 1159, 1160,  767, 1161, 1162, 1149,
     1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172,
     1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180,  767,  767,

      767,  756,  756, 1181,  756,  756,  756, 1182,  756,  756,
      756,  756,  756, 1183,  756, 1184, 1185, 1186, 1187, 1188,
     1189, 1190, 1191, 1192,  756,  756,  756,  756,  756, 1193,
     1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203,
     1204, 1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213,
     1214, 1215, 1216, 1217, 1218, 1219, 1220, 1221,  756, 1222,
     1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232,
     1233, 1234, 1235, 1236, 1237, 1238, 1239, 1240,  889,  888,
      756,  756,  756,  767,  767,  887,  767,  767,  767,  884,
      767,  767,  767,  767,  767,  883,  767,  882,  881,  880,

      879,  395,  874,  873,  872,  871,  767,  767,  767,  767,
      767,  870,  869,  868,  867,  866,  865,  864,  863,  862,
      861,  860,  859,  858,  857,  856,  855,  854,  853,  852,
      851,  850,  849,  848,  847,  846,  845,  844,  843,  842,
      767,  841,  840,  839,  838,  837,  836,  835,  834,  833,
      832,  829,  828,  827,  826,  825,  824,  823,  822,  821,
      820,  819,  767,  767,  767,   20,   20,   20,   20,   20,
       20,   20,   20,   20,   20,   20,   20,   71,   71,   71,
       71,   71,   71,   71,   71,   71,   71,   71,   71,   21,
       21,   21,   21,   21,   21,   21,   21,   21,   21,   21,

       21,  202,  202,  202,  202,  202,  202,  202,  202,  202,
      202,  202,  202,  209,  209,  209,  209,  209,  209,  209,
      209,  209,  209,  209,  209,  211,  818,  211,  211,  211,
      211,  211,  211,  211,  211,  211,  211,  212,  212,  212,
      212,  212,  212,  212,  212,  212,  273,  817,  816,  815,
      273,  273,  814,  273,  273,  276,  813,  812,  811,  276,
      276,  276,  276,  276,  327,  327,  327,  327,  327,  327,
      327,  327,  327,  327,  327,  327,  329,  329,  810,  329,
      329,  329,  329,  329,  329,  331,  809,  331,  331,  331,
      331,  331,  331,  331,  331,  331,  331,  333,  808,  333,

      333,  333,  333,  333,  333,  333,  333,  333,  333,  369,
      369,  369,  369,  369,  369,  369,  369,  369,  369,  393,
      807,  393,  393,  393,  394,  394,  806,  805,  394,  394,
      804,  394,  394,  394,  400,  400,  455,  455,  455,  455,
      455,  455,  455,  455,  455,  456,  456,  456,  456,  456,
      456,  456,  456,  456,  284,  284,  284,  757,  803,  757,
      757,  757,  757,  757,  757,  757,  757,  757,  757,  768,
      802,  768,  768,  768,  768,  768,  768,  768,  768,  768,
      768,  756,  801,  756,  756,  756,  756,  756,  756,  756,
      756,  756,  756,  767,  800,  767,  767,  767,  767,  767,

      767,  767,  767,  767,  767,  799,  798,  797,  796,  795,
      794,  793,  790,  786,  785,  784,  783,  782,  781,  780,
      779,  778,  777,  776,  775,  774,  773,  772,  771,  770,
      769,  766,  765,  764,  763,  762,  761,  760,  759,  758,
      755,  754,  753,  752,  751,  750,  749,  748,  747,  746,
      745,  744,  743,  742,  741,  740,  739,  738,  737,  736,
      735,  734,  733,  732,  731,  730,  729,  728,  727,  726,
      725,  724,  723,  722,  721,  720,  719,  718,  717,  716,
      715,  714,  713,  712,  711,  710,  709,  708,  707,  706,
      705,  704,  703,  702,  701,  700,  699,  698,  697,  696,

      695,  694,  693,  692,  691,  690,  689,  688,  687,  686,
      685,  684,  683,  682,  681,  677,  676,  675,  674,  673,
      672,  671,  670,  669,  668,  667,  666,  665,  664,  663,
      662,  661,  660,  659,  658,  657,  656,  655,  654,  653,
      652,  651,  650,  649,  648,  647,  646,  643,  642,  641,
      640,  639,  638,  637,  636,  635,  634,  633,  632,  631,
      630,  629,  626,  625,  624,  623,  622,  621,  620,  619,
      618,  617,  616,  615,  614,  613,  612,  611,  610,  609,
      608,  607,  606,  604,  603,  602,  601,  600,  599,  598,
      596,  595,  594,  593,  592,  591,  590,  589,  588,  587,

      586,  585,  584,  583,  582,  581,  580,  579,  578,  577,
      576,  575,  574,  573,  572,  571,  570,  569,  568,  567,
      566,  565,  564,  563,  562,  561,  560,  559,  558,  557,
      556,  555,  554,  553,  552,  551,  550,  549,  548,  394,
      395,  544,  543,  542,  541,  540,  539,  538,  537,  536,
      533,  532,  531,  530,  529,  528,  525,  524,  523,  522,
      521,  520,  519,  518,  517,  516,  515,  514,  511,  509,
      508,  507,  506,  505,  504,  503,  502,  501,  500,  499,
      498,  497,  494,  328,  491,  490,  489,  488,  487,  486,
      485,  484,  483,  482,  479,  478,  477,  474,  471,  470,

      465,  464,  463,  462,  402,  401,  459,  457,  454,  453,
      452,  451,  450,  449,  448,  447,  446,  442,  441,  440,
      439,  438,  437,  436,  433,  432,  431,  426,  425,  420,
      419,  418,  417,  416,  415,  414,  413,  412,  411,  410,
      409,  408,  407,  406,  405,  404,  403,  402,  401,  210,
      208,  395,  218,  392,  388,  387,  386,  383,  382,  381,
      380,  379,  376,  224,  373,  372,  371,  370,  214,  368,
      365,  364,  363,  268,  352,  349,  348,  347,  344,  292,
      279,  332,  328,  275,  268,  325,  320,  319,  309,  308,
      292,  217,  216,  215,  210,  275,  208,  274,  218,  272,

      210,  208,  271,  270,  269,  268,  267,  266,  259,  244,
      241,  234,  224,  223,  217,  216,  215,  214,  210,  208,
     1241,   19, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,

     1241, 1241, 1241, 1241, 1241
    } ;

static const flex_int16_t yy_chk[2306] =
    {   0,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    5,    5,    5,    5,    5,    5,  204,
        5,    5,    5,    5,    5,    5,    5,    5,   36,    5,

        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,   36,  101,  101,  203,   13,   13,   14,   14,
       13,   47,   14,   45,   44,   47,   44,   45,   44,   49,
       45,   13,   49,   14,   44,   48,  204,    5,   86,    5,
        5,   44,   44,   51,   55,   48,   51,   53,   53,   54,
      806,   57,   56,   54,   55,   86,   56,   54,   53,   56,
       56,   57,    5,    5,    5,    6,    6,    6,    6,    6,
        6,  203,    6,    6,    6,    6,    6,    6,    6,    6,
       96,    6,    6,    6,    6,    6,    6,    6,    6,    6,
        6,    6,    6,    6,   13,   59,   14,  113,   94,   59,

      103,  103,  135,  112,  168,  113,   59,   96,  139,  139,
       59,   59,   94,  112,  107,   59,  107,  168,   94,    6,
      130,    6,    6,  106,  107,  106,  114,  107,  154,  135,
      106,  107,  107,  106,  115,  799,  114,  130,  115,  799,
      106,  106,  115,  154,    6,    6,    6,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,

        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,

        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   15,   15,   15,   15,

       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   17,
       17,   17,  248,   17,   17,  122,   17,   17,   17,   17,
      248,   17,   17,  141,  141,   17,   17,   17,   17,   17,

       17,   17,   17,   17,   17,   17,  146,   97,   97,  546,
       98,   98,   98,   98,  108,  108,  146,  108,  108,   97,
      109,  160,  109,  118,  164,  108,  205,  118,  281,  164,
      109,  160,  108,  108,  118,   98,  170,  109,  109,  118,
      122,   97,   17,  150,   17,  144,  144,  546,   17,  150,
       97,  160,  180,  180,  182,  281,  144,  182,   17,   17,
       17,   17,   18,   18,   18,   98,   18,   18,   97,   18,
       18,   18,   18,  807,   18,   18,  205,  545,   18,   18,
       18,   18,   18,   18,   18,   18,   18,   18,   18,  145,
      145,  170,  252,  188,  809,  252,  145,  147,  148,  188,

      145,   37,   37,   37,   37,   37,  247,  147,  148,  147,
      163,  148,  247,   38,   38,   38,   38,   38,  545,  147,
      163,  192,   37,  162,   37,   18,  309,   18,  192,  309,
      192,   18,  311,  162,   38,   37,   38,  810,  311,  284,
      159,   18,   18,   18,   18,   27,   27,   27,   27,   27,
      159,  811,   37,  163,   37,  284,   27,   27,   27,   27,
       27,   27,   37,  244,   38,  162,   38,  304,  244,  304,
      284,  159,  162,  161,  334,  260,  244,  260,  397,  244,
      159,  260,  284,  161,  334,  813,  398,   27,   27,   27,
       27,   27,   27,   84,   84,   84,   84,   84,  220,  220,

      220,  220,  220,  161,   84,   84,   84,   84,   84,   84,
      161,  315,  295,  382,  295,  285,  374,  286,  814,  220,
      315,  220,  295,  396,  353,  398,  382,  787,  397,  295,
      295,  285,  374,  286,  353,   84,   84,   84,   84,   84,
       84,   95,   95,   95,   95,   95,  285,  678,  286,  220,
      815,  220,   95,   95,   95,   95,   95,   95,  285,   95,
      286,  296,   95,  296,   95,  400,   95,  400,  494,  785,
      353,  296,  335,  816,  494,   95,  787,  396,  296,  296,
      817,  785,  335,   95,   95,   95,   95,   95,   95,  335,
       95,  297,   95,  297,   95,  400,   95,  400,  547,  678,

      818,  297,   95,  105,  105,  105,  105,  105,  297,  297,
      305,  680,  305,  338,  105,  105,  105,  105,  105,  105,
      305,  105,  679,  338,  339,  105,  355,  305,  305,  356,
      338,  819,  105,  105,  339,  547,  355,  105,  511,  356,
      683,  339,  820,  788,  511,  105,  105,  105,  105,  105,
      105,  821,  105,  306,  822,  306,  683,  306,  680,  679,
      823,  826,  827,  306,  105,  128,  128,  128,  128,  128,
      306,  306,  355,  727,  828,  356,  128,  128,  128,  128,
      128,  128,  461,  829,  461,  830,  469,  831,  469,  727,
      788,  833,  461,  469,  834,  835,  469,  837,  461,  461,

      461,  839,  840,  469,  469,  841,  843,  128,  128,  128,
      128,  128,  128,  143,  143,  143,  143,  143,  845,  846,
      847,  848,  849,  850,  143,  143,  143,  143,  143,  143,
      851,  143,  852,  853,  856,  143,  858,  859,  860,  864,
      866,  867,  868,  870,  871,  872,  873,  143,  874,  875,
      876,  877,  878,  879,  881,  143,  143,  143,  143,  143,
      143,  882,  143,  883,  885,  886,  888,  889,  890,  891,
      892,  894,  897,  898,  143,  213,  213,  213,  213,  213,
      895,  899,  900,  901,  902,  895,  213,  213,  213,  213,
      213,  213,  905,  907,  908,  909,  213,  911,  213,  912,

      913,  916,  917,  918,  919,  921,  922,  923,  924,  926,
      927,  928,  930,  931,  932,  933,  934,  213,  213,  213,
      213,  213,  213,  935,  936,  938,  213,  939,  213,  277,
      277,  277,  277,  277,  940,  942,  943,  945,  947,  948,
      277,  277,  277,  277,  277,  277,  949,  950,  951,  954,
      277,  955,  277,  956,  957,  958,  959,  960,  962,  963,
      965,  966,  968,  970,  973,  974,  975,  977,  978,  986,
      987,  277,  277,  277,  277,  277,  277,  988,  989,  990,
      277,  991,  277,  330,  330,  330,  330,  330,  993,  994,
      995,  996,  992,  997,  330,  330,  330,  330,  330,  330,

      992,  998,  999, 1000,  330,  992,  330, 1001, 1002, 1003,
     1004, 1005, 1006, 1007, 1008, 1001, 1011, 1012, 1013, 1015,
     1016, 1017, 1018, 1014, 1019,  330,  330,  330,  330,  330,
      330, 1014, 1020, 1021,  330, 1022,  330,  635,  635, 1023,
      635,  635,  635, 1024,  635,  635,  635,  635,  635, 1025,
      635, 1026, 1028, 1029, 1030, 1031, 1032, 1034, 1037, 1038,
      635,  635,  635,  635,  635, 1039, 1040, 1042, 1043, 1044,
     1045, 1046, 1049, 1050, 1051, 1052, 1053, 1054, 1055, 1056,
     1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 1065, 1066,
     1068, 1069, 1070, 1071,  635, 1072, 1073, 1074, 1075, 1076,

     1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086,
     1087, 1088, 1089, 1090, 1091, 1092,  635,  635,  635,  651,
      651, 1093,  651,  651,  651, 1094,  651,  651,  651,  651,
      651, 1095,  651, 1097, 1098, 1099, 1100, 1101, 1102, 1103,
     1104, 1106,  651,  651,  651,  651,  651, 1108, 1109, 1110,
     1111, 1112, 1114, 1115, 1116, 1117, 1118, 1115, 1119, 1121,
     1123, 1124, 1125, 1126, 1127, 1129, 1125, 1130, 1131, 1132,
     1115, 1133, 1134, 1135, 1136, 1137,  651, 1138, 1139, 1125,
     1140, 1141, 1142, 1146, 1147, 1148, 1149, 1153, 1154, 1157,
     1158, 1159, 1160, 1161, 1162, 1163, 1164, 1165,  651,  651,

      651,  757,  757, 1166,  757,  757,  757, 1167,  757,  757,
      757,  757,  757, 1168,  757, 1169, 1170, 1171, 1172, 1173,
     1175, 1177, 1178, 1179,  757,  757,  757,  757,  757, 1180,
     1182, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192,
     1193, 1194, 1195, 1196, 1197, 1199, 1201, 1202, 1203, 1204,
     1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213,  757, 1214,
     1215, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 1225,
     1226, 1227, 1228, 1229, 1233, 1235, 1238, 1239,  804,  802,
      757,  757,  757,  768,  768,  801,  768,  768,  768,  797,
      768,  768,  768,  768,  768,  796,  768,  795,  792,  791,

      790,  789,  783,  782,  781,  780,  768,  768,  768,  768,
      768,  779,  778,  777,  776,  775,  774,  772,  770,  766,
      765,  764,  762,  761,  759,  755,  754,  753,  752,  750,
      749,  748,  747,  746,  745,  744,  743,  742,  741,  740,
      768,  739,  738,  737,  736,  735,  734,  732,  731,  730,
      728,  726,  725,  724,  723,  722,  721,  720,  719,  718,
      717,  716,  768,  768,  768, 1242, 1242, 1242, 1242, 1242,
     1242, 1242, 1242, 1242, 1242, 1242, 1242, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1244,
     1244, 1244, 1244, 1244, 1244, 1244, 1244, 1244, 1244, 1244,

     1244, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1246, 1246, 1246, 1246, 1246, 1246, 1246,
     1246, 1246, 1246, 1246, 1246, 1247,  715, 1247, 1247, 1247,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1249,  714,  713,  712,
     1249, 1249,  710, 1249, 1249, 1250,  709,  708,  707, 1250,
     1250, 1250, 1250, 1250, 1251, 1251, 1251, 1251, 1251, 1251,
     1251, 1251, 1251, 1251, 1251, 1251, 1252, 1252,  706, 1252,
     1252, 1252, 1252, 1252, 1252, 1253,  705, 1253, 1253, 1253,
     1253, 1253, 1253, 1253, 1253, 1253, 1253, 1254,  704, 1254,

     1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254, 1255,
     1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1255, 1256,
      703, 1256, 1256, 1256, 1257, 1257,  702,  701, 1257, 1257,
      700, 1257, 1257, 1257, 1258, 1258, 1259, 1259, 1259, 1259,
     1259, 1259, 1259, 1259, 1259, 1260, 1260, 1260, 1260, 1260,
     1260, 1260, 1260, 1260, 1261, 1261, 1261, 1262,  699, 1262,
     1262, 1262, 1262, 1262, 1262, 1262, 1262, 1262, 1262, 1263,
      697, 1263, 1263, 1263, 1263, 1263, 1263, 1263, 1263, 1263,
     1263, 1264,  696, 1264, 1264, 1264, 1264, 1264, 1264, 1264,
     1264, 1264, 1264, 1265,  695, 1265, 1265, 1265, 1265, 1265,

     1265, 1265, 1265, 1265, 1265,  693,  691,  689,  688,  687,
      685,  684,  681,  677,  676,  675,  674,  672,  670,  668,
      667,  666,  664,  663,  662,  660,  659,  658,  657,  655,
      654,  650,  649,  645,  644,  643,  642,  641,  639,  638,
      634,  633,  632,  628,  627,  626,  624,  623,  622,  621,
      620,  619,  618,  617,  616,  615,  614,  612,  611,  610,
      608,  607,  606,  605,  604,  602,  601,  599,  598,  596,
      595,  594,  593,  592,  591,  590,  589,  588,  587,  586,
      585,  584,  583,  582,  581,  580,  579,  578,  577,  576,
      575,  573,  572,  571,  570,  569,  568,  567,  566,  565,

      564,  563,  562,  561,  560,  559,  558,  557,  556,  555,
      553,  552,  551,  550,  548,  544,  543,  542,  541,  540,
      539,  538,  537,  536,  535,  534,  533,  532,  531,  530,
      529,  528,  527,  526,  525,  524,  523,  522,  521,  520,
      519,  518,  517,  516,  514,  513,  512,  510,  509,  508,
      507,  506,  505,  504,  503,  502,  501,  500,  499,  497,
      496,  495,  493,  491,  490,  489,  488,  487,  486,  485,
      484,  483,  482,  481,  480,  479,  476,  475,  474,  473,
      472,  471,  470,  468,  467,  466,  465,  464,  463,  462,
      460,  459,  457,  452,  451,  450,  449,  448,  447,  446,

      445,  444,  443,  442,  441,  440,  439,  438,  437,  436,
      435,  434,  433,  431,  428,  427,  426,  425,  424,  423,
      422,  421,  419,  418,  417,  416,  415,  414,  413,  412,
      411,  410,  409,  408,  407,  406,  405,  404,  403,  395,
      394,  391,  390,  389,  388,  387,  386,  385,  384,  383,
      381,  380,  379,  378,  377,  376,  368,  367,  366,  365,
      364,  363,  362,  361,  360,  359,  358,  357,  354,  352,
      351,  350,  349,  348,  347,  346,  345,  344,  343,  342,
      341,  340,  337,  327,  325,  324,  323,  322,  321,  320,
      319,  318,  317,  316,  314,  313,  312,  310,  308,  307,

      303,  302,  300,  299,  294,  290,  280,  274,  270,  269,
      267,  266,  265,  264,  263,  262,  261,  259,  258,  257,
      256,  255,  254,  253,  251,  250,  249,  246,  245,  243,
      242,  241,  240,  239,  238,  237,  236,  235,  234,  233,
      232,  231,  229,  228,  227,  226,  225,  224,  223,  209,
      208,  202,  196,  195,  191,  190,  189,  187,  186,  185,
      184,  183,  181,  179,  177,  176,  175,  174,  173,  169,
      167,  166,  165,  158,  155,  153,  152,  151,  149,  140,
      133,  131,  127,  126,  120,  119,  117,  116,  111,  110,
      102,   92,   90,   89,   82,   81,   80,   78,   76,   75,

       70,   69,   66,   64,   63,   62,   61,   60,   58,   52,
       50,   46,   43,   41,   34,   32,   31,   28,   25,   22,
       19, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241,

     1241, 1241, 1241, 1241, 1241
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

extern int yy_flex_debug;
int yy_flex_debug = 0;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
#define yymore() yymore_used_but_not_detected
#define YY_MORE_ADJ 0
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#line 1 "ldlex.l"
#line 4 "ldlex.l"

/* Copyright (C) 1991-2026 Free Software Foundation, Inc.
   Written by Steve Chamberlain of Cygnus Support.

   This file is part of the GNU Binutils.

   This program is free software; you can redistribute it and/or modify
   it under the terms of the GNU General Public License as published by
   the Free Software Foundation; either version 3 of the License, or
   (at your option) any later version.

   This program is distributed in the hope that it will be useful,
   but WITHOUT ANY WARRANTY; without even the implied warranty of
   MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
   GNU General Public License for more details.

   You should have received a copy of the GNU General Public License
   along with this program; if not, write to the Free Software
   Foundation, Inc., 51 Franklin Street - Fifth Floor, Boston,
   MA 02110-1301, USA.  */

#include "bfd.h"
#include "safe-ctype.h"
#include "bfdlink.h"
#include "ctf-api.h"
#include "ld.h"
#include "ldmisc.h"
#include "ldexp.h"
#include "ldlang.h"
#include <ldgram.h>
#include "ldfile.h"
#include "ldlex.h"
#include "ldmain.h"
#include "libiberty.h"

/* The type of top-level parser input.
   yylex and yyparse (indirectly) both check this.  */
input_type parser_input;

/* Line number in the current input file.  */
unsigned int lineno;

/* The string we are currently lexing, or NULL if we are reading a
   file.  */
const char *lex_string = NULL;

/* Support for flex reading from more than one input file (stream).
   `include_stack' is flex's input state for each open file;
   `file_name_stack' is the file names.  `lineno_stack' is the current
   line numbers.

   If `include_stack_ptr' is 0, we haven't started reading anything yet.
   Otherwise, stack elements 0 through `include_stack_ptr - 1' are valid.  */

#undef YY_INPUT
#define YY_INPUT(buf,result,max_size) result = yy_input (buf, max_size)

#ifndef YY_NO_UNPUT
#define YY_NO_UNPUT
#endif

#define MAX_INCLUDE_DEPTH 10
static YY_BUFFER_STATE include_stack[MAX_INCLUDE_DEPTH];
static const char *file_name_stack[MAX_INCLUDE_DEPTH];
static unsigned int lineno_stack[MAX_INCLUDE_DEPTH];
static unsigned int sysrooted_stack[MAX_INCLUDE_DEPTH];
static unsigned int include_stack_ptr = 0;
static int vers_node_nesting = 0;

static int yy_input (char *, int);
static void comment (void);
static void lex_warn_invalid (char *where, char *what);

/* STATES
	EXPRESSION	in an expression
	SCRIPT		in a script
	INPUTLIST	in a script, a filename-list
	MRI		in an MRI script
	WILD		inside the braces of an output section or overlay,
			for input section wildcards
	VERS_START	starting a Sun style mapfile
	VERS_SCRIPT	a Sun style mapfile
	VERS_NODE	a node within a Sun style mapfile
*/
#define RTOKEN(x)  {  yylval.token = x; return x; }

#line 1456 "ldlex.c"

#line 1458 "ldlex.c"

#define INITIAL 0
#define SCRIPT 1
#define INPUTLIST 2
#define EXPRESSION 3
#define MRI 4
#define WILD 5
#define VERS_START 6
#define VERS_SCRIPT 7
#define VERS_NODE 8

#ifndef YY_NO_UNISTD_H
/* Special case for "unistd.h", since it is non-ANSI. We include it way
 * down here because we want the user's section 1 to have been scanned first.
 * The user has a chance to override it with an option.
 */
#include <unistd.h>
#endif

#ifndef YY_EXTRA_TYPE
#define YY_EXTRA_TYPE void *
#endif

static int yy_init_globals ( void );

/* Accessor methods to globals.
   These are made visible to non-reentrant scanners for convenience. */

int yylex_destroy ( void );

int yyget_debug ( void );

void yyset_debug ( int debug_flag  );

YY_EXTRA_TYPE yyget_extra ( void );

void yyset_extra ( YY_EXTRA_TYPE user_defined  );

FILE *yyget_in ( void );

void yyset_in  ( FILE * _in_str  );

FILE *yyget_out ( void );

void yyset_out  ( FILE * _out_str  );

			int yyget_leng ( void );

char *yyget_text ( void );

int yyget_lineno ( void );

void yyset_lineno ( int _line_number  );

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap ( void );
#else
extern int yywrap ( void );
#endif
#endif

#ifndef YY_NO_UNPUT
    
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy ( char *, const char *, int );
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen ( const char * );
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int yyinput ( void );
#else
static int input ( void );
#endif

#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k */
#define YY_READ_BUF_SIZE 16384
#else
#define YY_READ_BUF_SIZE 8192
#endif /* __ia64__ */
#endif

/* Copy whatever the last rule matched to the standard output. */
#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO do { if (fwrite( yytext, (size_t) yyleng, 1, yyout )) {} } while (0)
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( YY_CURRENT_BUFFER_LVALUE->yy_is_interactive ) \
		{ \
		int c = '*'; \
		int n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else \
		{ \
		errno=0; \
		while ( (result = (int) fread(buf, 1, (yy_size_t) max_size, yyin)) == 0 && ferror(yyin)) \
			{ \
			if( errno != EINTR) \
				{ \
				YY_FATAL_ERROR( "input in flex scanner failed" ); \
				break; \
				} \
			errno=0; \
			clearerr(yyin); \
			} \
		}\
\

#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif

/* end tables serialization structures and prototypes */

/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL_IS_OURS 1

extern int yylex (void);

#define YY_DECL int yylex (void)
#endif /* !YY_DECL */

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK /*LINTED*/break;
#endif

#define YY_RULE_SETUP \
	YY_USER_ACTION

/** The main scanner function which does all the work.
 */
YY_DECL
{
	yy_state_type yy_current_state;
	char *yy_cp, *yy_bp;
	int yy_act;
    
	if ( !(yy_init) )
		{
		(yy_init) = 1;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! (yy_start) )
			(yy_start) = 1;	/* first start state */

		if ( ! yyin )
			yyin = stdin;

		if ( ! yyout )
			yyout = stdout;

		if ( ! YY_CURRENT_BUFFER ) {
			yyensure_buffer_stack ();
			YY_CURRENT_BUFFER_LVALUE =
				yy_create_buffer( yyin, YY_BUF_SIZE );
		}

		yy_load_buffer_state(  );
		}

	{
#line 114 "ldlex.l"


#line 117 "ldlex.l"
  if (parser_input != input_selected)
    {
      /* The first token of the input determines the initial parser state.  */
      input_type t = parser_input;
      parser_input = input_selected;
      switch (t)
	{
	case input_script: return INPUT_SCRIPT;
	case input_mri_script: return INPUT_MRI_SCRIPT;
	case input_version_script: return INPUT_VERSION_SCRIPT;
	case input_section_ordering_script: return INPUT_SECTION_ORDERING_SCRIPT;
	case input_dynamic_list: return INPUT_DYNAMIC_LIST;
	case input_defsym: return INPUT_DEFSYM;
	default: abort ();
	}
    }

#line 1702 "ldlex.c"

	while ( /*CONSTCOND*/1 )		/* loops until end-of-file is reached */
		{
		yy_cp = (yy_c_buf_p);

		/* Support of yytext. */
		*yy_cp = (yy_hold_char);

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = (yy_start);
yy_match:
		do
			{
			YY_CHAR yy_c = yy_ec[YY_SC_TO_UI(*yy_cp)] ;
			if ( yy_accept[yy_current_state] )
				{
				(yy_last_accepting_state) = yy_current_state;
				(yy_last_accepting_cpos) = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 1242 )
					yy_c = yy_meta[yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 2222 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;

do_action:	/* This label is used only to access EOF actions. */

		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = (yy_hold_char);
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			goto yy_find_action;

case 1:
YY_RULE_SETUP
#line 134 "ldlex.l"
{
				comment (); }
	YY_BREAK
case 2:
YY_RULE_SETUP
#line 137 "ldlex.l"
{
				yylval.integer = strtoull (yytext + 1, 0, 16);
				yylval.bigint.str = NULL;
				return INT;
			}
	YY_BREAK
case 3:
YY_RULE_SETUP
#line 143 "ldlex.l"
{
				   int ibase ;
				   switch (yytext[yyleng - 1]) {
				    case 'X':
				    case 'x':
				    case 'H':
				    case 'h':
				     ibase = 16;
				     break;
				    case 'O':
				    case 'o':
				     ibase = 8;
				     break;
				    case 'B':
				    case 'b':
				     ibase = 2;
				     break;
				    default:
				     ibase = 10;
				   }
				   yylval.integer = strtoull (yytext, 0, ibase);
				   yylval.bigint.str = NULL;
				   return INT;
				 }
	YY_BREAK
case 4:
YY_RULE_SETUP
#line 167 "ldlex.l"
{
				  char *s = yytext;
				  int ibase = 0;

				  if (*s == '$')
				    {
				      ++s;
				      ibase = 16;
				    }
				  yylval.integer = strtoull (s, 0, ibase);
				  yylval.bigint.str = NULL;
				  if (yytext[yyleng - 1] == 'M'
				      || yytext[yyleng - 1] == 'm')
				    {
				      yylval.integer *= 1024 * 1024;
				    }
				  else if (yytext[yyleng - 1] == 'K'
				      || yytext[yyleng - 1]=='k')
				    {
				      yylval.integer *= 1024;
				    }
				  else if (yytext[0] == '0'
					   && (yytext[1] == 'x'
					       || yytext[1] == 'X'))
				    {
				      yylval.bigint.str
					= stat_strdup (yytext + 2);
				    }
				  return INT;
				}
	YY_BREAK
/* Some tokens that only appear in expressions must be enabled for
     states other than EXPRESSION, since parser lookahead means they
     must be recognised before the parser switches the lexer out of
     SCRIPT or WILD state into EXPRESSION state.

     This sort of thing happens for example with NAME in ldgram.y
     "section" rule, which is immediately followed by ldlex_expression.
     However, if you follow the grammar from "sec_or_group_p1" you see
     "assignment" appearing in "statement_anywhere".  Now,
     "assignment" also has NAME as its first token, just like
     "section".  So the parser can't know whether it is in the
     "section" or the "assignment" rule until it has scanned the next
     token to find an assignment operator.  Thus the next token after
     NAME in the "section" rule may be lexed before the lexer is
     switched to EXPRESSION state, and there are quite a number of
     optional components.  The first token in all those components
     must be able to be lexed in SCRIPT state, as well as the
     assignment operators.  In fact, due to "opt_exp_with_type",
     anything that can appear on the left hand side of "exp" might
     need to be lexed in SCRIPT state.

     MRI mode tends to cover everything in MRI scripts.
  */
case 5:
YY_RULE_SETUP
#line 221 "ldlex.l"
{ RTOKEN(']'); }
	YY_BREAK
case 6:
YY_RULE_SETUP
#line 222 "ldlex.l"
{ RTOKEN('['); }
	YY_BREAK
case 7:
YY_RULE_SETUP
#line 223 "ldlex.l"
{ RTOKEN(LSHIFTEQ); }
	YY_BREAK
case 8:
YY_RULE_SETUP
#line 224 "ldlex.l"
{ RTOKEN(RSHIFTEQ); }
	YY_BREAK
case 9:
YY_RULE_SETUP
#line 225 "ldlex.l"
{ RTOKEN(OROR); }
	YY_BREAK
case 10:
YY_RULE_SETUP
#line 226 "ldlex.l"
{ RTOKEN(EQ); }
	YY_BREAK
case 11:
YY_RULE_SETUP
#line 227 "ldlex.l"
{ RTOKEN(NE); }
	YY_BREAK
case 12:
YY_RULE_SETUP
#line 228 "ldlex.l"
{ RTOKEN(GE); }
	YY_BREAK
case 13:
YY_RULE_SETUP
#line 229 "ldlex.l"
{ RTOKEN(LE); }
	YY_BREAK
case 14:
YY_RULE_SETUP
#line 230 "ldlex.l"
{ RTOKEN(LSHIFT); }
	YY_BREAK
case 15:
YY_RULE_SETUP
#line 231 "ldlex.l"
{ RTOKEN(RSHIFT); }
	YY_BREAK
case 16:
YY_RULE_SETUP
#line 232 "ldlex.l"
{ RTOKEN(PLUSEQ); }
	YY_BREAK
case 17:
YY_RULE_SETUP
#line 233 "ldlex.l"
{ RTOKEN(MINUSEQ); }
	YY_BREAK
case 18:
YY_RULE_SETUP
#line 234 "ldlex.l"
{ RTOKEN(MULTEQ); }
	YY_BREAK
case 19:
YY_RULE_SETUP
#line 235 "ldlex.l"
{ RTOKEN(DIVEQ); }
	YY_BREAK
case 20:
YY_RULE_SETUP
#line 236 "ldlex.l"
{ RTOKEN(ANDEQ); }
	YY_BREAK
case 21:
YY_RULE_SETUP
#line 237 "ldlex.l"
{ RTOKEN(OREQ); }
	YY_BREAK
case 22:
YY_RULE_SETUP
#line 238 "ldlex.l"
{ RTOKEN(XOREQ); }
	YY_BREAK
case 23:
YY_RULE_SETUP
#line 239 "ldlex.l"
{ RTOKEN(ANDAND); }
	YY_BREAK
case 24:
YY_RULE_SETUP
#line 240 "ldlex.l"
{ RTOKEN('>'); }
	YY_BREAK
case 25:
YY_RULE_SETUP
#line 241 "ldlex.l"
{ RTOKEN(','); }
	YY_BREAK
case 26:
YY_RULE_SETUP
#line 242 "ldlex.l"
{ RTOKEN('&'); }
	YY_BREAK
case 27:
YY_RULE_SETUP
#line 243 "ldlex.l"
{ RTOKEN('|'); }
	YY_BREAK
case 28:
YY_RULE_SETUP
#line 244 "ldlex.l"
{ RTOKEN('~'); }
	YY_BREAK
case 29:
YY_RULE_SETUP
#line 245 "ldlex.l"
{ RTOKEN('!'); }
	YY_BREAK
case 30:
YY_RULE_SETUP
#line 246 "ldlex.l"
{ RTOKEN('?'); }
	YY_BREAK
case 31:
YY_RULE_SETUP
#line 247 "ldlex.l"
{ RTOKEN('*'); }
	YY_BREAK
case 32:
YY_RULE_SETUP
#line 248 "ldlex.l"
{ RTOKEN('+'); }
	YY_BREAK
case 33:
YY_RULE_SETUP
#line 249 "ldlex.l"
{ RTOKEN('-'); }
	YY_BREAK
case 34:
YY_RULE_SETUP
#line 250 "ldlex.l"
{ RTOKEN('/'); }
	YY_BREAK
case 35:
YY_RULE_SETUP
#line 251 "ldlex.l"
{ RTOKEN('%'); }
	YY_BREAK
case 36:
YY_RULE_SETUP
#line 252 "ldlex.l"
{ RTOKEN('<'); }
	YY_BREAK
case 37:
YY_RULE_SETUP
#line 253 "ldlex.l"
{ RTOKEN('^'); }
	YY_BREAK
case 38:
YY_RULE_SETUP
#line 254 "ldlex.l"
{ RTOKEN('='); }
	YY_BREAK
case 39:
YY_RULE_SETUP
#line 255 "ldlex.l"
{ RTOKEN('}'); }
	YY_BREAK
case 40:
YY_RULE_SETUP
#line 256 "ldlex.l"
{ RTOKEN('{'); }
	YY_BREAK
case 41:
YY_RULE_SETUP
#line 257 "ldlex.l"
{ RTOKEN(')'); }
	YY_BREAK
case 42:
YY_RULE_SETUP
#line 258 "ldlex.l"
{ RTOKEN('('); }
	YY_BREAK
case 43:
YY_RULE_SETUP
#line 259 "ldlex.l"
{ RTOKEN(':'); }
	YY_BREAK
case 44:
YY_RULE_SETUP
#line 260 "ldlex.l"
{ RTOKEN(';'); }
	YY_BREAK
case 45:
YY_RULE_SETUP
#line 261 "ldlex.l"
{ RTOKEN(MEMORY); }
	YY_BREAK
case 46:
YY_RULE_SETUP
#line 262 "ldlex.l"
{ RTOKEN(REGION_ALIAS); }
	YY_BREAK
case 47:
YY_RULE_SETUP
#line 263 "ldlex.l"
{ RTOKEN(LD_FEATURE); }
	YY_BREAK
case 48:
YY_RULE_SETUP
#line 264 "ldlex.l"
{ RTOKEN(ORIGIN); }
	YY_BREAK
case 49:
YY_RULE_SETUP
#line 265 "ldlex.l"
{ RTOKEN(VERSIONK); }
	YY_BREAK
case 50:
YY_RULE_SETUP
#line 266 "ldlex.l"
{ RTOKEN(BLOCK); }
	YY_BREAK
case 51:
YY_RULE_SETUP
#line 267 "ldlex.l"
{ RTOKEN(BIND); }
	YY_BREAK
case 52:
YY_RULE_SETUP
#line 268 "ldlex.l"
{ RTOKEN(LENGTH); }
	YY_BREAK
case 53:
YY_RULE_SETUP
#line 269 "ldlex.l"
{ RTOKEN(ALIGN_K); }
	YY_BREAK
case 54:
YY_RULE_SETUP
#line 270 "ldlex.l"
{ RTOKEN(DATA_SEGMENT_ALIGN); }
	YY_BREAK
case 55:
YY_RULE_SETUP
#line 271 "ldlex.l"
{ RTOKEN(DATA_SEGMENT_RELRO_END); }
	YY_BREAK
case 56:
YY_RULE_SETUP
#line 272 "ldlex.l"
{ RTOKEN(DATA_SEGMENT_END); }
	YY_BREAK
case 57:
YY_RULE_SETUP
#line 273 "ldlex.l"
{ RTOKEN(ADDR); }
	YY_BREAK
case 58:
YY_RULE_SETUP
#line 274 "ldlex.l"
{ RTOKEN(LOADADDR); }
	YY_BREAK
case 59:
YY_RULE_SETUP
#line 275 "ldlex.l"
{ RTOKEN(ALIGNOF); }
	YY_BREAK
case 60:
YY_RULE_SETUP
#line 276 "ldlex.l"
{ RTOKEN(ABSOLUTE); }
	YY_BREAK
case 61:
YY_RULE_SETUP
#line 277 "ldlex.l"
{ RTOKEN(MAX_K); }
	YY_BREAK
case 62:
YY_RULE_SETUP
#line 278 "ldlex.l"
{ RTOKEN(MIN_K); }
	YY_BREAK
case 63:
YY_RULE_SETUP
#line 279 "ldlex.l"
{ RTOKEN(LOG2CEIL); }
	YY_BREAK
case 64:
YY_RULE_SETUP
#line 280 "ldlex.l"
{ RTOKEN(ASSERT_K); }
	YY_BREAK
case 65:
YY_RULE_SETUP
#line 281 "ldlex.l"
{ RTOKEN(ENTRY); }
	YY_BREAK
case 66:
YY_RULE_SETUP
#line 282 "ldlex.l"
{ RTOKEN(EXTERN); }
	YY_BREAK
case 67:
YY_RULE_SETUP
#line 283 "ldlex.l"
{ RTOKEN(NEXT); }
	YY_BREAK
case 68:
YY_RULE_SETUP
#line 284 "ldlex.l"
{ RTOKEN(SIZEOF_HEADERS); }
	YY_BREAK
case 69:
YY_RULE_SETUP
#line 285 "ldlex.l"
{ RTOKEN(SEGMENT_START); }
	YY_BREAK
case 70:
YY_RULE_SETUP
#line 286 "ldlex.l"
{ RTOKEN(MAP); }
	YY_BREAK
case 71:
YY_RULE_SETUP
#line 287 "ldlex.l"
{ RTOKEN(SIZEOF); }
	YY_BREAK
case 72:
YY_RULE_SETUP
#line 288 "ldlex.l"
{ RTOKEN(TARGET_K); }
	YY_BREAK
case 73:
YY_RULE_SETUP
#line 289 "ldlex.l"
{ RTOKEN(SEARCH_DIR); }
	YY_BREAK
case 74:
YY_RULE_SETUP
#line 290 "ldlex.l"
{ RTOKEN(OUTPUT); }
	YY_BREAK
case 75:
YY_RULE_SETUP
#line 291 "ldlex.l"
{ RTOKEN(INPUT); }
	YY_BREAK
case 76:
YY_RULE_SETUP
#line 292 "ldlex.l"
{ RTOKEN(GROUP); }
	YY_BREAK
case 77:
YY_RULE_SETUP
#line 293 "ldlex.l"
{ RTOKEN(AS_NEEDED); }
	YY_BREAK
case 78:
YY_RULE_SETUP
#line 294 "ldlex.l"
{ RTOKEN(DEFINED); }
	YY_BREAK
case 79:
YY_RULE_SETUP
#line 295 "ldlex.l"
{ RTOKEN(CREATE_OBJECT_SYMBOLS); }
	YY_BREAK
case 80:
YY_RULE_SETUP
#line 296 "ldlex.l"
{ RTOKEN(CONSTRUCTORS); }
	YY_BREAK
case 81:
YY_RULE_SETUP
#line 297 "ldlex.l"
{ RTOKEN(FORCE_COMMON_ALLOCATION); }
	YY_BREAK
case 82:
YY_RULE_SETUP
#line 298 "ldlex.l"
{ RTOKEN(FORCE_GROUP_ALLOCATION); }
	YY_BREAK
case 83:
YY_RULE_SETUP
#line 299 "ldlex.l"
{ RTOKEN(INHIBIT_COMMON_ALLOCATION); }
	YY_BREAK
case 84:
YY_RULE_SETUP
#line 300 "ldlex.l"
{ RTOKEN(SECTIONS); }
	YY_BREAK
case 85:
YY_RULE_SETUP
#line 301 "ldlex.l"
{ RTOKEN(INSERT_K); }
	YY_BREAK
case 86:
YY_RULE_SETUP
#line 302 "ldlex.l"
{ RTOKEN(AFTER); }
	YY_BREAK
case 87:
YY_RULE_SETUP
#line 303 "ldlex.l"
{ RTOKEN(BEFORE); }
	YY_BREAK
case 88:
YY_RULE_SETUP
#line 304 "ldlex.l"
{ RTOKEN(FILL); }
	YY_BREAK
case 89:
YY_RULE_SETUP
#line 305 "ldlex.l"
{ RTOKEN(STARTUP); }
	YY_BREAK
case 90:
YY_RULE_SETUP
#line 306 "ldlex.l"
{ RTOKEN(OUTPUT_FORMAT); }
	YY_BREAK
case 91:
YY_RULE_SETUP
#line 307 "ldlex.l"
{ RTOKEN(OUTPUT_ARCH); }
	YY_BREAK
case 92:
YY_RULE_SETUP
#line 308 "ldlex.l"
{ RTOKEN(HLL); }
	YY_BREAK
case 93:
YY_RULE_SETUP
#line 309 "ldlex.l"
{ RTOKEN(SYSLIB); }
	YY_BREAK
case 94:
YY_RULE_SETUP
#line 310 "ldlex.l"
{ RTOKEN(FLOAT); }
	YY_BREAK
case 95:
YY_RULE_SETUP
#line 311 "ldlex.l"
{ RTOKEN(QUAD); }
	YY_BREAK
case 96:
YY_RULE_SETUP
#line 312 "ldlex.l"
{ RTOKEN(SQUAD); }
	YY_BREAK
case 97:
YY_RULE_SETUP
#line 313 "ldlex.l"
{ RTOKEN(LONG); }
	YY_BREAK
case 98:
YY_RULE_SETUP
#line 314 "ldlex.l"
{ RTOKEN(SHORT); }
	YY_BREAK
case 99:
YY_RULE_SETUP
#line 315 "ldlex.l"
{ RTOKEN(BYTE); }
	YY_BREAK
case 100:
YY_RULE_SETUP
#line 316 "ldlex.l"
{ RTOKEN(ASCIZ); }
	YY_BREAK
case 101:
YY_RULE_SETUP
#line 317 "ldlex.l"
{ RTOKEN(LINKER_VERSION); }
	YY_BREAK
case 102:
YY_RULE_SETUP
#line 318 "ldlex.l"
{ RTOKEN(NOFLOAT); }
	YY_BREAK
case 103:
YY_RULE_SETUP
#line 319 "ldlex.l"
{ RTOKEN(NOCROSSREFS); }
	YY_BREAK
case 104:
YY_RULE_SETUP
#line 320 "ldlex.l"
{ RTOKEN(NOCROSSREFS_TO); }
	YY_BREAK
case 105:
YY_RULE_SETUP
#line 321 "ldlex.l"
{ RTOKEN(OVERLAY); }
	YY_BREAK
case 106:
YY_RULE_SETUP
#line 322 "ldlex.l"
{ RTOKEN(SORT_BY_NAME); }
	YY_BREAK
case 107:
YY_RULE_SETUP
#line 323 "ldlex.l"
{ RTOKEN(SORT_BY_ALIGNMENT); }
	YY_BREAK
case 108:
YY_RULE_SETUP
#line 324 "ldlex.l"
{ RTOKEN(SORT_BY_NAME); }
	YY_BREAK
case 109:
YY_RULE_SETUP
#line 325 "ldlex.l"
{ RTOKEN(SORT_BY_INIT_PRIORITY); }
	YY_BREAK
case 110:
YY_RULE_SETUP
#line 326 "ldlex.l"
{ RTOKEN(SORT_NONE); }
	YY_BREAK
case 111:
YY_RULE_SETUP
#line 327 "ldlex.l"
{ RTOKEN(REVERSE); }
	YY_BREAK
case 112:
YY_RULE_SETUP
#line 328 "ldlex.l"
{ RTOKEN(NOLOAD); }
	YY_BREAK
case 113:
YY_RULE_SETUP
#line 329 "ldlex.l"
{ RTOKEN(READONLY); }
	YY_BREAK
case 114:
YY_RULE_SETUP
#line 330 "ldlex.l"
{ RTOKEN(DSECT); }
	YY_BREAK
case 115:
YY_RULE_SETUP
#line 331 "ldlex.l"
{ RTOKEN(COPY); }
	YY_BREAK
case 116:
YY_RULE_SETUP
#line 332 "ldlex.l"
{ RTOKEN(INFO); }
	YY_BREAK
case 117:
YY_RULE_SETUP
#line 333 "ldlex.l"
{ RTOKEN(TYPE); }
	YY_BREAK
case 118:
YY_RULE_SETUP
#line 334 "ldlex.l"
{ RTOKEN(ONLY_IF_RO); }
	YY_BREAK
case 119:
YY_RULE_SETUP
#line 335 "ldlex.l"
{ RTOKEN(ONLY_IF_RW); }
	YY_BREAK
case 120:
YY_RULE_SETUP
#line 336 "ldlex.l"
{ RTOKEN(SPECIAL); }
	YY_BREAK
case 121:
YY_RULE_SETUP
#line 337 "ldlex.l"
{ RTOKEN(ORIGIN); }
	YY_BREAK
case 122:
YY_RULE_SETUP
#line 338 "ldlex.l"
{ RTOKEN(ORIGIN); }
	YY_BREAK
case 123:
YY_RULE_SETUP
#line 339 "ldlex.l"
{ RTOKEN(LENGTH); }
	YY_BREAK
case 124:
YY_RULE_SETUP
#line 340 "ldlex.l"
{ RTOKEN(LENGTH); }
	YY_BREAK
case 125:
YY_RULE_SETUP
#line 341 "ldlex.l"
{ RTOKEN(INPUT_SECTION_FLAGS); }
	YY_BREAK
case 126:
YY_RULE_SETUP
#line 342 "ldlex.l"
{ RTOKEN(INCLUDE);}
	YY_BREAK
case 127:
YY_RULE_SETUP
#line 343 "ldlex.l"
{ RTOKEN(PHDRS); }
	YY_BREAK
case 128:
YY_RULE_SETUP
#line 344 "ldlex.l"
{ RTOKEN(AT);}
	YY_BREAK
case 129:
YY_RULE_SETUP
#line 345 "ldlex.l"
{ RTOKEN(ALIGN_WITH_INPUT);}
	YY_BREAK
case 130:
YY_RULE_SETUP
#line 346 "ldlex.l"
{ RTOKEN(SUBALIGN);}
	YY_BREAK
case 131:
YY_RULE_SETUP
#line 347 "ldlex.l"
{ RTOKEN(HIDDEN); }
	YY_BREAK
case 132:
YY_RULE_SETUP
#line 348 "ldlex.l"
{ RTOKEN(PROVIDE); }
	YY_BREAK
case 133:
YY_RULE_SETUP
#line 349 "ldlex.l"
{ RTOKEN(PROVIDE_HIDDEN); }
	YY_BREAK
case 134:
YY_RULE_SETUP
#line 350 "ldlex.l"
{ RTOKEN(KEEP); }
	YY_BREAK
case 135:
YY_RULE_SETUP
#line 351 "ldlex.l"
{ RTOKEN(EXCLUDE_FILE); }
	YY_BREAK
case 136:
YY_RULE_SETUP
#line 352 "ldlex.l"
{ RTOKEN(CONSTANT);}
	YY_BREAK
case 137:
/* rule 137 can match eol */
YY_RULE_SETUP
#line 354 "ldlex.l"
{ ++ lineno; }
	YY_BREAK
case 138:
/* rule 138 can match eol */
YY_RULE_SETUP
#line 355 "ldlex.l"
{ ++ lineno;  RTOKEN(NEWLINE); }
	YY_BREAK
case 139:
YY_RULE_SETUP
#line 356 "ldlex.l"
{ /* Mri comment line */ }
	YY_BREAK
case 140:
YY_RULE_SETUP
#line 357 "ldlex.l"
{ /* Mri comment line */ }
	YY_BREAK
case 141:
YY_RULE_SETUP
#line 358 "ldlex.l"
{ RTOKEN(ENDWORD); }
	YY_BREAK
case 142:
YY_RULE_SETUP
#line 359 "ldlex.l"
{ RTOKEN(ABSOLUTE); }
	YY_BREAK
case 143:
YY_RULE_SETUP
#line 360 "ldlex.l"
{ RTOKEN(ALIGNMOD);}
	YY_BREAK
case 144:
YY_RULE_SETUP
#line 361 "ldlex.l"
{ RTOKEN(ALIGN_K);}
	YY_BREAK
case 145:
YY_RULE_SETUP
#line 362 "ldlex.l"
{ RTOKEN(CHIP); }
	YY_BREAK
case 146:
YY_RULE_SETUP
#line 363 "ldlex.l"
{ RTOKEN(BASE); }
	YY_BREAK
case 147:
YY_RULE_SETUP
#line 364 "ldlex.l"
{ RTOKEN(ALIAS); }
	YY_BREAK
case 148:
YY_RULE_SETUP
#line 365 "ldlex.l"
{ RTOKEN(TRUNCATE); }
	YY_BREAK
case 149:
YY_RULE_SETUP
#line 366 "ldlex.l"
{ RTOKEN(LOAD); }
	YY_BREAK
case 150:
YY_RULE_SETUP
#line 367 "ldlex.l"
{ RTOKEN(PUBLIC); }
	YY_BREAK
case 151:
YY_RULE_SETUP
#line 368 "ldlex.l"
{ RTOKEN(ORDER); }
	YY_BREAK
case 152:
YY_RULE_SETUP
#line 369 "ldlex.l"
{ RTOKEN(NAMEWORD); }
	YY_BREAK
case 153:
YY_RULE_SETUP
#line 370 "ldlex.l"
{ RTOKEN(FORMAT); }
	YY_BREAK
case 154:
YY_RULE_SETUP
#line 371 "ldlex.l"
{ RTOKEN(CASE); }
	YY_BREAK
case 155:
YY_RULE_SETUP
#line 372 "ldlex.l"
{ RTOKEN(START); }
	YY_BREAK
case 156:
YY_RULE_SETUP
#line 373 "ldlex.l"
{ RTOKEN(LIST); /* LIST and ignore to end of line */ }
	YY_BREAK
case 157:
YY_RULE_SETUP
#line 374 "ldlex.l"
{ RTOKEN(SECT); }
	YY_BREAK
case 158:
YY_RULE_SETUP
#line 375 "ldlex.l"
{ RTOKEN(ENDWORD); }
	YY_BREAK
case 159:
YY_RULE_SETUP
#line 376 "ldlex.l"
{ RTOKEN(ABSOLUTE); }
	YY_BREAK
case 160:
YY_RULE_SETUP
#line 377 "ldlex.l"
{ RTOKEN(ALIGNMOD);}
	YY_BREAK
case 161:
YY_RULE_SETUP
#line 378 "ldlex.l"
{ RTOKEN(ALIGN_K);}
	YY_BREAK
case 162:
YY_RULE_SETUP
#line 379 "ldlex.l"
{ RTOKEN(CHIP); }
	YY_BREAK
case 163:
YY_RULE_SETUP
#line 380 "ldlex.l"
{ RTOKEN(BASE); }
	YY_BREAK
case 164:
YY_RULE_SETUP
#line 381 "ldlex.l"
{ RTOKEN(ALIAS); }
	YY_BREAK
case 165:
YY_RULE_SETUP
#line 382 "ldlex.l"
{ RTOKEN(TRUNCATE); }
	YY_BREAK
case 166:
YY_RULE_SETUP
#line 383 "ldlex.l"
{ RTOKEN(LOAD); }
	YY_BREAK
case 167:
YY_RULE_SETUP
#line 384 "ldlex.l"
{ RTOKEN(PUBLIC); }
	YY_BREAK
case 168:
YY_RULE_SETUP
#line 385 "ldlex.l"
{ RTOKEN(ORDER); }
	YY_BREAK
case 169:
YY_RULE_SETUP
#line 386 "ldlex.l"
{ RTOKEN(NAMEWORD); }
	YY_BREAK
case 170:
YY_RULE_SETUP
#line 387 "ldlex.l"
{ RTOKEN(FORMAT); }
	YY_BREAK
case 171:
YY_RULE_SETUP
#line 388 "ldlex.l"
{ RTOKEN(CASE); }
	YY_BREAK
case 172:
YY_RULE_SETUP
#line 389 "ldlex.l"
{ RTOKEN(EXTERN); }
	YY_BREAK
case 173:
YY_RULE_SETUP
#line 390 "ldlex.l"
{ RTOKEN(START); }
	YY_BREAK
case 174:
YY_RULE_SETUP
#line 391 "ldlex.l"
{ RTOKEN(LIST); /* LIST and ignore to end of line */ }
	YY_BREAK
case 175:
YY_RULE_SETUP
#line 392 "ldlex.l"
{ RTOKEN(SECT); }
	YY_BREAK
case 176:
YY_RULE_SETUP
#line 394 "ldlex.l"
{
/* Filename without commas, needed to parse mri stuff */
				  yylval.name = stat_strdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 177:
YY_RULE_SETUP
#line 401 "ldlex.l"
{
				  yylval.name = stat_strdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 178:
YY_RULE_SETUP
#line 405 "ldlex.l"
{
/* Filename to be prefixed by --sysroot or when non-sysrooted, nothing.  */
				  yylval.name = stat_strdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 179:
YY_RULE_SETUP
#line 410 "ldlex.l"
{
				  yylval.name = stat_strdup (yytext + 2);
				  return LNAME;
				}
	YY_BREAK
case 180:
YY_RULE_SETUP
#line 414 "ldlex.l"
{
				  yylval.name = stat_strdup (yytext);
				  return NAME;
				}
	YY_BREAK
/* The following rule is to prevent a fill expression on the output
     section before /DISCARD/ interpreting the '/' as a divide.  */
case 181:
YY_RULE_SETUP
#line 420 "ldlex.l"
{
				  yylval.name = stat_strdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 182:
YY_RULE_SETUP
#line 424 "ldlex.l"
{
		/* Annoyingly, this pattern can match comments, and we have
		   longest match issues to consider.  So if the first two
		   characters are a comment opening, put the input back and
		   try again.  */
		if (yytext[0] == '/' && yytext[1] == '*')
		  {
		    yyless (2);
		    comment ();
		  }
		else
		  {
		    yylval.name = stat_strdup (yytext);
		    return NAME;
		  }
	}
	YY_BREAK
case 183:
/* rule 183 can match eol */
YY_RULE_SETUP
#line 441 "ldlex.l"
{
		/* No matter the state, quotes give what's inside.  */
		yylval.name = stat_memdup (yytext + 1, yyleng - 2, yyleng - 1);
		return NAME;
	}
	YY_BREAK
case 184:
/* rule 184 can match eol */
YY_RULE_SETUP
#line 447 "ldlex.l"
{
				lineno++; }
	YY_BREAK
case 185:
YY_RULE_SETUP
#line 449 "ldlex.l"
{
				/* Eat up whitespace */ }
	YY_BREAK
case 186:
YY_RULE_SETUP
#line 451 "ldlex.l"
{
				/* Eat up comments */ }
	YY_BREAK
case 187:
YY_RULE_SETUP
#line 454 "ldlex.l"
{ return *yytext; }
	YY_BREAK
case 188:
YY_RULE_SETUP
#line 456 "ldlex.l"
{ RTOKEN(GLOBAL); }
	YY_BREAK
case 189:
YY_RULE_SETUP
#line 458 "ldlex.l"
{ RTOKEN(LOCAL); }
	YY_BREAK
case 190:
YY_RULE_SETUP
#line 460 "ldlex.l"
{ RTOKEN(EXTERN); }
	YY_BREAK
case 191:
YY_RULE_SETUP
#line 462 "ldlex.l"
{ yylval.name = stat_strdup (yytext);
				  return VERS_IDENTIFIER; }
	YY_BREAK
case 192:
YY_RULE_SETUP
#line 465 "ldlex.l"
{ yylval.name = stat_strdup (yytext);
				  return VERS_TAG; }
	YY_BREAK
case 193:
YY_RULE_SETUP
#line 468 "ldlex.l"
{ BEGIN(VERS_SCRIPT); return *yytext; }
	YY_BREAK
case 194:
YY_RULE_SETUP
#line 470 "ldlex.l"
{ BEGIN(VERS_NODE);
				  vers_node_nesting = 0;
				  return *yytext;
				}
	YY_BREAK
case 195:
YY_RULE_SETUP
#line 474 "ldlex.l"
{ return *yytext; }
	YY_BREAK
case 196:
YY_RULE_SETUP
#line 475 "ldlex.l"
{ vers_node_nesting++; return *yytext; }
	YY_BREAK
case 197:
YY_RULE_SETUP
#line 476 "ldlex.l"
{ if (--vers_node_nesting < 0)
				    BEGIN(VERS_SCRIPT);
				  return *yytext;
				}
	YY_BREAK
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(SCRIPT):
case YY_STATE_EOF(INPUTLIST):
case YY_STATE_EOF(EXPRESSION):
case YY_STATE_EOF(MRI):
case YY_STATE_EOF(WILD):
case YY_STATE_EOF(VERS_START):
case YY_STATE_EOF(VERS_SCRIPT):
case YY_STATE_EOF(VERS_NODE):
#line 481 "ldlex.l"
{
  yy_delete_buffer (YY_CURRENT_BUFFER);
  include_stack_ptr--;
  if (include_stack_ptr == 0)
    {
      lineno = 0;
      yyterminate ();
    }
  else
    yy_switch_to_buffer (include_stack[include_stack_ptr]);

  lineno = lineno_stack[include_stack_ptr];
  input_flags.sysrooted = sysrooted_stack[include_stack_ptr];

  return END;
}
	YY_BREAK
case 198:
YY_RULE_SETUP
#line 498 "ldlex.l"
lex_warn_invalid (_(" in script"), yytext);
	YY_BREAK
case 199:
YY_RULE_SETUP
#line 499 "ldlex.l"
lex_warn_invalid (_(" in expression"), yytext);
	YY_BREAK
case 200:
YY_RULE_SETUP
#line 501 "ldlex.l"
ECHO;
	YY_BREAK
#line 2922 "ldlex.c"

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - (yytext_ptr)) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = (yy_hold_char);
		YY_RESTORE_YY_MORE_OFFSET

		if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between YY_CURRENT_BUFFER and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
			YY_CURRENT_BUFFER_LVALUE->yy_input_file = yyin;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( (yy_c_buf_p) <= &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			(yy_c_buf_p) = (yytext_ptr) + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state(  );

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state );

			yy_bp = (yytext_ptr) + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++(yy_c_buf_p);
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = (yy_c_buf_p);
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer(  ) )
			{
			case EOB_ACT_END_OF_FILE:
				{
				(yy_did_buffer_switch_on_eof) = 0;

				if ( yywrap(  ) )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					(yy_c_buf_p) = (yytext_ptr) + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				(yy_c_buf_p) =
					(yytext_ptr) + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				(yy_c_buf_p) =
				&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)];

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of user's declarations */
} /* end of yylex */

/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */
static int yy_get_next_buffer (void)
{
    	char *dest = YY_CURRENT_BUFFER_LVALUE->yy_ch_buf;
	char *source = (yytext_ptr);
	int number_to_move, i;
	int ret_val;

	if ( (yy_c_buf_p) > &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( YY_CURRENT_BUFFER_LVALUE->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( (yy_c_buf_p) - (yytext_ptr) - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (int) ((yy_c_buf_p) - (yytext_ptr) - 1);

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars) = 0;

	else
		{
			int num_to_read =
			YY_CURRENT_BUFFER_LVALUE->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = YY_CURRENT_BUFFER_LVALUE;

			int yy_c_buf_p_offset =
				(int) ((yy_c_buf_p) - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				int new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yyrealloc( (void *) b->yy_ch_buf,
							 (yy_size_t) (b->yy_buf_size + 2)  );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = NULL;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			(yy_c_buf_p) = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = YY_CURRENT_BUFFER_LVALUE->yy_buf_size -
						number_to_move - 1;

			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[number_to_move]),
			(yy_n_chars), num_to_read );

		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	if ( (yy_n_chars) == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( yyin  );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	if (((yy_n_chars) + number_to_move) > YY_CURRENT_BUFFER_LVALUE->yy_buf_size) {
		/* Extend the array by 50%, plus the number we really need. */
		int new_size = (yy_n_chars) + number_to_move + ((yy_n_chars) >> 1);
		YY_CURRENT_BUFFER_LVALUE->yy_ch_buf = (char *) yyrealloc(
			(void *) YY_CURRENT_BUFFER_LVALUE->yy_ch_buf, (yy_size_t) new_size  );
		if ( ! YY_CURRENT_BUFFER_LVALUE->yy_ch_buf )
			YY_FATAL_ERROR( "out of dynamic memory in yy_get_next_buffer()" );
		/* "- 2" to take care of EOB's */
		YY_CURRENT_BUFFER_LVALUE->yy_buf_size = (int) (new_size - 2);
	}

	(yy_n_chars) += number_to_move;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] = YY_END_OF_BUFFER_CHAR;

	(yytext_ptr) = &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[0];

	return ret_val;
}

/* yy_get_previous_state - get the state just before the EOB char was reached */

    static yy_state_type yy_get_previous_state (void)
{
	yy_state_type yy_current_state;
	char *yy_cp;
    
	yy_current_state = (yy_start);

	for ( yy_cp = (yytext_ptr) + YY_MORE_ADJ; yy_cp < (yy_c_buf_p); ++yy_cp )
		{
		YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 1);
		if ( yy_accept[yy_current_state] )
			{
			(yy_last_accepting_state) = yy_current_state;
			(yy_last_accepting_cpos) = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 1242 )
				yy_c = yy_meta[yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
		}

	return yy_current_state;
}

/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */
    static yy_state_type yy_try_NUL_trans  (yy_state_type yy_current_state )
{
	int yy_is_jam;
    	char *yy_cp = (yy_c_buf_p);

	YY_CHAR yy_c = 1;
	if ( yy_accept[yy_current_state] )
		{
		(yy_last_accepting_state) = yy_current_state;
		(yy_last_accepting_cpos) = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 1242 )
			yy_c = yy_meta[yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
	yy_is_jam = (yy_current_state == 1241);

		return yy_is_jam ? 0 : yy_current_state;
}

#ifndef YY_NO_UNPUT

#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
    static int yyinput (void)
#else
    static int input  (void)
#endif

{
	int c;
    
	*(yy_c_buf_p) = (yy_hold_char);

	if ( *(yy_c_buf_p) == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( (yy_c_buf_p) < &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			/* This was really a NUL. */
			*(yy_c_buf_p) = '\0';

		else
			{ /* need more input */
			int offset = (int) ((yy_c_buf_p) - (yytext_ptr));
			++(yy_c_buf_p);

			switch ( yy_get_next_buffer(  ) )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( yyin );

					/*FALLTHROUGH*/

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap(  ) )
						return 0;

					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput();
#else
					return input();
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					(yy_c_buf_p) = (yytext_ptr) + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) (yy_c_buf_p);	/* cast for 8-bit char's */
	*(yy_c_buf_p) = '\0';	/* preserve yytext */
	(yy_hold_char) = *++(yy_c_buf_p);

	return c;
}
#endif	/* ifndef YY_NO_INPUT */

/** Immediately switch to a different input stream.
 * @param input_file A readable stream.
 * 
 * @note This function does not reset the start condition to @c INITIAL .
 */
    void yyrestart  (FILE * input_file )
{
    
	if ( ! YY_CURRENT_BUFFER ){
        yyensure_buffer_stack ();
		YY_CURRENT_BUFFER_LVALUE =
            yy_create_buffer( yyin, YY_BUF_SIZE );
	}

	yy_init_buffer( YY_CURRENT_BUFFER, input_file );
	yy_load_buffer_state(  );
}

/** Switch to a different input buffer.
 * @param new_buffer The new input buffer.
 * 
 */
    void yy_switch_to_buffer  (YY_BUFFER_STATE  new_buffer )
{
    
	/* TODO. We should be able to replace this entire function body
	 * with
	 *		yypop_buffer_state();
	 *		yypush_buffer_state(new_buffer);
     */
	yyensure_buffer_stack ();
	if ( YY_CURRENT_BUFFER == new_buffer )
		return;

	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	YY_CURRENT_BUFFER_LVALUE = new_buffer;
	yy_load_buffer_state(  );

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	(yy_did_buffer_switch_on_eof) = 1;
}

static void yy_load_buffer_state  (void)
{
    	(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
	(yytext_ptr) = (yy_c_buf_p) = YY_CURRENT_BUFFER_LVALUE->yy_buf_pos;
	yyin = YY_CURRENT_BUFFER_LVALUE->yy_input_file;
	(yy_hold_char) = *(yy_c_buf_p);
}

/** Allocate and initialize an input buffer state.
 * @param file A readable stream.
 * @param size The character buffer size in bytes. When in doubt, use @c YY_BUF_SIZE.
 * 
 * @return the allocated buffer state.
 */
    YY_BUFFER_STATE yy_create_buffer  (FILE * file, int  size )
{
	YY_BUFFER_STATE b;
    
	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yyalloc( (yy_size_t) (b->yy_buf_size + 2)  );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file );

	return b;
}

/** Destroy the buffer.
 * @param b a buffer created with yy_create_buffer()
 * 
 */
    void yy_delete_buffer (YY_BUFFER_STATE  b )
{
    
	if ( ! b )
		return;

	if ( b == YY_CURRENT_BUFFER ) /* Not sure if we should pop here. */
		YY_CURRENT_BUFFER_LVALUE = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yyfree( (void *) b->yy_ch_buf  );

	yyfree( (void *) b  );
}

/* Initializes or reinitializes a buffer.
 * This function is sometimes called more than once on the same buffer,
 * such as during a yyrestart() or at EOF.
 */
    static void yy_init_buffer  (YY_BUFFER_STATE  b, FILE * file )

{
	int oerrno = errno;
    
	yy_flush_buffer( b );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

    /* If b is the current buffer, then yy_init_buffer was _probably_
     * called from yyrestart() or through yy_get_next_buffer.
     * In that case, we don't want to reset the lineno or column.
     */
    if (b != YY_CURRENT_BUFFER){
        b->yy_bs_lineno = 1;
        b->yy_bs_column = 0;
    }

        b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
    
	errno = oerrno;
}

/** Discard all buffered characters. On the next scan, YY_INPUT will be called.
 * @param b the buffer state to be flushed, usually @c YY_CURRENT_BUFFER.
 * 
 */
    void yy_flush_buffer (YY_BUFFER_STATE  b )
{
    	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == YY_CURRENT_BUFFER )
		yy_load_buffer_state(  );
}

/** Pushes the new state onto the stack. The new state becomes
 *  the current state. This function will allocate the stack
 *  if necessary.
 *  @param new_buffer The new state.
 *  
 */
void yypush_buffer_state (YY_BUFFER_STATE new_buffer )
{
    	if (new_buffer == NULL)
		return;

	yyensure_buffer_stack();

	/* This block is copied from yy_switch_to_buffer. */
	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	/* Only push if top exists. Otherwise, replace top. */
	if (YY_CURRENT_BUFFER)
		(yy_buffer_stack_top)++;
	YY_CURRENT_BUFFER_LVALUE = new_buffer;

	/* copied from yy_switch_to_buffer. */
	yy_load_buffer_state(  );
	(yy_did_buffer_switch_on_eof) = 1;
}

/** Removes and deletes the top of the stack, if present.
 *  The next element becomes the new top.
 *  
 */
void yypop_buffer_state (void)
{
    	if (!YY_CURRENT_BUFFER)
		return;

	yy_delete_buffer(YY_CURRENT_BUFFER );
	YY_CURRENT_BUFFER_LVALUE = NULL;
	if ((yy_buffer_stack_top) > 0)
		--(yy_buffer_stack_top);

	if (YY_CURRENT_BUFFER) {
		yy_load_buffer_state(  );
		(yy_did_buffer_switch_on_eof) = 1;
	}
}

/* Allocates the stack if it does not exist.
 *  Guarantees space for at least one push.
 */
static void yyensure_buffer_stack (void)
{
	yy_size_t num_to_alloc;
    
	if (!(yy_buffer_stack)) {

		/* First allocation is just for 2 elements, since we don't know if this
		 * scanner will even need a stack. We use 2 instead of 1 to avoid an
		 * immediate realloc on the next call.
         */
      num_to_alloc = 1; /* After all that talk, this was set to 1 anyways... */
		(yy_buffer_stack) = (struct yy_buffer_state**)yyalloc
								(num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		memset((yy_buffer_stack), 0, num_to_alloc * sizeof(struct yy_buffer_state*));

		(yy_buffer_stack_max) = num_to_alloc;
		(yy_buffer_stack_top) = 0;
		return;
	}

	if ((yy_buffer_stack_top) >= ((yy_buffer_stack_max)) - 1){

		/* Increase the buffer to prepare for a possible push. */
		yy_size_t grow_size = 8 /* arbitrary grow size */;

		num_to_alloc = (yy_buffer_stack_max) + grow_size;
		(yy_buffer_stack) = (struct yy_buffer_state**)yyrealloc
								((yy_buffer_stack),
								num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		/* zero only the new slots.*/
		memset((yy_buffer_stack) + (yy_buffer_stack_max), 0, grow_size * sizeof(struct yy_buffer_state*));
		(yy_buffer_stack_max) = num_to_alloc;
	}
}

/** Setup the input buffer state to scan directly from a user-specified character buffer.
 * @param base the character buffer
 * @param size the size in bytes of the character buffer
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_buffer  (char * base, yy_size_t  size )
{
	YY_BUFFER_STATE b;
    
	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return NULL;

	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = (int) (size - 2);	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = NULL;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_is_interactive = 0;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b  );

	return b;
}

/** Setup the input buffer state to scan a string. The next call to yylex() will
 * scan from a @e copy of @a str.
 * @param yystr a NUL-terminated string to scan
 * 
 * @return the newly allocated buffer state object.
 * @note If you want to scan bytes that may contain NUL values, then use
 *       yy_scan_bytes() instead.
 */
YY_BUFFER_STATE yy_scan_string (const char * yystr )
{
    
	return yy_scan_bytes( yystr, (int) strlen(yystr) );
}

/** Setup the input buffer state to scan the given bytes. The next call to yylex() will
 * scan from a @e copy of @a bytes.
 * @param yybytes the byte buffer to scan
 * @param _yybytes_len the number of bytes in the buffer pointed to by @a bytes.
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_bytes  (const char * yybytes, int  _yybytes_len )
{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	int i;
    
	/* Get memory for full buffer, including space for trailing EOB's. */
	n = (yy_size_t) (_yybytes_len + 2);
	buf = (char *) yyalloc( n  );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < _yybytes_len; ++i )
		buf[i] = yybytes[i];

	buf[_yybytes_len] = buf[_yybytes_len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n );
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
}

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

static void yynoreturn yy_fatal_error (const char* msg )
{
			fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
}

/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		yytext[yyleng] = (yy_hold_char); \
		(yy_c_buf_p) = yytext + yyless_macro_arg; \
		(yy_hold_char) = *(yy_c_buf_p); \
		*(yy_c_buf_p) = '\0'; \
		yyleng = yyless_macro_arg; \
		} \
	while ( 0 )

/* Accessor  methods (get/set functions) to struct members. */

/** Get the current line number.
 * 
 */
int yyget_lineno  (void)
{
    
    return yylineno;
}

/** Get the input stream.
 * 
 */
FILE *yyget_in  (void)
{
        return yyin;
}

/** Get the output stream.
 * 
 */
FILE *yyget_out  (void)
{
        return yyout;
}

/** Get the length of the current token.
 * 
 */
int yyget_leng  (void)
{
        return yyleng;
}

/** Get the current token.
 * 
 */

char *yyget_text  (void)
{
        return yytext;
}

/** Set the current line number.
 * @param _line_number line number
 * 
 */
void yyset_lineno (int  _line_number )
{
    
    yylineno = _line_number;
}

/** Set the input stream. This does not discard the current
 * input buffer.
 * @param _in_str A readable stream.
 * 
 * @see yy_switch_to_buffer
 */
void yyset_in (FILE *  _in_str )
{
        yyin = _in_str ;
}

void yyset_out (FILE *  _out_str )
{
        yyout = _out_str ;
}

int yyget_debug  (void)
{
        return yy_flex_debug;
}

void yyset_debug (int  _bdebug )
{
        yy_flex_debug = _bdebug ;
}

static int yy_init_globals (void)
{
        /* Initialization is the same as for the non-reentrant scanner.
     * This function is called from yylex_destroy(), so don't allocate here.
     */

    (yy_buffer_stack) = NULL;
    (yy_buffer_stack_top) = 0;
    (yy_buffer_stack_max) = 0;
    (yy_c_buf_p) = NULL;
    (yy_init) = 0;
    (yy_start) = 0;

/* Defined in main.c */
#ifdef YY_STDINIT
    yyin = stdin;
    yyout = stdout;
#else
    yyin = NULL;
    yyout = NULL;
#endif

    /* For future reference: Set errno on error, since we are called by
     * yylex_init()
     */
    return 0;
}

/* yylex_destroy is for both reentrant and non-reentrant scanners. */
int yylex_destroy  (void)
{
    
    /* Pop the buffer stack, destroying each element. */
	while(YY_CURRENT_BUFFER){
		yy_delete_buffer( YY_CURRENT_BUFFER  );
		YY_CURRENT_BUFFER_LVALUE = NULL;
		yypop_buffer_state();
	}

	/* Destroy the stack itself. */
	yyfree((yy_buffer_stack) );
	(yy_buffer_stack) = NULL;

    /* Reset the globals. This is important in a non-reentrant scanner so the next time
     * yylex() is called, initialization will occur. */
    yy_init_globals( );

    return 0;
}

/*
 * Internal utility routines.
 */

#ifndef yytext_ptr
static void yy_flex_strncpy (char* s1, const char * s2, int n )
{
		
	int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
}
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen (const char * s )
{
	int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
}
#endif

void *yyalloc (yy_size_t  size )
{
			return malloc(size);
}

void *yyrealloc  (void * ptr, yy_size_t  size )
{
		
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return realloc(ptr, size);
}

void yyfree (void * ptr )
{
			free( (char *) ptr );	/* see yyrealloc() for (char *) cast */
}

#define YYTABLES_NAME "yytables"

#line 501 "ldlex.l"



/* Switch flex to reading script file NAME, open on FILE,
   saving the current input info on the include stack.  */

void
lex_push_file (FILE *file, const char *name, unsigned int sysrooted)
{
  if (include_stack_ptr >= MAX_INCLUDE_DEPTH)
    fatal (_("%P: includes nested too deeply\n"));
  file_name_stack[include_stack_ptr] = name;
  lineno_stack[include_stack_ptr] = lineno;
  sysrooted_stack[include_stack_ptr] = input_flags.sysrooted;
  include_stack[include_stack_ptr] = YY_CURRENT_BUFFER;

  include_stack_ptr++;
  lineno = 1;
  input_flags.sysrooted = sysrooted;
  yyin = file;
  yy_switch_to_buffer (yy_create_buffer (yyin, YY_BUF_SIZE));
}

/* Return a newly created flex input buffer containing STRING,
   which is SIZE bytes long.  */

static YY_BUFFER_STATE
yy_create_string_buffer (const char *string, size_t size)
{
  YY_BUFFER_STATE b;

  b = xmalloc (sizeof (struct yy_buffer_state));
  b->yy_input_file = 0;
  b->yy_buf_size = size;

  /* yy_ch_buf has to be 2 characters longer than the size given because
     we need to put in 2 end-of-buffer characters.  */
  b->yy_ch_buf = xmalloc (b->yy_buf_size + 3);

  b->yy_ch_buf[0] = '\n';
  strcpy (b->yy_ch_buf+1, string);
  b->yy_ch_buf[size+1] = YY_END_OF_BUFFER_CHAR;
  b->yy_ch_buf[size+2] = YY_END_OF_BUFFER_CHAR;
  b->yy_n_chars = size+1;
  b->yy_buf_pos = &b->yy_ch_buf[1];

  b->yy_is_our_buffer = 1;
  b->yy_is_interactive = 0;
  b->yy_at_bol = 1;
  b->yy_fill_buffer = 0;

  /* flex 2.4.7 changed the interface.  FIXME: We should not be using
     a flex internal interface in the first place!  */
#ifdef YY_BUFFER_NEW
  b->yy_buffer_status = YY_BUFFER_NEW;
#else
  b->yy_eof_status = EOF_NOT_SEEN;
#endif

  return b;
}

/* Switch flex to reading from STRING, saving the current input info
   on the include stack.  */

void
lex_redirect (const char *string, const char *fake_filename, unsigned int count)
{
  YY_BUFFER_STATE tmp;

  yy_init = 0;
  if (include_stack_ptr >= MAX_INCLUDE_DEPTH)
    fatal (_("%P: macros nested too deeply\n"));
  file_name_stack[include_stack_ptr] = fake_filename;
  lineno_stack[include_stack_ptr] = lineno;
  include_stack[include_stack_ptr] = YY_CURRENT_BUFFER;
  include_stack_ptr++;
  lineno = count;
  tmp = yy_create_string_buffer (string, strlen (string));
  yy_switch_to_buffer (tmp);
}

/* Functions to switch to a different flex start condition,
   saving the current start condition on `state_stack'.  */

static int state_stack[MAX_INCLUDE_DEPTH * 2];
static int *state_stack_p = state_stack;

void
ldlex_script (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (SCRIPT);
}

void
ldlex_inputlist (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (INPUTLIST);
}

void
ldlex_mri_script (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (MRI);
}

void
ldlex_version_script (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (VERS_START);
}

void
ldlex_version_file (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (VERS_SCRIPT);
}

void
ldlex_expression (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (EXPRESSION);
}

void
ldlex_wild (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (WILD);
}

void
ldlex_popstate (void)
{
  yy_start = *(--state_stack_p);
}

/* In cases where the parser needs to look ahead and the context
   changes from expression to script or vice-versa, throw away a
   NAME.  What constitutes a NAME depends on context.  */

void
ldlex_backup (void)
{
  yyless (0);
}

/* Return the current file name, or the previous file if no file is
   current.  */

const char*
ldlex_filename (void)
{
  return file_name_stack[include_stack_ptr - (include_stack_ptr != 0)];
}


/* Place up to MAX_SIZE characters in BUF and return
   either the number of characters read, or 0 to indicate EOF.  */

static int
yy_input (char *buf, int max_size)
{
  int result = 0;
  if (YY_CURRENT_BUFFER != NULL && YY_CURRENT_BUFFER->yy_input_file)
    {
      if (yyin)
	{
	  result = fread (buf, 1, max_size, yyin);
	  if (result < max_size && ferror (yyin))
	    fatal (_("%P: read in flex scanner failed\n"));
	}
    }
  return result;
}

/* Eat the rest of a C-style comment.  */

static void
comment (void)
{
  int c;

  while (1)
    {
      c = input();
      while (c != '*' && c != 0)
	{
	  if (c == '\n')
	    lineno++;
	  c = input();
	}

      if (c == '*')
	{
	  c = input();
	  while (c == '*')
	    c = input();
	  if (c == '/')
	    break;			/* found the end */
	}

      if (c == '\n')
	lineno++;

      if (c == 0)
	{
	  fatal (_("%P: EOF in comment\n"));
	  break;
	}
    }
}

/* Warn the user about a garbage character WHAT in the input
   in context WHERE.  */

static void
lex_warn_invalid (char *where, char *what)
{
  char buf[5];

  /* If we have found an input file whose format we do not recognize,
     and we are therefore treating it as a linker script, and we find
     an invalid character, then most likely this is a real object file
     of some different format.  Treat it as such.  */
  if (ldfile_assumed_script)
    {
      bfd_set_error (bfd_error_file_not_recognized);
      fatal (_("%s: file not recognized: %E\n"), ldlex_filename ());
    }

  if (! ISPRINT (*what))
    {
      sprintf (buf, "\\%03o", *(unsigned char *) what);
      what = buf;
    }

  einfo (_("%P:%pS: ignoring invalid character `%s'%s\n"), NULL, what, where);
}

