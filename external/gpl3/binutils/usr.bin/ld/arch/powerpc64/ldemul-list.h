/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-binutils,v 1.17 2026/02/11 21:04:24 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf64ppc_emulation;
extern ld_emulation_xfer_type ld_elf32ppc_nbsd_emulation;
extern ld_emulation_xfer_type ld_elf32ppc_emulation;
extern ld_emulation_xfer_type ld_elf32ppcsim_emulation;

#define EMULATION_LIST \
  &ld_elf64ppc_emulation, \
  &ld_elf32ppc_nbsd_emulation, \
  &ld_elf32ppc_emulation, \
  &ld_elf32ppcsim_emulation, \
  0
