/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-binutils,v 1.15 2023/02/07 20:37:30 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf64lriscv_emulation;
extern ld_emulation_xfer_type ld_elf64lriscv_lp64f_emulation;
extern ld_emulation_xfer_type ld_elf64lriscv_lp64_emulation;
extern ld_emulation_xfer_type ld_elf32lriscv_emulation;
extern ld_emulation_xfer_type ld_elf32lriscv_ilp32f_emulation;
extern ld_emulation_xfer_type ld_elf32lriscv_ilp32_emulation;
extern ld_emulation_xfer_type ld_elf64briscv_emulation;
extern ld_emulation_xfer_type ld_elf64briscv_lp64f_emulation;
extern ld_emulation_xfer_type ld_elf64briscv_lp64_emulation;
extern ld_emulation_xfer_type ld_elf32briscv_emulation;
extern ld_emulation_xfer_type ld_elf32briscv_ilp32f_emulation;
extern ld_emulation_xfer_type ld_elf32briscv_ilp32_emulation;

#define EMULATION_LIST \
  &ld_elf64lriscv_emulation, \
  &ld_elf64lriscv_lp64f_emulation, \
  &ld_elf64lriscv_lp64_emulation, \
  &ld_elf32lriscv_emulation, \
  &ld_elf32lriscv_ilp32f_emulation, \
  &ld_elf32lriscv_ilp32_emulation, \
  &ld_elf64briscv_emulation, \
  &ld_elf64briscv_lp64f_emulation, \
  &ld_elf64briscv_lp64_emulation, \
  &ld_elf32briscv_emulation, \
  &ld_elf32briscv_ilp32f_emulation, \
  &ld_elf32briscv_ilp32_emulation, \
  0
