/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc.old,v 1.5 2017/10/04 21:42:20 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc.old/dist/configure --target=arm--netbsdelf-eabihf --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20160606' --with-system-zlib --disable-libstdcxx-dual-abi --enable-__cxa_atexit --enable-libstdcxx-time=rt --enable-libstdcxx-threads --with-diagnostics-color=auto-if-env --with-mpc-lib=/usr/src/external/lgpl3/mpc/lib/libmpc/obj.evbarm-earmhf --with-mpfr-lib=/usr/src/external/lgpl3/mpfr/lib/libmpfr/obj.evbarm-earmhf --with-gmp-lib=/usr/src/external/lgpl3/gmp/lib/libgmp/obj.evbarm-earmhf --with-mpc-include=/usr/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/usr/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/usr/src/external/lgpl3/gmp/lib/libgmp/arch/arm --enable-tls --enable-initfini-array --disable-multilib --disable-symvers --disable-libstdcxx-pch --disable-libstdcxx-dual-abi --build=x86_64-unknown-netbsd8.99 --host=arm--netbsdelf-eabihf --with-sysroot=/usr/obj/evbarm-earmhf/release";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
