/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc.old,v 1.10 2021/04/11 01:44:14 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#define BUILDING_GCC_MAJOR 10
#define BUILDING_GCC_MINOR 5
#define BUILDING_GCC_PATCHLEVEL 0
#define BUILDING_GCC_VERSION (BUILDING_GCC_MAJOR * 1000 + BUILDING_GCC_MINOR)
