/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc.old,v 1.5 2017/10/04 21:42:20 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

/* Generated automatically. */
#ifdef _SOFT_FLOAT
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc.old/dist/configure --target=powerpc--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20160606' --with-system-zlib --disable-libstdcxx-dual-abi --enable-__cxa_atexit --enable-libstdcxx-time=rt --enable-libstdcxx-threads --with-diagnostics-color=auto-if-env --with-mpc-lib=/usr/src/external/lgpl3/mpc/lib/libmpc/obj.macppc-powerpc --with-mpfr-lib=/usr/src/external/lgpl3/mpfr/lib/libmpfr/obj.macppc-powerpc --with-gmp-lib=/usr/src/external/lgpl3/gmp/lib/libgmp/obj.macppc-powerpc --with-mpc-include=/usr/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/usr/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/usr/src/external/lgpl3/gmp/lib/libgmp/arch/powerpc --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --disable-libstdcxx-dual-abi --build=x86_64-unknown-netbsd8.99 --host=powerpc--netbsd --with-sysroot=/usr/obj/macppc-powerpc/release -with-float=soft";
#else
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc.old/dist/configure --target=powerpc--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20160606' --with-system-zlib --disable-libstdcxx-dual-abi --enable-__cxa_atexit --enable-libstdcxx-time=rt --enable-libstdcxx-threads --with-diagnostics-color=auto-if-env --with-mpc-lib=/p/netbsd/cvsroot/src/external/lgpl3/mpc/lib/libmpc/obj.macppc-powerpc --with-mpfr-lib=/p/netbsd/cvsroot/src/external/lgpl3/mpfr/lib/libmpfr/obj.macppc-powerpc --with-gmp-lib=/p/netbsd/cvsroot/src/external/lgpl3/gmp/lib/libgmp/obj.macppc-powerpc --with-mpc-include=/p/netbsd/cvsroot/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/p/netbsd/cvsroot/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/p/netbsd/cvsroot/src/external/lgpl3/gmp/lib/libgmp/arch/powerpc --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --disable-libstdcxx-dual-abi --build=x86_64-unknown-netbsd8.99 --host=powerpc--netbsd --with-sysroot=/usr/obj/macppc-powerpc/release";
#endif
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { 
#ifdef _SOFT_FLOAT
  { "float", "soft" },
#endif
  { NULL, NULL }
};
