/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.101 2019/02/23 06:54:45 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* This file is auto-generated by i386-builtin-types.awk.  */

enum ix86_builtin_type {
  IX86_BT_VOID,
  IX86_BT_CHAR,
  IX86_BT_UCHAR,
  IX86_BT_QI,
  IX86_BT_HI,
  IX86_BT_SI,
  IX86_BT_BND,
  IX86_BT_DI,
  IX86_BT_UQI,
  IX86_BT_UHI,
  IX86_BT_USI,
  IX86_BT_UDI,
  IX86_BT_SHORT,
  IX86_BT_USHORT,
  IX86_BT_INT,
  IX86_BT_UINT,
  IX86_BT_UNSIGNED,
  IX86_BT_ULONG,
  IX86_BT_LONGLONG,
  IX86_BT_ULONGLONG,
  IX86_BT_UINT8,
  IX86_BT_UINT16,
  IX86_BT_INT64,
  IX86_BT_UINT64,
  IX86_BT_FLOAT,
  IX86_BT_DOUBLE,
  IX86_BT_FLOAT80,
  IX86_BT_FLOAT128,
  IX86_BT_CONST_STRING,
  IX86_BT_LAST_PRIM = IX86_BT_CONST_STRING,
  IX86_BT_V2SF,
  IX86_BT_V1DI,
  IX86_BT_V2SI,
  IX86_BT_V4HI,
  IX86_BT_V8QI,
  IX86_BT_V2DF,
  IX86_BT_V4SF,
  IX86_BT_V2DI,
  IX86_BT_V4SI,
  IX86_BT_V8HI,
  IX86_BT_V16QI,
  IX86_BT_V2UDI,
  IX86_BT_V4USI,
  IX86_BT_V8UHI,
  IX86_BT_V16UQI,
  IX86_BT_V4DF,
  IX86_BT_V8SF,
  IX86_BT_V4DI,
  IX86_BT_V8SI,
  IX86_BT_V16HI,
  IX86_BT_V32QI,
  IX86_BT_V4UDI,
  IX86_BT_V8USI,
  IX86_BT_V16UHI,
  IX86_BT_V32SF,
  IX86_BT_V16SF,
  IX86_BT_V8DF,
  IX86_BT_V8DI,
  IX86_BT_V16SI,
  IX86_BT_V32HI,
  IX86_BT_V64QI,
  IX86_BT_V12QI,
  IX86_BT_V14QI,
  IX86_BT_V32SI,
  IX86_BT_V8UDI,
  IX86_BT_V16USI,
  IX86_BT_V32UHI,
  IX86_BT_LAST_VECT = IX86_BT_V32UHI,
  IX86_BT_PCHAR,
  IX86_BT_PVOID,
  IX86_BT_PDOUBLE,
  IX86_BT_PFLOAT,
  IX86_BT_PSHORT,
  IX86_BT_PUSHORT,
  IX86_BT_PINT,
  IX86_BT_PINT64,
  IX86_BT_PLONGLONG,
  IX86_BT_PULONGLONG,
  IX86_BT_PUNSIGNED,
  IX86_BT_PUQI,
  IX86_BT_PUHI,
  IX86_BT_PUSI,
  IX86_BT_PUDI,
  IX86_BT_PUCHAR,
  IX86_BT_PV2SI,
  IX86_BT_PV2DF,
  IX86_BT_PV2DI,
  IX86_BT_PV2SF,
  IX86_BT_PV4DF,
  IX86_BT_PV4DI,
  IX86_BT_PV4SF,
  IX86_BT_PV8DF,
  IX86_BT_PV8SF,
  IX86_BT_PV4SI,
  IX86_BT_PV8QI,
  IX86_BT_PV8HI,
  IX86_BT_PV8SI,
  IX86_BT_PV8DI,
  IX86_BT_PV16QI,
  IX86_BT_PV16HI,
  IX86_BT_PV16SI,
  IX86_BT_PV16SF,
  IX86_BT_PV32QI,
  IX86_BT_PV32HI,
  IX86_BT_PV64QI,
  IX86_BT_LAST_PTR = IX86_BT_PV64QI,
  IX86_BT_PCCHAR,
  IX86_BT_PCDOUBLE,
  IX86_BT_PCFLOAT,
  IX86_BT_PCINT,
  IX86_BT_PCINT64,
  IX86_BT_PCSHORT,
  IX86_BT_PCVOID,
  IX86_BT_PCV2SI,
  IX86_BT_PCV2DF,
  IX86_BT_PCV2SF,
  IX86_BT_PCV4DF,
  IX86_BT_PCV4SF,
  IX86_BT_PCV8DF,
  IX86_BT_PCV8SF,
  IX86_BT_PCV16SF,
  IX86_BT_PCV2DI,
  IX86_BT_PCV4SI,
  IX86_BT_PCV4DI,
  IX86_BT_PCV8HI,
  IX86_BT_PCV8SI,
  IX86_BT_PCV8DI,
  IX86_BT_PCV16QI,
  IX86_BT_PCV16HI,
  IX86_BT_PCV16SI,
  IX86_BT_PCV32QI,
  IX86_BT_PCV32HI,
  IX86_BT_PCV64QI,
  IX86_BT_LAST_CPTR = IX86_BT_PCV64QI
}
;


#define DEFINE_BUILTIN_PRIMITIVE_TYPES \
  ix86_builtin_type_tab[(int)IX86_BT_VOID] = void_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_CHAR] = char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UCHAR] = unsigned_char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_QI] = char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_HI] = intHI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_SI] = intSI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_BND] = pointer_bounds_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_DI] = long_long_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UQI] = unsigned_intQI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UHI] = unsigned_intHI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_USI] = unsigned_intSI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UDI] = long_long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_SHORT] = short_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_USHORT] = short_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_INT] = integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT] = unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UNSIGNED] = unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_ULONG] = long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_LONGLONG] = long_long_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_ULONGLONG] = long_long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT8] = unsigned_char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT16] = short_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_INT64] = long_long_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT64] = long_long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT] = float_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_DOUBLE] = double_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT80] = float80_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT128] = float128_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_CONST_STRING] = const_string_type_node


static const machine_mode ix86_builtin_type_vect_mode[] = {
  E_V2SFmode, E_V1DImode, E_V2SImode, E_V4HImode, E_V8QImode, E_V2DFmode,
  E_V4SFmode, E_V2DImode, E_V4SImode, E_V8HImode, E_V16QImode, E_V2DImode,
  E_V4SImode, E_V8HImode, E_V16QImode, E_V4DFmode, E_V8SFmode, E_V4DImode,
  E_V8SImode, E_V16HImode, E_V32QImode, E_V4DImode, E_V8SImode, E_V16HImode,
  E_V32SFmode, E_V16SFmode, E_V8DFmode, E_V8DImode, E_V16SImode, E_V32HImode,
  E_V64QImode, E_V12QImode, E_V14QImode, E_V32SImode, E_V8DImode, E_V16SImode,
  E_V32HImode
};


static const enum ix86_builtin_type ix86_builtin_type_vect_base[] = {
  IX86_BT_FLOAT, IX86_BT_DI, IX86_BT_SI, IX86_BT_HI,
  IX86_BT_QI, IX86_BT_DOUBLE, IX86_BT_FLOAT, IX86_BT_DI,
  IX86_BT_SI, IX86_BT_HI, IX86_BT_QI, IX86_BT_UDI,
  IX86_BT_USI, IX86_BT_UHI, IX86_BT_UQI, IX86_BT_DOUBLE,
  IX86_BT_FLOAT, IX86_BT_DI, IX86_BT_SI, IX86_BT_HI,
  IX86_BT_QI, IX86_BT_UDI, IX86_BT_USI, IX86_BT_UHI,
  IX86_BT_FLOAT, IX86_BT_FLOAT, IX86_BT_DOUBLE, IX86_BT_DI,
  IX86_BT_SI, IX86_BT_HI, IX86_BT_QI, IX86_BT_QI,
  IX86_BT_QI, IX86_BT_SI, IX86_BT_UDI, IX86_BT_USI,
  IX86_BT_UHI
};


static const enum ix86_builtin_type ix86_builtin_type_ptr_base[] = {
  IX86_BT_CHAR, IX86_BT_VOID, IX86_BT_DOUBLE, IX86_BT_FLOAT,
  IX86_BT_SHORT, IX86_BT_USHORT, IX86_BT_INT, IX86_BT_INT64,
  IX86_BT_LONGLONG, IX86_BT_ULONGLONG, IX86_BT_UNSIGNED, IX86_BT_UQI,
  IX86_BT_UHI, IX86_BT_USI, IX86_BT_UDI, IX86_BT_UCHAR,
  IX86_BT_V2SI, IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_V2SF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4SF, IX86_BT_V8DF,
  IX86_BT_V8SF, IX86_BT_V4SI, IX86_BT_V8QI, IX86_BT_V8HI,
  IX86_BT_V8SI, IX86_BT_V8DI, IX86_BT_V16QI, IX86_BT_V16HI,
  IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_V32QI, IX86_BT_V32HI,
  IX86_BT_V64QI,
  /* pointer-to-constant defs start here */
  IX86_BT_CHAR, IX86_BT_DOUBLE, IX86_BT_FLOAT, IX86_BT_INT,
  IX86_BT_INT64, IX86_BT_SHORT, IX86_BT_VOID, IX86_BT_V2SI,
  IX86_BT_V2DF, IX86_BT_V2SF, IX86_BT_V4DF, IX86_BT_V4SF,
  IX86_BT_V8DF, IX86_BT_V8SF, IX86_BT_V16SF, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V4DI, IX86_BT_V8HI, IX86_BT_V8SI,
  IX86_BT_V8DI, IX86_BT_V16QI, IX86_BT_V16HI, IX86_BT_V16SI,
  IX86_BT_V32QI, IX86_BT_V32HI, IX86_BT_V64QI
};


enum ix86_builtin_func_type {
  FLOAT128_FTYPE_VOID,
  UINT64_FTYPE_VOID,
  UNSIGNED_FTYPE_VOID,
  UINT_FTYPE_VOID,
  USHORT_FTYPE_VOID,
  INT_FTYPE_VOID,
  VOID_FTYPE_VOID,
  PVOID_FTYPE_VOID,
  FLOAT_FTYPE_FLOAT,
  FLOAT128_FTYPE_FLOAT128,
  FLOAT128_FTYPE_CONST_STRING,
  INT_FTYPE_INT,
  INT_FTYPE_V16QI,
  INT_FTYPE_V2DF,
  INT_FTYPE_V4DF,
  INT_FTYPE_V4SF,
  INT_FTYPE_V8QI,
  INT_FTYPE_V8SF,
  INT_FTYPE_V32QI,
  INT_FTYPE_PCCHAR,
  INT64_FTYPE_INT64,
  INT64_FTYPE_V2DF,
  INT64_FTYPE_V4SF,
  UINT_FTYPE_UINT,
  UINT16_FTYPE_UINT16,
  UINT64_FTYPE_INT,
  UINT64_FTYPE_PUNSIGNED,
  UINT64_FTYPE_UINT64,
  V16QI_FTYPE_PCCHAR,
  V16QI_FTYPE_V16QI,
  V2DF_FTYPE_PCDOUBLE,
  V2DF_FTYPE_V2DF,
  V2DF_FTYPE_V2SI,
  V2DF_FTYPE_V4DF,
  V2DF_FTYPE_V4SF,
  V2DF_FTYPE_V4SI,
  V2DI_FTYPE_PV2DI,
  V2DI_FTYPE_V16QI,
  V2DI_FTYPE_V2DI,
  V2DI_FTYPE_V4SI,
  V2DI_FTYPE_V8HI,
  V2SF_FTYPE_V2SF,
  V2SF_FTYPE_V2SI,
  V2SI_FTYPE_V2DF,
  V2SI_FTYPE_V2SF,
  V2SI_FTYPE_V2SI,
  V2SI_FTYPE_PCV2SI,
  V2SI_FTYPE_V4SF,
  V32QI_FTYPE_PCCHAR,
  V4DF_FTYPE_PCDOUBLE,
  V4DF_FTYPE_PCV2DF,
  V4DF_FTYPE_V2DF,
  V4DF_FTYPE_V4DF,
  V4DF_FTYPE_V4SF,
  V4DF_FTYPE_V4SI,
  V8DF_FTYPE_V8DF,
  V4HI_FTYPE_V4HI,
  V4SF_FTYPE_PCFLOAT,
  V4SF_FTYPE_V2DF,
  V4SF_FTYPE_V2DF_V4SF_UQI,
  V4SF_FTYPE_V4DF,
  V4SF_FTYPE_V4DF_V4SF_UQI,
  V4SF_FTYPE_V4SF,
  V4SF_FTYPE_PCV4SF,
  V4SF_FTYPE_V4SI,
  V4SF_FTYPE_V8SF,
  V4SF_FTYPE_V8HI,
  V4SF_FTYPE_V8HI_V4SF_UQI,
  V4SI_FTYPE_V16QI,
  V4SI_FTYPE_V2DF,
  V4SI_FTYPE_V4DF,
  V4SI_FTYPE_V4SF,
  V4SI_FTYPE_V4SI,
  V4SI_FTYPE_V8HI,
  V4SI_FTYPE_V8SI,
  V8HI_FTYPE_V16QI,
  V8HI_FTYPE_V8HI,
  V8QI_FTYPE_V8QI,
  V8SF_FTYPE_PCFLOAT,
  V8SF_FTYPE_PCV4SF,
  V8SF_FTYPE_PCV8SF,
  V8SF_FTYPE_V4SF,
  V8SF_FTYPE_V8SF,
  V8SF_FTYPE_V8SI,
  V8SF_FTYPE_V8HI,
  V8SF_FTYPE_V8HI_V8SF_UQI,
  V16SF_FTYPE_V16SF,
  V8SI_FTYPE_V4SI,
  V8SI_FTYPE_V8SF,
  V32QI_FTYPE_V32QI,
  V32QI_FTYPE_V16QI,
  V16HI_FTYPE_V16HI,
  V16HI_FTYPE_V8HI,
  V8SI_FTYPE_V8SI,
  VOID_FTYPE_PCVOID,
  VOID_FTYPE_PVOID,
  VOID_FTYPE_UINT64,
  VOID_FTYPE_UINT64_PVOID,
  VOID_FTYPE_UNSIGNED,
  VOID_FTYPE_UNSIGNED_PVOID,
  INT_FTYPE_PUSHORT,
  INT_FTYPE_PUNSIGNED,
  INT_FTYPE_PULONGLONG,
  V16HI_FTYPE_V16QI,
  V8SI_FTYPE_V16QI,
  V4DI_FTYPE_V16QI,
  V8SI_FTYPE_V8HI,
  V4DI_FTYPE_V8HI,
  V4DI_FTYPE_V4SI,
  V4DI_FTYPE_PV4DI,
  V4DI_FTYPE_V2DI,
  V16SI_FTYPE_INT,
  V16SF_FTYPE_V4SF,
  V16SF_FTYPE_V8SF,
  V8DF_FTYPE_V4DF,
  V8DF_FTYPE_V2DF,
  V16SI_FTYPE_V4SI,
  V16SI_FTYPE_V8SI,
  V16SI_FTYPE_V16SF,
  V16SI_FTYPE_V16SI,
  V32HI_FTYPE_V32HI,
  V64QI_FTYPE_V64QI,
  V16SI_FTYPE_V16SI_V16SI_UHI,
  V8DI_FTYPE_V8DI_V8DI_UQI,
  V8DI_FTYPE_PV8DI,
  V8DI_FTYPE_V8DI,
  VOID_FTYPE_INT_INT64,
  DI_FTYPE_V2DI_INT,
  DOUBLE_FTYPE_V2DF_INT,
  FLOAT_FTYPE_V4SF_INT,
  FLOAT128_FTYPE_FLOAT128_FLOAT128,
  HI_FTYPE_V4HI_INT,
  HI_FTYPE_V8HI_INT,
  INT_FTYPE_V2DF_V2DF,
  INT_FTYPE_V2DI_V2DI,
  INT_FTYPE_V4DF_V4DF,
  INT_FTYPE_V4DI_V4DI,
  INT_FTYPE_V4SF_V4SF,
  INT_FTYPE_V8SF_V8SF,
  QI_FTYPE_V16QI_INT,
  QI_FTYPE_V8QI_INT,
  SI_FTYPE_V2SI_INT,
  SI_FTYPE_V4SI_INT,
  UINT_FTYPE_UINT_UCHAR,
  UINT_FTYPE_UINT_UINT,
  UINT_FTYPE_UINT_USHORT,
  UINT16_FTYPE_UINT16_INT,
  UINT64_FTYPE_UINT64_UINT64,
  UINT8_FTYPE_UINT8_INT,
  V16QI_FTYPE_V16QI_SI,
  V16QI_FTYPE_V16QI_V16QI,
  V16QI_FTYPE_V8HI_V8HI,
  V1DI_FTYPE_V1DI_SI,
  V1DI_FTYPE_V1DI_V1DI,
  V1DI_FTYPE_V2SI_V2SI,
  V1DI_FTYPE_V8QI_V8QI,
  V2DF_FTYPE_PCV2DF_V2DI,
  V2DF_FTYPE_V2DF_UINT,
  V2DF_FTYPE_V2DF_DI,
  V2DF_FTYPE_V2DF_INT,
  V2DF_FTYPE_V2DF_PCDOUBLE,
  V2DF_FTYPE_V2DF_SI,
  V2DF_FTYPE_V2DF_V2DF,
  V2DF_FTYPE_V2DF_V2DI,
  V2DF_FTYPE_V2DF_V4SF,
  V2DF_FTYPE_V4DF_INT,
  V2DF_FTYPE_V4DF_INT_V2DF_UQI,
  V2DF_FTYPE_V8DF_INT,
  V2DF_FTYPE_V8DF_INT_V2DF_UQI,
  V2DI_FTYPE_V16QI_V16QI,
  V2DI_FTYPE_V2DI_INT,
  V2DI_FTYPE_V2DI_INT_V2DI_UQI,
  V2DI_FTYPE_V2DI_SI,
  V2DI_FTYPE_V2DI_V16QI,
  V2DI_FTYPE_V2DI_V2DI,
  V2DI_FTYPE_V4SI_V4SI,
  V2DI_FTYPE_PCV2DI_V2DI,
  V2SF_FTYPE_V2SF_V2SF,
  V2SI_FTYPE_INT_INT,
  V2SI_FTYPE_V2SF_V2SF,
  V2SI_FTYPE_V2SI_SI,
  V2SI_FTYPE_V2SI_V2SI,
  V2SI_FTYPE_V4HI_V4HI,
  V4DF_FTYPE_PCV4DF_V4DI,
  V4DF_FTYPE_V4DF_INT,
  V8DF_FTYPE_V8DF_INT,
  V4DF_FTYPE_V8DF_INT,
  V4DF_FTYPE_V8DF_INT_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DF,
  V4DF_FTYPE_V4DF_V4DI,
  V4HI_FTYPE_V2SI_V2SI,
  V4HI_FTYPE_V4HI_INT,
  V4HI_FTYPE_V4HI_SI,
  V4HI_FTYPE_V4HI_V4HI,
  V4HI_FTYPE_V8QI_V8QI,
  V4SF_FTYPE_PCV4SF_V4SI,
  V4SF_FTYPE_V4SF_UINT,
  V4SF_FTYPE_V4SF_DI,
  V4SF_FTYPE_V4SF_INT,
  INT_FTYPE_V4SF_V4SF_INT_INT,
  INT_FTYPE_V2DF_V2DF_INT_INT,
  V4SF_FTYPE_V4SF_PCV2SF,
  V4SF_FTYPE_V4SF_SI,
  V4SF_FTYPE_V4SF_V2DF,
  V4SF_FTYPE_V4SF_V2SI,
  V4SF_FTYPE_V4SF_V4SF,
  V4SF_FTYPE_V4SF_V4SI,
  V4SF_FTYPE_V8SF_INT,
  V4SF_FTYPE_V8SF_INT_V4SF_UQI,
  V4SI_FTYPE_V2DF_V2DF,
  V4SI_FTYPE_V2DF_V4SI_UQI,
  V4SI_FTYPE_V4SI_INT,
  V4SI_FTYPE_V4SI_INT_V4SI_UQI,
  V4SI_FTYPE_V4SI_SI,
  V4SI_FTYPE_V4SI_V4SI,
  V4SI_FTYPE_V8HI_V8HI,
  V4SI_FTYPE_V8HI_V8HI_V4SI_UQI,
  V4SI_FTYPE_V8SI_INT,
  V4SI_FTYPE_V8SI_INT_V4SI_UQI,
  V4SI_FTYPE_PCV4SI_V4SI,
  V8HI_FTYPE_V16QI_V16QI,
  V8HI_FTYPE_V16QI_V16QI_V8HI_UQI,
  V8HI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_INT,
  V8DI_FTYPE_V8DI_INT,
  V8HI_FTYPE_V8HI_SI,
  V8HI_FTYPE_V8HI_V8HI,
  V8HI_FTYPE_V8SF_INT,
  V8HI_FTYPE_V8SF_INT_V8HI_UQI,
  V8HI_FTYPE_V4SF_INT,
  V8HI_FTYPE_V4SF_INT_V8HI_UQI,
  V8QI_FTYPE_V4HI_V4HI,
  V8QI_FTYPE_V8QI_V8QI,
  V8SF_FTYPE_PCV8SF_V8SI,
  V8SF_FTYPE_V8SF_INT,
  V8SF_FTYPE_V16SF_INT,
  V8SF_FTYPE_V16SF_INT_V8SF_UQI,
  V16SF_FTYPE_V16SF_INT,
  V4SF_FTYPE_V16SF_INT,
  V4SF_FTYPE_V16SF_INT_V4SF_UQI,
  V8SF_FTYPE_V8SF_V8SF,
  V16SF_FTYPE_V16SF_V16SF,
  V8SF_FTYPE_V8SF_V8SI,
  V32QI_FTYPE_V16HI_V16HI,
  V16HI_FTYPE_V8SI_V8SI,
  V8DF_FTYPE_V8DF_V2DF_INT,
  V8DF_FTYPE_V8DF_V2DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V4DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_INT,
  V8DF_FTYPE_V8DF_V8DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_INT_V8DF_QI_INT,
  V8DF_FTYPE_V8DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_V8DI_INT,
  V4DF_FTYPE_V4DF_V4DF_V4DI_INT_UQI,
  V2DF_FTYPE_V2DF_V2DF_V2DI_INT_UQI,
  V8DF_FTYPE_V8DF_V8DF_V8DI_INT_QI_INT,
  V8DF_FTYPE_V8DF_V8DF,
  V16SF_FTYPE_V16SF_V16SF_INT,
  V16SF_FTYPE_V16SF_V16SF_INT_V16SF_UHI,
  V16SF_FTYPE_V16SF_V16SF_INT_V16SF_HI_INT,
  V16SF_FTYPE_V16SF_INT_V16SF_UHI,
  V16SI_FTYPE_V16SI_V4SI_INT_V16SI_UHI,
  V16SF_FTYPE_V16SF_V16SF_V16SI_INT,
  V16SF_FTYPE_V16SF_V16SF_V16SI_INT_HI_INT,
  V8SF_FTYPE_V8SF_V8SF_V8SI_INT_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SI_INT_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SI_INT_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DI_INT_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_INT_V2DF_UQI_INT,
  V4SF_FTYPE_V4SF_V4SF_INT_V4SF_UQI_INT,
  V16SF_FTYPE_V16SF_V4SF_INT,
  V16SF_FTYPE_V16SF_V4SF_INT_V16SF_UHI,
  V16SF_FTYPE_V16SF_V8SF_INT_V16SF_UHI,
  V32QI_FTYPE_V32QI_V32QI,
  V16HI_FTYPE_V32QI_V32QI,
  V16HI_FTYPE_V32QI_V32QI_V16HI_UHI,
  V32HI_FTYPE_V64QI_V64QI_V32HI_USI,
  V16HI_FTYPE_V16HI_V8HI,
  V16HI_FTYPE_V16HI_V16HI,
  V32HI_FTYPE_V32HI_INT,
  V16HI_FTYPE_V16HI_INT,
  V16HI_FTYPE_V16SF_INT,
  V16HI_FTYPE_V16SF_INT_V16HI_UHI,
  V16HI_FTYPE_V16HI_SI,
  V16HI_FTYPE_V16HI_V16HI_INT,
  V32QI_FTYPE_V32QI_V32QI_INT,
  V8SI_FTYPE_V4DF_V4DF,
  V8SI_FTYPE_V8SI_V4SI,
  V16SI_FTYPE_V16SI_V4SI_INT,
  V16SI_FTYPE_V16SI_V8SI_INT_V16SI_UHI,
  V4SI_FTYPE_V16SI_INT,
  V4SI_FTYPE_V16SI_INT_V4SI_UQI,
  V8SI_FTYPE_V8SI_V8SI,
  V16SI_FTYPE_V16SI_V16SI_INT_V16SI_UHI,
  V8SI_FTYPE_V16HI_V16HI,
  V8SI_FTYPE_V16HI_V16HI_V8SI_UQI,
  V16SI_FTYPE_V32HI_V32HI_V16SI_UHI,
  V8SI_FTYPE_V8SI_INT,
  V8SI_FTYPE_V8SI_INT_V8SI_UQI,
  V8SI_FTYPE_V16SI_INT,
  V8SI_FTYPE_V16SI_INT_V8SI_UQI,
  V8SI_FTYPE_V8SI_SI,
  V16SI_FTYPE_V16SI_INT,
  V16SI_FTYPE_V16SI_V4SI_V16SI_UHI,
  V16SI_FTYPE_V16SI_INT_V16SI_UHI,
  V8SI_FTYPE_PCV8SI_V8SI,
  V4DI_FTYPE_V4DI_V4DI,
  V16SI_FTYPE_V8DF_V8DF,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UQI,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UDI,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_USI,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UHI,
  V8DI_FTYPE_V8DI_V4DI_INT,
  V8DI_FTYPE_V8DI_V2DI_INT,
  V8DI_FTYPE_V8DI_V2DI_INT_V8DI_UQI,
  V8DI_FTYPE_V8DI_V4DI_INT_V8DI_UQI,
  V4DI_FTYPE_V8SI_V8SI,
  V8DI_FTYPE_V64QI_V64QI,
  V4DI_FTYPE_V4DI_V2DI,
  V4DI_FTYPE_PCV4DI_V4DI,
  V4DI_FTYPE_V8DI_INT,
  V4DI_FTYPE_V8DI_INT_V4DI_UQI,
  V8DI_FTYPE_V8DI_V2DI_V8DI_UQI,
  V8DI_FTYPE_V8DI_INT_V8DI_UQI,
  V4DI_FTYPE_V4DI_INT,
  V4DI_FTYPE_V4DI_INT_V4DI_UQI,
  V2DI_FTYPE_V4DI_INT,
  VOID_FTYPE_PVOID_INT64,
  V2DI_FTYPE_V4DI_INT_V2DI_UQI,
  V2DI_FTYPE_V8DI_INT,
  V2DI_FTYPE_V8DI_INT_V2DI_UQI,
  VOID_FTYPE_PCHAR_V16QI,
  VOID_FTYPE_PCHAR_V32QI,
  VOID_FTYPE_PDOUBLE_V2DF,
  VOID_FTYPE_PDOUBLE_V4DF,
  VOID_FTYPE_PDOUBLE_V8DF,
  VOID_FTYPE_PFLOAT_V4SF,
  VOID_FTYPE_PFLOAT_V8SF,
  VOID_FTYPE_PFLOAT_V16SF,
  VOID_FTYPE_PINT_INT,
  VOID_FTYPE_PUNSIGNED_UNSIGNED,
  VOID_FTYPE_PVOID_PCVOID,
  VOID_FTYPE_PLONGLONG_LONGLONG,
  VOID_FTYPE_PULONGLONG_ULONGLONG,
  VOID_FTYPE_PV2SI_V2SI,
  VOID_FTYPE_PV2DI_V2DI,
  VOID_FTYPE_PV2SF_V4SF,
  VOID_FTYPE_PV4DI_V4DI,
  VOID_FTYPE_PV4SF_V4SF,
  VOID_FTYPE_PV8SF_V8SF,
  VOID_FTYPE_UNSIGNED_UNSIGNED,
  VOID_FTYPE_UNSIGNED_UNSIGNED_UNSIGNED,
  VOID_FTYPE_PV8DI_V8DI,
  V16SF_FTYPE_V16SF_V16SF_V16SF_V16SF_V16SF_PCV4SF_V16SF_UHI,
  V16SF_FTYPE_V16SF_V16SF_V16SF_V16SF_V16SF_PCV4SF,
  V4SF_FTYPE_V4SF_V4SF_V4SF_V4SF_V4SF_PCV4SF,
  V4SF_FTYPE_V4SF_V4SF_V4SF_V4SF_V4SF_PCV4SF_V4SF_UQI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_V16SI_V16SI_PCV4SI_V16SI_UHI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_V16SI_V16SI_PCV4SI,
  UCHAR_FTYPE_UQI_UQI_PUCHAR,
  UCHAR_FTYPE_UQI_UQI,
  UCHAR_FTYPE_UHI_UHI_PUCHAR,
  UCHAR_FTYPE_UHI_UHI,
  UCHAR_FTYPE_USI_USI_PUCHAR,
  UCHAR_FTYPE_USI_USI,
  UCHAR_FTYPE_UDI_UDI_PUCHAR,
  UCHAR_FTYPE_UDI_UDI,
  USI_FTYPE_UQI,
  USI_FTYPE_UHI,
  UQI_FTYPE_USI,
  UHI_FTYPE_USI,
  UHI_FTYPE_UHI_UQI,
  USI_FTYPE_USI_UQI,
  UDI_FTYPE_UDI_UQI,
  UQI_FTYPE_UQI,
  UHI_FTYPE_UHI,
  USI_FTYPE_USI,
  UDI_FTYPE_UDI,
  UHI_FTYPE_V16QI,
  USI_FTYPE_V32QI,
  UDI_FTYPE_V64QI,
  UQI_FTYPE_V8HI,
  UHI_FTYPE_V16HI,
  USI_FTYPE_V32HI,
  UQI_FTYPE_V4SI,
  UQI_FTYPE_V8SI,
  UHI_FTYPE_V16SI,
  UQI_FTYPE_V2DI,
  UQI_FTYPE_V4DI,
  UQI_FTYPE_V8DI,
  UQI_FTYPE_UQI_UQI,
  UHI_FTYPE_UHI_UHI,
  USI_FTYPE_USI_USI,
  UDI_FTYPE_UDI_UDI,
  UHI_FTYPE_V16QI_V16QI_UHI,
  UHI_FTYPE_V16QI_V16QI_INT_UHI,
  USI_FTYPE_V32QI_V32QI_USI,
  USI_FTYPE_V32QI_V32QI_INT_USI,
  UDI_FTYPE_V64QI_V64QI_UDI,
  UDI_FTYPE_V64QI_V64QI_INT_UDI,
  UQI_FTYPE_V8HI_V8HI_UQI,
  UQI_FTYPE_V8HI_V8HI_INT_UQI,
  UHI_FTYPE_V16HI_V16HI_UHI,
  UHI_FTYPE_V16HI_V16HI_INT_UHI,
  USI_FTYPE_V32HI_V32HI_USI,
  USI_FTYPE_V32HI_V32HI_INT_USI,
  UQI_FTYPE_V4SI_V4SI_UQI,
  UQI_FTYPE_V4SI_V4SI_INT_UQI,
  UQI_FTYPE_V8SI_V8SI_UQI,
  UQI_FTYPE_V8SI_V8SI_INT_UQI,
  UQI_FTYPE_V2DI_V2DI_UQI,
  UQI_FTYPE_V2DI_V2DI_INT_UQI,
  UQI_FTYPE_V4DI_V4DI_UQI,
  UQI_FTYPE_V4DI_V4DI_INT_UQI,
  UQI_FTYPE_V8DI_V8DI_UQI,
  UHI_FTYPE_V16SI_V16SI_UHI,
  UQI_FTYPE_V8DI_V8UDI_INT,
  UQI_FTYPE_V8DI_V8DI_INT_UQI,
  UHI_FTYPE_V16SI_V16SI_INT,
  UHI_FTYPE_V16SI_V16SI_INT_UHI,
  UQI_FTYPE_V8DF_V8DF_INT,
  UQI_FTYPE_V8DF_V8DF_INT_UQI_INT,
  UHI_FTYPE_V16SF_V16SF_INT,
  UHI_FTYPE_V16SF_V16SF_INT_UHI_INT,
  UQI_FTYPE_V2DF_V2DF_INT,
  UQI_FTYPE_V2DF_V2DF_INT_UQI,
  UQI_FTYPE_V2DF_V2DF_INT_UQI_INT,
  UQI_FTYPE_V4SF_V4SF_INT,
  UQI_FTYPE_V4SF_V4SF_INT_UQI,
  UQI_FTYPE_V4SF_V4SF_INT_UQI_INT,
  V16SI_FTYPE_UHI,
  V8DI_FTYPE_UQI,
  V16QI_FTYPE_UHI,
  V32QI_FTYPE_USI,
  V64QI_FTYPE_UDI,
  V8HI_FTYPE_UQI,
  V16HI_FTYPE_UHI,
  V32HI_FTYPE_USI,
  V4SI_FTYPE_UQI,
  V4SI_FTYPE_UHI,
  V8SI_FTYPE_UQI,
  V8SI_FTYPE_UHI,
  V2DI_FTYPE_UQI,
  V4DI_FTYPE_UQI,
  INT_FTYPE_V16QI_V16QI_INT,
  UCHAR_FTYPE_UINT_UINT_UINT,
  UCHAR_FTYPE_UINT64_UINT_UINT,
  V16HI_FTYPE_V16HI_V16HI_V16HI,
  V16QI_FTYPE_V16QI_QI_INT,
  V16QI_FTYPE_V16QI_V16QI_INT,
  V16QI_FTYPE_V16QI_V16QI_V16QI,
  V1DI_FTYPE_V1DI_V1DI_INT,
  V2DF_FTYPE_V2DF_V2DF_INT,
  V2DF_FTYPE_V2DF_V2DF_INT_INT,
  V4DF_FTYPE_V4DF_V4DI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF,
  V2DF_FTYPE_V2DI_V2DF_V2DF_UQI,
  V2DF_FTYPE_V2DF_V2DI_V2DF_UQI,
  V2DF_FTYPE_V2DF_V2DF_V2DI_INT,
  V2DI_FTYPE_V2DI_DI_INT,
  V2DI_FTYPE_V2DI_UINT_UINT,
  V2DI_FTYPE_V2DI_V2DI_INT,
  V2DI_FTYPE_V2DI_V2DI_V2DI,
  V32QI_FTYPE_V32QI_V32QI_V32QI,
  V4DF_FTYPE_V4DF_V2DF_INT,
  V4DF_FTYPE_V4DF_V2DF_INT_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DF_INT,
  V4DF_FTYPE_V4DF_V4DF_V4DF,
  V4DF_FTYPE_V4DF_V4DF_V4DI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT,
  V4DI_FTYPE_V4DI_V4DI_V4DI,
  V4HI_FTYPE_V4HI_HI_INT,
  V4SF_FTYPE_V4SF_FLOAT_INT,
  V4SF_FTYPE_V4SF_V4SF_INT,
  V4SF_FTYPE_V4SF_V4SF_INT_INT,
  V4SF_FTYPE_V4SF_V2DF_INT,
  V2DF_FTYPE_V2DF_V4SF_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF,
  V4SF_FTYPE_V4SI_V4SF_V4SF_UQI,
  V4SF_FTYPE_V4SF_V4SI_V4SF_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SF_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SI_INT,
  V4SI_FTYPE_V4SI_SI_INT,
  V4SI_FTYPE_V4SI_V4SI_INT,
  V4SI_FTYPE_V4SI_V4SI_V2DI,
  V4SI_FTYPE_V4SI_V4SI_V4SI,
  V8HI_FTYPE_V8HI_HI_INT,
  V8HI_FTYPE_V8HI_V8HI_INT,
  V8HI_FTYPE_V8HI_V8HI_V4SI,
  V8HI_FTYPE_V8HI_V8HI_V8HI,
  V8SF_FTYPE_V8SF_V4SF_INT,
  V8SF_FTYPE_V8SF_V4SF_INT_V8SF_UQI,
  V8SF_FTYPE_V8SF_V8SF_INT,
  V8SF_FTYPE_V8SF_V8SF_V8SF,
  V8SF_FTYPE_V8SF_V8SF_V8SI_INT,
  V8SI_FTYPE_V8SI_V4SI_INT,
  V8SI_FTYPE_V8SI_V4SI_INT_V8SI_UQI,
  V8SI_FTYPE_V8SI_V8SI_INT,
  V8SI_FTYPE_V8SI_V8SI_V8SI,
  V4DI_FTYPE_V4DI_V4DI_INT,
  V4DI_FTYPE_V4DI_V2DI_INT,
  V4DI_FTYPE_V4DI_V2DI_INT_V4DI_UQI,
  V2DF_FTYPE_V2DF_V2DF_UQI,
  V2DF_FTYPE_V4SF_V2DF_UQI,
  V2DF_FTYPE_V4SI_V2DF_UQI,
  V4DF_FTYPE_V4DF_V4DF_UQI,
  V4DF_FTYPE_V4SF_V4DF_UQI,
  V4DF_FTYPE_V4SI_V4DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_UQI,
  V8DF_FTYPE_V8SI_V8DF_UQI,
  V2DI_FTYPE_V4SI_V2DI_UQI,
  V2DI_FTYPE_V8HI_V2DI_UQI,
  V4DI_FTYPE_V4DF_V4DI_UQI,
  V2DI_FTYPE_V2DF_V2DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_V2DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UQI,
  V4DI_FTYPE_V4DI_V4DI_V4DI_UQI,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_UQI,
  V8DI_FTYPE_V8SI_V8DI_UQI,
  V8DI_FTYPE_V8HI_V8DI_UQI,
  V8DI_FTYPE_V16QI_V8DI_UQI,
  V2DI_FTYPE_V16QI_V2DI_UQI,
  V4DI_FTYPE_V16QI_V4DI_UQI,
  V4DI_FTYPE_V4DI_V4DI_UQI,
  V4DI_FTYPE_V4SI_V4DI_UQI,
  V4DI_FTYPE_V8HI_V4DI_UQI,
  V8DI_FTYPE_V8DI_V8DI_V8DI_UQI,
  V8DF_FTYPE_V8DI_V8DF_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DI_V8DF_UQI,
  V4DF_FTYPE_V4DI_V4DF_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DI_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DF_V4DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_V8DF_UQI,
  V16QI_FTYPE_V16QI_V16QI_V16QI_UHI,
  V16HI_FTYPE_V16HI_V16HI_V16HI_UHI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_UHI,
  V2DF_FTYPE_V2DF_V2DF_V2DF_UQI,
  V32HI_FTYPE_V32HI_V32HI_V32HI_USI,
  V64QI_FTYPE_V64QI_V64QI_V64QI_UDI,
  V32QI_FTYPE_V32QI_V32QI_V32QI_USI,
  V8HI_FTYPE_V8HI_V8HI_V8HI_UQI,
  V4SF_FTYPE_V4SF_V4SF_UQI,
  V4SF_FTYPE_V4SI_V4SF_UQI,
  V8SF_FTYPE_V8SF_V8SF_UQI,
  V8SF_FTYPE_V8SI_V8SF_UQI,
  V16SF_FTYPE_V16SF_V16SF_UHI,
  V4SI_FTYPE_V16QI_V4SI_UQI,
  V4SI_FTYPE_V8HI_V4SI_UQI,
  V8SI_FTYPE_V8SI_V8SI_UQI,
  V8SI_FTYPE_V8HI_V8SI_UQI,
  V8SI_FTYPE_V16QI_V8SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_V4SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_INT_V4SI_UQI,
  V8SF_FTYPE_V8SF_V8SF_V8SF_UQI,
  V8SF_FTYPE_V8SI_V8SF_V8SF_UQI,
  V8SF_FTYPE_V8SF_V8SI_V8SF_UQI,
  V8SI_FTYPE_V8SI_V8SI_V8SI_UQI,
  V8SI_FTYPE_V8SI_V8SI_INT_V8SI_UQI,
  V16SF_FTYPE_V16SF_V16SF_V16SF_UHI,
  V16SF_FTYPE_V16SI_V16SF_V16SF_UHI,
  V16SF_FTYPE_V16SF_V16SI_V16SF_UHI,
  V16SF_FTYPE_V8SF_V16SF_UHI,
  V16SF_FTYPE_V4SF_V16SF_UHI,
  V8DF_FTYPE_V4DF_V8DF_UQI,
  V8DF_FTYPE_V2DF_V8DF_UQI,
  V16SI_FTYPE_V8SI_V16SI_UHI,
  V16SI_FTYPE_V4SI_V16SI_UHI,
  V16SI_FTYPE_SI_V16SI_UHI,
  V16SI_FTYPE_V16HI_V16SI_UHI,
  V16SI_FTYPE_V16QI_V16SI_UHI,
  V8DI_FTYPE_V4DI_V8DI_UQI,
  V4SI_FTYPE_V4DF_V4SI_UQI,
  V8DI_FTYPE_V2DI_V8DI_UQI,
  V8DI_FTYPE_DI_V8DI_UQI,
  V16QI_FTYPE_V16SI_V16QI_UHI,
  V16QI_FTYPE_V8DI_V16QI_UQI,
  V32HI_FTYPE_V32HI_V32HI_USI,
  V32HI_FTYPE_V64QI_V64QI_INT,
  V32HI_FTYPE_V32QI_V32HI_USI,
  V16HI_FTYPE_V16HI_V16HI_UHI,
  V16HI_FTYPE_V32QI_V32QI_INT,
  V16HI_FTYPE_V16QI_V16HI_UHI,
  V8HI_FTYPE_V16QI_V8HI_UQI,
  V8HI_FTYPE_V16QI_V16QI_INT,
  V8SF_FTYPE_V4SF_V8SF_UQI,
  V4DF_FTYPE_V2DF_V4DF_UQI,
  V8SI_FTYPE_V4SI_V8SI_UQI,
  V8SI_FTYPE_SI_V8SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_UQI,
  V4SI_FTYPE_SI_V4SI_UQI,
  V4DI_FTYPE_V2DI_V4DI_UQI,
  V4DI_FTYPE_DI_V4DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_UQI,
  V2DI_FTYPE_DI_V2DI_UQI,
  V64QI_FTYPE_V64QI_V64QI_UDI,
  V64QI_FTYPE_V16QI_V64QI_UDI,
  V64QI_FTYPE_QI_V64QI_UDI,
  V32QI_FTYPE_V32QI_V32QI_USI,
  V32QI_FTYPE_V16QI_V32QI_USI,
  V32QI_FTYPE_QI_V32QI_USI,
  V16QI_FTYPE_V16QI_V16QI_UHI,
  V16QI_FTYPE_QI_V16QI_UHI,
  V32HI_FTYPE_V8HI_V32HI_USI,
  V32HI_FTYPE_HI_V32HI_USI,
  V16HI_FTYPE_V8HI_V16HI_UHI,
  V16HI_FTYPE_HI_V16HI_UHI,
  V8HI_FTYPE_V8HI_V8HI_UQI,
  V8HI_FTYPE_HI_V8HI_UQI,
  V16SF_FTYPE_PCV16SF_V16SF_UHI,
  V8DF_FTYPE_PCV8DF_V8DF_UQI,
  V16SI_FTYPE_PCV16SI_V16SI_UHI,
  V8SF_FTYPE_PCV8SF_V8SF_UQI,
  V8DI_FTYPE_PCV8DI_V8DI_UQI,
  V8SI_FTYPE_PCV8SI_V8SI_UQI,
  V4DF_FTYPE_PCV4DF_V4DF_UQI,
  V4SF_FTYPE_PCV4SF_V4SF_UQI,
  V4DI_FTYPE_PCV4DI_V4DI_UQI,
  V4SI_FTYPE_PCV4SI_V4SI_UQI,
  V2DF_FTYPE_PCV2DF_V2DF_UQI,
  V2DI_FTYPE_PCV2DI_V2DI_UQI,
  V64QI_FTYPE_PCCHAR_V64QI_UDI,
  V32HI_FTYPE_PCSHORT_V32HI_USI,
  V32QI_FTYPE_PCCHAR_V32QI_USI,
  V16SF_FTYPE_PCFLOAT_V16SF_UHI,
  V8DF_FTYPE_PCDOUBLE_V8DF_UQI,
  V16SI_FTYPE_PCINT_V16SI_UHI,
  V16HI_FTYPE_PCSHORT_V16HI_UHI,
  V16QI_FTYPE_PCCHAR_V16QI_UHI,
  V8SF_FTYPE_PCFLOAT_V8SF_UQI,
  V8DI_FTYPE_PCINT64_V8DI_UQI,
  V8SI_FTYPE_PCINT_V8SI_UQI,
  V8HI_FTYPE_PCSHORT_V8HI_UQI,
  V4DF_FTYPE_PCDOUBLE_V4DF_UQI,
  V4SF_FTYPE_PCFLOAT_V4SF_UQI,
  V4DI_FTYPE_PCINT64_V4DI_UQI,
  V4SI_FTYPE_PCINT_V4SI_UQI,
  V2DF_FTYPE_PCDOUBLE_V2DF_UQI,
  V2DI_FTYPE_PCINT64_V2DI_UQI,
  V16HI_FTYPE_V16SI_V16HI_UHI,
  V8SI_FTYPE_V8DI_V8SI_UQI,
  V8HI_FTYPE_V8DI_V8HI_UQI,
  V16QI_FTYPE_V8HI_V16QI_UQI,
  V16QI_FTYPE_V16HI_V16QI_UHI,
  V16QI_FTYPE_V4SI_V16QI_UQI,
  V16QI_FTYPE_V8SI_V16QI_UQI,
  V8HI_FTYPE_V4SI_V8HI_UQI,
  V8HI_FTYPE_V8SI_V8HI_UQI,
  V16QI_FTYPE_V2DI_V16QI_UQI,
  V16QI_FTYPE_V4DI_V16QI_UQI,
  V8HI_FTYPE_V2DI_V8HI_UQI,
  V8HI_FTYPE_V4DI_V8HI_UQI,
  V4SI_FTYPE_V2DI_V4SI_UQI,
  V4SI_FTYPE_V4DI_V4SI_UQI,
  V32QI_FTYPE_V32HI_V32QI_USI,
  V2DF_FTYPE_V2DF_INT_V2DF_UQI,
  V4DF_FTYPE_V4DF_INT_V4DF_UQI,
  V4SF_FTYPE_V4SF_INT_V4SF_UQI,
  V8SF_FTYPE_V8SF_INT_V8SF_UQI,
  V4DF_FTYPE_V4DF_V4DF_INT_V4DF_UQI,
  V2DF_FTYPE_V2DF_V2DF_INT_V2DF_UQI,
  V8SF_FTYPE_V8SF_V8SF_INT_V8SF_UQI,
  V4SF_FTYPE_V4SF_V4SF_INT_V4SF_UQI,
  VOID_FTYPE_PV8DF_V8DF_UQI,
  VOID_FTYPE_PV8SI_V8DI_UQI,
  VOID_FTYPE_PV8HI_V8DI_UQI,
  VOID_FTYPE_PV8HI_V4DI_UQI,
  VOID_FTYPE_PV8HI_V2DI_UQI,
  VOID_FTYPE_PV4SI_V4DI_UQI,
  VOID_FTYPE_PV4SI_V2DI_UQI,
  VOID_FTYPE_PV8HI_V8SI_UQI,
  VOID_FTYPE_PV8HI_V4SI_UQI,
  VOID_FTYPE_PV4DF_V4DF_UQI,
  VOID_FTYPE_PV2DF_V2DF_UQI,
  VOID_FTYPE_PV16SF_V16SF_UHI,
  VOID_FTYPE_PV8SF_V8SF_UQI,
  VOID_FTYPE_PV4SF_V4SF_UQI,
  VOID_FTYPE_PV8DI_V8DI_UQI,
  VOID_FTYPE_PV4DI_V4DI_UQI,
  VOID_FTYPE_PV2DI_V2DI_UQI,
  VOID_FTYPE_PV16SI_V16SI_UHI,
  VOID_FTYPE_PV16HI_V16SI_UHI,
  VOID_FTYPE_PV16QI_V16SI_UHI,
  VOID_FTYPE_PV16QI_V8SI_UQI,
  VOID_FTYPE_PV16QI_V4SI_UQI,
  VOID_FTYPE_PV16QI_V8DI_UQI,
  VOID_FTYPE_PV16QI_V4DI_UQI,
  VOID_FTYPE_PV16QI_V2DI_UQI,
  VOID_FTYPE_PV8SI_V8SI_UQI,
  VOID_FTYPE_PV4SI_V4SI_UQI,
  VOID_FTYPE_PDOUBLE_V8DF_UQI,
  VOID_FTYPE_PDOUBLE_V4DF_UQI,
  VOID_FTYPE_PDOUBLE_V2DF_UQI,
  VOID_FTYPE_PFLOAT_V16SF_UHI,
  VOID_FTYPE_PFLOAT_V8SF_UQI,
  VOID_FTYPE_PFLOAT_V4SF_UQI,
  VOID_FTYPE_PINT64_V8DI_UQI,
  VOID_FTYPE_PINT64_V4DI_UQI,
  VOID_FTYPE_PINT64_V2DI_UQI,
  VOID_FTYPE_PINT_V16SI_UHI,
  VOID_FTYPE_PINT_V8SI_UQI,
  VOID_FTYPE_PINT_V4SI_UQI,
  VOID_FTYPE_PSHORT_V32HI_USI,
  VOID_FTYPE_PSHORT_V16HI_UHI,
  VOID_FTYPE_PSHORT_V8HI_UQI,
  VOID_FTYPE_PCHAR_V64QI_UDI,
  VOID_FTYPE_PCHAR_V32QI_USI,
  VOID_FTYPE_PCHAR_V16QI_UHI,
  V8DI_FTYPE_V8DI_V8DI_V8DI_INT_UQI,
  V8SI_FTYPE_V8SF_V8SI_UQI,
  V4SI_FTYPE_V4SF_V4SI_UQI,
  V4DI_FTYPE_V4SF_V4DI_UQI,
  V2DI_FTYPE_V4SF_V2DI_UQI,
  V4SF_FTYPE_V4DI_V4SF_UQI,
  V4SF_FTYPE_V2DI_V4SF_UQI,
  V4DF_FTYPE_V4DI_V4DF_UQI,
  V2DF_FTYPE_V2DI_V2DF_UQI,
  V32HI_FTYPE_V32HI_INT_V32HI_USI,
  V32HI_FTYPE_V32HI_V8HI_V32HI_USI,
  V16HI_FTYPE_V16HI_INT_V16HI_UHI,
  V16HI_FTYPE_V16HI_V8HI_V16HI_UHI,
  V8HI_FTYPE_V8HI_INT_V8HI_UQI,
  V32HI_FTYPE_V64QI_V64QI_INT_V32HI_USI,
  V16HI_FTYPE_V32QI_V32QI_INT_V16HI_UHI,
  V8HI_FTYPE_V16QI_V16QI_INT_V8HI_UQI,
  V64QI_FTYPE_V32HI_V32HI_V64QI_UDI,
  V32QI_FTYPE_V16HI_V16HI_V32QI_USI,
  V16QI_FTYPE_V8HI_V8HI_V16QI_UHI,
  V32HI_FTYPE_V16SI_V16SI_V32HI_USI,
  V16HI_FTYPE_V8SI_V8SI_V16HI_UHI,
  V8HI_FTYPE_V4SI_V4SI_V8HI_UQI,
  V8DI_FTYPE_V16SI_V16SI_V8DI_UQI,
  V4DI_FTYPE_V8SI_V8SI_V4DI_UQI,
  V2DI_FTYPE_V4SI_V4SI_V2DI_UQI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_INT_UHI,
  V8SI_FTYPE_V8SI_V8SI_V8SI_INT_UQI,
  V4DI_FTYPE_V4DI_V4DI_V4DI_INT_UQI,
  V4SI_FTYPE_V4SI_V4SI_V4SI_INT_UQI,
  V2DI_FTYPE_V2DI_V2DI_V2DI_INT_UQI,
  VOID_FTYPE_PCVOID_UNSIGNED_UNSIGNED,
  VOID_FTYPE_PV2DF_V2DI_V2DF,
  VOID_FTYPE_PV4DF_V4DI_V4DF,
  VOID_FTYPE_PV4SF_V4SI_V4SF,
  VOID_FTYPE_PV8SF_V8SI_V8SF,
  VOID_FTYPE_PV2DI_V2DI_V2DI,
  VOID_FTYPE_PV4DI_V4DI_V4DI,
  VOID_FTYPE_PV4SI_V4SI_V4SI,
  VOID_FTYPE_PV8SI_V8SI_V8SI,
  VOID_FTYPE_UINT_UINT_UINT,
  VOID_FTYPE_UINT64_UINT_UINT,
  VOID_FTYPE_V16QI_V16QI_PCHAR,
  VOID_FTYPE_V8QI_V8QI_PCHAR,
  V8SI_FTYPE_V8SI_V4SI_V8SI_UQI,
  V4DI_FTYPE_V4DI_V2DI_V4DI_UQI,
  QI_FTYPE_V8DF_INT,
  QI_FTYPE_V4DF_INT,
  QI_FTYPE_V4DF_V4DF_INT_UQI,
  QI_FTYPE_V2DF_INT,
  HI_FTYPE_V16SF_INT,
  QI_FTYPE_V8SF_INT,
  QI_FTYPE_V8SF_V8SF_INT_UQI,
  QI_FTYPE_V4SF_INT,
  QI_FTYPE_V8DF_INT_UQI,
  QI_FTYPE_V4DF_INT_UQI,
  QI_FTYPE_V2DF_INT_UQI,
  HI_FTYPE_V16SF_INT_UHI,
  QI_FTYPE_V8SF_INT_UQI,
  QI_FTYPE_V4SF_INT_UQI,
  VOID_FTYPE_PV32QI_V32HI_USI,
  V2DI_FTYPE_V2DI_V2DI_UINT_UINT,
  V4HI_FTYPE_HI_HI_HI_HI,
  INT_FTYPE_V16QI_INT_V16QI_INT_INT,
  V16QI_FTYPE_V16QI_INT_V16QI_INT_INT,
  V8QI_FTYPE_QI_QI_QI_QI_QI_QI_QI_QI,
  UCHAR_FTYPE_UCHAR_UINT_UINT_PUNSIGNED,
  UCHAR_FTYPE_UCHAR_ULONGLONG_ULONGLONG_PULONGLONG,
  UINT64_FTYPE_V2DF_INT,
  UINT64_FTYPE_V4SF_INT,
  UINT_FTYPE_V2DF_INT,
  UINT_FTYPE_V4SF_INT,
  INT64_FTYPE_V2DF_INT,
  INT64_FTYPE_V4SF_INT,
  INT_FTYPE_V2DF_INT,
  INT_FTYPE_V4SF_INT,
  V2DF_FTYPE_V2DF_UINT64_INT,
  V4SF_FTYPE_V4SF_UINT64_INT,
  V4SF_FTYPE_V4SF_UINT_INT,
  V2DF_FTYPE_V2DF_INT64_INT,
  V4SF_FTYPE_V4SF_INT64_INT,
  V4SF_FTYPE_V4SF_INT_INT,
  V16SI_FTYPE_V16SF_V16SI_HI_INT,
  V16SF_FTYPE_V16SI_V16SF_HI_INT,
  V16SF_FTYPE_V16SF_V16SF_HI_INT,
  V16SF_FTYPE_V16HI_V16SF_HI_INT,
  V8SI_FTYPE_V8DF_V8SI_QI_INT,
  V8SF_FTYPE_V8DF_V8SF_QI_INT,
  V8DF_FTYPE_V8DF_V8DF_QI_INT,
  V8DF_FTYPE_V8SF_V8DF_QI_INT,
  V8DI_FTYPE_V8DF_V8DI_QI_INT,
  V8DI_FTYPE_V8SF_V8DI_QI_INT,
  V8DF_FTYPE_V8DI_V8DF_QI_INT,
  V8SF_FTYPE_V8DI_V8SF_QI_INT,
  V16SF_FTYPE_V16SF_V16SF_V16SF_HI_INT,
  V8DF_FTYPE_V8DF_V8DF_V8DF_UQI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF_UQI_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF_UQI_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF_QI_INT,
  V4SF_FTYPE_V4SF_V2DF_V4SF_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF_QI_INT,
  V2DF_FTYPE_V2DF_V4SF_V2DF_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF_INT,
  V16SF_FTYPE_V16SF_INT_V16SF_HI_INT,
  V8DF_FTYPE_V8DF_INT_V8DF_QI_INT,
  V4SF_FTYPE_V4SF_V4SF_INT_V4SF_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_INT_V2DF_QI_INT,
  V2DF_FTYPE_V2DF_PCDOUBLE_V4SI_V2DF_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V4SI_V4DF_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V8SI_V4DF_INT,
  V2DF_FTYPE_V2DF_PCDOUBLE_V2DI_V2DF_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V4DI_V4DF_INT,
  V4SF_FTYPE_V4SF_PCFLOAT_V4SI_V4SF_INT,
  V8SF_FTYPE_V8SF_PCFLOAT_V8SI_V8SF_INT,
  V4SF_FTYPE_V4SF_PCFLOAT_V2DI_V4SF_INT,
  V4SF_FTYPE_V4SF_PCFLOAT_V4DI_V4SF_INT,
  V8SF_FTYPE_V8SF_PCFLOAT_V4DI_V8SF_INT,
  V2DI_FTYPE_V2DI_PCINT64_V4SI_V2DI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V4SI_V4DI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V8SI_V4DI_INT,
  V2DI_FTYPE_V2DI_PCINT64_V2DI_V2DI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V4DI_V4DI_INT,
  V4SI_FTYPE_V4SI_PCINT_V4SI_V4SI_INT,
  V8SI_FTYPE_V8SI_PCINT_V8SI_V8SI_INT,
  V4SI_FTYPE_V4SI_PCINT_V2DI_V4SI_INT,
  V4SI_FTYPE_V4SI_PCINT_V4DI_V4SI_INT,
  V8SI_FTYPE_V8SI_PCINT_V4DI_V8SI_INT,
  V16SF_FTYPE_V16SF_PCFLOAT_V8DI_HI_INT,
  V8DF_FTYPE_V8DF_PCDOUBLE_V16SI_QI_INT,
  V16SI_FTYPE_V16SI_PCINT_V8DI_HI_INT,
  V8DI_FTYPE_V8DI_PCINT64_V16SI_QI_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V8SI_QI_INT,
  V8SF_FTYPE_V8SF_PCFLOAT_V4DI_QI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V8SI_QI_INT,
  V8SI_FTYPE_V8SI_PCINT_V4DI_QI_INT,
  VOID_FTYPE_PFLOAT_HI_V8DI_V16SF_INT,
  VOID_FTYPE_PDOUBLE_QI_V16SI_V8DF_INT,
  VOID_FTYPE_PINT_HI_V8DI_V16SI_INT,
  VOID_FTYPE_PLONGLONG_QI_V16SI_V8DI_INT,
  V16SF_FTYPE_V16SF_PCVOID_V16SI_HI_INT,
  V8DF_FTYPE_V8DF_PCVOID_V8SI_QI_INT,
  V8SF_FTYPE_V8SF_PCVOID_V8DI_QI_INT,
  V8DF_FTYPE_V8DF_PCVOID_V8DI_QI_INT,
  V16SI_FTYPE_V16SI_PCVOID_V16SI_HI_INT,
  V8DI_FTYPE_V8DI_PCVOID_V8SI_QI_INT,
  V8SI_FTYPE_V8SI_PCVOID_V8DI_QI_INT,
  V8DI_FTYPE_V8DI_PCVOID_V8DI_QI_INT,
  VOID_FTYPE_PVOID_HI_V16SI_V16SF_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8DF_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8SF_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8DF_INT,
  VOID_FTYPE_PVOID_HI_V16SI_V16SI_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8DI_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8SI_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8DI_INT,
  V2DF_FTYPE_V2DF_PCVOID_V4SI_QI_INT,
  V4DF_FTYPE_V4DF_PCVOID_V4SI_QI_INT,
  V2DF_FTYPE_V2DF_PCVOID_V2DI_QI_INT,
  V4DF_FTYPE_V4DF_PCVOID_V4DI_QI_INT,
  V4SF_FTYPE_V4SF_PCVOID_V4SI_QI_INT,
  V8SF_FTYPE_V8SF_PCVOID_V8SI_QI_INT,
  V4SF_FTYPE_V4SF_PCVOID_V2DI_QI_INT,
  V4SF_FTYPE_V4SF_PCVOID_V4DI_QI_INT,
  V2DI_FTYPE_V2DI_PCVOID_V4SI_QI_INT,
  V4DI_FTYPE_V4DI_PCVOID_V4SI_QI_INT,
  V2DI_FTYPE_V2DI_PCVOID_V2DI_QI_INT,
  V4DI_FTYPE_V4DI_PCVOID_V4DI_QI_INT,
  V4SI_FTYPE_V4SI_PCVOID_V4SI_QI_INT,
  V8SI_FTYPE_V8SI_PCVOID_V8SI_QI_INT,
  V4SI_FTYPE_V4SI_PCVOID_V2DI_QI_INT,
  V4SI_FTYPE_V4SI_PCVOID_V4DI_QI_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8SF_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4SF_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4DF_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V2DF_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4SF_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V4SF_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4DF_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V2DF_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8SI_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4SI_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4DI_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V2DI_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4SI_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V4SI_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4DI_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V2DI_INT,
  VOID_FTYPE_QI_V8SI_PCVOID_INT_INT,
  VOID_FTYPE_HI_V16SI_PCVOID_INT_INT,
  VOID_FTYPE_QI_V8DI_PCVOID_INT_INT,
  VOID_FTYPE_PV8QI_V8HI_UQI,
  VOID_FTYPE_PV16QI_V16HI_UHI,
  BND_FTYPE_PCVOID_ULONG,
  VOID_FTYPE_PCVOID_BND,
  VOID_FTYPE_PCVOID_BND_PCVOID,
  BND_FTYPE_PCVOID_PCVOID,
  BND_FTYPE_PCVOID,
  BND_FTYPE_BND_BND,
  PVOID_FTYPE_PCVOID_BND_ULONG,
  ULONG_FTYPE_VOID,
  PVOID_FTYPE_BND,
  V64QI_FTYPE_V64QI_V64QI_INT,
  V64QI_FTYPE_V64QI_V64QI_INT_V64QI_UDI,
  V32QI_FTYPE_V32QI_V32QI_INT_V32QI_USI,
  V16QI_FTYPE_V16QI_V16QI_INT_V16QI_UHI,
  V64QI_FTYPE_V64QI_V64QI,
  VOID_FTYPE_PV64QI_V64QI_UDI,
  VOID_FTYPE_PV32HI_V32HI_USI,
  VOID_FTYPE_PV32QI_V32QI_USI,
  VOID_FTYPE_PV16QI_V16QI_UHI,
  VOID_FTYPE_PV16HI_V16HI_UHI,
  VOID_FTYPE_PV8HI_V8HI_UQI,
  V64QI_FTYPE_PCV64QI_V64QI_UDI,
  V32HI_FTYPE_PCV32HI_V32HI_USI,
  V32QI_FTYPE_PCV32QI_V32QI_USI,
  V16QI_FTYPE_PCV16QI_V16QI_UHI,
  V16HI_FTYPE_PCV16HI_V16HI_UHI,
  V8HI_FTYPE_PCV8HI_V8HI_UQI,
  V32HI_FTYPE_V32HI_V32HI_INT,
  V32HI_FTYPE_V32HI_V32HI_INT_V32HI_INT,
  V16SI_FTYPE_V16SI_V16SI_INT,
  V16SI_FTYPE_V16SI_V16SI_INT_V16SI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_INT,
  V16HI_FTYPE_V16HI_V16HI_INT_V16HI_INT,
  V8SI_FTYPE_V8SI_V8SI_INT_V8SI_INT,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_INT,
  V8HI_FTYPE_V8HI_V8HI_INT_V8HI_INT,
  V4SI_FTYPE_V4SI_V4SI_INT_V4SI_INT,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_INT,
  V32HI_FTYPE_V32HI_V32HI_V32HI,
  V32HI_FTYPE_V32HI_V32HI_V32HI_INT,
  V16HI_FTYPE_V16HI_V16HI_V16HI_INT,
  V8HI_FTYPE_V8HI_V8HI_V8HI_INT,
  V8SI_FTYPE_V8SI_V8SI_V8SI_INT,
  V4SI_FTYPE_V4SI_V4SI_V4SI_INT,
  V8DI_FTYPE_V8DI_V8DI_V8DI,
  V8DI_FTYPE_V8DI_V8DI_V8DI_INT,
  V4DI_FTYPE_V4DI_V4DI_V4DI_INT,
  V16SI_FTYPE_V16SI_V16SI_V16SI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_INT,
  V2DI_FTYPE_V2DI_V2DI_V2DI_INT,
  V4DI_FTYPE_V4DI,
  V4SI_FTYPE_V4SI_V4SI_UHI,
  V8SI_FTYPE_V8SI_V8SI_UHI,
  IX86_BT_LAST_FUNC = V8SI_FTYPE_V8SI_V8SI_UHI,
  UQI_FTYPE_UQI_UQI_CONST,
  V2DF_FTYPE_V2DF_ROUND,
  V4DF_FTYPE_V4DF_ROUND,
  V8DF_FTYPE_V8DF_ROUND,
  V4SF_FTYPE_V4SF_ROUND,
  V8SF_FTYPE_V8SF_ROUND,
  V16SF_FTYPE_V16SF_ROUND,
  V4SI_FTYPE_V2DF_V2DF_ROUND,
  V8SI_FTYPE_V4DF_V4DF_ROUND,
  V16SI_FTYPE_V8DF_V8DF_ROUND,
  V4SI_FTYPE_V4SF_ROUND,
  V8SI_FTYPE_V8SF_ROUND,
  V16SI_FTYPE_V16SF_ROUND,
  INT_FTYPE_V2DF_V2DF_PTEST,
  INT_FTYPE_V2DI_V2DI_PTEST,
  INT_FTYPE_V4DF_V4DF_PTEST,
  INT_FTYPE_V4DI_V4DI_PTEST,
  INT_FTYPE_V4SF_V4SF_PTEST,
  INT_FTYPE_V8SF_V8SF_PTEST,
  V2DF_FTYPE_V2DF_VEC_MERGE,
  V4SF_FTYPE_V4SF_VEC_MERGE,
  V1DI_FTYPE_V1DI_SI_COUNT,
  V2DI_FTYPE_V2DI_SI_COUNT,
  V2SI_FTYPE_V2SI_SI_COUNT,
  V4HI_FTYPE_V4HI_SI_COUNT,
  V4SI_FTYPE_V4SI_SI_COUNT,
  V8HI_FTYPE_V8HI_SI_COUNT,
  V1DI_FTYPE_V1DI_V1DI_COUNT,
  V2DI_FTYPE_V2DI_V2DI_COUNT,
  V2SI_FTYPE_V2SI_V2SI_COUNT,
  V4HI_FTYPE_V4HI_V4HI_COUNT,
  V4SI_FTYPE_V4SI_V4SI_COUNT,
  V8HI_FTYPE_V8HI_V8HI_COUNT,
  V16HI_FTYPE_V16HI_SI_COUNT,
  V16HI_FTYPE_V16HI_V8HI_COUNT,
  V8SI_FTYPE_V8SI_SI_COUNT,
  V8SI_FTYPE_V8SI_V4SI_COUNT,
  V4DI_FTYPE_V4DI_INT_COUNT,
  V4DI_FTYPE_V4DI_V2DI_COUNT,
  V16HI_FTYPE_V16HI_INT_V16HI_UHI_COUNT,
  V16HI_FTYPE_V16HI_V8HI_V16HI_UHI_COUNT,
  V16SI_FTYPE_V16SI_INT_V16SI_UHI_COUNT,
  V16SI_FTYPE_V16SI_V4SI_V16SI_UHI_COUNT,
  V2DI_FTYPE_V2DI_INT_V2DI_UQI_COUNT,
  V2DI_FTYPE_V2DI_V2DI_V2DI_UQI_COUNT,
  V32HI_FTYPE_V32HI_INT_V32HI_USI_COUNT,
  V32HI_FTYPE_V32HI_V8HI_V32HI_USI_COUNT,
  V4DI_FTYPE_V4DI_INT_V4DI_UQI_COUNT,
  V4DI_FTYPE_V4DI_V2DI_V4DI_UQI_COUNT,
  V4SI_FTYPE_V4SI_INT_V4SI_UQI_COUNT,
  V4SI_FTYPE_V4SI_V4SI_V4SI_UQI_COUNT,
  V8DI_FTYPE_V8DI_INT_V8DI_UQI_COUNT,
  V8DI_FTYPE_V8DI_V2DI_V8DI_UQI_COUNT,
  V8HI_FTYPE_V8HI_INT_V8HI_UQI_COUNT,
  V8HI_FTYPE_V8HI_V8HI_V8HI_UQI_COUNT,
  V8SI_FTYPE_V8SI_INT_V8SI_UQI_COUNT,
  V8SI_FTYPE_V8SI_V4SI_V8SI_UQI_COUNT,
  V2DF_FTYPE_V2DF_V2DF_SWAP,
  V4SF_FTYPE_V4SF_V4SF_SWAP,
  V8DI_FTYPE_V8DI_INT_CONVERT,
  V4DI_FTYPE_V4DI_INT_CONVERT,
  V2DI_FTYPE_V2DI_INT_CONVERT,
  V8DI_FTYPE_V8DI_V8DI_INT_CONVERT,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UDI_CONVERT,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_USI_CONVERT,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UHI_CONVERT,
  V4DI_FTYPE_V4DI_V4DI_INT_CONVERT,
  V2DI_FTYPE_V2DI_V2DI_INT_CONVERT,
  V1DI_FTYPE_V1DI_V1DI_INT_CONVERT,
  V16QI_FTYPE_V16QI_V16QI_CMP,
  V2DI_FTYPE_V2DI_V2DI_CMP,
  V4SI_FTYPE_V4SI_V4SI_CMP,
  V8HI_FTYPE_V8HI_V8HI_CMP,
  V16QI_FTYPE_V16QI_V16QI_TF,
  V2DF_FTYPE_V2DF_V2DF_TF,
  V2DI_FTYPE_V2DI_V2DI_TF,
  V4SF_FTYPE_V4SF_V4SF_TF,
  V4SI_FTYPE_V4SI_V4SI_TF,
  V8HI_FTYPE_V8HI_V8HI_TF,
  IX86_BT_LAST_ALIAS = V8HI_FTYPE_V8HI_V8HI_TF
}
;


static const enum ix86_builtin_type ix86_builtin_func_args[] = {
  IX86_BT_FLOAT128, IX86_BT_UINT64, IX86_BT_UNSIGNED, IX86_BT_UINT,
  IX86_BT_USHORT, IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID,
  IX86_BT_FLOAT, IX86_BT_FLOAT, IX86_BT_FLOAT128, IX86_BT_FLOAT128,
  IX86_BT_FLOAT128, IX86_BT_CONST_STRING, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V8QI, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_V32QI, IX86_BT_INT, IX86_BT_PCCHAR,
  IX86_BT_INT64, IX86_BT_INT64, IX86_BT_INT64, IX86_BT_V2DF,
  IX86_BT_INT64, IX86_BT_V4SF, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_UINT16, IX86_BT_UINT16, IX86_BT_UINT64, IX86_BT_INT,
  IX86_BT_UINT64, IX86_BT_PUNSIGNED, IX86_BT_UINT64, IX86_BT_UINT64,
  IX86_BT_V16QI, IX86_BT_PCCHAR, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2SI, IX86_BT_V2DF, IX86_BT_V4DF,
  IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_V4SI,
  IX86_BT_V2DI, IX86_BT_PV2DI, IX86_BT_V2DI, IX86_BT_V16QI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V4SI,
  IX86_BT_V2DI, IX86_BT_V8HI, IX86_BT_V2SF, IX86_BT_V2SF,
  IX86_BT_V2SF, IX86_BT_V2SI, IX86_BT_V2SI, IX86_BT_V2DF,
  IX86_BT_V2SI, IX86_BT_V2SF, IX86_BT_V2SI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_PCV2SI, IX86_BT_V2SI, IX86_BT_V4SF,
  IX86_BT_V32QI, IX86_BT_PCCHAR, IX86_BT_V4DF, IX86_BT_PCDOUBLE,
  IX86_BT_V4DF, IX86_BT_PCV2DF, IX86_BT_V4DF, IX86_BT_V2DF,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4SF,
  IX86_BT_V4DF, IX86_BT_V4SI, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V4SF, IX86_BT_PCFLOAT,
  IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4DF,
  IX86_BT_V4SF, IX86_BT_V4DF, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCV4SF,
  IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V8SF,
  IX86_BT_V4SF, IX86_BT_V8HI, IX86_BT_V4SF, IX86_BT_V8HI,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V16QI,
  IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_V4SI, IX86_BT_V4DF,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V8SI,
  IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8QI, IX86_BT_V8QI, IX86_BT_V8SF, IX86_BT_PCFLOAT,
  IX86_BT_V8SF, IX86_BT_PCV4SF, IX86_BT_V8SF, IX86_BT_PCV8SF,
  IX86_BT_V8SF, IX86_BT_V4SF, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V8HI,
  IX86_BT_V8SF, IX86_BT_V8HI, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V8SI, IX86_BT_V4SI,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V16QI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V8HI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_VOID, IX86_BT_PCVOID, IX86_BT_VOID, IX86_BT_PVOID,
  IX86_BT_VOID, IX86_BT_UINT64, IX86_BT_VOID, IX86_BT_UINT64,
  IX86_BT_PVOID, IX86_BT_VOID, IX86_BT_UNSIGNED, IX86_BT_VOID,
  IX86_BT_UNSIGNED, IX86_BT_PVOID, IX86_BT_INT, IX86_BT_PUSHORT,
  IX86_BT_INT, IX86_BT_PUNSIGNED, IX86_BT_INT, IX86_BT_PULONGLONG,
  IX86_BT_V16HI, IX86_BT_V16QI, IX86_BT_V8SI, IX86_BT_V16QI,
  IX86_BT_V4DI, IX86_BT_V16QI, IX86_BT_V8SI, IX86_BT_V8HI,
  IX86_BT_V4DI, IX86_BT_V8HI, IX86_BT_V4DI, IX86_BT_V4SI,
  IX86_BT_V4DI, IX86_BT_PV4DI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V4SF,
  IX86_BT_V16SF, IX86_BT_V8SF, IX86_BT_V8DF, IX86_BT_V4DF,
  IX86_BT_V8DF, IX86_BT_V2DF, IX86_BT_V16SI, IX86_BT_V4SI,
  IX86_BT_V16SI, IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_V16SF,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_PV8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_VOID, IX86_BT_INT,
  IX86_BT_INT64, IX86_BT_DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_DOUBLE, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_FLOAT,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_FLOAT128, IX86_BT_FLOAT128,
  IX86_BT_FLOAT128, IX86_BT_HI, IX86_BT_V4HI, IX86_BT_INT,
  IX86_BT_HI, IX86_BT_V8HI, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_QI, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_QI, IX86_BT_V8QI, IX86_BT_INT, IX86_BT_SI,
  IX86_BT_V2SI, IX86_BT_INT, IX86_BT_SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UCHAR,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_USHORT, IX86_BT_UINT16, IX86_BT_UINT16,
  IX86_BT_INT, IX86_BT_UINT64, IX86_BT_UINT64, IX86_BT_UINT64,
  IX86_BT_UINT8, IX86_BT_UINT8, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_SI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_SI, IX86_BT_V1DI,
  IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V1DI, IX86_BT_V8QI, IX86_BT_V8QI,
  IX86_BT_V2DF, IX86_BT_PCV2DF, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_UINT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_DI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_SI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DI,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_SI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V16QI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_PCV2DI,
  IX86_BT_V2DI, IX86_BT_V2SF, IX86_BT_V2SF, IX86_BT_V2SF,
  IX86_BT_V2SI, IX86_BT_INT, IX86_BT_INT, IX86_BT_V2SI,
  IX86_BT_V2SF, IX86_BT_V2SF, IX86_BT_V2SI, IX86_BT_V2SI,
  IX86_BT_SI, IX86_BT_V2SI, IX86_BT_V2SI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V4DF,
  IX86_BT_PCV4DF, IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4HI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_INT,
  IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_SI, IX86_BT_V4HI,
  IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V8QI,
  IX86_BT_V8QI, IX86_BT_V4SF, IX86_BT_PCV4SF, IX86_BT_V4SI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UINT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_DI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCV2SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_SI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2SI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_PCV4SI,
  IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_SI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8HI,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8HI,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8QI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V8QI,
  IX86_BT_V8QI, IX86_BT_V8QI, IX86_BT_V8SF, IX86_BT_PCV8SF,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI,
  IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_HI, IX86_BT_INT,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SI, IX86_BT_INT,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V32HI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V8HI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V16HI,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_SI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V4SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V16SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8SI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V8SI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V16SI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V4SI, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_PCV8SI, IX86_BT_V8SI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V16SI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_UDI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_USI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8DI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V2DI, IX86_BT_V4DI, IX86_BT_PCV4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V4DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V2DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V4DI, IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID,
  IX86_BT_INT64, IX86_BT_V2DI, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PCHAR,
  IX86_BT_V16QI, IX86_BT_VOID, IX86_BT_PCHAR, IX86_BT_V32QI,
  IX86_BT_VOID, IX86_BT_PDOUBLE, IX86_BT_V2DF, IX86_BT_VOID,
  IX86_BT_PDOUBLE, IX86_BT_V4DF, IX86_BT_VOID, IX86_BT_PDOUBLE,
  IX86_BT_V8DF, IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_V4SF,
  IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_V8SF, IX86_BT_VOID,
  IX86_BT_PFLOAT, IX86_BT_V16SF, IX86_BT_VOID, IX86_BT_PINT,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PUNSIGNED, IX86_BT_UNSIGNED,
  IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_PCVOID, IX86_BT_VOID,
  IX86_BT_PLONGLONG, IX86_BT_LONGLONG, IX86_BT_VOID, IX86_BT_PULONGLONG,
  IX86_BT_ULONGLONG, IX86_BT_VOID, IX86_BT_PV2SI, IX86_BT_V2SI,
  IX86_BT_VOID, IX86_BT_PV2DI, IX86_BT_V2DI, IX86_BT_VOID,
  IX86_BT_PV2SF, IX86_BT_V4SF, IX86_BT_VOID, IX86_BT_PV4DI,
  IX86_BT_V4DI, IX86_BT_VOID, IX86_BT_PV4SF, IX86_BT_V4SF,
  IX86_BT_VOID, IX86_BT_PV8SF, IX86_BT_V8SF, IX86_BT_VOID,
  IX86_BT_UNSIGNED, IX86_BT_UNSIGNED, IX86_BT_VOID, IX86_BT_UNSIGNED,
  IX86_BT_UNSIGNED, IX86_BT_UNSIGNED, IX86_BT_VOID, IX86_BT_PV8DI,
  IX86_BT_V8DI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_PCV4SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_PCV4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCV4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCV4SF, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_PCV4SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_PCV4SI, IX86_BT_UCHAR, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_PUCHAR, IX86_BT_UCHAR, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_UCHAR, IX86_BT_UHI, IX86_BT_UHI, IX86_BT_PUCHAR,
  IX86_BT_UCHAR, IX86_BT_UHI, IX86_BT_UHI, IX86_BT_UCHAR,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_PUCHAR, IX86_BT_UCHAR,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_UCHAR, IX86_BT_UDI,
  IX86_BT_UDI, IX86_BT_PUCHAR, IX86_BT_UCHAR, IX86_BT_UDI,
  IX86_BT_UDI, IX86_BT_USI, IX86_BT_UQI, IX86_BT_USI,
  IX86_BT_UHI, IX86_BT_UQI, IX86_BT_USI, IX86_BT_UHI,
  IX86_BT_USI, IX86_BT_UHI, IX86_BT_UHI, IX86_BT_UQI,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_UQI, IX86_BT_UDI,
  IX86_BT_UDI, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_UHI, IX86_BT_UHI, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_UDI, IX86_BT_UDI, IX86_BT_UHI, IX86_BT_V16QI,
  IX86_BT_USI, IX86_BT_V32QI, IX86_BT_UDI, IX86_BT_V64QI,
  IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_USI, IX86_BT_V32HI, IX86_BT_UQI, IX86_BT_V4SI,
  IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_UHI, IX86_BT_V16SI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_UHI, IX86_BT_UHI, IX86_BT_UHI,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_USI, IX86_BT_UDI,
  IX86_BT_UDI, IX86_BT_UDI, IX86_BT_UHI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_UHI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_INT, IX86_BT_UHI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_INT, IX86_BT_USI,
  IX86_BT_UDI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_UDI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT,
  IX86_BT_UDI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_INT, IX86_BT_UHI, IX86_BT_USI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT, IX86_BT_USI,
  IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8UDI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_UHI, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_INT,
  IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT,
  IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT,
  IX86_BT_UHI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_INT,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_UHI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_UCHAR, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_UCHAR, IX86_BT_UINT64, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4HI,
  IX86_BT_V4HI, IX86_BT_HI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_FLOAT, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SI,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_HI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V4SI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4DF,
  IX86_BT_V4SF, IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4DF,
  IX86_BT_V4SI, IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8SI, IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V8HI, IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8SI, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8HI, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V16QI, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V16QI, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V16QI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4SI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V8HI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DI,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_USI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V4SI, IX86_BT_V16QI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8HI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V16QI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_UQI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SI,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V16SF, IX86_BT_V8SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V16SF, IX86_BT_V4SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V8DF, IX86_BT_V4DF, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V2DF, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V16SI, IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V4SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V16HI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V16QI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8DI, IX86_BT_V4DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4DF, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V8DI, IX86_BT_V2DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V8DI, IX86_BT_DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V16SI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V16QI, IX86_BT_V8DI, IX86_BT_V16QI, IX86_BT_UQI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V32HI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT,
  IX86_BT_V32HI, IX86_BT_V32QI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V16HI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_INT,
  IX86_BT_V16HI, IX86_BT_V16QI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V4SF, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V2DF, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V4SI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_SI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_SI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V2DI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_DI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_DI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V64QI, IX86_BT_V16QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V64QI, IX86_BT_QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_V16QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V16QI, IX86_BT_QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V32HI, IX86_BT_V8HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V32HI, IX86_BT_HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V16HI, IX86_BT_V8HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V16HI, IX86_BT_HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V16SF, IX86_BT_PCV16SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V8DF, IX86_BT_PCV8DF, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V16SI, IX86_BT_PCV16SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8SF, IX86_BT_PCV8SF, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8DI, IX86_BT_PCV8DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_PCV8SI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_PCV4DF, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_PCV4SF, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_PCV4DI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_PCV4SI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V2DF, IX86_BT_PCV2DF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_PCV2DI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V64QI, IX86_BT_PCCHAR, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V32HI, IX86_BT_PCSHORT, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_PCCHAR, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V16SF, IX86_BT_PCFLOAT, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V8DF, IX86_BT_PCDOUBLE, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V16SI, IX86_BT_PCINT, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V16HI, IX86_BT_PCSHORT, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V16QI, IX86_BT_PCCHAR, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V8SF, IX86_BT_PCFLOAT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8DI, IX86_BT_PCINT64, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_PCINT, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_PCSHORT, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_PCDOUBLE, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_PCFLOAT, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_PCINT64, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_PCINT, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_PCINT64, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V16HI, IX86_BT_V16SI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_V8DI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V8DI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V16HI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V16QI, IX86_BT_V4SI, IX86_BT_V16QI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V8SI, IX86_BT_V16QI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V8SI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V2DI, IX86_BT_V16QI, IX86_BT_UQI,
  IX86_BT_V16QI, IX86_BT_V4DI, IX86_BT_V16QI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V2DI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V4DI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4DI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V32QI, IX86_BT_V32HI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8DF, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8SI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV4SI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV4SI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV4DF, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV2DF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV16SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV8SF, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV4SF, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV4DI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV2DI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV16SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV16HI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV8SI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PV4SI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PDOUBLE, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PDOUBLE, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PDOUBLE, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PINT64, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PINT64, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PINT64, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PINT, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PINT, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PINT, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PSHORT, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_VOID, IX86_BT_PSHORT, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PSHORT, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PCHAR, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_VOID, IX86_BT_PCHAR, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_VOID, IX86_BT_PCHAR, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SF,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SF,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4SF,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V4SF,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4DI,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V2DI,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DI,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DI,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_INT, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V32HI,
  IX86_BT_V32HI, IX86_BT_V8HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V16HI,
  IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V8HI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_INT, IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V32HI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT, IX86_BT_V32HI,
  IX86_BT_USI, IX86_BT_V16HI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_INT, IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V8HI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_V64QI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V32QI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V16QI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V32HI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V32HI,
  IX86_BT_USI, IX86_BT_V16HI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V8HI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_VOID, IX86_BT_PCVOID, IX86_BT_UNSIGNED, IX86_BT_UNSIGNED,
  IX86_BT_VOID, IX86_BT_PV2DF, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_VOID, IX86_BT_PV4DF, IX86_BT_V4DI, IX86_BT_V4DF,
  IX86_BT_VOID, IX86_BT_PV4SF, IX86_BT_V4SI, IX86_BT_V4SF,
  IX86_BT_VOID, IX86_BT_PV8SF, IX86_BT_V8SI, IX86_BT_V8SF,
  IX86_BT_VOID, IX86_BT_PV2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_VOID, IX86_BT_PV4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_VOID, IX86_BT_PV4SI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_VOID, IX86_BT_PV8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_VOID, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_VOID, IX86_BT_UINT64, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_VOID, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_PCHAR,
  IX86_BT_VOID, IX86_BT_V8QI, IX86_BT_V8QI, IX86_BT_PCHAR,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4SI, IX86_BT_V8SI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_QI, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_QI, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_QI, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_HI, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_QI,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_QI, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_QI, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_HI, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_UHI, IX86_BT_QI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV32QI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_V4HI,
  IX86_BT_HI, IX86_BT_HI, IX86_BT_HI, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_INT, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_V8QI, IX86_BT_QI, IX86_BT_QI, IX86_BT_QI,
  IX86_BT_QI, IX86_BT_QI, IX86_BT_QI, IX86_BT_QI,
  IX86_BT_QI, IX86_BT_UCHAR, IX86_BT_UCHAR, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_PUNSIGNED, IX86_BT_UCHAR, IX86_BT_UCHAR,
  IX86_BT_ULONGLONG, IX86_BT_ULONGLONG, IX86_BT_PULONGLONG, IX86_BT_UINT64,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_UINT64, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_UINT, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_UINT, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_INT64,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_INT64, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_UINT64, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_UINT64, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_UINT, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT64, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_INT64, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_INT, IX86_BT_V16SI,
  IX86_BT_V16SF, IX86_BT_V16SI, IX86_BT_HI, IX86_BT_INT,
  IX86_BT_V16SF, IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_HI, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16HI,
  IX86_BT_V16SF, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8DF, IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V8DF, IX86_BT_V8SF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8SF,
  IX86_BT_V8DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V8DI, IX86_BT_V8SF, IX86_BT_V8DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_V8DF,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8DI,
  IX86_BT_V8SF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V4SF,
  IX86_BT_V2DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT,
  IX86_BT_V16SF, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V4SI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_PCDOUBLE,
  IX86_BT_V4SI, IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_PCDOUBLE, IX86_BT_V8SI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_PCDOUBLE,
  IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_PCDOUBLE, IX86_BT_V4DI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCFLOAT,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_PCFLOAT, IX86_BT_V8SI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCFLOAT,
  IX86_BT_V2DI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCFLOAT, IX86_BT_V4DI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_PCFLOAT,
  IX86_BT_V4DI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_PCINT64, IX86_BT_V4SI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_PCINT64,
  IX86_BT_V4SI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_PCINT64, IX86_BT_V8SI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_PCINT64,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_PCINT64, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_PCINT,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_PCINT, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_PCINT,
  IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_PCINT, IX86_BT_V4DI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_PCINT,
  IX86_BT_V4DI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_PCFLOAT, IX86_BT_V8DI, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_PCDOUBLE,
  IX86_BT_V16SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_PCINT, IX86_BT_V8DI, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_PCINT64,
  IX86_BT_V16SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_PCDOUBLE, IX86_BT_V8SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_PCFLOAT,
  IX86_BT_V4DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_PCINT64, IX86_BT_V8SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_PCINT,
  IX86_BT_V4DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PFLOAT, IX86_BT_HI, IX86_BT_V8DI, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PDOUBLE, IX86_BT_QI,
  IX86_BT_V16SI, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PINT, IX86_BT_HI, IX86_BT_V8DI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PLONGLONG, IX86_BT_QI,
  IX86_BT_V16SI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_PCVOID, IX86_BT_V16SI, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_PCVOID,
  IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_PCVOID, IX86_BT_V8DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_PCVOID,
  IX86_BT_V8DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_PCVOID, IX86_BT_V16SI, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_PCVOID,
  IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_PCVOID, IX86_BT_V8DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_PCVOID,
  IX86_BT_V8DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_HI, IX86_BT_V16SI, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8SI, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8DI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8DI, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_HI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8SI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8DI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_PCVOID, IX86_BT_V4SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_PCVOID,
  IX86_BT_V4SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_PCVOID, IX86_BT_V2DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_PCVOID,
  IX86_BT_V4DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCVOID, IX86_BT_V4SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_PCVOID,
  IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCVOID, IX86_BT_V2DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCVOID,
  IX86_BT_V4DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_PCVOID, IX86_BT_V4SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_PCVOID,
  IX86_BT_V4SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_PCVOID, IX86_BT_V2DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_PCVOID,
  IX86_BT_V4DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_PCVOID, IX86_BT_V4SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_PCVOID,
  IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_PCVOID, IX86_BT_V2DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_PCVOID,
  IX86_BT_V4DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8SI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4DI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V2DI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4DI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4DI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_QI, IX86_BT_V8SI, IX86_BT_PCVOID, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_HI, IX86_BT_V16SI,
  IX86_BT_PCVOID, IX86_BT_INT, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_QI, IX86_BT_V8DI, IX86_BT_PCVOID, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PV8QI, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V16HI,
  IX86_BT_UHI, IX86_BT_BND, IX86_BT_PCVOID, IX86_BT_ULONG,
  IX86_BT_VOID, IX86_BT_PCVOID, IX86_BT_BND, IX86_BT_VOID,
  IX86_BT_PCVOID, IX86_BT_BND, IX86_BT_PCVOID, IX86_BT_BND,
  IX86_BT_PCVOID, IX86_BT_PCVOID, IX86_BT_BND, IX86_BT_PCVOID,
  IX86_BT_BND, IX86_BT_BND, IX86_BT_BND, IX86_BT_PVOID,
  IX86_BT_PCVOID, IX86_BT_BND, IX86_BT_ULONG, IX86_BT_ULONG,
  IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_BND, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT, IX86_BT_V64QI,
  IX86_BT_UDI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_INT, IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_UHI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V64QI,
  IX86_BT_VOID, IX86_BT_PV64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_VOID, IX86_BT_PV32HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_VOID, IX86_BT_PV32QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V64QI, IX86_BT_PCV64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V32HI, IX86_BT_PCV32HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_PCV32QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V16QI, IX86_BT_PCV16QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V16HI, IX86_BT_PCV16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8HI, IX86_BT_PCV8HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT,
  IX86_BT_V32HI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_INT,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_INT,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_UHI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_UHI
};


static const unsigned short ix86_builtin_func_start[] = {
  0, 1, 2, 3, 4, 5, 6, 7, 8, 10,
  12, 14, 16, 18, 20, 22, 24, 26, 28, 30,
  32, 34, 36, 38, 40, 42, 44, 46, 48, 50,
  52, 54, 56, 58, 60, 62, 64, 66, 68, 70,
  72, 74, 76, 78, 80, 82, 84, 86, 88, 90,
  92, 94, 96, 98, 100, 102, 104, 106, 108, 110,
  114, 116, 120, 122, 124, 126, 128, 130, 134, 136,
  138, 140, 142, 144, 146, 148, 150, 152, 154, 156,
  158, 160, 162, 164, 166, 168, 172, 174, 176, 178,
  180, 182, 184, 186, 188, 190, 192, 194, 197, 199,
  202, 204, 206, 208, 210, 212, 214, 216, 218, 220,
  222, 224, 226, 228, 230, 232, 234, 236, 238, 240,
  242, 244, 246, 250, 254, 256, 258, 261, 264, 267,
  270, 273, 276, 279, 282, 285, 288, 291, 294, 297,
  300, 303, 306, 309, 312, 315, 318, 321, 324, 327,
  330, 333, 336, 339, 342, 345, 348, 351, 354, 357,
  360, 363, 366, 369, 372, 375, 378, 383, 386, 391,
  394, 397, 402, 405, 408, 411, 414, 417, 420, 423,
  426, 429, 432, 435, 438, 441, 444, 447, 452, 455,
  458, 461, 464, 467, 470, 473, 476, 479, 482, 485,
  490, 495, 498, 501, 504, 507, 510, 513, 516, 521,
  524, 528, 531, 536, 539, 542, 545, 550, 553, 558,
  561, 564, 569, 572, 575, 578, 581, 584, 587, 592,
  595, 600, 603, 606, 609, 612, 615, 620, 623, 626,
  631, 634, 637, 640, 643, 646, 650, 656, 662, 666,
  672, 679, 684, 689, 695, 701, 708, 711, 715, 721,
  728, 733, 739, 744, 751, 757, 763, 770, 777, 784,
  791, 795, 801, 807, 810, 813, 818, 823, 826, 829,
  832, 835, 838, 843, 846, 850, 854, 857, 860, 864,
  870, 873, 878, 881, 887, 890, 895, 900, 903, 908,
  911, 916, 919, 922, 927, 932, 935, 938, 941, 947,
  953, 959, 965, 969, 973, 979, 985, 988, 991, 994,
  997, 1000, 1005, 1010, 1015, 1018, 1023, 1026, 1029, 1034,
  1037, 1042, 1045, 1048, 1051, 1054, 1057, 1060, 1063, 1066,
  1069, 1072, 1075, 1078, 1081, 1084, 1087, 1090, 1093, 1096,
  1099, 1102, 1106, 1109, 1118, 1125, 1132, 1141, 1150, 1157,
  1161, 1164, 1168, 1171, 1175, 1178, 1182, 1185, 1187, 1189,
  1191, 1193, 1196, 1199, 1202, 1204, 1206, 1208, 1210, 1212,
  1214, 1216, 1218, 1220, 1222, 1224, 1226, 1228, 1230, 1232,
  1234, 1237, 1240, 1243, 1246, 1250, 1255, 1259, 1264, 1268,
  1273, 1277, 1282, 1286, 1291, 1295, 1300, 1304, 1309, 1313,
  1318, 1322, 1327, 1331, 1336, 1340, 1344, 1348, 1353, 1357,
  1362, 1366, 1372, 1376, 1382, 1386, 1391, 1397, 1401, 1406,
  1412, 1414, 1416, 1418, 1420, 1422, 1424, 1426, 1428, 1430,
  1432, 1434, 1436, 1438, 1440, 1444, 1448, 1452, 1456, 1460,
  1464, 1468, 1472, 1476, 1481, 1485, 1489, 1494, 1499, 1504,
  1508, 1512, 1516, 1520, 1524, 1528, 1534, 1538, 1542, 1547,
  1551, 1555, 1559, 1563, 1567, 1572, 1576, 1580, 1584, 1589,
  1594, 1599, 1604, 1608, 1612, 1616, 1620, 1624, 1628, 1632,
  1636, 1640, 1646, 1650, 1654, 1659, 1663, 1669, 1673, 1677,
  1681, 1685, 1691, 1695, 1699, 1703, 1707, 1711, 1715, 1719,
  1723, 1727, 1731, 1735, 1739, 1744, 1750, 1755, 1761, 1765,
  1769, 1773, 1777, 1781, 1785, 1789, 1793, 1798, 1803, 1808,
  1813, 1818, 1823, 1828, 1833, 1838, 1843, 1848, 1853, 1858,
  1863, 1868, 1872, 1876, 1880, 1884, 1888, 1892, 1896, 1900,
  1904, 1908, 1913, 1919, 1924, 1929, 1934, 1939, 1945, 1950,
  1955, 1960, 1964, 1968, 1972, 1976, 1980, 1984, 1988, 1992,
  1996, 2000, 2004, 2008, 2012, 2016, 2020, 2024, 2028, 2032,
  2036, 2040, 2044, 2048, 2052, 2056, 2060, 2064, 2068, 2072,
  2076, 2080, 2084, 2088, 2092, 2096, 2100, 2104, 2108, 2112,
  2116, 2120, 2124, 2128, 2132, 2136, 2140, 2144, 2148, 2152,
  2156, 2160, 2164, 2168, 2172, 2176, 2180, 2184, 2188, 2192,
  2196, 2200, 2204, 2208, 2212, 2216, 2220, 2224, 2228, 2232,
  2236, 2240, 2244, 2248, 2252, 2256, 2260, 2264, 2268, 2272,
  2276, 2280, 2284, 2288, 2292, 2296, 2300, 2304, 2308, 2312,
  2316, 2320, 2324, 2328, 2332, 2337, 2342, 2347, 2352, 2358,
  2364, 2370, 2376, 2380, 2384, 2388, 2392, 2396, 2400, 2404,
  2408, 2412, 2416, 2420, 2424, 2428, 2432, 2436, 2440, 2444,
  2448, 2452, 2456, 2460, 2464, 2468, 2472, 2476, 2480, 2484,
  2488, 2492, 2496, 2500, 2504, 2508, 2512, 2516, 2520, 2524,
  2528, 2532, 2536, 2540, 2544, 2548, 2552, 2556, 2562, 2566,
  2570, 2574, 2578, 2582, 2586, 2590, 2594, 2599, 2604, 2609,
  2614, 2619, 2625, 2631, 2637, 2642, 2647, 2652, 2657, 2662,
  2667, 2672, 2677, 2682, 2688, 2694, 2700, 2706, 2712, 2716,
  2720, 2724, 2728, 2732, 2736, 2740, 2744, 2748, 2752, 2756,
  2760, 2764, 2769, 2774, 2777, 2780, 2785, 2788, 2791, 2794,
  2799, 2802, 2806, 2810, 2814, 2818, 2822, 2826, 2830, 2835,
  2840, 2846, 2852, 2861, 2866, 2871, 2874, 2877, 2880, 2883,
  2886, 2889, 2892, 2895, 2899, 2903, 2907, 2911, 2915, 2919,
  2924, 2929, 2934, 2939, 2944, 2949, 2954, 2959, 2964, 2969,
  2974, 2979, 2985, 2991, 2997, 3003, 3009, 3015, 3021, 3027,
  3032, 3037, 3043, 3049, 3056, 3063, 3069, 3075, 3081, 3087,
  3093, 3099, 3105, 3111, 3117, 3123, 3129, 3135, 3141, 3147,
  3153, 3159, 3165, 3171, 3177, 3183, 3189, 3195, 3201, 3207,
  3213, 3219, 3225, 3231, 3237, 3243, 3249, 3255, 3261, 3267,
  3273, 3279, 3285, 3291, 3297, 3303, 3309, 3315, 3321, 3327,
  3333, 3339, 3345, 3351, 3357, 3363, 3369, 3375, 3381, 3387,
  3393, 3399, 3405, 3411, 3417, 3423, 3429, 3435, 3441, 3447,
  3453, 3459, 3465, 3471, 3477, 3483, 3489, 3495, 3501, 3507,
  3513, 3519, 3525, 3531, 3537, 3543, 3549, 3555, 3561, 3565,
  3569, 3572, 3575, 3579, 3582, 3584, 3587, 3591, 3593, 3595,
  3599, 3605, 3611, 3617, 3620, 3624, 3628, 3632, 3636, 3640,
  3644, 3648, 3652, 3656, 3660, 3664, 3668, 3672, 3678, 3682,
  3688, 3694, 3700, 3706, 3712, 3718, 3724, 3730, 3734, 3739,
  3744, 3749, 3754, 3759, 3763, 3768, 3773, 3777, 3782, 3787,
  3789, 3793, 3797
};


static const enum ix86_builtin_func_type ix86_builtin_func_alias_base[] = {
  UQI_FTYPE_UQI_UQI,
  V2DF_FTYPE_V2DF,
  V4DF_FTYPE_V4DF,
  V8DF_FTYPE_V8DF,
  V4SF_FTYPE_V4SF,
  V8SF_FTYPE_V8SF,
  V16SF_FTYPE_V16SF,
  V4SI_FTYPE_V2DF_V2DF,
  V8SI_FTYPE_V4DF_V4DF,
  V16SI_FTYPE_V8DF_V8DF,
  V4SI_FTYPE_V4SF,
  V8SI_FTYPE_V8SF,
  V16SI_FTYPE_V16SF,
  INT_FTYPE_V2DF_V2DF,
  INT_FTYPE_V2DI_V2DI,
  INT_FTYPE_V4DF_V4DF,
  INT_FTYPE_V4DI_V4DI,
  INT_FTYPE_V4SF_V4SF,
  INT_FTYPE_V8SF_V8SF,
  V2DF_FTYPE_V2DF,
  V4SF_FTYPE_V4SF,
  V1DI_FTYPE_V1DI_SI,
  V2DI_FTYPE_V2DI_SI,
  V2SI_FTYPE_V2SI_SI,
  V4HI_FTYPE_V4HI_SI,
  V4SI_FTYPE_V4SI_SI,
  V8HI_FTYPE_V8HI_SI,
  V1DI_FTYPE_V1DI_V1DI,
  V2DI_FTYPE_V2DI_V2DI,
  V2SI_FTYPE_V2SI_V2SI,
  V4HI_FTYPE_V4HI_V4HI,
  V4SI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_V8HI,
  V16HI_FTYPE_V16HI_SI,
  V16HI_FTYPE_V16HI_V8HI,
  V8SI_FTYPE_V8SI_SI,
  V8SI_FTYPE_V8SI_V4SI,
  V4DI_FTYPE_V4DI_INT,
  V4DI_FTYPE_V4DI_V2DI,
  V16HI_FTYPE_V16HI_INT_V16HI_UHI,
  V16HI_FTYPE_V16HI_V8HI_V16HI_UHI,
  V16SI_FTYPE_V16SI_INT_V16SI_UHI,
  V16SI_FTYPE_V16SI_V4SI_V16SI_UHI,
  V2DI_FTYPE_V2DI_INT_V2DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_V2DI_UQI,
  V32HI_FTYPE_V32HI_INT_V32HI_USI,
  V32HI_FTYPE_V32HI_V8HI_V32HI_USI,
  V4DI_FTYPE_V4DI_INT_V4DI_UQI,
  V4DI_FTYPE_V4DI_V2DI_V4DI_UQI,
  V4SI_FTYPE_V4SI_INT_V4SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_V4SI_UQI,
  V8DI_FTYPE_V8DI_INT_V8DI_UQI,
  V8DI_FTYPE_V8DI_V2DI_V8DI_UQI,
  V8HI_FTYPE_V8HI_INT_V8HI_UQI,
  V8HI_FTYPE_V8HI_V8HI_V8HI_UQI,
  V8SI_FTYPE_V8SI_INT_V8SI_UQI,
  V8SI_FTYPE_V8SI_V4SI_V8SI_UQI,
  V2DF_FTYPE_V2DF_V2DF,
  V4SF_FTYPE_V4SF_V4SF,
  V8DI_FTYPE_V8DI_INT,
  V4DI_FTYPE_V4DI_INT,
  V2DI_FTYPE_V2DI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UDI,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_USI,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UHI,
  V4DI_FTYPE_V4DI_V4DI_INT,
  V2DI_FTYPE_V2DI_V2DI_INT,
  V1DI_FTYPE_V1DI_V1DI_INT,
  V16QI_FTYPE_V16QI_V16QI,
  V2DI_FTYPE_V2DI_V2DI,
  V4SI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_V8HI,
  V16QI_FTYPE_V16QI_V16QI,
  V2DF_FTYPE_V2DF_V2DF,
  V2DI_FTYPE_V2DI_V2DI,
  V4SF_FTYPE_V4SF_V4SF,
  V4SI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_V8HI
};
