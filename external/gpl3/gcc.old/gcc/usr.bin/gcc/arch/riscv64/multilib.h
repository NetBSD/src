/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.101 2019/02/23 06:54:45 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

static const char *const multilib_raw[] = {
". !march=rv64i !march=rv64g !march=rv32i !march=rv32g;",
".:. march=rv64i !march=rv64g !march=rv32i !march=rv32g;",
".:. !march=rv64i march=rv64g !march=rv32i !march=rv32g;",
".:../lib/rv32 !march=rv64i !march=rv64g march=rv32i !march=rv32g;",
".:../lib/rv32 !march=rv64i !march=rv64g !march=rv32i march=rv32g;",
NULL
};

static const char *const multilib_reuse_raw[] = {
NULL
};

static const char *const multilib_matches_raw[] = {
"march=rv64i march=rv64i;",
"march=rv64g march=rv64g;",
"march=rv32i march=rv32i;",
"march=rv32g march=rv32g;",
NULL
};

static const char *multilib_extra = "";

static const char *const multilib_exclusions_raw[] = {
NULL
};

static const char *multilib_options = "march=rv64i/march=rv64g/march=rv32i/march=rv32g";
