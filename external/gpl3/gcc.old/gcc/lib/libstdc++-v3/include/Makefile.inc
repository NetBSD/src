# $NetBSD: Makefile.inc,v 1.1.1.1 2023/07/14 06:34:27 mrg Exp $

.ifndef _EXTERNAL_GPL3_GCC_LIB_LIBSTDCXX_INCLUDE_MAKEFILE_INC_
_EXTERNAL_GPL3_GCC_LIB_LIBSTDCXX_INCLUDE_MAKEFILE_INC_=1

.include "${.PARSEDIR}/../Makefile.inc"

DIST=${GCCDIST}

.endif
