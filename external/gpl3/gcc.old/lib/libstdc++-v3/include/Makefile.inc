# $NetBSD: Makefile.inc,v 1.1.1.4 2021/04/09 22:33:16 mrg Exp $

.ifndef _EXTERNAL_GPL3_GCC_LIB_LIBSTDCXX_INCLUDE_MAKEFILE_INC_
_EXTERNAL_GPL3_GCC_LIB_LIBSTDCXX_INCLUDE_MAKEFILE_INC_=1

.include "${.PARSEDIR}/../Makefile.inc"

DIST=${GCCDIST}

.endif
