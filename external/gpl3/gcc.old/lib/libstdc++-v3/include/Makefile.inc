# $NetBSD: Makefile.inc,v 1.10.2.1 2026/11/04 23:00:50 perseant Exp $

.ifndef _EXTERNAL_GPL3_GCC_LIB_LIBSTDCXX_INCLUDE_MAKEFILE_INC_
_EXTERNAL_GPL3_GCC_LIB_LIBSTDCXX_INCLUDE_MAKEFILE_INC_=1

.include "${.PARSEDIR}/../Makefile.inc"

DIST=${GCCDIST}

.endif
