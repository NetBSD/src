/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc.old,v 1.8 2020/08/13 01:52:37 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `8.4.0 (8 4) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x4138342a)  /* A84* */
