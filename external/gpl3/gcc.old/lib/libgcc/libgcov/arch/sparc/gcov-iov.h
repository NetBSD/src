/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.91 2018/02/03 19:06:25 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.15 2017/11/29 03:32:28 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `6.4.0 (6 4) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x3630342a)  /* 604* */
