/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.92 2018/02/06 07:04:01 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `6.4.0 (6 4) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x3630342a)  /* 604* */
