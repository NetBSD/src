/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc.old,v 1.6 2018/09/05 01:20:20 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `7.5.0 (7 5) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x4137352a)  /* A75* */
