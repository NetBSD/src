/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.116 2022/07/22 06:50:26 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `10.5.0 (10 5) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x4230352a)  /* B05* */
