	.text
start:
	.byte 0x0f
	.byte 0x22
	.byte 0x1f
	.byte 0x0f
	.byte 0x20
	.byte 0x1f
	.byte 0x0f
	.byte 0x21
	.byte 0x1f
	.byte 0x0f
	.byte 0x23
	.byte 0x1f
