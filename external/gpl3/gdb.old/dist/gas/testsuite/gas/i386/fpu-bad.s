	.text
start:
	.byte 0xdd
	.byte 0xf0
