/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.13 2020/09/23 23:21:29 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "gdbsupport/version.h"
const char version[] = "11.0.50.20200914-git";
const char host_name[] = "x86_64--netbsd";
const char target_name[] = "x86_64--netbsd";
