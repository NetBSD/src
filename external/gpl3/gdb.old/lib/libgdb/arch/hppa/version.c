/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.19 2024/08/27 21:50:20 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "gdbsupport/version.h"
const char version[] = "16.3";
const char host_name[] = "hppa--netbsd";
const char target_name[] = "hppa--netbsd";
