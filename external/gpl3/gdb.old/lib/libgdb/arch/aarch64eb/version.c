/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb.old,v 1.1 2020/09/17 02:14:48 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "common/version.h"
const char version[] = "8.3";
const char host_name[] = "aarch64_be--netbsd";
const char target_name[] = "aarch64_be--netbsd";
