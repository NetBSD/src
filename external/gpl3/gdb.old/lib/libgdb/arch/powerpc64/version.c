/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.16 2023/07/31 17:09:59 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "gdbsupport/version.h"
const char version[] = "13.2";
const char host_name[] = "powerpc64--netbsd";
const char target_name[] = "powerpc64--netbsd";
