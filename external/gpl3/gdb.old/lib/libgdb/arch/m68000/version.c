/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.7 2016/10/16 04:37:42 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

#include "version.h"
const char version[] = "7.12";
const char host_name[] = "m68010--netbsdelf";
const char target_name[] = "m68010--netbsdelf";
