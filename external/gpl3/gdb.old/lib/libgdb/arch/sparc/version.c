/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.17 2024/08/18 03:47:55 rin Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "gdbsupport/version.h"
const char version[] = "15.1";
const char host_name[] = "sparc--netbsdelf";
const char target_name[] = "sparc--netbsdelf";
