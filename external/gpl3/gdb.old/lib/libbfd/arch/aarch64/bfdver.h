/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.7 2016/10/16 04:37:42 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#define BFD_VERSION_DATE 20170907
#define BFD_VERSION 228510000
#define BFD_VERSION_STRING  "(GNU Binutils) " "2.28.51"
#define REPORT_BUGS_TO "<http://www.sourceware.org/bugzilla/>"
