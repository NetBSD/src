# C++ and some __extension__ stuff we don't handle
MKLINT:=no
.include "../Makefile.inc"
