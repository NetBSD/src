/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.50 2011/06/28 04:30:32 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src3/tools/gcc/../../external/gpl3/gcc/dist/configure --target=sparc64--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20110620' --enable-__cxa_atexit --with-mpc=/var/obj/sparc64/usr/src3/destdir.sparc64/usr --with-mpfr=/var/obj/sparc64/usr/src3/destdir.sparc64/usr --with-gmp=/var/obj/sparc64/usr/src3/destdir.sparc64/usr --disable-multilib --disable-symvers --build=x86_64-unknown-netbsd5.99.48 --host=sparc64--netbsd";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { "cpu", "ultrasparc" } };
