/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.114 2021/04/11 07:35:45 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

const char omp_offload_device_kind[] = 
"";
const char omp_offload_device_arch[] = 
"";
const char omp_offload_device_isa[] = 
"";
