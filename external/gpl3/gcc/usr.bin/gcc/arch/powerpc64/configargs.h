/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.79 2014/05/29 16:27:50 skrll Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=powerpc64--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20140527' --with-system-zlib --enable-__cxa_atexit --enable-libstdcxx-threads --with-mpc-lib=/p/netbsd/cvsroot/src/external/lgpl3/mpc/lib/libmpc/obj.evbppc --with-mpfr-lib=/p/netbsd/cvsroot/src/external/lgpl3/mpfr/lib/libmpfr/obj.evbppc --with-gmp-lib=/p/netbsd/cvsroot/src/external/lgpl3/gmp/lib/libgmp/obj.evbppc --with-mpc-include=/p/netbsd/cvsroot/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/p/netbsd/cvsroot/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/p/netbsd/cvsroot/src/external/lgpl3/gmp/lib/libgmp/arch/powerpc64 --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --build=x86_64-unknown-netbsd6.99.40 --host=powerpc64--netbsd --with-sysroot=/usr/obj/evbppc/release";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
