/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.69 2013/04/25 16:18:43 skrll Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=arm--netbsdelf-eabi --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20120916' --with-system-zlib --enable-__cxa_atexit --with-mpc-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl2/mpc/lib/libmpc --with-mpfr-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl3/mpfr/lib/libmpfr --with-gmp-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl3/gmp/lib/libgmp --with-mpc-include=/usr/src/tools/gcc/../../external/lgpl2/mpc/dist/src --with-mpfr-include=/usr/src/tools/gcc/../../external/lgpl3/mpfr/dist --with-gmp-include=/usr/src/tools/gcc/../../external/lgpl3/gmp/lib/libgmp/arch/earm --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --build=x86_64-unknown-netbsd6.99.19 --host=arm--netbsdelf-eabi : (reconfigured) /usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=arm--netbsdelf-eabi --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20120916' --with-system-zlib --enable-__cxa_atexit --with-mpc-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl2/mpc/lib/libmpc --with-mpfr-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl3/mpfr/lib/libmpfr --with-gmp-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl3/gmp/lib/libgmp --with-mpc-include=/usr/src/tools/gcc/../../external/lgpl2/mpc/dist/src --with-mpfr-include=/usr/src/tools/gcc/../../external/lgpl3/mpfr/dist --with-gmp-include=/usr/src/tools/gcc/../../external/lgpl3/gmp/lib/libgmp/arch/earm --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --build=x86_64-unknown-netbsd6.99.19 --host=arm--netbsdelf-eabi : (reconfigured) /usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=arm--netbsdelf-eabi --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20120916' --with-system-zlib --enable-__cxa_atexit --with-mpc-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl2/mpc/lib/libmpc --with-mpfr-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl3/mpfr/lib/libmpfr --with-gmp-lib=/wrk/obj/evbearm-el/usr/src/external/lgpl3/gmp/lib/libgmp --with-mpc-include=/usr/src/tools/gcc/../../external/lgpl2/mpc/dist/src --with-mpfr-include=/usr/src/tools/gcc/../../external/lgpl3/mpfr/dist --with-gmp-include=/usr/src/tools/gcc/../../external/lgpl3/gmp/lib/libgmp/arch/earm --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --build=x86_64-unknown-netbsd6.99.19 --host=arm--netbsdelf-eabi";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
