/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.79 2014/05/29 16:27:50 skrll Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/u1/netbsd-openrisc/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=or1k--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/Misc/send-pr.html --with-pkgversion='NetBSD nb1 20140527' --with-system-zlib --enable-__cxa_atexit --enable-libstdcxx-threads --with-mpc-lib=/u2/netbsd-openrisc/or1k/obj/external/lgpl3/mpc/lib/libmpc --with-mpfr-lib=/u2/netbsd-openrisc/or1k/obj/external/lgpl3/mpfr/lib/libmpfr --with-gmp-lib=/u2/netbsd-openrisc/or1k/obj/external/lgpl3/gmp/lib/libgmp --with-mpc-include=/u1/netbsd-openrisc/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/u1/netbsd-openrisc/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/u1/netbsd-openrisc/src/external/lgpl3/gmp/lib/libgmp/arch/or1k --enable-tls --disable-multilib --disable-symvers --disable-libstdcxx-pch --build=x86_64-unknown-netbsd6.1. --host=or1k--netbsd --with-sysroot=/u2/netbsd-openrisc/or1k/root";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
