/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.114 2021/04/11 07:35:45 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=armv7eb--netbsdelf-eabihf --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/support/send-pr.html --with-pkgversion='NetBSD nb1 20210411' --with-system-zlib --without-isl --enable-__cxa_atexit --enable-libstdcxx-time=rt --enable-libstdcxx-threads --with-diagnostics-color=auto-if-env --with-default-libstdcxx-abi=new --with-mpc-lib=/usr/src/external/lgpl3/mpc/lib/libmpc/obj.evbarm-earmv7hfeb --with-mpfr-lib=/usr/src/external/lgpl3/mpfr/lib/libmpfr/obj.evbarm-earmv7hfeb --with-gmp-lib=/usr/src/external/lgpl3/gmp/lib/libgmp/obj.evbarm-earmv7hfeb --with-mpc-include=/usr/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/usr/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/usr/src/external/lgpl3/gmp/lib/libgmp/arch/armeb --enable-tls --enable-initfini-array --disable-multilib --disable-libstdcxx-pch --build=armv7eb--netbsdelf-eabihf --host=armv7eb--netbsdelf-eabihf --with-sysroot=/build/dest/evbarm-earmv7hfeb";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { "cpu", "cortex-a8" } };
