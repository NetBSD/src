/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.119 2025/09/16 03:04:17 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* This file is auto-generated by i386-builtin-types.awk.  */

enum ix86_builtin_type {
  IX86_BT_VOID,
  IX86_BT_CHAR,
  IX86_BT_UCHAR,
  IX86_BT_QI,
  IX86_BT_HI,
  IX86_BT_SI,
  IX86_BT_DI,
  IX86_BT_UQI,
  IX86_BT_UHI,
  IX86_BT_USI,
  IX86_BT_UDI,
  IX86_BT_SHORT,
  IX86_BT_USHORT,
  IX86_BT_INT,
  IX86_BT_UINT,
  IX86_BT_UNSIGNED,
  IX86_BT_ULONG,
  IX86_BT_LONGLONG,
  IX86_BT_ULONGLONG,
  IX86_BT_UINT8,
  IX86_BT_UINT16,
  IX86_BT_INT64,
  IX86_BT_UINT64,
  IX86_BT_FLOAT16,
  IX86_BT_BFLOAT16,
  IX86_BT_FLOAT,
  IX86_BT_DOUBLE,
  IX86_BT_FLOAT80,
  IX86_BT_FLOAT128,
  IX86_BT_CONST_STRING,
  IX86_BT_LAST_PRIM = IX86_BT_CONST_STRING,
  IX86_BT_V2SF,
  IX86_BT_V1DI,
  IX86_BT_V2SI,
  IX86_BT_V4HI,
  IX86_BT_V8QI,
  IX86_BT_V2DF,
  IX86_BT_V4SF,
  IX86_BT_V8HF,
  IX86_BT_V8BF,
  IX86_BT_V2DI,
  IX86_BT_V4SI,
  IX86_BT_V8HI,
  IX86_BT_V16QI,
  IX86_BT_V2UDI,
  IX86_BT_V4USI,
  IX86_BT_V8UHI,
  IX86_BT_V16UQI,
  IX86_BT_V4DF,
  IX86_BT_V8SF,
  IX86_BT_V16HF,
  IX86_BT_V16BF,
  IX86_BT_V4DI,
  IX86_BT_V8SI,
  IX86_BT_V16HI,
  IX86_BT_V32QI,
  IX86_BT_V4UDI,
  IX86_BT_V8USI,
  IX86_BT_V16UHI,
  IX86_BT_V32SF,
  IX86_BT_V32HF,
  IX86_BT_V32BF,
  IX86_BT_V16SF,
  IX86_BT_V8DF,
  IX86_BT_V8DI,
  IX86_BT_V16SI,
  IX86_BT_V32HI,
  IX86_BT_V64QI,
  IX86_BT_V12QI,
  IX86_BT_V14QI,
  IX86_BT_V32SI,
  IX86_BT_V8UDI,
  IX86_BT_V16USI,
  IX86_BT_V32UHI,
  IX86_BT_LAST_VECT = IX86_BT_V32UHI,
  IX86_BT_PCHAR,
  IX86_BT_PVOID,
  IX86_BT_PDOUBLE,
  IX86_BT_PFLOAT,
  IX86_BT_PSHORT,
  IX86_BT_PUSHORT,
  IX86_BT_PINT,
  IX86_BT_PINT64,
  IX86_BT_PLONGLONG,
  IX86_BT_PULONGLONG,
  IX86_BT_PUNSIGNED,
  IX86_BT_PUQI,
  IX86_BT_PUHI,
  IX86_BT_PUSI,
  IX86_BT_PUDI,
  IX86_BT_PUCHAR,
  IX86_BT_PV2SI,
  IX86_BT_PV2DF,
  IX86_BT_PV2DI,
  IX86_BT_PV2SF,
  IX86_BT_PV4DF,
  IX86_BT_PV4DI,
  IX86_BT_PV4SF,
  IX86_BT_PV8DF,
  IX86_BT_PV8SF,
  IX86_BT_PV4SI,
  IX86_BT_PV8QI,
  IX86_BT_PV8HI,
  IX86_BT_PV8SI,
  IX86_BT_PV8DI,
  IX86_BT_PV16QI,
  IX86_BT_PV16HI,
  IX86_BT_PV16SI,
  IX86_BT_PV16SF,
  IX86_BT_PV32QI,
  IX86_BT_PV32HI,
  IX86_BT_PV64QI,
  IX86_BT_LAST_PTR = IX86_BT_PV64QI,
  IX86_BT_PCCHAR,
  IX86_BT_PCDOUBLE,
  IX86_BT_PCFLOAT,
  IX86_BT_PCINT,
  IX86_BT_PCINT64,
  IX86_BT_PCSHORT,
  IX86_BT_PCVOID,
  IX86_BT_PCFLOAT16,
  IX86_BT_PCBFLOAT16,
  IX86_BT_PCV2SI,
  IX86_BT_PCV2DF,
  IX86_BT_PCV2SF,
  IX86_BT_PCV4DF,
  IX86_BT_PCV4SF,
  IX86_BT_PCV8DF,
  IX86_BT_PCV8SF,
  IX86_BT_PCV8HF,
  IX86_BT_PCV8BF,
  IX86_BT_PCV16HF,
  IX86_BT_PCV16BF,
  IX86_BT_PCV16SF,
  IX86_BT_PCV2DI,
  IX86_BT_PCV4SI,
  IX86_BT_PCV4DI,
  IX86_BT_PCV8HI,
  IX86_BT_PCV8SI,
  IX86_BT_PCV8DI,
  IX86_BT_PCV16QI,
  IX86_BT_PCV16HI,
  IX86_BT_PCV16SI,
  IX86_BT_PCV32QI,
  IX86_BT_PCV32HI,
  IX86_BT_PCV64QI,
  IX86_BT_LAST_CPTR = IX86_BT_PCV64QI
}
;


#define DEFINE_BUILTIN_PRIMITIVE_TYPES \
  ix86_builtin_type_tab[(int)IX86_BT_VOID] = void_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_CHAR] = char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UCHAR] = unsigned_char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_QI] = char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_HI] = intHI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_SI] = intSI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_DI] = long_long_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UQI] = unsigned_intQI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UHI] = unsigned_intHI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_USI] = unsigned_intSI_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UDI] = long_long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_SHORT] = short_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_USHORT] = short_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_INT] = integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT] = unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UNSIGNED] = unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_ULONG] = long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_LONGLONG] = long_long_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_ULONGLONG] = long_long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT8] = unsigned_char_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT16] = short_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_INT64] = long_long_integer_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_UINT64] = long_long_unsigned_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT16] = ix86_float16_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_BFLOAT16] = ix86_bf16_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT] = float_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_DOUBLE] = double_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT80] = float80_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_FLOAT128] = float128t_type_node, \
  ix86_builtin_type_tab[(int)IX86_BT_CONST_STRING] = const_string_type_node


static const machine_mode ix86_builtin_type_vect_mode[] = {
  E_V2SFmode, E_V1DImode, E_V2SImode, E_V4HImode, E_V8QImode, E_V2DFmode,
  E_V4SFmode, E_V8HFmode, E_V8BFmode, E_V2DImode, E_V4SImode, E_V8HImode,
  E_V16QImode, E_V2DImode, E_V4SImode, E_V8HImode, E_V16QImode, E_V4DFmode,
  E_V8SFmode, E_V16HFmode, E_V16BFmode, E_V4DImode, E_V8SImode, E_V16HImode,
  E_V32QImode, E_V4DImode, E_V8SImode, E_V16HImode, E_V32SFmode, E_V32HFmode,
  E_V32BFmode, E_V16SFmode, E_V8DFmode, E_V8DImode, E_V16SImode, E_V32HImode,
  E_V64QImode, E_V12QImode, E_V14QImode, E_V32SImode, E_V8DImode, E_V16SImode,
  E_V32HImode
};


static const enum ix86_builtin_type ix86_builtin_type_vect_base[] = {
  IX86_BT_FLOAT, IX86_BT_DI, IX86_BT_SI, IX86_BT_HI,
  IX86_BT_QI, IX86_BT_DOUBLE, IX86_BT_FLOAT, IX86_BT_FLOAT16,
  IX86_BT_BFLOAT16, IX86_BT_DI, IX86_BT_SI, IX86_BT_HI,
  IX86_BT_QI, IX86_BT_UDI, IX86_BT_USI, IX86_BT_UHI,
  IX86_BT_UQI, IX86_BT_DOUBLE, IX86_BT_FLOAT, IX86_BT_FLOAT16,
  IX86_BT_BFLOAT16, IX86_BT_DI, IX86_BT_SI, IX86_BT_HI,
  IX86_BT_QI, IX86_BT_UDI, IX86_BT_USI, IX86_BT_UHI,
  IX86_BT_FLOAT, IX86_BT_FLOAT16, IX86_BT_BFLOAT16, IX86_BT_FLOAT,
  IX86_BT_DOUBLE, IX86_BT_DI, IX86_BT_SI, IX86_BT_HI,
  IX86_BT_QI, IX86_BT_QI, IX86_BT_QI, IX86_BT_SI,
  IX86_BT_UDI, IX86_BT_USI, IX86_BT_UHI
};


static const enum ix86_builtin_type ix86_builtin_type_ptr_base[] = {
  IX86_BT_CHAR, IX86_BT_VOID, IX86_BT_DOUBLE, IX86_BT_FLOAT,
  IX86_BT_SHORT, IX86_BT_USHORT, IX86_BT_INT, IX86_BT_INT64,
  IX86_BT_LONGLONG, IX86_BT_ULONGLONG, IX86_BT_UNSIGNED, IX86_BT_UQI,
  IX86_BT_UHI, IX86_BT_USI, IX86_BT_UDI, IX86_BT_UCHAR,
  IX86_BT_V2SI, IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_V2SF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4SF, IX86_BT_V8DF,
  IX86_BT_V8SF, IX86_BT_V4SI, IX86_BT_V8QI, IX86_BT_V8HI,
  IX86_BT_V8SI, IX86_BT_V8DI, IX86_BT_V16QI, IX86_BT_V16HI,
  IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_V32QI, IX86_BT_V32HI,
  IX86_BT_V64QI,
  /* pointer-to-constant defs start here */
  IX86_BT_CHAR, IX86_BT_DOUBLE, IX86_BT_FLOAT, IX86_BT_INT,
  IX86_BT_INT64, IX86_BT_SHORT, IX86_BT_VOID, IX86_BT_FLOAT16,
  IX86_BT_BFLOAT16, IX86_BT_V2SI, IX86_BT_V2DF, IX86_BT_V2SF,
  IX86_BT_V4DF, IX86_BT_V4SF, IX86_BT_V8DF, IX86_BT_V8SF,
  IX86_BT_V8HF, IX86_BT_V8BF, IX86_BT_V16HF, IX86_BT_V16BF,
  IX86_BT_V16SF, IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_V4DI,
  IX86_BT_V8HI, IX86_BT_V8SI, IX86_BT_V8DI, IX86_BT_V16QI,
  IX86_BT_V16HI, IX86_BT_V16SI, IX86_BT_V32QI, IX86_BT_V32HI,
  IX86_BT_V64QI
};


enum ix86_builtin_func_type {
  FLOAT128_FTYPE_VOID,
  UINT64_FTYPE_VOID,
  UNSIGNED_FTYPE_VOID,
  UINT_FTYPE_VOID,
  USHORT_FTYPE_VOID,
  INT_FTYPE_VOID,
  UINT8_FTYPE_VOID,
  VOID_FTYPE_VOID,
  PVOID_FTYPE_VOID,
  FLOAT_FTYPE_FLOAT,
  FLOAT128_FTYPE_FLOAT128,
  FLOAT128_FTYPE_CONST_STRING,
  INT_FTYPE_INT,
  INT_FTYPE_V16QI,
  INT_FTYPE_V2DF,
  INT_FTYPE_V4DF,
  INT_FTYPE_V4SF,
  INT_FTYPE_V8QI,
  INT_FTYPE_V8SF,
  INT_FTYPE_V32QI,
  INT_FTYPE_PCCHAR,
  INT64_FTYPE_INT64,
  INT64_FTYPE_V2DF,
  INT64_FTYPE_V4SF,
  UINT_FTYPE_UINT,
  UINT16_FTYPE_UINT16,
  UINT64_FTYPE_INT,
  UINT64_FTYPE_PUNSIGNED,
  UINT64_FTYPE_UINT64,
  V16QI_FTYPE_PCCHAR,
  V16QI_FTYPE_V16QI,
  V2DF_FTYPE_PCDOUBLE,
  V2DF_FTYPE_V2DF,
  V2DF_FTYPE_V2SI,
  V2DF_FTYPE_V4DF,
  V2DF_FTYPE_V4SF,
  V2DF_FTYPE_V4SI,
  V2DI_FTYPE_PV2DI,
  V2DI_FTYPE_V16QI,
  V2DI_FTYPE_V2DI,
  V2DI_FTYPE_V4SI,
  V2DI_FTYPE_V8HI,
  V2SF_FTYPE_V2SF,
  V2SF_FTYPE_V2SI,
  V2SI_FTYPE_V2DF,
  V2SI_FTYPE_V2SF,
  V2SI_FTYPE_V2SI,
  V2SI_FTYPE_PCV2SI,
  V2SI_FTYPE_V4SF,
  V32QI_FTYPE_PCCHAR,
  V4DF_FTYPE_PCDOUBLE,
  V4DF_FTYPE_PCV2DF,
  V4DF_FTYPE_V2DF,
  V4DF_FTYPE_V4DF,
  V4DF_FTYPE_V4SF,
  V4DF_FTYPE_V4SI,
  V8DF_FTYPE_V8DF,
  V4HI_FTYPE_V4HI,
  V4SF_FTYPE_PCFLOAT,
  V4SF_FTYPE_V2DF,
  V4SF_FTYPE_V2DF_V4SF_UQI,
  V4SF_FTYPE_V4DF,
  V4SF_FTYPE_V4DF_V4SF_UQI,
  V4SF_FTYPE_V4SF,
  V4SF_FTYPE_PCV4SF,
  V4SF_FTYPE_V4SI,
  V4SF_FTYPE_V8SF,
  V4SF_FTYPE_V8HI,
  V4SF_FTYPE_V8HI_V4SF_UQI,
  V4SI_FTYPE_V16QI,
  V4SI_FTYPE_V2DF,
  V4SI_FTYPE_V4DF,
  V4SI_FTYPE_V4SF,
  V4SI_FTYPE_V4SI,
  V4SI_FTYPE_V8HI,
  V4SI_FTYPE_V8SI,
  V8HI_FTYPE_V16QI,
  V8HI_FTYPE_V8HI,
  V8QI_FTYPE_V8QI,
  V8SF_FTYPE_PCFLOAT,
  V8SF_FTYPE_PCV4SF,
  V8SF_FTYPE_PCV8SF,
  V8SF_FTYPE_V4SF,
  V8SF_FTYPE_V8SF,
  V8SF_FTYPE_V8SI,
  V8SF_FTYPE_V8HI,
  V8SF_FTYPE_V8HI_V8SF_UQI,
  V16SF_FTYPE_V16SF,
  V8SI_FTYPE_V4SI,
  V8SI_FTYPE_V8SF,
  V32QI_FTYPE_V32QI,
  V32QI_FTYPE_V16QI,
  V16HI_FTYPE_V16HI,
  V16HI_FTYPE_V8HI,
  V8SI_FTYPE_V8SI,
  VOID_FTYPE_PCVOID,
  VOID_FTYPE_PVOID,
  VOID_FTYPE_UINT64,
  VOID_FTYPE_UINT64_PVOID,
  VOID_FTYPE_UNSIGNED,
  VOID_FTYPE_UNSIGNED_PVOID,
  UINT8_FTYPE_UNSIGNED_UINT64,
  INT_FTYPE_PUSHORT,
  INT_FTYPE_PUNSIGNED,
  INT_FTYPE_PULONGLONG,
  V16HI_FTYPE_V16QI,
  V8SI_FTYPE_V16QI,
  V4DI_FTYPE_V16QI,
  V8SI_FTYPE_V8HI,
  V4DI_FTYPE_V8HI,
  V4DI_FTYPE_V4SI,
  V4DI_FTYPE_PV4DI,
  V4DI_FTYPE_V2DI,
  V16SI_FTYPE_INT,
  V16SF_FTYPE_V4SF,
  V16SF_FTYPE_V8SF,
  V8DF_FTYPE_V4DF,
  V8DF_FTYPE_V2DF,
  V16SI_FTYPE_V4SI,
  V16SI_FTYPE_V8SI,
  V16SI_FTYPE_V16SF,
  V16SI_FTYPE_V16SI,
  V32HI_FTYPE_V32HI,
  V64QI_FTYPE_V64QI,
  V16SI_FTYPE_V16SI_V16SI_UHI,
  V8DI_FTYPE_V8DI_V8DI_UQI,
  V8DI_FTYPE_PV8DI,
  V8DI_FTYPE_V8DI,
  VOID_FTYPE_INT_INT64,
  DI_FTYPE_V2DI_INT,
  DOUBLE_FTYPE_V2DF_INT,
  FLOAT_FTYPE_V4SF_INT,
  FLOAT128_FTYPE_FLOAT128_FLOAT128,
  HI_FTYPE_V4HI_INT,
  HI_FTYPE_V8HI_INT,
  INT_FTYPE_V2DF_V2DF,
  INT_FTYPE_V2DI_V2DI,
  INT_FTYPE_V4DF_V4DF,
  INT_FTYPE_V4DI_V4DI,
  INT_FTYPE_V4SF_V4SF,
  INT_FTYPE_V8SF_V8SF,
  QI_FTYPE_V16QI_INT,
  QI_FTYPE_V8QI_INT,
  SI_FTYPE_V2SI_INT,
  SI_FTYPE_V4SI_INT,
  UINT_FTYPE_UINT_UCHAR,
  UINT_FTYPE_UINT_UINT,
  UINT_FTYPE_UINT_USHORT,
  UINT16_FTYPE_UINT16_INT,
  UINT64_FTYPE_UINT64_UINT64,
  UINT8_FTYPE_UINT8_INT,
  V16QI_FTYPE_V16QI_SI,
  V16QI_FTYPE_V16QI_V16QI,
  V16QI_FTYPE_V8HI_V8HI,
  V1DI_FTYPE_V1DI_SI,
  V1DI_FTYPE_V1DI_V1DI,
  V1DI_FTYPE_V2SI_V2SI,
  V1DI_FTYPE_V8QI_V8QI,
  V2DF_FTYPE_PCV2DF_V2DI,
  V2DF_FTYPE_V2DF_UINT,
  V2DF_FTYPE_V2DF_DI,
  V2DF_FTYPE_V2DF_INT,
  V2DF_FTYPE_V2DF_PCDOUBLE,
  V2DF_FTYPE_V2DF_SI,
  V2DF_FTYPE_V2DF_V2DF,
  V2DF_FTYPE_V2DF_V2DI,
  V2DF_FTYPE_V2DF_V4SF,
  V2DF_FTYPE_V4DF_INT,
  V2DF_FTYPE_V4DF_INT_V2DF_UQI,
  V2DF_FTYPE_V8DF_INT,
  V2DF_FTYPE_V8DF_INT_V2DF_UQI,
  V2DI_FTYPE_V16QI_V16QI,
  V2DI_FTYPE_V2DI_INT,
  V2DI_FTYPE_V2DI_INT_V2DI_UQI,
  V2DI_FTYPE_V2DI_SI,
  V2DI_FTYPE_V2DI_V16QI,
  V2DI_FTYPE_V2DI_V2DI,
  V2DI_FTYPE_V4SI_V4SI,
  V2DI_FTYPE_PCV2DI_V2DI,
  V2SF_FTYPE_V2SF_V2SF,
  V2SI_FTYPE_INT_INT,
  V2SI_FTYPE_V2SF_V2SF,
  V2SI_FTYPE_V2SI_SI,
  V2SI_FTYPE_V2SI_V2SI,
  V2SI_FTYPE_V4HI_V4HI,
  V4DF_FTYPE_PCV4DF_V4DI,
  V4DF_FTYPE_V4DF_INT,
  V8DF_FTYPE_V8DF_INT,
  V4DF_FTYPE_V8DF_INT,
  V4DF_FTYPE_V8DF_INT_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DF,
  V4DF_FTYPE_V4DF_V4DI,
  V4HI_FTYPE_V2SI_V2SI,
  V4HI_FTYPE_V4HI_INT,
  V4HI_FTYPE_V4HI_SI,
  V4HI_FTYPE_V4HI_V4HI,
  V4HI_FTYPE_V8QI_V8QI,
  V4SF_FTYPE_PCV4SF_V4SI,
  V4SF_FTYPE_V4SF_UINT,
  V4SF_FTYPE_V4SF_DI,
  V4SF_FTYPE_V4SF_INT,
  INT_FTYPE_V4SF_V4SF_INT_INT,
  INT_FTYPE_V2DF_V2DF_INT_INT,
  V4SF_FTYPE_V4SF_PCV2SF,
  V4SF_FTYPE_V4SF_SI,
  V4SF_FTYPE_V4SF_V2DF,
  V4SF_FTYPE_V4SF_V2SI,
  V4SF_FTYPE_V4SF_V4SF,
  V4SF_FTYPE_V4SF_V4SI,
  V4SF_FTYPE_V8SF_INT,
  V4SF_FTYPE_V8SF_INT_V4SF_UQI,
  V4SI_FTYPE_V2DF_V2DF,
  V4SI_FTYPE_V2DF_V4SI_UQI,
  V4SI_FTYPE_V4SI_INT,
  V4SI_FTYPE_V4SI_INT_V4SI_UQI,
  V4SI_FTYPE_V4SI_SI,
  V4SI_FTYPE_V4SI_V4SI,
  V4SI_FTYPE_V8HI_V8HI,
  V4SI_FTYPE_V8HI_V8HI_V4SI_UQI,
  V4SI_FTYPE_V8SI_INT,
  V4SI_FTYPE_V8SI_INT_V4SI_UQI,
  V4SI_FTYPE_PCV4SI_V4SI,
  V8HI_FTYPE_V16QI_V16QI,
  V8HI_FTYPE_V16QI_V16QI_V8HI_UQI,
  V8HI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_INT,
  V8DI_FTYPE_V8DI_INT,
  V8HI_FTYPE_V8HI_SI,
  V8HI_FTYPE_V8HI_V8HI,
  V8HI_FTYPE_V8SF_INT,
  V8HI_FTYPE_V8SF_INT_V8HI_UQI,
  V8HI_FTYPE_V4SF_INT,
  V8HI_FTYPE_V4SF_INT_V8HI_UQI,
  V8QI_FTYPE_V4HI_V4HI,
  V8QI_FTYPE_V8QI_V8QI,
  V8SF_FTYPE_PCV8SF_V8SI,
  V8SF_FTYPE_V8SF_INT,
  V8SF_FTYPE_V16SF_INT,
  V8SF_FTYPE_V16SF_INT_V8SF_UQI,
  V16SF_FTYPE_V16SF_INT,
  V4SF_FTYPE_V16SF_INT,
  V4SF_FTYPE_V16SF_INT_V4SF_UQI,
  V8SF_FTYPE_V8SF_V8SF,
  V16SF_FTYPE_V16SF_V16SF,
  V8SF_FTYPE_V8SF_V8SI,
  V32QI_FTYPE_V16HI_V16HI,
  V16HI_FTYPE_V8SI_V8SI,
  V8DF_FTYPE_V8DF_V2DF_INT,
  V8DF_FTYPE_V8DF_V2DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V4DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_INT,
  V8DF_FTYPE_V8DF_V8DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_INT_V8DF_QI_INT,
  V8DF_FTYPE_V8DF_INT_V8DF_UQI,
  V8DF_FTYPE_V8DF_INT_V8DF_UQI_INT,
  V8DF_FTYPE_V8DF_V8DF_V8DI_INT,
  V4DF_FTYPE_V4DF_V4DF_V4DI_INT_UQI,
  V2DF_FTYPE_V2DF_V2DF_V2DI_INT_UQI,
  V8DF_FTYPE_V8DF_V8DF_V8DI_INT_QI_INT,
  V8DF_FTYPE_V8DF_V8DF,
  V16SF_FTYPE_V16SF_V16SF_INT,
  V16SF_FTYPE_V16SF_V16SF_INT_V16SF_UHI,
  V16SF_FTYPE_V16SF_V16SF_INT_V16SF_HI_INT,
  V16SF_FTYPE_V16SF_INT_V16SF_UHI,
  V16SF_FTYPE_V16SF_INT_V16SF_UHI_INT,
  V16SI_FTYPE_V16SI_V4SI_INT_V16SI_UHI,
  V16SF_FTYPE_V16SF_V16SF_V16SI_INT,
  V16SF_FTYPE_V16SF_V16SF_V16SI_INT_HI_INT,
  V8SF_FTYPE_V8SF_V8SF_V8SI_INT_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SI_INT_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SI_INT_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DI_INT_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_INT_V2DF_UQI_INT,
  V4SF_FTYPE_V4SF_V4SF_INT_V4SF_UQI_INT,
  V16SF_FTYPE_V16SF_V4SF_INT,
  V16SF_FTYPE_V16SF_V4SF_INT_V16SF_UHI,
  V16SF_FTYPE_V16SF_V8SF_INT_V16SF_UHI,
  V32QI_FTYPE_V32QI_V32QI,
  V16HI_FTYPE_V32QI_V32QI,
  V16HI_FTYPE_V32QI_V32QI_V16HI_UHI,
  V32HI_FTYPE_V64QI_V64QI_V32HI_USI,
  V16HI_FTYPE_V16HI_V8HI,
  V16HI_FTYPE_V16HI_V16HI,
  V32HI_FTYPE_V32HI_INT,
  V16HI_FTYPE_V16HI_INT,
  V16HI_FTYPE_V16SF_INT,
  V16HI_FTYPE_V16SF_INT_V16HI_UHI,
  V16HI_FTYPE_V16HI_SI,
  V16HI_FTYPE_V16HI_V16HI_INT,
  V32QI_FTYPE_V32QI_V32QI_INT,
  V8SI_FTYPE_V4DF_V4DF,
  V8SI_FTYPE_V8SI_V4SI,
  V16SI_FTYPE_V16SI_V4SI_INT,
  V16SI_FTYPE_V16SI_V8SI_INT_V16SI_UHI,
  V4SI_FTYPE_V16SI_INT,
  V4SI_FTYPE_V16SI_INT_V4SI_UQI,
  V8SI_FTYPE_V8SI_V8SI,
  V16SI_FTYPE_V16SI_V16SI_INT_V16SI_UHI,
  V8SI_FTYPE_V16HI_V16HI,
  V8SI_FTYPE_V16HI_V16HI_V8SI_UQI,
  V16SI_FTYPE_V32HI_V32HI_V16SI_UHI,
  V8SI_FTYPE_V8SI_INT,
  V8SI_FTYPE_V8SI_INT_V8SI_UQI,
  V8SI_FTYPE_V16SI_INT,
  V8SI_FTYPE_V16SI_INT_V8SI_UQI,
  V8SI_FTYPE_V8SI_SI,
  V16SI_FTYPE_V16SI_INT,
  V16SI_FTYPE_V16SI_V4SI_V16SI_UHI,
  V16SI_FTYPE_V16SI_INT_V16SI_UHI,
  V8SI_FTYPE_PCV8SI_V8SI,
  V4DI_FTYPE_V4DI_V4DI,
  V16SI_FTYPE_V8DF_V8DF,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UQI,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UDI,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_USI,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UHI,
  V8DI_FTYPE_V8DI_V4DI_INT,
  V8DI_FTYPE_V8DI_V2DI_INT,
  V8DI_FTYPE_V8DI_V2DI_INT_V8DI_UQI,
  V8DI_FTYPE_V8DI_V4DI_INT_V8DI_UQI,
  V4DI_FTYPE_V8SI_V8SI,
  V4DI_FTYPE_V32QI_V32QI,
  V8DI_FTYPE_V64QI_V64QI,
  V4DI_FTYPE_V4DI_V2DI,
  V4DI_FTYPE_PCV4DI_V4DI,
  V4DI_FTYPE_V8DI_INT,
  V4DI_FTYPE_V8DI_INT_V4DI_UQI,
  V8DI_FTYPE_V8DI_V2DI_V8DI_UQI,
  V8DI_FTYPE_V8DI_INT_V8DI_UQI,
  V4DI_FTYPE_V4DI_INT,
  V4DI_FTYPE_V4DI_INT_V4DI_UQI,
  V2DI_FTYPE_V4DI_INT,
  VOID_FTYPE_PVOID_INT64,
  V2DI_FTYPE_V4DI_INT_V2DI_UQI,
  V2DI_FTYPE_V8DI_INT,
  V2DI_FTYPE_V8DI_INT_V2DI_UQI,
  VOID_FTYPE_PCHAR_V16QI,
  VOID_FTYPE_PCHAR_V32QI,
  VOID_FTYPE_PDOUBLE_V2DF,
  VOID_FTYPE_PDOUBLE_V4DF,
  VOID_FTYPE_PDOUBLE_V8DF,
  VOID_FTYPE_PFLOAT_V4SF,
  VOID_FTYPE_PFLOAT_V8SF,
  VOID_FTYPE_PFLOAT_V16SF,
  VOID_FTYPE_PINT_INT,
  VOID_FTYPE_PUNSIGNED_UNSIGNED,
  VOID_FTYPE_PVOID_PCVOID,
  INT_FTYPE_PVOID_PCVOID,
  VOID_FTYPE_PLONGLONG_LONGLONG,
  VOID_FTYPE_PULONGLONG_ULONGLONG,
  VOID_FTYPE_PV2SI_V2SI,
  VOID_FTYPE_PV2DI_V2DI,
  VOID_FTYPE_PV2SF_V4SF,
  VOID_FTYPE_PV4DI_V4DI,
  VOID_FTYPE_PV4SF_V4SF,
  VOID_FTYPE_PV8SF_V8SF,
  VOID_FTYPE_UNSIGNED_UNSIGNED,
  VOID_FTYPE_UNSIGNED_UNSIGNED_UNSIGNED,
  VOID_FTYPE_PV8DI_V8DI,
  V16SF_FTYPE_V16SF_V16SF_V16SF_V16SF_V16SF_PCV4SF_V16SF_UHI,
  V16SF_FTYPE_V16SF_V16SF_V16SF_V16SF_V16SF_PCV4SF,
  V4SF_FTYPE_V4SF_V4SF_V4SF_V4SF_V4SF_PCV4SF,
  V4SF_FTYPE_V4SF_V4SF_V4SF_V4SF_V4SF_PCV4SF_V4SF_UQI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_V16SI_V16SI_PCV4SI_V16SI_UHI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_V16SI_V16SI_PCV4SI,
  UCHAR_FTYPE_UQI_UQI_PUCHAR,
  UCHAR_FTYPE_UQI_UQI,
  UCHAR_FTYPE_UHI_UHI_PUCHAR,
  UCHAR_FTYPE_UHI_UHI,
  UCHAR_FTYPE_USI_USI_PUCHAR,
  UCHAR_FTYPE_USI_USI,
  UCHAR_FTYPE_UDI_UDI_PUCHAR,
  UCHAR_FTYPE_UDI_UDI,
  USI_FTYPE_UQI,
  USI_FTYPE_UHI,
  UQI_FTYPE_USI,
  UHI_FTYPE_USI,
  UHI_FTYPE_UHI_UQI,
  USI_FTYPE_USI_UQI,
  UDI_FTYPE_UDI_UQI,
  UQI_FTYPE_UQI,
  UHI_FTYPE_UHI,
  USI_FTYPE_USI,
  UDI_FTYPE_UDI,
  UHI_FTYPE_V16QI,
  USI_FTYPE_V32QI,
  UDI_FTYPE_V64QI,
  UQI_FTYPE_V8HI,
  UHI_FTYPE_V16HI,
  USI_FTYPE_V32HI,
  UQI_FTYPE_V4SI,
  UQI_FTYPE_V8SI,
  UHI_FTYPE_V16SI,
  UQI_FTYPE_V2DI,
  UQI_FTYPE_V4DI,
  UQI_FTYPE_V8DI,
  UQI_FTYPE_UQI_UQI,
  UHI_FTYPE_UHI_UHI,
  USI_FTYPE_USI_USI,
  UDI_FTYPE_UDI_UDI,
  UHI_FTYPE_V16QI_V16QI_UHI,
  UHI_FTYPE_V16QI_V16QI_INT_UHI,
  USI_FTYPE_V32QI_V32QI_USI,
  USI_FTYPE_V32QI_V32QI_INT_USI,
  UDI_FTYPE_V64QI_V64QI_UDI,
  UDI_FTYPE_V64QI_V64QI_INT_UDI,
  UQI_FTYPE_V8HI_V8HI_UQI,
  UQI_FTYPE_V8HI_V8HI_INT_UQI,
  UHI_FTYPE_V16HI_V16HI_UHI,
  UHI_FTYPE_V16HI_V16HI_INT_UHI,
  USI_FTYPE_V32HI_V32HI_USI,
  USI_FTYPE_V32HI_V32HI_INT_USI,
  UQI_FTYPE_V4SI_V4SI_UQI,
  UQI_FTYPE_V4SI_V4SI_INT_UQI,
  UQI_FTYPE_V8SI_V8SI_UQI,
  UQI_FTYPE_V8SI_V8SI_INT_UQI,
  UQI_FTYPE_V2DI_V2DI_UQI,
  UQI_FTYPE_V2DI_V2DI_INT_UQI,
  UQI_FTYPE_V4DI_V4DI_UQI,
  UQI_FTYPE_V4DI_V4DI_INT_UQI,
  UQI_FTYPE_V8DI_V8DI_UQI,
  UHI_FTYPE_V16SI_V16SI_UHI,
  UQI_FTYPE_V8DI_V8UDI_INT,
  UQI_FTYPE_V8DI_V8DI_INT_UQI,
  UHI_FTYPE_V16SI_V16SI_INT,
  UHI_FTYPE_V16SI_V16SI_INT_UHI,
  UQI_FTYPE_V8DF_V8DF_INT,
  UQI_FTYPE_V8DF_V8DF_INT_UQI_INT,
  UHI_FTYPE_V16SF_V16SF_INT,
  UHI_FTYPE_V16SF_V16SF_INT_UHI_INT,
  UQI_FTYPE_V2DF_V2DF_INT,
  UQI_FTYPE_V2DF_V2DF_INT_UQI,
  UQI_FTYPE_V2DF_V2DF_INT_UQI_INT,
  UQI_FTYPE_V4SF_V4SF_INT,
  UQI_FTYPE_V4SF_V4SF_INT_UQI,
  UQI_FTYPE_V4SF_V4SF_INT_UQI_INT,
  V16SI_FTYPE_UHI,
  V8DI_FTYPE_UQI,
  V16QI_FTYPE_UHI,
  V32QI_FTYPE_USI,
  V64QI_FTYPE_UDI,
  V8HI_FTYPE_UQI,
  V16HI_FTYPE_UHI,
  V32HI_FTYPE_USI,
  V4SI_FTYPE_UQI,
  V4SI_FTYPE_UHI,
  V8SI_FTYPE_UQI,
  V8SI_FTYPE_UHI,
  V2DI_FTYPE_UQI,
  V4DI_FTYPE_UQI,
  INT_FTYPE_V16QI_V16QI_INT,
  UCHAR_FTYPE_UINT_UINT_UINT,
  UCHAR_FTYPE_UINT64_UINT_UINT,
  V16HI_FTYPE_V16HI_V16HI_V16HI,
  V16QI_FTYPE_V16QI_QI_INT,
  V16QI_FTYPE_V16QI_V16QI_INT,
  V16QI_FTYPE_V16QI_V16QI_V16QI,
  V1DI_FTYPE_V1DI_V1DI_INT,
  V2DF_FTYPE_V2DF_V2DF_INT,
  V2DF_FTYPE_V2DF_V2DF_INT_INT,
  V4DF_FTYPE_V4DF_V4DI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF,
  V2DF_FTYPE_V2DI_V2DF_V2DF_UQI,
  V2DF_FTYPE_V2DF_V2DI_V2DF_UQI,
  V2DF_FTYPE_V2DF_V2DF_V2DI_INT,
  V2DI_FTYPE_V2DI_DI_INT,
  V2DI_FTYPE_V2DI_UINT_UINT,
  V2DI_FTYPE_V2DI_V2DI_INT,
  V2DI_FTYPE_V2DI_V2DI_V2DI,
  V32QI_FTYPE_V32QI_V32QI_V32QI,
  V4DF_FTYPE_V4DF_V2DF_INT,
  V4DF_FTYPE_V4DF_V2DF_INT_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DF_INT,
  V4DF_FTYPE_V4DF_V4DF_V4DF,
  V4DF_FTYPE_V4DF_V4DF_V4DI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT,
  V4DI_FTYPE_V4DI_V4DI_V4DI,
  V4HI_FTYPE_V4HI_HI_INT,
  V4SF_FTYPE_V4SF_FLOAT_INT,
  V4SF_FTYPE_V4SF_V4SF_INT,
  V4SF_FTYPE_V4SF_V4SF_INT_INT,
  V4SF_FTYPE_V4SF_V2DF_INT,
  V2DF_FTYPE_V2DF_V4SF_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF,
  V4SF_FTYPE_V4SI_V4SF_V4SF_UQI,
  V4SF_FTYPE_V4SF_V4SI_V4SF_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SF_UQI,
  V4SF_FTYPE_V4SF_V4SF_V4SI_INT,
  V4SI_FTYPE_V4SI_SI_INT,
  V4SI_FTYPE_V4SI_V4SI_INT,
  V4SI_FTYPE_V4SI_V4SI_V2DI,
  V4SI_FTYPE_V4SI_V4SI_V4SI,
  V8HI_FTYPE_V8HI_HI_INT,
  V8HI_FTYPE_V8HI_V8HI_INT,
  V8HI_FTYPE_V8HI_V8HI_V4SI,
  V8HI_FTYPE_V8HI_V8HI_V8HI,
  V8SF_FTYPE_V8SF_V4SF_INT,
  V8SF_FTYPE_V8SF_V4SF_INT_V8SF_UQI,
  V8SF_FTYPE_V8SF_V8SF_INT,
  V8SF_FTYPE_V8SF_V8SF_V8SF,
  V8SF_FTYPE_V8SF_V8SF_V8SI_INT,
  V8SI_FTYPE_V8SI_V4SI_INT,
  V8SI_FTYPE_V8SI_V4SI_INT_V8SI_UQI,
  V8SI_FTYPE_V8SI_V8SI_INT,
  V8SI_FTYPE_V8SI_V8SI_V8SI,
  V4DI_FTYPE_V4DI_V4DI_INT,
  V4DI_FTYPE_V4DI_V2DI_INT,
  V4DI_FTYPE_V4DI_V2DI_INT_V4DI_UQI,
  V2DF_FTYPE_V2DF_V2DF_UQI,
  V2DF_FTYPE_V4SF_V2DF_UQI,
  V2DF_FTYPE_V4SI_V2DF_UQI,
  V4DF_FTYPE_V4DF_V4DF_UQI,
  V4DF_FTYPE_V4SF_V4DF_UQI,
  V4DF_FTYPE_V4SI_V4DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_UQI,
  V8DF_FTYPE_V8SI_V8DF_UQI,
  V2DI_FTYPE_V4SI_V2DI_UQI,
  V2DI_FTYPE_V8HI_V2DI_UQI,
  V4DI_FTYPE_V4DF_V4DI_UQI,
  V2DI_FTYPE_V2DF_V2DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_V2DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UQI,
  V4DI_FTYPE_V4DI_V4DI_V4DI_UQI,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_UQI,
  V8DI_FTYPE_V8SI_V8DI_UQI,
  V8DI_FTYPE_V8HI_V8DI_UQI,
  V8DI_FTYPE_V16QI_V8DI_UQI,
  V2DI_FTYPE_V16QI_V2DI_UQI,
  V4DI_FTYPE_V16QI_V4DI_UQI,
  V4DI_FTYPE_V4DI_V4DI_UQI,
  V4DI_FTYPE_V4SI_V4DI_UQI,
  V4DI_FTYPE_V8HI_V4DI_UQI,
  V8DI_FTYPE_V8DI_V8DI_V8DI_UQI,
  V8DF_FTYPE_V8DI_V8DF_V8DF_UQI,
  V8DF_FTYPE_V8DF_V8DI_V8DF_UQI,
  V4DF_FTYPE_V4DI_V4DF_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DI_V4DF_UQI,
  V4DF_FTYPE_V4DF_V4DF_V4DF_UQI,
  V8DF_FTYPE_V8DF_V8DF_V8DF_UQI,
  V16QI_FTYPE_V16QI_V16QI_V16QI_UHI,
  V16HI_FTYPE_V16HI_V16HI_V16HI_UHI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_UHI,
  V2DF_FTYPE_V2DF_V2DF_V2DF_UQI,
  V32HI_FTYPE_V32HI_V32HI_V32HI_USI,
  V64QI_FTYPE_V64QI_V64QI_V64QI_UDI,
  V32QI_FTYPE_V32QI_V32QI_V32QI_USI,
  V8HI_FTYPE_V8HI_V8HI_V8HI_UQI,
  V4SF_FTYPE_V4SF_V4SF_UQI,
  V4SF_FTYPE_V4SI_V4SF_UQI,
  V8SF_FTYPE_V8SF_V8SF_UQI,
  V8SF_FTYPE_V8SI_V8SF_UQI,
  V16SF_FTYPE_V16SF_V16SF_UHI,
  V4SI_FTYPE_V16QI_V4SI_UQI,
  V4SI_FTYPE_V8HI_V4SI_UQI,
  V8SI_FTYPE_V8SI_V8SI_UQI,
  V8SI_FTYPE_V8HI_V8SI_UQI,
  V8SI_FTYPE_V16QI_V8SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_V4SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_INT_V4SI_UQI,
  V8SF_FTYPE_V8SF_V8SF_V8SF_UQI,
  V8SF_FTYPE_V8SI_V8SF_V8SF_UQI,
  V8SF_FTYPE_V8SF_V8SI_V8SF_UQI,
  V8SI_FTYPE_V8SI_V8SI_V8SI_UQI,
  V8SI_FTYPE_V8SI_V8SI_INT_V8SI_UQI,
  V16SF_FTYPE_V16SF_V16SF_V16SF_UHI,
  V16SF_FTYPE_V16SI_V16SF_V16SF_UHI,
  V16SF_FTYPE_V16SF_V16SI_V16SF_UHI,
  V16SF_FTYPE_V8SF_V16SF_UHI,
  V16SF_FTYPE_V4SF_V16SF_UHI,
  V8DF_FTYPE_V4DF_V8DF_UQI,
  V8DF_FTYPE_V2DF_V8DF_UQI,
  V16SI_FTYPE_V8SI_V16SI_UHI,
  V16SI_FTYPE_V4SI_V16SI_UHI,
  V16SI_FTYPE_SI_V16SI_UHI,
  V16SI_FTYPE_V16HI_V16SI_UHI,
  V16SI_FTYPE_V16QI_V16SI_UHI,
  V8DI_FTYPE_V4DI_V8DI_UQI,
  V4SI_FTYPE_V4DF_V4SI_UQI,
  V8DI_FTYPE_V2DI_V8DI_UQI,
  V8DI_FTYPE_DI_V8DI_UQI,
  V16QI_FTYPE_V16SI_V16QI_UHI,
  V16QI_FTYPE_V8DI_V16QI_UQI,
  V32HI_FTYPE_V32HI_V32HI_USI,
  V32HI_FTYPE_V64QI_V64QI_INT,
  V32HI_FTYPE_V32QI_V32HI_USI,
  V16HI_FTYPE_V16HI_V16HI_UHI,
  V16HI_FTYPE_V32QI_V32QI_INT,
  V16HI_FTYPE_V16QI_V16HI_UHI,
  V8HI_FTYPE_V16QI_V8HI_UQI,
  V8HI_FTYPE_V16QI_V16QI_INT,
  V8SF_FTYPE_V4SF_V8SF_UQI,
  V4DF_FTYPE_V2DF_V4DF_UQI,
  V8SI_FTYPE_V4SI_V8SI_UQI,
  V8SI_FTYPE_SI_V8SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_UQI,
  V4SI_FTYPE_SI_V4SI_UQI,
  V4DI_FTYPE_V2DI_V4DI_UQI,
  V4DI_FTYPE_DI_V4DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_UQI,
  V2DI_FTYPE_DI_V2DI_UQI,
  V64QI_FTYPE_V64QI_V64QI_UDI,
  V64QI_FTYPE_V16QI_V64QI_UDI,
  V64QI_FTYPE_QI_V64QI_UDI,
  V32QI_FTYPE_V32QI_V32QI_USI,
  V32QI_FTYPE_V16QI_V32QI_USI,
  V32QI_FTYPE_QI_V32QI_USI,
  V16QI_FTYPE_V16QI_V16QI_UHI,
  V16QI_FTYPE_QI_V16QI_UHI,
  V32HI_FTYPE_V8HI_V32HI_USI,
  V32HI_FTYPE_HI_V32HI_USI,
  V16HI_FTYPE_V8HI_V16HI_UHI,
  V16HI_FTYPE_HI_V16HI_UHI,
  V8HI_FTYPE_V8HI_V8HI_UQI,
  V8HI_FTYPE_HI_V8HI_UQI,
  V16SF_FTYPE_PCV16SF_V16SF_UHI,
  V8DF_FTYPE_PCV8DF_V8DF_UQI,
  V16SI_FTYPE_PCV16SI_V16SI_UHI,
  V8SF_FTYPE_PCV8SF_V8SF_UQI,
  V8DI_FTYPE_PCV8DI_V8DI_UQI,
  V8SI_FTYPE_PCV8SI_V8SI_UQI,
  V4DF_FTYPE_PCV4DF_V4DF_UQI,
  V4SF_FTYPE_PCV4SF_V4SF_UQI,
  V4DI_FTYPE_PCV4DI_V4DI_UQI,
  V4SI_FTYPE_PCV4SI_V4SI_UQI,
  V2DF_FTYPE_PCV2DF_V2DF_UQI,
  V2DI_FTYPE_PCV2DI_V2DI_UQI,
  V64QI_FTYPE_PCCHAR_V64QI_UDI,
  V32HI_FTYPE_PCSHORT_V32HI_USI,
  V32QI_FTYPE_PCCHAR_V32QI_USI,
  V16SF_FTYPE_PCFLOAT_V16SF_UHI,
  V8DF_FTYPE_PCDOUBLE_V8DF_UQI,
  V16SI_FTYPE_PCINT_V16SI_UHI,
  V16HI_FTYPE_PCSHORT_V16HI_UHI,
  V16QI_FTYPE_PCCHAR_V16QI_UHI,
  V8SF_FTYPE_PCFLOAT_V8SF_UQI,
  V8DI_FTYPE_PCINT64_V8DI_UQI,
  V8SI_FTYPE_PCINT_V8SI_UQI,
  V8HI_FTYPE_PCSHORT_V8HI_UQI,
  V4DF_FTYPE_PCDOUBLE_V4DF_UQI,
  V4SF_FTYPE_PCFLOAT_V4SF_UQI,
  V4DI_FTYPE_PCINT64_V4DI_UQI,
  V4SI_FTYPE_PCINT_V4SI_UQI,
  V2DF_FTYPE_PCDOUBLE_V2DF_UQI,
  V2DI_FTYPE_PCINT64_V2DI_UQI,
  V16HI_FTYPE_V16SI_V16HI_UHI,
  V8SI_FTYPE_V8DI_V8SI_UQI,
  V8HI_FTYPE_V8DI_V8HI_UQI,
  V16QI_FTYPE_V8HI_V16QI_UQI,
  V16QI_FTYPE_V16HI_V16QI_UHI,
  V16QI_FTYPE_V4SI_V16QI_UQI,
  V16QI_FTYPE_V8SI_V16QI_UQI,
  V8HI_FTYPE_V4SI_V8HI_UQI,
  V8HI_FTYPE_V8SI_V8HI_UQI,
  V16QI_FTYPE_V2DI_V16QI_UQI,
  V16QI_FTYPE_V4DI_V16QI_UQI,
  V8HI_FTYPE_V2DI_V8HI_UQI,
  V8HI_FTYPE_V4DI_V8HI_UQI,
  V4SI_FTYPE_V2DI_V4SI_UQI,
  V4SI_FTYPE_V4DI_V4SI_UQI,
  V32QI_FTYPE_V32HI_V32QI_USI,
  V2DF_FTYPE_V2DF_INT_V2DF_UQI,
  V4DF_FTYPE_V4DF_INT_V4DF_UQI,
  V4SF_FTYPE_V4SF_INT_V4SF_UQI,
  V8SF_FTYPE_V8SF_INT_V8SF_UQI,
  V4DF_FTYPE_V4DF_V4DF_INT_V4DF_UQI,
  V2DF_FTYPE_V2DF_V2DF_INT_V2DF_UQI,
  V8SF_FTYPE_V8SF_V8SF_INT_V8SF_UQI,
  V4SF_FTYPE_V4SF_V4SF_INT_V4SF_UQI,
  VOID_FTYPE_PV8DF_V8DF_UQI,
  VOID_FTYPE_PV8SI_V8DI_UQI,
  VOID_FTYPE_PV8HI_V8DI_UQI,
  VOID_FTYPE_PUDI_V4DI_UQI,
  VOID_FTYPE_PUSI_V2DI_UQI,
  VOID_FTYPE_PV4SI_V4DI_UQI,
  VOID_FTYPE_PUDI_V2DI_UQI,
  VOID_FTYPE_PV8HI_V8SI_UQI,
  VOID_FTYPE_PUDI_V4SI_UQI,
  VOID_FTYPE_PV4DF_V4DF_UQI,
  VOID_FTYPE_PV2DF_V2DF_UQI,
  VOID_FTYPE_PV16SF_V16SF_UHI,
  VOID_FTYPE_PV8SF_V8SF_UQI,
  VOID_FTYPE_PV4SF_V4SF_UQI,
  VOID_FTYPE_PV8DI_V8DI_UQI,
  VOID_FTYPE_PV4DI_V4DI_UQI,
  VOID_FTYPE_PV2DI_V2DI_UQI,
  VOID_FTYPE_PV16SI_V16SI_UHI,
  VOID_FTYPE_PV16HI_V16SI_UHI,
  VOID_FTYPE_PV16QI_V16SI_UHI,
  VOID_FTYPE_PUDI_V8SI_UQI,
  VOID_FTYPE_PUSI_V4SI_UQI,
  VOID_FTYPE_PUDI_V8DI_UQI,
  VOID_FTYPE_PUSI_V4DI_UQI,
  VOID_FTYPE_PUHI_V2DI_UQI,
  VOID_FTYPE_PV8SI_V8SI_UQI,
  VOID_FTYPE_PV4SI_V4SI_UQI,
  VOID_FTYPE_PDOUBLE_V8DF_UQI,
  VOID_FTYPE_PDOUBLE_V4DF_UQI,
  VOID_FTYPE_PDOUBLE_V2DF_UQI,
  VOID_FTYPE_PFLOAT_V16SF_UHI,
  VOID_FTYPE_PFLOAT_V8SF_UQI,
  VOID_FTYPE_PFLOAT_V4SF_UQI,
  VOID_FTYPE_PINT64_V8DI_UQI,
  VOID_FTYPE_PINT64_V4DI_UQI,
  VOID_FTYPE_PINT64_V2DI_UQI,
  VOID_FTYPE_PINT_V16SI_UHI,
  VOID_FTYPE_PINT_V8SI_UQI,
  VOID_FTYPE_PINT_V4SI_UQI,
  VOID_FTYPE_PSHORT_V32HI_USI,
  VOID_FTYPE_PSHORT_V16HI_UHI,
  VOID_FTYPE_PSHORT_V8HI_UQI,
  VOID_FTYPE_PCHAR_V64QI_UDI,
  VOID_FTYPE_PCHAR_V32QI_USI,
  VOID_FTYPE_PCHAR_V16QI_UHI,
  V8DI_FTYPE_V8DI_V8DI_V8DI_INT_UQI,
  V8SI_FTYPE_V8SF_V8SI_UQI,
  V4SI_FTYPE_V4SF_V4SI_UQI,
  V4DI_FTYPE_V4SF_V4DI_UQI,
  V2DI_FTYPE_V4SF_V2DI_UQI,
  V4SF_FTYPE_V4DI_V4SF_UQI,
  V4SF_FTYPE_V2DI_V4SF_UQI,
  V4DF_FTYPE_V4DI_V4DF_UQI,
  V2DF_FTYPE_V2DI_V2DF_UQI,
  V32HI_FTYPE_V32HI_INT_V32HI_USI,
  V32HI_FTYPE_V32HI_V8HI_V32HI_USI,
  V16HI_FTYPE_V16HI_INT_V16HI_UHI,
  V16HI_FTYPE_V16HI_V8HI_V16HI_UHI,
  V8HI_FTYPE_V8HI_INT_V8HI_UQI,
  V32HI_FTYPE_V64QI_V64QI_INT_V32HI_USI,
  V16HI_FTYPE_V32QI_V32QI_INT_V16HI_UHI,
  V8HI_FTYPE_V16QI_V16QI_INT_V8HI_UQI,
  V64QI_FTYPE_V32HI_V32HI_V64QI_UDI,
  V32QI_FTYPE_V16HI_V16HI_V32QI_USI,
  V16QI_FTYPE_V8HI_V8HI_V16QI_UHI,
  V32HI_FTYPE_V16SI_V16SI_V32HI_USI,
  V16HI_FTYPE_V8SI_V8SI_V16HI_UHI,
  V8HI_FTYPE_V4SI_V4SI_V8HI_UQI,
  V8DI_FTYPE_V16SI_V16SI_V8DI_UQI,
  V4DI_FTYPE_V8SI_V8SI_V4DI_UQI,
  V2DI_FTYPE_V4SI_V4SI_V2DI_UQI,
  V16SI_FTYPE_V16SI_V16SI_V16SI_INT_UHI,
  V8SI_FTYPE_V8SI_V8SI_V8SI_INT_UQI,
  V4DI_FTYPE_V4DI_V4DI_V4DI_INT_UQI,
  V4SI_FTYPE_V4SI_V4SI_V4SI_INT_UQI,
  V2DI_FTYPE_V2DI_V2DI_V2DI_INT_UQI,
  VOID_FTYPE_PCVOID_UNSIGNED_UNSIGNED,
  VOID_FTYPE_PV2DF_V2DI_V2DF,
  VOID_FTYPE_PV4DF_V4DI_V4DF,
  VOID_FTYPE_PV4SF_V4SI_V4SF,
  VOID_FTYPE_PV8SF_V8SI_V8SF,
  VOID_FTYPE_PV2DI_V2DI_V2DI,
  VOID_FTYPE_PV4DI_V4DI_V4DI,
  VOID_FTYPE_PV4SI_V4SI_V4SI,
  VOID_FTYPE_PV8SI_V8SI_V8SI,
  VOID_FTYPE_UINT_UINT_UINT,
  VOID_FTYPE_UINT64_UINT_UINT,
  VOID_FTYPE_V16QI_V16QI_PCHAR,
  VOID_FTYPE_V8QI_V8QI_PCHAR,
  V8SI_FTYPE_V8SI_V4SI_V8SI_UQI,
  V4DI_FTYPE_V4DI_V2DI_V4DI_UQI,
  QI_FTYPE_V8DF_INT,
  QI_FTYPE_V4DF_INT,
  QI_FTYPE_V4DF_V4DF_INT_UQI,
  HI_FTYPE_V16SF_INT,
  QI_FTYPE_V8SF_INT,
  QI_FTYPE_V8SF_V8SF_INT_UQI,
  QI_FTYPE_V8DF_INT_UQI,
  QI_FTYPE_V4DF_INT_UQI,
  QI_FTYPE_V2DF_INT_UQI,
  HI_FTYPE_V16SF_INT_UHI,
  QI_FTYPE_V8SF_INT_UQI,
  QI_FTYPE_V4SF_INT_UQI,
  VOID_FTYPE_PV32QI_V32HI_USI,
  VOID_FTYPE_PUHI_PUHI_V16SI_V16SI,
  VOID_FTYPE_PUQI_PUQI_V8SI_V8SI,
  VOID_FTYPE_PUQI_PUQI_V4SI_V4SI,
  VOID_FTYPE_PUQI_PUQI_V8DI_V8DI,
  VOID_FTYPE_PUQI_PUQI_V4DI_V4DI,
  VOID_FTYPE_PUQI_PUQI_V2DI_V2DI,
  V2DI_FTYPE_V2DI_V2DI_UINT_UINT,
  V4HI_FTYPE_HI_HI_HI_HI,
  INT_FTYPE_V16QI_INT_V16QI_INT_INT,
  V16QI_FTYPE_V16QI_INT_V16QI_INT_INT,
  V8QI_FTYPE_QI_QI_QI_QI_QI_QI_QI_QI,
  UCHAR_FTYPE_UCHAR_UINT_UINT_PUNSIGNED,
  UCHAR_FTYPE_UCHAR_ULONGLONG_ULONGLONG_PULONGLONG,
  UINT64_FTYPE_V2DF_INT,
  UINT64_FTYPE_V4SF_INT,
  UINT_FTYPE_V2DF_INT,
  UINT_FTYPE_V4SF_INT,
  INT64_FTYPE_V2DF_INT,
  INT64_FTYPE_V4SF_INT,
  INT_FTYPE_V2DF_INT,
  INT_FTYPE_V4SF_INT,
  V2DF_FTYPE_V2DF_UINT64_INT,
  V4SF_FTYPE_V4SF_UINT64_INT,
  V4SF_FTYPE_V4SF_UINT_INT,
  V2DF_FTYPE_V2DF_INT64_INT,
  V4SF_FTYPE_V4SF_INT64_INT,
  V4SF_FTYPE_V4SF_INT_INT,
  V16SI_FTYPE_V16SF_V16SI_HI_INT,
  V16SF_FTYPE_V16SI_V16SF_HI_INT,
  V16SF_FTYPE_V16SF_V16SF_HI_INT,
  V16SF_FTYPE_V16HI_V16SF_HI_INT,
  V8SI_FTYPE_V8DF_V8SI_QI_INT,
  V8SF_FTYPE_V8DF_V8SF_QI_INT,
  V8DF_FTYPE_V8DF_V8DF_QI_INT,
  V8DF_FTYPE_V8SF_V8DF_QI_INT,
  V8DI_FTYPE_V8DF_V8DI_QI_INT,
  V8DI_FTYPE_V8SF_V8DI_QI_INT,
  V8DF_FTYPE_V8DI_V8DF_QI_INT,
  V8SF_FTYPE_V8DI_V8SF_QI_INT,
  V16SF_FTYPE_V16SF_V16SF_V16SF_HI_INT,
  V8DF_FTYPE_V8DF_V8DF_V8DF_UQI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF_UQI_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF_UQI_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF_QI_INT,
  V4SF_FTYPE_V4SF_V2DF_V4SF_QI_INT,
  V4SF_FTYPE_V4SF_V2DF_V4SF_UQI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF_QI_INT,
  V2DF_FTYPE_V2DF_V4SF_V2DF_QI_INT,
  V2DF_FTYPE_V2DF_V4SF_V2DF_UQI_INT,
  V2DF_FTYPE_V2DF_V2DF_V2DF_INT,
  V4SF_FTYPE_V4SF_V4SF_V4SF_INT,
  V16SF_FTYPE_V16SF_INT_V16SF_HI_INT,
  V8DF_FTYPE_V8DF_INT_V8DF_QI_INT,
  V4SF_FTYPE_V4SF_V4SF_INT_V4SF_QI_INT,
  V2DF_FTYPE_V2DF_V2DF_INT_V2DF_QI_INT,
  V2DF_FTYPE_V2DF_PCDOUBLE_V4SI_V2DF_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V4SI_V4DF_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V8SI_V4DF_INT,
  V2DF_FTYPE_V2DF_PCDOUBLE_V2DI_V2DF_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V4DI_V4DF_INT,
  V4SF_FTYPE_V4SF_PCFLOAT_V4SI_V4SF_INT,
  V8SF_FTYPE_V8SF_PCFLOAT_V8SI_V8SF_INT,
  V4SF_FTYPE_V4SF_PCFLOAT_V2DI_V4SF_INT,
  V4SF_FTYPE_V4SF_PCFLOAT_V4DI_V4SF_INT,
  V8SF_FTYPE_V8SF_PCFLOAT_V4DI_V8SF_INT,
  V2DI_FTYPE_V2DI_PCINT64_V4SI_V2DI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V4SI_V4DI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V8SI_V4DI_INT,
  V2DI_FTYPE_V2DI_PCINT64_V2DI_V2DI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V4DI_V4DI_INT,
  V4SI_FTYPE_V4SI_PCINT_V4SI_V4SI_INT,
  V8SI_FTYPE_V8SI_PCINT_V8SI_V8SI_INT,
  V4SI_FTYPE_V4SI_PCINT_V2DI_V4SI_INT,
  V4SI_FTYPE_V4SI_PCINT_V4DI_V4SI_INT,
  V8SI_FTYPE_V8SI_PCINT_V4DI_V8SI_INT,
  V16SF_FTYPE_V16SF_PCFLOAT_V8DI_HI_INT,
  V8DF_FTYPE_V8DF_PCDOUBLE_V16SI_QI_INT,
  V16SI_FTYPE_V16SI_PCINT_V8DI_HI_INT,
  V8DI_FTYPE_V8DI_PCINT64_V16SI_QI_INT,
  V4DF_FTYPE_V4DF_PCDOUBLE_V8SI_QI_INT,
  V8SF_FTYPE_V8SF_PCFLOAT_V4DI_QI_INT,
  V4DI_FTYPE_V4DI_PCINT64_V8SI_QI_INT,
  V8SI_FTYPE_V8SI_PCINT_V4DI_QI_INT,
  VOID_FTYPE_PFLOAT_HI_V8DI_V16SF_INT,
  VOID_FTYPE_PDOUBLE_QI_V16SI_V8DF_INT,
  VOID_FTYPE_PINT_HI_V8DI_V16SI_INT,
  VOID_FTYPE_PLONGLONG_QI_V16SI_V8DI_INT,
  VOID_FTYPE_PFLOAT_QI_V4DI_V8SF_INT,
  VOID_FTYPE_PDOUBLE_QI_V8SI_V4DF_INT,
  VOID_FTYPE_PINT_QI_V4DI_V8SI_INT,
  VOID_FTYPE_PLONGLONG_QI_V8SI_V4DI_INT,
  VOID_FTYPE_PFLOAT_QI_V2DI_V4SF_INT,
  VOID_FTYPE_PDOUBLE_QI_V4SI_V2DF_INT,
  VOID_FTYPE_PINT_QI_V2DI_V4SI_INT,
  VOID_FTYPE_PLONGLONG_QI_V4SI_V2DI_INT,
  V16SF_FTYPE_V16SF_PCVOID_V16SI_HI_INT,
  V8DF_FTYPE_V8DF_PCVOID_V8SI_QI_INT,
  V8SF_FTYPE_V8SF_PCVOID_V8DI_QI_INT,
  V8DF_FTYPE_V8DF_PCVOID_V8DI_QI_INT,
  V16SI_FTYPE_V16SI_PCVOID_V16SI_HI_INT,
  V8DI_FTYPE_V8DI_PCVOID_V8SI_QI_INT,
  V8SI_FTYPE_V8SI_PCVOID_V8DI_QI_INT,
  V8DI_FTYPE_V8DI_PCVOID_V8DI_QI_INT,
  VOID_FTYPE_PVOID_HI_V16SI_V16SF_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8DF_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8SF_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8DF_INT,
  VOID_FTYPE_PVOID_HI_V16SI_V16SI_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8DI_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8SI_INT,
  VOID_FTYPE_PVOID_QI_V8DI_V8DI_INT,
  V2DF_FTYPE_V2DF_PCVOID_V4SI_QI_INT,
  V4DF_FTYPE_V4DF_PCVOID_V4SI_QI_INT,
  V2DF_FTYPE_V2DF_PCVOID_V2DI_QI_INT,
  V4DF_FTYPE_V4DF_PCVOID_V4DI_QI_INT,
  V4SF_FTYPE_V4SF_PCVOID_V4SI_QI_INT,
  V8SF_FTYPE_V8SF_PCVOID_V8SI_QI_INT,
  V4SF_FTYPE_V4SF_PCVOID_V2DI_QI_INT,
  V4SF_FTYPE_V4SF_PCVOID_V4DI_QI_INT,
  V2DI_FTYPE_V2DI_PCVOID_V4SI_QI_INT,
  V4DI_FTYPE_V4DI_PCVOID_V4SI_QI_INT,
  V2DI_FTYPE_V2DI_PCVOID_V2DI_QI_INT,
  V4DI_FTYPE_V4DI_PCVOID_V4DI_QI_INT,
  V4SI_FTYPE_V4SI_PCVOID_V4SI_QI_INT,
  V8SI_FTYPE_V8SI_PCVOID_V8SI_QI_INT,
  V4SI_FTYPE_V4SI_PCVOID_V2DI_QI_INT,
  V4SI_FTYPE_V4SI_PCVOID_V4DI_QI_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8SF_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4SF_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4DF_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V2DF_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4SF_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V4SF_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4DF_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V2DF_INT,
  VOID_FTYPE_PVOID_QI_V8SI_V8SI_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4SI_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V4DI_INT,
  VOID_FTYPE_PVOID_QI_V4SI_V2DI_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4SI_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V4SI_INT,
  VOID_FTYPE_PVOID_QI_V4DI_V4DI_INT,
  VOID_FTYPE_PVOID_QI_V2DI_V2DI_INT,
  VOID_FTYPE_QI_V8SI_PCVOID_INT_INT,
  VOID_FTYPE_HI_V16SI_PCVOID_INT_INT,
  VOID_FTYPE_QI_V8DI_PCVOID_INT_INT,
  VOID_FTYPE_PUDI_V8HI_UQI,
  VOID_FTYPE_PV16QI_V16HI_UHI,
  V64QI_FTYPE_V64QI_V64QI_INT,
  V64QI_FTYPE_V64QI_V64QI_INT_V64QI_UDI,
  V32QI_FTYPE_V32QI_V32QI_INT_V32QI_USI,
  V16QI_FTYPE_V16QI_V16QI_INT_V16QI_UHI,
  V64QI_FTYPE_V64QI_V64QI,
  VOID_FTYPE_PV64QI_V64QI_UDI,
  VOID_FTYPE_PV32HI_V32HI_USI,
  VOID_FTYPE_PV32QI_V32QI_USI,
  VOID_FTYPE_PV16QI_V16QI_UHI,
  VOID_FTYPE_PV16HI_V16HI_UHI,
  VOID_FTYPE_PV8HI_V8HI_UQI,
  V64QI_FTYPE_PCV64QI_V64QI_UDI,
  V32HI_FTYPE_PCV32HI_V32HI_USI,
  V32QI_FTYPE_PCV32QI_V32QI_USI,
  V16QI_FTYPE_PCV16QI_V16QI_UHI,
  V16HI_FTYPE_PCV16HI_V16HI_UHI,
  V8HI_FTYPE_PCV8HI_V8HI_UQI,
  V32HI_FTYPE_V32HI_V32HI_INT,
  V32HI_FTYPE_V32HI_V32HI_INT_V32HI_INT,
  V16SI_FTYPE_V16SI_V16SI_INT,
  V16SI_FTYPE_V16SI_V16SI_INT_V16SI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_INT,
  V16HI_FTYPE_V16HI_V16HI_INT_V16HI_INT,
  V8SI_FTYPE_V8SI_V8SI_INT_V8SI_INT,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_INT,
  V8HI_FTYPE_V8HI_V8HI_INT_V8HI_INT,
  V4SI_FTYPE_V4SI_V4SI_INT_V4SI_INT,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_INT,
  V32HI_FTYPE_V32HI_V32HI_V32HI,
  V8DI_FTYPE_V8DI_V8DI_V8DI,
  V16SI_FTYPE_V16SI_V16SI_V16SI,
  V4DI_FTYPE_V4DI,
  V4SI_FTYPE_V4SI_V4SI_UHI,
  V8SI_FTYPE_V8SI_V8SI_UHI,
  FLOAT_FTYPE_BFLOAT16,
  V32BF_FTYPE_V16SF_V16SF,
  V32BF_FTYPE_V16SF_V16SF_V32BF_USI,
  V32BF_FTYPE_V16SF_V16SF_USI,
  V16BF_FTYPE_V8SF_V8SF,
  V16BF_FTYPE_V8SF_V8SF_V16BF_UHI,
  V16BF_FTYPE_V8SF_V8SF_UHI,
  V8BF_FTYPE_V4SF_V4SF,
  V8BF_FTYPE_V4SF_V4SF_V8BF_UQI,
  V8BF_FTYPE_V4SF_V4SF_UQI,
  V16BF_FTYPE_V16SF,
  V16BF_FTYPE_V16SF_V16BF_UHI,
  V16BF_FTYPE_V16SF_UHI,
  V8BF_FTYPE_V8SF,
  V8BF_FTYPE_V8SF_V8BF_UQI,
  V8BF_FTYPE_V8SF_UQI,
  V8BF_FTYPE_V4SF,
  V8BF_FTYPE_V4SF_V8BF_UQI,
  V8BF_FTYPE_V4SF_UQI,
  V16SF_FTYPE_V16SF_V32BF_V32BF,
  V16SF_FTYPE_V16SF_V32BF_V32BF_UHI,
  V8SF_FTYPE_V8SF_V16BF_V16BF,
  V8SF_FTYPE_V8SF_V16BF_V16BF_UQI,
  V4SF_FTYPE_V4SF_V8BF_V8BF,
  V4SF_FTYPE_V4SF_V8BF_V8BF_UQI,
  UINT_FTYPE_UINT_V2DI_V2DI_PVOID,
  UINT_FTYPE_UINT_V2DI_PVOID,
  VOID_FTYPE_V2DI_V2DI_V2DI_UINT,
  UINT8_FTYPE_PV2DI_V2DI_PCVOID,
  UINT8_FTYPE_PV2DI_PCV2DI_PCVOID,
  V8HF_FTYPE_V8HI,
  QI_FTYPE_V8HF_INT_UQI,
  HI_FTYPE_V16HF_INT_UHI,
  SI_FTYPE_V32HF_INT_USI,
  INT_FTYPE_V8HF_INT,
  INT64_FTYPE_V8HF_INT,
  UINT_FTYPE_V8HF_INT,
  UINT64_FTYPE_V8HF_INT,
  V8HF_FTYPE_V8HF_V8HF,
  VOID_FTYPE_PCFLOAT16_V8HF_UQI,
  V8HF_FTYPE_PCFLOAT16_V8HF_UQI,
  V8HF_FTYPE_V8HF_INT_INT,
  V8HF_FTYPE_V8HF_INT64_INT,
  V8HF_FTYPE_V8HF_UINT_INT,
  V8HF_FTYPE_V8HF_UINT64_INT,
  V2DI_FTYPE_V8HF_V2DI_UQI,
  V4DI_FTYPE_V8HF_V4DI_UQI,
  V2DF_FTYPE_V8HF_V2DF_UQI,
  V4DF_FTYPE_V8HF_V4DF_UQI,
  V4SI_FTYPE_V8HF_V4SI_UQI,
  V4SF_FTYPE_V8HF_V4SF_UQI,
  V8SI_FTYPE_V8HF_V8SI_UQI,
  V8SF_FTYPE_V8HF_V8SF_UQI,
  V8HI_FTYPE_V8HF_V8HI_UQI,
  V8HF_FTYPE_V4SI_V8HF_UQI,
  V8HF_FTYPE_V4SF_V8HF_UQI,
  V8HF_FTYPE_V8SI_V8HF_UQI,
  V8HF_FTYPE_V8SF_V8HF_UQI,
  V8HF_FTYPE_V2DI_V8HF_UQI,
  V8HF_FTYPE_V4DI_V8HF_UQI,
  V8HF_FTYPE_V2DF_V8HF_UQI,
  V8HF_FTYPE_V4DF_V8HF_UQI,
  V8HF_FTYPE_V8HI_V8HF_UQI,
  V8HF_FTYPE_V8HF_V8HF_UQI,
  V8HF_FTYPE_V8HF_V8HF_INT,
  V8HF_FTYPE_V8HF_INT_V8HF_UQI,
  UQI_FTYPE_V8HF_V8HF_INT_UQI,
  V8HF_FTYPE_V8HF_V8HF_V8HF_UQI,
  V8HF_FTYPE_V8HF_V8HF_V8HF_INT,
  UQI_FTYPE_V8HF_V8HF_INT_UQI_INT,
  V8DI_FTYPE_V8HF_V8DI_UQI_INT,
  V8DF_FTYPE_V8HF_V8DF_UQI_INT,
  V8HF_FTYPE_V8DI_V8HF_UQI_INT,
  V8HF_FTYPE_V8DF_V8HF_UQI_INT,
  V8HF_FTYPE_V8HF_V8HF_V8HF,
  V8HF_FTYPE_V8HF_V8HF_V8HF_UQI_INT,
  V8HF_FTYPE_V2DF_V8HF_V8HF_UQI_INT,
  V8HF_FTYPE_V4SF_V8HF_V8HF_UQI_INT,
  V2DF_FTYPE_V8HF_V2DF_V2DF_UQI_INT,
  V4SF_FTYPE_V8HF_V4SF_V4SF_UQI_INT,
  V8HF_FTYPE_V8HF_V8HF_INT_V8HF_UQI_INT,
  V16HF_FTYPE_V16HF_V16HF,
  V16HI_FTYPE_V16HF_V16HI_UHI,
  V16HF_FTYPE_V16HI_V16HF_UHI,
  V16HF_FTYPE_V16HF_V16HF_UHI,
  V16HF_FTYPE_V16HF_V16HF_V16HF,
  V16SI_FTYPE_V16HF_V16SI_UHI_INT,
  V16SF_FTYPE_V16HF_V16SF_UHI_INT,
  V16HF_FTYPE_V16HF_INT_V16HF_UHI,
  UHI_FTYPE_V16HF_V16HF_INT_UHI,
  V16HF_FTYPE_V16SI_V16HF_UHI_INT,
  V16HF_FTYPE_V16SF_V16HF_UHI_INT,
  V16HF_FTYPE_V16HF_V16HF_V16HF_UQI,
  V16HF_FTYPE_V16HF_V16HF_V16HF_UHI,
  V32HF_FTYPE_V32HF_V32HF_USI,
  V32HF_FTYPE_V32HF_V32HF_INT,
  V32HI_FTYPE_V32HF_V32HI_USI_INT,
  V32HF_FTYPE_V32HI_V32HF_USI_INT,
  USI_FTYPE_V32HF_V32HF_INT_USI,
  V32HF_FTYPE_V32HF_V32HF_USI_INT,
  V32HF_FTYPE_V32HF_V32HF_V32HF_INT,
  V32HF_FTYPE_V32HF_V32HF_V32HF_USI,
  USI_FTYPE_V32HF_V32HF_INT_USI_INT,
  V32HF_FTYPE_V32HF_V32HF_V32HF_UHI_INT,
  V32HF_FTYPE_V32HF_V32HF_V32HF_USI_INT,
  V32HF_FTYPE_V32HF_INT_V32HF_USI_INT,
  V8HF_FTYPE_V8HF,
  V16HF_FTYPE_V16HF,
  V32HF_FTYPE_V32HF,
  V4SF_FTYPE_PCBFLOAT16,
  V8SF_FTYPE_PCBFLOAT16,
  V4SF_FTYPE_PCFLOAT16,
  V8SF_FTYPE_PCFLOAT16,
  V4SF_FTYPE_PCV8HF,
  V8SF_FTYPE_PCV16HF,
  V4SF_FTYPE_PCV8BF,
  V8SF_FTYPE_PCV16BF,
  INT_FTYPE_PINT_INT_INT_INT,
  LONGLONG_FTYPE_PLONGLONG_LONGLONG_LONGLONG_INT,
  VOID_FTYPE_PCVOID_INT,
  VOID_FTYPE_PCVOID_INT_INT_INT,
  V4SI_FTYPE_V4SI_V4SI_V4SI_INT,
  V4DI_FTYPE_V4DI_V4DI_V2DI,
  VOID_FTYPE_UINT64_UINT64,
  IX86_BT_LAST_FUNC = VOID_FTYPE_UINT64_UINT64,
  UQI_FTYPE_UQI_UQI_CONST,
  V2DF_FTYPE_V2DF_ROUND,
  V4DF_FTYPE_V4DF_ROUND,
  V8DF_FTYPE_V8DF_ROUND,
  V4SF_FTYPE_V4SF_ROUND,
  V8SF_FTYPE_V8SF_ROUND,
  V16SF_FTYPE_V16SF_ROUND,
  V4SI_FTYPE_V2DF_V2DF_ROUND,
  V8SI_FTYPE_V4DF_V4DF_ROUND,
  V16SI_FTYPE_V8DF_V8DF_ROUND,
  V4SI_FTYPE_V4SF_ROUND,
  V8SI_FTYPE_V8SF_ROUND,
  V16SI_FTYPE_V16SF_ROUND,
  INT_FTYPE_V2DF_V2DF_PTEST,
  INT_FTYPE_V2DI_V2DI_PTEST,
  INT_FTYPE_V4DF_V4DF_PTEST,
  INT_FTYPE_V4DI_V4DI_PTEST,
  INT_FTYPE_V4SF_V4SF_PTEST,
  INT_FTYPE_V8SF_V8SF_PTEST,
  V2DF_FTYPE_V2DF_VEC_MERGE,
  V4SF_FTYPE_V4SF_VEC_MERGE,
  V1DI_FTYPE_V1DI_SI_COUNT,
  V2DI_FTYPE_V2DI_SI_COUNT,
  V2SI_FTYPE_V2SI_SI_COUNT,
  V4HI_FTYPE_V4HI_SI_COUNT,
  V4SI_FTYPE_V4SI_SI_COUNT,
  V8HI_FTYPE_V8HI_SI_COUNT,
  V1DI_FTYPE_V1DI_V1DI_COUNT,
  V2DI_FTYPE_V2DI_V2DI_COUNT,
  V2SI_FTYPE_V2SI_V2SI_COUNT,
  V4HI_FTYPE_V4HI_V4HI_COUNT,
  V4SI_FTYPE_V4SI_V4SI_COUNT,
  V8HI_FTYPE_V8HI_V8HI_COUNT,
  V16HI_FTYPE_V16HI_SI_COUNT,
  V16HI_FTYPE_V16HI_V8HI_COUNT,
  V8SI_FTYPE_V8SI_SI_COUNT,
  V8SI_FTYPE_V8SI_V4SI_COUNT,
  V4DI_FTYPE_V4DI_INT_COUNT,
  V4DI_FTYPE_V4DI_V2DI_COUNT,
  V16HI_FTYPE_V16HI_INT_V16HI_UHI_COUNT,
  V16HI_FTYPE_V16HI_V8HI_V16HI_UHI_COUNT,
  V16SI_FTYPE_V16SI_INT_V16SI_UHI_COUNT,
  V16SI_FTYPE_V16SI_V4SI_V16SI_UHI_COUNT,
  V2DI_FTYPE_V2DI_INT_V2DI_UQI_COUNT,
  V2DI_FTYPE_V2DI_V2DI_V2DI_UQI_COUNT,
  V32HI_FTYPE_V32HI_INT_V32HI_USI_COUNT,
  V32HI_FTYPE_V32HI_V8HI_V32HI_USI_COUNT,
  V4DI_FTYPE_V4DI_INT_V4DI_UQI_COUNT,
  V4DI_FTYPE_V4DI_V2DI_V4DI_UQI_COUNT,
  V4SI_FTYPE_V4SI_INT_V4SI_UQI_COUNT,
  V4SI_FTYPE_V4SI_V4SI_V4SI_UQI_COUNT,
  V8DI_FTYPE_V8DI_INT_V8DI_UQI_COUNT,
  V8DI_FTYPE_V8DI_V2DI_V8DI_UQI_COUNT,
  V8HI_FTYPE_V8HI_INT_V8HI_UQI_COUNT,
  V8HI_FTYPE_V8HI_V8HI_V8HI_UQI_COUNT,
  V8SI_FTYPE_V8SI_INT_V8SI_UQI_COUNT,
  V8SI_FTYPE_V8SI_V4SI_V8SI_UQI_COUNT,
  V2DF_FTYPE_V2DF_V2DF_SWAP,
  V4SF_FTYPE_V4SF_V4SF_SWAP,
  V8DI_FTYPE_V8DI_INT_CONVERT,
  V4DI_FTYPE_V4DI_INT_CONVERT,
  V2DI_FTYPE_V2DI_INT_CONVERT,
  V8DI_FTYPE_V8DI_V8DI_INT_CONVERT,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UDI_CONVERT,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_USI_CONVERT,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UHI_CONVERT,
  V4DI_FTYPE_V4DI_V4DI_INT_CONVERT,
  V2DI_FTYPE_V2DI_V2DI_INT_CONVERT,
  V1DI_FTYPE_V1DI_V1DI_INT_CONVERT,
  V16QI_FTYPE_V16QI_V16QI_CMP,
  V2DI_FTYPE_V2DI_V2DI_CMP,
  V4SI_FTYPE_V4SI_V4SI_CMP,
  V8HI_FTYPE_V8HI_V8HI_CMP,
  V16QI_FTYPE_V16QI_V16QI_TF,
  V2DF_FTYPE_V2DF_V2DF_TF,
  V2DI_FTYPE_V2DI_V2DI_TF,
  V4SF_FTYPE_V4SF_V4SF_TF,
  V4SI_FTYPE_V4SI_V4SI_TF,
  V8HI_FTYPE_V8HI_V8HI_TF,
  V8HF_FTYPE_V8HF_ROUND,
  V16HF_FTYPE_V16HF_ROUND,
  V32HF_FTYPE_V32HF_ROUND,
  IX86_BT_LAST_ALIAS = V32HF_FTYPE_V32HF_ROUND
}
;


static const enum ix86_builtin_type ix86_builtin_func_args[] = {
  IX86_BT_FLOAT128, IX86_BT_UINT64, IX86_BT_UNSIGNED, IX86_BT_UINT,
  IX86_BT_USHORT, IX86_BT_INT, IX86_BT_UINT8, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_FLOAT, IX86_BT_FLOAT, IX86_BT_FLOAT128,
  IX86_BT_FLOAT128, IX86_BT_FLOAT128, IX86_BT_CONST_STRING, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8QI, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V32QI, IX86_BT_INT,
  IX86_BT_PCCHAR, IX86_BT_INT64, IX86_BT_INT64, IX86_BT_INT64,
  IX86_BT_V2DF, IX86_BT_INT64, IX86_BT_V4SF, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_UINT16, IX86_BT_UINT16, IX86_BT_UINT64,
  IX86_BT_INT, IX86_BT_UINT64, IX86_BT_PUNSIGNED, IX86_BT_UINT64,
  IX86_BT_UINT64, IX86_BT_V16QI, IX86_BT_PCCHAR, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2SI, IX86_BT_V2DF,
  IX86_BT_V4DF, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_PV2DI, IX86_BT_V2DI,
  IX86_BT_V16QI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_V8HI, IX86_BT_V2SF,
  IX86_BT_V2SF, IX86_BT_V2SF, IX86_BT_V2SI, IX86_BT_V2SI,
  IX86_BT_V2DF, IX86_BT_V2SI, IX86_BT_V2SF, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V2SI, IX86_BT_PCV2SI, IX86_BT_V2SI,
  IX86_BT_V4SF, IX86_BT_V32QI, IX86_BT_PCCHAR, IX86_BT_V4DF,
  IX86_BT_PCDOUBLE, IX86_BT_V4DF, IX86_BT_PCV2DF, IX86_BT_V4DF,
  IX86_BT_V2DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4SF, IX86_BT_V4DF, IX86_BT_V4SI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V4SF,
  IX86_BT_PCFLOAT, IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_V4SF,
  IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4DF, IX86_BT_V4SF, IX86_BT_V4DF, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_PCV4SF, IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_V4SF,
  IX86_BT_V8SF, IX86_BT_V4SF, IX86_BT_V8HI, IX86_BT_V4SF,
  IX86_BT_V8HI, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SI,
  IX86_BT_V16QI, IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_V4SI,
  IX86_BT_V4DF, IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V4SI,
  IX86_BT_V8SI, IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V8QI, IX86_BT_V8QI, IX86_BT_V8SF,
  IX86_BT_PCFLOAT, IX86_BT_V8SF, IX86_BT_PCV4SF, IX86_BT_V8SF,
  IX86_BT_PCV8SF, IX86_BT_V8SF, IX86_BT_V4SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_V8SF,
  IX86_BT_V8HI, IX86_BT_V8SF, IX86_BT_V8HI, IX86_BT_V8SF,
  IX86_BT_UQI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V8SI,
  IX86_BT_V4SI, IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V16QI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V8HI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_VOID, IX86_BT_PCVOID, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_VOID, IX86_BT_UINT64, IX86_BT_VOID,
  IX86_BT_UINT64, IX86_BT_PVOID, IX86_BT_VOID, IX86_BT_UNSIGNED,
  IX86_BT_VOID, IX86_BT_UNSIGNED, IX86_BT_PVOID, IX86_BT_UINT8,
  IX86_BT_UNSIGNED, IX86_BT_UINT64, IX86_BT_INT, IX86_BT_PUSHORT,
  IX86_BT_INT, IX86_BT_PUNSIGNED, IX86_BT_INT, IX86_BT_PULONGLONG,
  IX86_BT_V16HI, IX86_BT_V16QI, IX86_BT_V8SI, IX86_BT_V16QI,
  IX86_BT_V4DI, IX86_BT_V16QI, IX86_BT_V8SI, IX86_BT_V8HI,
  IX86_BT_V4DI, IX86_BT_V8HI, IX86_BT_V4DI, IX86_BT_V4SI,
  IX86_BT_V4DI, IX86_BT_PV4DI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V4SF,
  IX86_BT_V16SF, IX86_BT_V8SF, IX86_BT_V8DF, IX86_BT_V4DF,
  IX86_BT_V8DF, IX86_BT_V2DF, IX86_BT_V16SI, IX86_BT_V4SI,
  IX86_BT_V16SI, IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_V16SF,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_PV8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_VOID, IX86_BT_INT,
  IX86_BT_INT64, IX86_BT_DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_DOUBLE, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_FLOAT,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_FLOAT128, IX86_BT_FLOAT128,
  IX86_BT_FLOAT128, IX86_BT_HI, IX86_BT_V4HI, IX86_BT_INT,
  IX86_BT_HI, IX86_BT_V8HI, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_QI, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_QI, IX86_BT_V8QI, IX86_BT_INT, IX86_BT_SI,
  IX86_BT_V2SI, IX86_BT_INT, IX86_BT_SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UCHAR,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_USHORT, IX86_BT_UINT16, IX86_BT_UINT16,
  IX86_BT_INT, IX86_BT_UINT64, IX86_BT_UINT64, IX86_BT_UINT64,
  IX86_BT_UINT8, IX86_BT_UINT8, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_SI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_SI, IX86_BT_V1DI,
  IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_V1DI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V1DI, IX86_BT_V8QI, IX86_BT_V8QI,
  IX86_BT_V2DF, IX86_BT_PCV2DF, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_UINT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_DI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_SI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DI,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_SI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V16QI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_PCV2DI,
  IX86_BT_V2DI, IX86_BT_V2SF, IX86_BT_V2SF, IX86_BT_V2SF,
  IX86_BT_V2SI, IX86_BT_INT, IX86_BT_INT, IX86_BT_V2SI,
  IX86_BT_V2SF, IX86_BT_V2SF, IX86_BT_V2SI, IX86_BT_V2SI,
  IX86_BT_SI, IX86_BT_V2SI, IX86_BT_V2SI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V4DF,
  IX86_BT_PCV4DF, IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4HI, IX86_BT_V2SI,
  IX86_BT_V2SI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_INT,
  IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_SI, IX86_BT_V4HI,
  IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V8QI,
  IX86_BT_V8QI, IX86_BT_V4SF, IX86_BT_PCV4SF, IX86_BT_V4SI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UINT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_DI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCV2SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_SI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2SI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_PCV4SI,
  IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_SI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8HI,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8HI,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V8QI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_V8QI,
  IX86_BT_V8QI, IX86_BT_V8QI, IX86_BT_V8SF, IX86_BT_PCV8SF,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI,
  IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_UQI, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_HI, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SI, IX86_BT_INT,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V32HI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V8HI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V16HI,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_SI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V4SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V16SI, IX86_BT_INT,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8SI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V8SI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V16SI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V4SI, IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_PCV8SI, IX86_BT_V8SI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V16SI, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_UDI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_USI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V4DI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V8DI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V2DI, IX86_BT_V4DI, IX86_BT_PCV4DI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V2DI, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_INT64,
  IX86_BT_V2DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PCHAR, IX86_BT_V16QI,
  IX86_BT_VOID, IX86_BT_PCHAR, IX86_BT_V32QI, IX86_BT_VOID,
  IX86_BT_PDOUBLE, IX86_BT_V2DF, IX86_BT_VOID, IX86_BT_PDOUBLE,
  IX86_BT_V4DF, IX86_BT_VOID, IX86_BT_PDOUBLE, IX86_BT_V8DF,
  IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_V4SF, IX86_BT_VOID,
  IX86_BT_PFLOAT, IX86_BT_V8SF, IX86_BT_VOID, IX86_BT_PFLOAT,
  IX86_BT_V16SF, IX86_BT_VOID, IX86_BT_PINT, IX86_BT_INT,
  IX86_BT_VOID, IX86_BT_PUNSIGNED, IX86_BT_UNSIGNED, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_PCVOID, IX86_BT_INT, IX86_BT_PVOID,
  IX86_BT_PCVOID, IX86_BT_VOID, IX86_BT_PLONGLONG, IX86_BT_LONGLONG,
  IX86_BT_VOID, IX86_BT_PULONGLONG, IX86_BT_ULONGLONG, IX86_BT_VOID,
  IX86_BT_PV2SI, IX86_BT_V2SI, IX86_BT_VOID, IX86_BT_PV2DI,
  IX86_BT_V2DI, IX86_BT_VOID, IX86_BT_PV2SF, IX86_BT_V4SF,
  IX86_BT_VOID, IX86_BT_PV4DI, IX86_BT_V4DI, IX86_BT_VOID,
  IX86_BT_PV4SF, IX86_BT_V4SF, IX86_BT_VOID, IX86_BT_PV8SF,
  IX86_BT_V8SF, IX86_BT_VOID, IX86_BT_UNSIGNED, IX86_BT_UNSIGNED,
  IX86_BT_VOID, IX86_BT_UNSIGNED, IX86_BT_UNSIGNED, IX86_BT_UNSIGNED,
  IX86_BT_VOID, IX86_BT_PV8DI, IX86_BT_V8DI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_PCV4SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_PCV4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCV4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_PCV4SF, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_PCV4SI, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_PCV4SI, IX86_BT_UCHAR,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_PUCHAR, IX86_BT_UCHAR,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_UCHAR, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_PUCHAR, IX86_BT_UCHAR, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_UCHAR, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_PUCHAR, IX86_BT_UCHAR, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_UCHAR, IX86_BT_UDI, IX86_BT_UDI, IX86_BT_PUCHAR,
  IX86_BT_UCHAR, IX86_BT_UDI, IX86_BT_UDI, IX86_BT_USI,
  IX86_BT_UQI, IX86_BT_USI, IX86_BT_UHI, IX86_BT_UQI,
  IX86_BT_USI, IX86_BT_UHI, IX86_BT_USI, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_UQI, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_UQI, IX86_BT_UDI, IX86_BT_UDI, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_UHI, IX86_BT_UHI,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_UDI, IX86_BT_UDI,
  IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_USI, IX86_BT_V32QI,
  IX86_BT_UDI, IX86_BT_V64QI, IX86_BT_UQI, IX86_BT_V8HI,
  IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_USI, IX86_BT_V32HI,
  IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V8SI,
  IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_UHI, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_USI, IX86_BT_UDI, IX86_BT_UDI, IX86_BT_UDI,
  IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT,
  IX86_BT_UHI, IX86_BT_USI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_INT, IX86_BT_USI, IX86_BT_UDI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_UDI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_INT, IX86_BT_UDI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_INT,
  IX86_BT_UHI, IX86_BT_USI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_USI, IX86_BT_USI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_INT, IX86_BT_USI, IX86_BT_UQI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_UHI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8UDI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_UQI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_UHI,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_INT, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_UHI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_UHI, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_UHI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_UHI, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_UHI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_INT, IX86_BT_UCHAR, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_UCHAR, IX86_BT_UINT64,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_V1DI, IX86_BT_V1DI,
  IX86_BT_V1DI, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_DI, IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_INT,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4HI, IX86_BT_V4HI, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_FLOAT,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_HI, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_INT, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_V4SI, IX86_BT_V2DF,
  IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4SF, IX86_BT_V4DF,
  IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4SI, IX86_BT_V4DF,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8SI, IX86_BT_V8DF,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V8HI, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_V2DI,
  IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8SI, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8HI, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V16QI, IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V16QI, IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V16QI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V4SI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V8HI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_UQI,
  IX86_BT_V8DF, IX86_BT_V8DI, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DI,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_UHI, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_USI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_V4SI,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SI,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V4SI, IX86_BT_V16QI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V8HI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8HI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V16QI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SI,
  IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_UHI,
  IX86_BT_V16SF, IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SI,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V8SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V16SF, IX86_BT_V4SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V8DF, IX86_BT_V4DF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V8DF, IX86_BT_V2DF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V16SI, IX86_BT_V8SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V4SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16HI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16SI, IX86_BT_V16QI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_V4DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4DF,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V2DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V16SI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_V8DI,
  IX86_BT_V16QI, IX86_BT_UQI, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V32HI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_INT, IX86_BT_V32HI, IX86_BT_V32QI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_V16QI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V8HI, IX86_BT_V16QI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V4SF,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V2DF,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_V4SI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_SI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_SI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_DI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_DI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V64QI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V64QI, IX86_BT_V16QI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V64QI, IX86_BT_QI,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V32QI, IX86_BT_V16QI,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V32QI, IX86_BT_QI,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_QI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V32HI, IX86_BT_V8HI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V32HI, IX86_BT_HI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI, IX86_BT_V8HI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_HI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_HI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V16SF, IX86_BT_PCV16SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V8DF, IX86_BT_PCV8DF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V16SI, IX86_BT_PCV16SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V8SF, IX86_BT_PCV8SF,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_PCV8DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_PCV8SI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_PCV4DF,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_PCV4SF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_PCV4DI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_PCV4SI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_PCV2DF,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_PCV2DI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V64QI, IX86_BT_PCCHAR,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_V32HI, IX86_BT_PCSHORT,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V32QI, IX86_BT_PCCHAR,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V16SF, IX86_BT_PCFLOAT,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V8DF, IX86_BT_PCDOUBLE,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_V16SI, IX86_BT_PCINT,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_V16HI, IX86_BT_PCSHORT,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_PCCHAR,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V8SF, IX86_BT_PCFLOAT,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_PCINT64,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V8SI, IX86_BT_PCINT,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_PCSHORT,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_PCDOUBLE,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4SF, IX86_BT_PCFLOAT,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_PCINT64,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_PCINT,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V2DF, IX86_BT_PCDOUBLE,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V2DI, IX86_BT_PCINT64,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V16HI, IX86_BT_V16SI,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V8SI, IX86_BT_V8DI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V8DI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V8HI,
  IX86_BT_V16QI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V16HI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V16QI, IX86_BT_V4SI,
  IX86_BT_V16QI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V8SI,
  IX86_BT_V16QI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V4SI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V8SI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V2DI,
  IX86_BT_V16QI, IX86_BT_UQI, IX86_BT_V16QI, IX86_BT_V4DI,
  IX86_BT_V16QI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V2DI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V8HI, IX86_BT_V4DI,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4DI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V32QI, IX86_BT_V32HI,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V4DF, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV8DF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV8SI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV8HI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUDI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUSI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV4SI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUDI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV8HI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUDI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV4DF,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV2DF,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV16SF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PV8SF,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV4SF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV8DI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV4DI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV2DI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV16SI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PV16HI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PV16QI,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PUDI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUSI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUDI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUSI,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PUHI,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV8SI,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV4SI,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PDOUBLE,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PDOUBLE,
  IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PDOUBLE,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PFLOAT,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PFLOAT,
  IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PFLOAT,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PINT64,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PINT64,
  IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PINT64,
  IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PINT,
  IX86_BT_V16SI, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PINT,
  IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PINT,
  IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PSHORT,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_VOID, IX86_BT_PSHORT,
  IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_VOID, IX86_BT_PSHORT,
  IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PCHAR,
  IX86_BT_V64QI, IX86_BT_UDI, IX86_BT_VOID, IX86_BT_PCHAR,
  IX86_BT_V32QI, IX86_BT_USI, IX86_BT_VOID, IX86_BT_PCHAR,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_V8SI, IX86_BT_UQI,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_V4SI, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V4SF, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_V4SF, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V4DI, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4SF, IX86_BT_V2DI, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_V4DF, IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_UQI,
  IX86_BT_V2DF, IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT, IX86_BT_V32HI,
  IX86_BT_USI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V8HI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_INT, IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_V8HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_V32HI, IX86_BT_V64QI, IX86_BT_V64QI,
  IX86_BT_INT, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI,
  IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_INT, IX86_BT_V16HI,
  IX86_BT_UHI, IX86_BT_V8HI, IX86_BT_V16QI, IX86_BT_V16QI,
  IX86_BT_INT, IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V64QI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V32QI, IX86_BT_V16HI, IX86_BT_V16HI, IX86_BT_V32QI,
  IX86_BT_USI, IX86_BT_V16QI, IX86_BT_V8HI, IX86_BT_V8HI,
  IX86_BT_V16QI, IX86_BT_UHI, IX86_BT_V32HI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V32HI, IX86_BT_USI, IX86_BT_V16HI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8HI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V8HI,
  IX86_BT_UQI, IX86_BT_V8DI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V8DI, IX86_BT_UQI, IX86_BT_V4DI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_UQI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_INT, IX86_BT_UHI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PCVOID,
  IX86_BT_UNSIGNED, IX86_BT_UNSIGNED, IX86_BT_VOID, IX86_BT_PV2DF,
  IX86_BT_V2DI, IX86_BT_V2DF, IX86_BT_VOID, IX86_BT_PV4DF,
  IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_VOID, IX86_BT_PV4SF,
  IX86_BT_V4SI, IX86_BT_V4SF, IX86_BT_VOID, IX86_BT_PV8SF,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_VOID, IX86_BT_PV2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_VOID, IX86_BT_PV4DI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_VOID, IX86_BT_PV4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_VOID, IX86_BT_PV8SI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_VOID, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_VOID, IX86_BT_UINT64,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_VOID, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_PCHAR, IX86_BT_VOID, IX86_BT_V8QI,
  IX86_BT_V8QI, IX86_BT_PCHAR, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_V4SI, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_V2DI, IX86_BT_V4DI, IX86_BT_UQI,
  IX86_BT_QI, IX86_BT_V8DF, IX86_BT_INT, IX86_BT_QI,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_QI, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_INT, IX86_BT_UQI, IX86_BT_HI,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_QI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_QI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_HI, IX86_BT_V16SF,
  IX86_BT_INT, IX86_BT_UHI, IX86_BT_QI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_QI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_UQI, IX86_BT_VOID, IX86_BT_PV32QI,
  IX86_BT_V32HI, IX86_BT_USI, IX86_BT_VOID, IX86_BT_PUHI,
  IX86_BT_PUHI, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_VOID,
  IX86_BT_PUQI, IX86_BT_PUQI, IX86_BT_V8SI, IX86_BT_V8SI,
  IX86_BT_VOID, IX86_BT_PUQI, IX86_BT_PUQI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_VOID, IX86_BT_PUQI, IX86_BT_PUQI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_VOID, IX86_BT_PUQI,
  IX86_BT_PUQI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_VOID,
  IX86_BT_PUQI, IX86_BT_PUQI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_UINT,
  IX86_BT_UINT, IX86_BT_V4HI, IX86_BT_HI, IX86_BT_HI,
  IX86_BT_HI, IX86_BT_HI, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_INT, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_V8QI, IX86_BT_QI,
  IX86_BT_QI, IX86_BT_QI, IX86_BT_QI, IX86_BT_QI,
  IX86_BT_QI, IX86_BT_QI, IX86_BT_QI, IX86_BT_UCHAR,
  IX86_BT_UCHAR, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_PUNSIGNED,
  IX86_BT_UCHAR, IX86_BT_UCHAR, IX86_BT_ULONGLONG, IX86_BT_ULONGLONG,
  IX86_BT_PULONGLONG, IX86_BT_UINT64, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_UINT64, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_UINT,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_UINT, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_INT64, IX86_BT_V2DF, IX86_BT_INT,
  IX86_BT_INT64, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_INT,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_UINT64,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UINT64,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UINT,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_INT64,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT64,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_V16SI,
  IX86_BT_HI, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SI,
  IX86_BT_V16SF, IX86_BT_HI, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_HI, IX86_BT_INT,
  IX86_BT_V16SF, IX86_BT_V16HI, IX86_BT_V16SF, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8DF, IX86_BT_V8SI,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8DF,
  IX86_BT_V8SF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_V8SF, IX86_BT_V8DF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8DF, IX86_BT_V8DI,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8SF,
  IX86_BT_V8DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DI, IX86_BT_V8DF, IX86_BT_QI, IX86_BT_INT,
  IX86_BT_V8SF, IX86_BT_V8DI, IX86_BT_V8SF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_V2DF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V4SF,
  IX86_BT_V2DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_V4SF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_HI,
  IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8DF, IX86_BT_INT,
  IX86_BT_V8DF, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_QI, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V2DF, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_PCDOUBLE,
  IX86_BT_V4SI, IX86_BT_V2DF, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_PCDOUBLE, IX86_BT_V4SI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_PCDOUBLE,
  IX86_BT_V8SI, IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V2DF, IX86_BT_PCDOUBLE, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_PCDOUBLE,
  IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCFLOAT, IX86_BT_V4SI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_PCFLOAT,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCFLOAT, IX86_BT_V2DI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCFLOAT,
  IX86_BT_V4DI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_PCFLOAT, IX86_BT_V4DI, IX86_BT_V8SF,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_PCINT64,
  IX86_BT_V4SI, IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_PCINT64, IX86_BT_V4SI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_PCINT64,
  IX86_BT_V8SI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_PCINT64, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_PCINT64,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_PCINT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_PCINT,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_PCINT, IX86_BT_V2DI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_PCINT,
  IX86_BT_V4DI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_PCINT, IX86_BT_V4DI, IX86_BT_V8SI,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_PCFLOAT,
  IX86_BT_V8DI, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_PCDOUBLE, IX86_BT_V16SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_PCINT,
  IX86_BT_V8DI, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_PCINT64, IX86_BT_V16SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4DF, IX86_BT_V4DF, IX86_BT_PCDOUBLE,
  IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_PCFLOAT, IX86_BT_V4DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_PCINT64,
  IX86_BT_V8SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_PCINT, IX86_BT_V4DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_HI,
  IX86_BT_V8DI, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PDOUBLE, IX86_BT_QI, IX86_BT_V16SI, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PINT, IX86_BT_HI,
  IX86_BT_V8DI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PLONGLONG, IX86_BT_QI, IX86_BT_V16SI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_QI,
  IX86_BT_V4DI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PDOUBLE, IX86_BT_QI, IX86_BT_V8SI, IX86_BT_V4DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PINT, IX86_BT_QI,
  IX86_BT_V4DI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PLONGLONG, IX86_BT_QI, IX86_BT_V8SI, IX86_BT_V4DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PFLOAT, IX86_BT_QI,
  IX86_BT_V2DI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PDOUBLE, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PINT, IX86_BT_QI,
  IX86_BT_V2DI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PLONGLONG, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_PCVOID,
  IX86_BT_V16SI, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_PCVOID, IX86_BT_V8SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8SF, IX86_BT_V8SF, IX86_BT_PCVOID,
  IX86_BT_V8DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DF,
  IX86_BT_V8DF, IX86_BT_PCVOID, IX86_BT_V8DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_PCVOID,
  IX86_BT_V16SI, IX86_BT_HI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_PCVOID, IX86_BT_V8SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_PCVOID,
  IX86_BT_V8DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_PCVOID, IX86_BT_V8DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_HI,
  IX86_BT_V16SI, IX86_BT_V16SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8SI, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8DI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8DI, IX86_BT_V8DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_HI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8SI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8DI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_PCVOID,
  IX86_BT_V4SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_PCVOID, IX86_BT_V4SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_PCVOID,
  IX86_BT_V2DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4DF,
  IX86_BT_V4DF, IX86_BT_PCVOID, IX86_BT_V4DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCVOID,
  IX86_BT_V4SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_PCVOID, IX86_BT_V8SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V4SF, IX86_BT_PCVOID,
  IX86_BT_V2DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_PCVOID, IX86_BT_V4DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_PCVOID,
  IX86_BT_V4SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_PCVOID, IX86_BT_V4SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_PCVOID,
  IX86_BT_V2DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_PCVOID, IX86_BT_V4DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_PCVOID,
  IX86_BT_V4SI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V8SI,
  IX86_BT_V8SI, IX86_BT_PCVOID, IX86_BT_V8SI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_PCVOID,
  IX86_BT_V2DI, IX86_BT_QI, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_PCVOID, IX86_BT_V4DI, IX86_BT_QI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8SI, IX86_BT_V8SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4SI, IX86_BT_V4DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4DI, IX86_BT_V4SF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V2DI, IX86_BT_V4SF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4DI, IX86_BT_V4DF, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V2DI, IX86_BT_V2DF,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4SI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V4SI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4DI, IX86_BT_V4SI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V2DI, IX86_BT_V4SI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_PVOID, IX86_BT_QI,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PVOID, IX86_BT_QI, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_QI, IX86_BT_V8SI,
  IX86_BT_PCVOID, IX86_BT_INT, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_HI, IX86_BT_V16SI, IX86_BT_PCVOID, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_VOID, IX86_BT_QI, IX86_BT_V8DI,
  IX86_BT_PCVOID, IX86_BT_INT, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PUDI, IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_VOID,
  IX86_BT_PV16QI, IX86_BT_V16HI, IX86_BT_UHI, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT, IX86_BT_V64QI,
  IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_INT, IX86_BT_V64QI,
  IX86_BT_UDI, IX86_BT_V32QI, IX86_BT_V32QI, IX86_BT_V32QI,
  IX86_BT_INT, IX86_BT_V32QI, IX86_BT_USI, IX86_BT_V16QI,
  IX86_BT_V16QI, IX86_BT_V16QI, IX86_BT_INT, IX86_BT_V16QI,
  IX86_BT_UHI, IX86_BT_V64QI, IX86_BT_V64QI, IX86_BT_V64QI,
  IX86_BT_VOID, IX86_BT_PV64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_VOID, IX86_BT_PV32HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_VOID, IX86_BT_PV32QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_VOID, IX86_BT_PV16QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_VOID, IX86_BT_PV8HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V64QI, IX86_BT_PCV64QI, IX86_BT_V64QI, IX86_BT_UDI,
  IX86_BT_V32HI, IX86_BT_PCV32HI, IX86_BT_V32HI, IX86_BT_USI,
  IX86_BT_V32QI, IX86_BT_PCV32QI, IX86_BT_V32QI, IX86_BT_USI,
  IX86_BT_V16QI, IX86_BT_PCV16QI, IX86_BT_V16QI, IX86_BT_UHI,
  IX86_BT_V16HI, IX86_BT_PCV16HI, IX86_BT_V16HI, IX86_BT_UHI,
  IX86_BT_V8HI, IX86_BT_PCV8HI, IX86_BT_V8HI, IX86_BT_UQI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_INT,
  IX86_BT_V32HI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_INT, IX86_BT_V16SI, IX86_BT_INT,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_INT,
  IX86_BT_V8DI, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_V16HI,
  IX86_BT_V16HI, IX86_BT_INT, IX86_BT_V16HI, IX86_BT_INT,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_INT,
  IX86_BT_V8SI, IX86_BT_INT, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V4DI, IX86_BT_INT, IX86_BT_V4DI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_V8HI, IX86_BT_INT,
  IX86_BT_V8HI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_INT, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_V2DI, IX86_BT_INT,
  IX86_BT_V2DI, IX86_BT_INT, IX86_BT_V32HI, IX86_BT_V32HI,
  IX86_BT_V32HI, IX86_BT_V32HI, IX86_BT_V8DI, IX86_BT_V8DI,
  IX86_BT_V8DI, IX86_BT_V8DI, IX86_BT_V16SI, IX86_BT_V16SI,
  IX86_BT_V16SI, IX86_BT_V16SI, IX86_BT_V4DI, IX86_BT_V4DI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_UHI,
  IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_V8SI, IX86_BT_UHI,
  IX86_BT_FLOAT, IX86_BT_BFLOAT16, IX86_BT_V32BF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_V32BF, IX86_BT_V16SF, IX86_BT_V16SF,
  IX86_BT_V32BF, IX86_BT_USI, IX86_BT_V32BF, IX86_BT_V16SF,
  IX86_BT_V16SF, IX86_BT_USI, IX86_BT_V16BF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_V16BF, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V16BF, IX86_BT_UHI, IX86_BT_V16BF, IX86_BT_V8SF,
  IX86_BT_V8SF, IX86_BT_UHI, IX86_BT_V8BF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V8BF, IX86_BT_V4SF, IX86_BT_V4SF,
  IX86_BT_V8BF, IX86_BT_UQI, IX86_BT_V8BF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V16BF, IX86_BT_V16SF,
  IX86_BT_V16BF, IX86_BT_V16SF, IX86_BT_V16BF, IX86_BT_UHI,
  IX86_BT_V16BF, IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_V8BF,
  IX86_BT_V8SF, IX86_BT_V8BF, IX86_BT_V8SF, IX86_BT_V8BF,
  IX86_BT_UQI, IX86_BT_V8BF, IX86_BT_V8SF, IX86_BT_UQI,
  IX86_BT_V8BF, IX86_BT_V4SF, IX86_BT_V8BF, IX86_BT_V4SF,
  IX86_BT_V8BF, IX86_BT_UQI, IX86_BT_V8BF, IX86_BT_V4SF,
  IX86_BT_UQI, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V32BF,
  IX86_BT_V32BF, IX86_BT_V16SF, IX86_BT_V16SF, IX86_BT_V32BF,
  IX86_BT_V32BF, IX86_BT_UHI, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V16BF, IX86_BT_V16BF, IX86_BT_V8SF, IX86_BT_V8SF,
  IX86_BT_V16BF, IX86_BT_V16BF, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V8BF, IX86_BT_V8BF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_V8BF, IX86_BT_V8BF, IX86_BT_UQI,
  IX86_BT_UINT, IX86_BT_UINT, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_PVOID, IX86_BT_UINT, IX86_BT_UINT, IX86_BT_V2DI,
  IX86_BT_PVOID, IX86_BT_VOID, IX86_BT_V2DI, IX86_BT_V2DI,
  IX86_BT_V2DI, IX86_BT_UINT, IX86_BT_UINT8, IX86_BT_PV2DI,
  IX86_BT_V2DI, IX86_BT_PCVOID, IX86_BT_UINT8, IX86_BT_PV2DI,
  IX86_BT_PCV2DI, IX86_BT_PCVOID, IX86_BT_V8HF, IX86_BT_V8HI,
  IX86_BT_QI, IX86_BT_V8HF, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_HI, IX86_BT_V16HF, IX86_BT_INT, IX86_BT_UHI,
  IX86_BT_SI, IX86_BT_V32HF, IX86_BT_INT, IX86_BT_USI,
  IX86_BT_INT, IX86_BT_V8HF, IX86_BT_INT, IX86_BT_INT64,
  IX86_BT_V8HF, IX86_BT_INT, IX86_BT_UINT, IX86_BT_V8HF,
  IX86_BT_INT, IX86_BT_UINT64, IX86_BT_V8HF, IX86_BT_INT,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_VOID,
  IX86_BT_PCFLOAT16, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_PCFLOAT16, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_INT, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_INT64, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_UINT, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_UINT64, IX86_BT_INT, IX86_BT_V2DI,
  IX86_BT_V8HF, IX86_BT_V2DI, IX86_BT_UQI, IX86_BT_V4DI,
  IX86_BT_V8HF, IX86_BT_V4DI, IX86_BT_UQI, IX86_BT_V2DF,
  IX86_BT_V8HF, IX86_BT_V2DF, IX86_BT_UQI, IX86_BT_V4DF,
  IX86_BT_V8HF, IX86_BT_V4DF, IX86_BT_UQI, IX86_BT_V4SI,
  IX86_BT_V8HF, IX86_BT_V4SI, IX86_BT_UQI, IX86_BT_V4SF,
  IX86_BT_V8HF, IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_V8SI,
  IX86_BT_V8HF, IX86_BT_V8SI, IX86_BT_UQI, IX86_BT_V8SF,
  IX86_BT_V8HF, IX86_BT_V8SF, IX86_BT_UQI, IX86_BT_V8HI,
  IX86_BT_V8HF, IX86_BT_V8HI, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V4SI, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V4SF, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V8SI, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V8SF, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V2DI, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V4DI, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V2DF, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V4DF, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V8HI, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_INT, IX86_BT_V8HF, IX86_BT_UQI,
  IX86_BT_UQI, IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_INT,
  IX86_BT_UQI, IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_V8HF, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_INT, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V8DI, IX86_BT_V8HF, IX86_BT_V8DI,
  IX86_BT_UQI, IX86_BT_INT, IX86_BT_V8DF, IX86_BT_V8HF,
  IX86_BT_V8DF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8DI, IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_INT,
  IX86_BT_V8HF, IX86_BT_V8DF, IX86_BT_V8HF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V2DF, IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V8HF, IX86_BT_V4SF, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V2DF,
  IX86_BT_V8HF, IX86_BT_V2DF, IX86_BT_V2DF, IX86_BT_UQI,
  IX86_BT_INT, IX86_BT_V4SF, IX86_BT_V8HF, IX86_BT_V4SF,
  IX86_BT_V4SF, IX86_BT_UQI, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_V8HF, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_UQI, IX86_BT_INT, IX86_BT_V16HF, IX86_BT_V16HF,
  IX86_BT_V16HF, IX86_BT_V16HI, IX86_BT_V16HF, IX86_BT_V16HI,
  IX86_BT_UHI, IX86_BT_V16HF, IX86_BT_V16HI, IX86_BT_V16HF,
  IX86_BT_UHI, IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_V16HF,
  IX86_BT_UHI, IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_V16HF,
  IX86_BT_V16HF, IX86_BT_V16SI, IX86_BT_V16HF, IX86_BT_V16SI,
  IX86_BT_UHI, IX86_BT_INT, IX86_BT_V16SF, IX86_BT_V16HF,
  IX86_BT_V16SF, IX86_BT_UHI, IX86_BT_INT, IX86_BT_V16HF,
  IX86_BT_V16HF, IX86_BT_INT, IX86_BT_V16HF, IX86_BT_UHI,
  IX86_BT_UHI, IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_INT,
  IX86_BT_UHI, IX86_BT_V16HF, IX86_BT_V16SI, IX86_BT_V16HF,
  IX86_BT_UHI, IX86_BT_INT, IX86_BT_V16HF, IX86_BT_V16SF,
  IX86_BT_V16HF, IX86_BT_UHI, IX86_BT_INT, IX86_BT_V16HF,
  IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_UQI,
  IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_V16HF,
  IX86_BT_UHI, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_V32HF,
  IX86_BT_USI, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_V32HF,
  IX86_BT_INT, IX86_BT_V32HI, IX86_BT_V32HF, IX86_BT_V32HI,
  IX86_BT_USI, IX86_BT_INT, IX86_BT_V32HF, IX86_BT_V32HI,
  IX86_BT_V32HF, IX86_BT_USI, IX86_BT_INT, IX86_BT_USI,
  IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_INT, IX86_BT_USI,
  IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_USI,
  IX86_BT_INT, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_V32HF,
  IX86_BT_V32HF, IX86_BT_INT, IX86_BT_V32HF, IX86_BT_V32HF,
  IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_USI, IX86_BT_USI,
  IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_INT, IX86_BT_USI,
  IX86_BT_INT, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_V32HF,
  IX86_BT_V32HF, IX86_BT_UHI, IX86_BT_INT, IX86_BT_V32HF,
  IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_USI,
  IX86_BT_INT, IX86_BT_V32HF, IX86_BT_V32HF, IX86_BT_INT,
  IX86_BT_V32HF, IX86_BT_USI, IX86_BT_INT, IX86_BT_V8HF,
  IX86_BT_V8HF, IX86_BT_V16HF, IX86_BT_V16HF, IX86_BT_V32HF,
  IX86_BT_V32HF, IX86_BT_V4SF, IX86_BT_PCBFLOAT16, IX86_BT_V8SF,
  IX86_BT_PCBFLOAT16, IX86_BT_V4SF, IX86_BT_PCFLOAT16, IX86_BT_V8SF,
  IX86_BT_PCFLOAT16, IX86_BT_V4SF, IX86_BT_PCV8HF, IX86_BT_V8SF,
  IX86_BT_PCV16HF, IX86_BT_V4SF, IX86_BT_PCV8BF, IX86_BT_V8SF,
  IX86_BT_PCV16BF, IX86_BT_INT, IX86_BT_PINT, IX86_BT_INT,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_LONGLONG, IX86_BT_PLONGLONG,
  IX86_BT_LONGLONG, IX86_BT_LONGLONG, IX86_BT_INT, IX86_BT_VOID,
  IX86_BT_PCVOID, IX86_BT_INT, IX86_BT_VOID, IX86_BT_PCVOID,
  IX86_BT_INT, IX86_BT_INT, IX86_BT_INT, IX86_BT_V4SI,
  IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_V4SI, IX86_BT_INT,
  IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V4DI, IX86_BT_V2DI,
  IX86_BT_VOID, IX86_BT_UINT64, IX86_BT_UINT64
};


static const unsigned short ix86_builtin_func_start[] = {
  0, 1, 2, 3, 4, 5, 6, 7, 8, 9,
  11, 13, 15, 17, 19, 21, 23, 25, 27, 29,
  31, 33, 35, 37, 39, 41, 43, 45, 47, 49,
  51, 53, 55, 57, 59, 61, 63, 65, 67, 69,
  71, 73, 75, 77, 79, 81, 83, 85, 87, 89,
  91, 93, 95, 97, 99, 101, 103, 105, 107, 109,
  111, 115, 117, 121, 123, 125, 127, 129, 131, 135,
  137, 139, 141, 143, 145, 147, 149, 151, 153, 155,
  157, 159, 161, 163, 165, 167, 169, 173, 175, 177,
  179, 181, 183, 185, 187, 189, 191, 193, 195, 198,
  200, 203, 206, 208, 210, 212, 214, 216, 218, 220,
  222, 224, 226, 228, 230, 232, 234, 236, 238, 240,
  242, 244, 246, 248, 250, 254, 258, 260, 262, 265,
  268, 271, 274, 277, 280, 283, 286, 289, 292, 295,
  298, 301, 304, 307, 310, 313, 316, 319, 322, 325,
  328, 331, 334, 337, 340, 343, 346, 349, 352, 355,
  358, 361, 364, 367, 370, 373, 376, 379, 382, 387,
  390, 395, 398, 401, 406, 409, 412, 415, 418, 421,
  424, 427, 430, 433, 436, 439, 442, 445, 448, 451,
  456, 459, 462, 465, 468, 471, 474, 477, 480, 483,
  486, 489, 494, 499, 502, 505, 508, 511, 514, 517,
  520, 525, 528, 532, 535, 540, 543, 546, 549, 554,
  557, 562, 565, 568, 573, 576, 579, 582, 585, 588,
  591, 596, 599, 604, 607, 610, 613, 616, 619, 624,
  627, 630, 635, 638, 641, 644, 647, 650, 654, 660,
  666, 670, 676, 683, 688, 694, 699, 705, 711, 718,
  721, 725, 731, 738, 743, 749, 755, 760, 767, 773,
  779, 786, 793, 800, 807, 811, 817, 823, 826, 829,
  834, 839, 842, 845, 848, 851, 854, 859, 862, 866,
  870, 873, 876, 880, 886, 889, 894, 897, 903, 906,
  911, 916, 919, 924, 927, 932, 935, 938, 943, 948,
  951, 954, 957, 963, 969, 975, 981, 985, 989, 995,
  1001, 1004, 1007, 1010, 1013, 1016, 1019, 1024, 1029, 1034,
  1037, 1042, 1045, 1048, 1053, 1056, 1061, 1064, 1067, 1070,
  1073, 1076, 1079, 1082, 1085, 1088, 1091, 1094, 1097, 1100,
  1103, 1106, 1109, 1112, 1115, 1118, 1121, 1124, 1128, 1131,
  1140, 1147, 1154, 1163, 1172, 1179, 1183, 1186, 1190, 1193,
  1197, 1200, 1204, 1207, 1209, 1211, 1213, 1215, 1218, 1221,
  1224, 1226, 1228, 1230, 1232, 1234, 1236, 1238, 1240, 1242,
  1244, 1246, 1248, 1250, 1252, 1254, 1256, 1259, 1262, 1265,
  1268, 1272, 1277, 1281, 1286, 1290, 1295, 1299, 1304, 1308,
  1313, 1317, 1322, 1326, 1331, 1335, 1340, 1344, 1349, 1353,
  1358, 1362, 1366, 1370, 1375, 1379, 1384, 1388, 1394, 1398,
  1404, 1408, 1413, 1419, 1423, 1428, 1434, 1436, 1438, 1440,
  1442, 1444, 1446, 1448, 1450, 1452, 1454, 1456, 1458, 1460,
  1462, 1466, 1470, 1474, 1478, 1482, 1486, 1490, 1494, 1498,
  1503, 1507, 1511, 1516, 1521, 1526, 1530, 1534, 1538, 1542,
  1546, 1550, 1556, 1560, 1564, 1569, 1573, 1577, 1581, 1585,
  1589, 1594, 1598, 1602, 1606, 1611, 1616, 1621, 1626, 1630,
  1634, 1638, 1642, 1646, 1650, 1654, 1658, 1662, 1668, 1672,
  1676, 1681, 1685, 1691, 1695, 1699, 1703, 1707, 1713, 1717,
  1721, 1725, 1729, 1733, 1737, 1741, 1745, 1749, 1753, 1757,
  1761, 1766, 1772, 1777, 1783, 1787, 1791, 1795, 1799, 1803,
  1807, 1811, 1815, 1820, 1825, 1830, 1835, 1840, 1845, 1850,
  1855, 1860, 1865, 1870, 1875, 1880, 1885, 1890, 1894, 1898,
  1902, 1906, 1910, 1914, 1918, 1922, 1926, 1930, 1935, 1941,
  1946, 1951, 1956, 1961, 1967, 1972, 1977, 1982, 1986, 1990,
  1994, 1998, 2002, 2006, 2010, 2014, 2018, 2022, 2026, 2030,
  2034, 2038, 2042, 2046, 2050, 2054, 2058, 2062, 2066, 2070,
  2074, 2078, 2082, 2086, 2090, 2094, 2098, 2102, 2106, 2110,
  2114, 2118, 2122, 2126, 2130, 2134, 2138, 2142, 2146, 2150,
  2154, 2158, 2162, 2166, 2170, 2174, 2178, 2182, 2186, 2190,
  2194, 2198, 2202, 2206, 2210, 2214, 2218, 2222, 2226, 2230,
  2234, 2238, 2242, 2246, 2250, 2254, 2258, 2262, 2266, 2270,
  2274, 2278, 2282, 2286, 2290, 2294, 2298, 2302, 2306, 2310,
  2314, 2318, 2322, 2326, 2330, 2334, 2338, 2342, 2346, 2350,
  2354, 2359, 2364, 2369, 2374, 2380, 2386, 2392, 2398, 2402,
  2406, 2410, 2414, 2418, 2422, 2426, 2430, 2434, 2438, 2442,
  2446, 2450, 2454, 2458, 2462, 2466, 2470, 2474, 2478, 2482,
  2486, 2490, 2494, 2498, 2502, 2506, 2510, 2514, 2518, 2522,
  2526, 2530, 2534, 2538, 2542, 2546, 2550, 2554, 2558, 2562,
  2566, 2570, 2574, 2578, 2584, 2588, 2592, 2596, 2600, 2604,
  2608, 2612, 2616, 2621, 2626, 2631, 2636, 2641, 2647, 2653,
  2659, 2664, 2669, 2674, 2679, 2684, 2689, 2694, 2699, 2704,
  2710, 2716, 2722, 2728, 2734, 2738, 2742, 2746, 2750, 2754,
  2758, 2762, 2766, 2770, 2774, 2778, 2782, 2786, 2791, 2796,
  2799, 2802, 2807, 2810, 2813, 2818, 2822, 2826, 2830, 2834,
  2838, 2842, 2846, 2851, 2856, 2861, 2866, 2871, 2876, 2881,
  2886, 2892, 2898, 2907, 2912, 2917, 2920, 2923, 2926, 2929,
  2932, 2935, 2938, 2941, 2945, 2949, 2953, 2957, 2961, 2965,
  2970, 2975, 2980, 2985, 2990, 2995, 3000, 3005, 3010, 3015,
  3020, 3025, 3031, 3037, 3043, 3049, 3055, 3061, 3067, 3073,
  3079, 3085, 3090, 3095, 3101, 3107, 3114, 3121, 3127, 3133,
  3139, 3145, 3151, 3157, 3163, 3169, 3175, 3181, 3187, 3193,
  3199, 3205, 3211, 3217, 3223, 3229, 3235, 3241, 3247, 3253,
  3259, 3265, 3271, 3277, 3283, 3289, 3295, 3301, 3307, 3313,
  3319, 3325, 3331, 3337, 3343, 3349, 3355, 3361, 3367, 3373,
  3379, 3385, 3391, 3397, 3403, 3409, 3415, 3421, 3427, 3433,
  3439, 3445, 3451, 3457, 3463, 3469, 3475, 3481, 3487, 3493,
  3499, 3505, 3511, 3517, 3523, 3529, 3535, 3541, 3547, 3553,
  3559, 3565, 3571, 3577, 3583, 3589, 3595, 3601, 3607, 3613,
  3619, 3625, 3631, 3637, 3643, 3649, 3655, 3661, 3667, 3671,
  3675, 3679, 3685, 3691, 3697, 3700, 3704, 3708, 3712, 3716,
  3720, 3724, 3728, 3732, 3736, 3740, 3744, 3748, 3752, 3758,
  3762, 3768, 3774, 3780, 3786, 3792, 3798, 3804, 3810, 3814,
  3818, 3822, 3824, 3828, 3832, 3834, 3837, 3842, 3846, 3849,
  3854, 3858, 3861, 3866, 3870, 3872, 3876, 3879, 3881, 3885,
  3888, 3890, 3894, 3897, 3901, 3906, 3910, 3915, 3919, 3924,
  3929, 3933, 3938, 3942, 3946, 3948, 3952, 3956, 3960, 3963,
  3966, 3969, 3972, 3975, 3979, 3983, 3987, 3991, 3995, 3999,
  4003, 4007, 4011, 4015, 4019, 4023, 4027, 4031, 4035, 4039,
  4043, 4047, 4051, 4055, 4059, 4063, 4067, 4071, 4075, 4079,
  4084, 4089, 4094, 4099, 4105, 4110, 4115, 4120, 4125, 4129,
  4135, 4141, 4147, 4153, 4159, 4166, 4169, 4173, 4177, 4181,
  4185, 4190, 4195, 4200, 4205, 4210, 4215, 4220, 4225, 4229,
  4233, 4238, 4243, 4248, 4253, 4258, 4263, 4269, 4275, 4281,
  4287, 4289, 4291, 4293, 4295, 4297, 4299, 4301, 4303, 4305,
  4307, 4309, 4314, 4319, 4322, 4327, 4332, 4336, 4339
};


static const enum ix86_builtin_func_type ix86_builtin_func_alias_base[] = {
  UQI_FTYPE_UQI_UQI,
  V2DF_FTYPE_V2DF,
  V4DF_FTYPE_V4DF,
  V8DF_FTYPE_V8DF,
  V4SF_FTYPE_V4SF,
  V8SF_FTYPE_V8SF,
  V16SF_FTYPE_V16SF,
  V4SI_FTYPE_V2DF_V2DF,
  V8SI_FTYPE_V4DF_V4DF,
  V16SI_FTYPE_V8DF_V8DF,
  V4SI_FTYPE_V4SF,
  V8SI_FTYPE_V8SF,
  V16SI_FTYPE_V16SF,
  INT_FTYPE_V2DF_V2DF,
  INT_FTYPE_V2DI_V2DI,
  INT_FTYPE_V4DF_V4DF,
  INT_FTYPE_V4DI_V4DI,
  INT_FTYPE_V4SF_V4SF,
  INT_FTYPE_V8SF_V8SF,
  V2DF_FTYPE_V2DF,
  V4SF_FTYPE_V4SF,
  V1DI_FTYPE_V1DI_SI,
  V2DI_FTYPE_V2DI_SI,
  V2SI_FTYPE_V2SI_SI,
  V4HI_FTYPE_V4HI_SI,
  V4SI_FTYPE_V4SI_SI,
  V8HI_FTYPE_V8HI_SI,
  V1DI_FTYPE_V1DI_V1DI,
  V2DI_FTYPE_V2DI_V2DI,
  V2SI_FTYPE_V2SI_V2SI,
  V4HI_FTYPE_V4HI_V4HI,
  V4SI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_V8HI,
  V16HI_FTYPE_V16HI_SI,
  V16HI_FTYPE_V16HI_V8HI,
  V8SI_FTYPE_V8SI_SI,
  V8SI_FTYPE_V8SI_V4SI,
  V4DI_FTYPE_V4DI_INT,
  V4DI_FTYPE_V4DI_V2DI,
  V16HI_FTYPE_V16HI_INT_V16HI_UHI,
  V16HI_FTYPE_V16HI_V8HI_V16HI_UHI,
  V16SI_FTYPE_V16SI_INT_V16SI_UHI,
  V16SI_FTYPE_V16SI_V4SI_V16SI_UHI,
  V2DI_FTYPE_V2DI_INT_V2DI_UQI,
  V2DI_FTYPE_V2DI_V2DI_V2DI_UQI,
  V32HI_FTYPE_V32HI_INT_V32HI_USI,
  V32HI_FTYPE_V32HI_V8HI_V32HI_USI,
  V4DI_FTYPE_V4DI_INT_V4DI_UQI,
  V4DI_FTYPE_V4DI_V2DI_V4DI_UQI,
  V4SI_FTYPE_V4SI_INT_V4SI_UQI,
  V4SI_FTYPE_V4SI_V4SI_V4SI_UQI,
  V8DI_FTYPE_V8DI_INT_V8DI_UQI,
  V8DI_FTYPE_V8DI_V2DI_V8DI_UQI,
  V8HI_FTYPE_V8HI_INT_V8HI_UQI,
  V8HI_FTYPE_V8HI_V8HI_V8HI_UQI,
  V8SI_FTYPE_V8SI_INT_V8SI_UQI,
  V8SI_FTYPE_V8SI_V4SI_V8SI_UQI,
  V2DF_FTYPE_V2DF_V2DF,
  V4SF_FTYPE_V4SF_V4SF,
  V8DI_FTYPE_V8DI_INT,
  V4DI_FTYPE_V4DI_INT,
  V2DI_FTYPE_V2DI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT,
  V8DI_FTYPE_V8DI_V8DI_INT_V8DI_UDI,
  V4DI_FTYPE_V4DI_V4DI_INT_V4DI_USI,
  V2DI_FTYPE_V2DI_V2DI_INT_V2DI_UHI,
  V4DI_FTYPE_V4DI_V4DI_INT,
  V2DI_FTYPE_V2DI_V2DI_INT,
  V1DI_FTYPE_V1DI_V1DI_INT,
  V16QI_FTYPE_V16QI_V16QI,
  V2DI_FTYPE_V2DI_V2DI,
  V4SI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_V8HI,
  V16QI_FTYPE_V16QI_V16QI,
  V2DF_FTYPE_V2DF_V2DF,
  V2DI_FTYPE_V2DI_V2DI,
  V4SF_FTYPE_V4SF_V4SF,
  V4SI_FTYPE_V4SI_V4SI,
  V8HI_FTYPE_V8HI_V8HI,
  V8HF_FTYPE_V8HF,
  V16HF_FTYPE_V16HF,
  V32HF_FTYPE_V32HF
};
