/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.114 2021/04/11 07:35:45 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=mipsn64el--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/support/send-pr.html --with-pkgversion='NetBSD nb1 20210411' --with-system-zlib --without-isl --enable-__cxa_atexit --enable-libstdcxx-time=rt --enable-libstdcxx-threads --with-diagnostics-color=auto-if-env --with-default-libstdcxx-abi=new --with-mpc-lib=/usr/src/external/lgpl3/mpc/lib/libmpc/obj.evbmips-mipsn64el --with-mpfr-lib=/usr/src/external/lgpl3/mpfr/lib/libmpfr/obj.evbmips-mipsn64el --with-gmp-lib=/usr/src/external/lgpl3/gmp/lib/libgmp/obj.evbmips-mipsn64el --with-mpc-include=/usr/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/usr/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/usr/src/external/lgpl3/gmp/lib/libgmp/arch/mipsn64el --enable-tls --disable-multilib --disable-libstdcxx-pch --build=mipsn64el--netbsd --host=mipsn64el--netbsd --with-sysroot=/usr/obj/evbmips-mipsn64el/release : (reconfigured) /usr/src/tools/gcc/../../external/gpl3/gcc/dist/configure --target=mipsn64el--netbsd --enable-long-long --enable-threads --with-bugurl=http://www.NetBSD.org/support/send-pr.html --with-pkgversion='NetBSD nb1 20210411' --with-system-zlib --without-isl --enable-__cxa_atexit --enable-libstdcxx-time=rt --enable-libstdcxx-threads --with-diagnostics-color=auto-if-env --with-default-libstdcxx-abi=new --with-mpc-lib=/usr/src/external/lgpl3/mpc/lib/libmpc/obj.evbmips-mipsn64el --with-mpfr-lib=/usr/src/external/lgpl3/mpfr/lib/libmpfr/obj.evbmips-mipsn64el --with-gmp-lib=/usr/src/external/lgpl3/gmp/lib/libgmp/obj.evbmips-mipsn64el --with-mpc-include=/usr/src/external/lgpl3/mpc/dist/src --with-mpfr-include=/usr/src/external/lgpl3/mpfr/dist/src --with-gmp-include=/usr/src/external/lgpl3/gmp/lib/libgmp/arch/mipsn64el --enable-tls --disable-multilib --disable-libstdcxx-pch --build=x86_64-unknown-netbsd9.99 --host=mipsn64el--netbsd --with-sysroot=/usr/obj/evbmips-mipsn64el/release";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
