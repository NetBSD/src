/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.79 2014/05/29 16:27:50 skrll Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

static const char *const multilib_raw[] = {
". !mabi=aapcs-linux !mabi=apcs-gnu;",
".:. mabi=aapcs-linux !mabi=apcs-gnu;",
".:../lib/oabi !mabi=aapcs-linux mabi=apcs-gnu;",
NULL
};

static const char *const multilib_reuse_raw[] = {
NULL
};

static const char *const multilib_matches_raw[] = {
"mabi=aapcs-linux mabi=aapcs-linux;",
"mabi=apcs-gnu mabi=apcs-gnu;",
NULL
};

static const char *multilib_extra = "";

static const char *const multilib_exclusions_raw[] = {
NULL
};

static const char *multilib_options = "mabi=aapcs-linux/mabi=apcs-gnu";
