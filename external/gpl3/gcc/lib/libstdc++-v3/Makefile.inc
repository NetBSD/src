# $NetBSD: Makefile.inc,v 1.3.4.2 2014/05/22 16:53:29 yamt Exp $

GCC_MACHINE_ARCH=${MACHINE_ARCH:S/earmv5/earm/}
