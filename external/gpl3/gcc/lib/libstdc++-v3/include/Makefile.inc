# $NetBSD: Makefile.inc,v 1.3.4.2 2014/05/22 16:53:33 yamt Exp $

.include "../Makefile.inc"
