/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.123 2026/01/17 23:43:46 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* config.h.  Generated from config.h.in by configure.  */
/* config.h.in.  Generated from configure.ac by autoheader.  */

/* Define to 0 if the target shouldn't use #pragma weak */
/* #undef GTHREAD_USE_WEAK */

/* Define to 1 if you have the `access' function. */
#define HAVE_ACCESS 1

/* Define to 1 if you have the `acos' function. */
#define HAVE_ACOS 1

/* Define to 1 if you have the `acosf' function. */
#define HAVE_ACOSF 1

/* Define to 1 if you have the `acosf128' function. */
/* #undef HAVE_ACOSF128 */

/* Define to 1 if you have the `acosh' function. */
#define HAVE_ACOSH 1

/* Define to 1 if you have the `acoshf' function. */
#define HAVE_ACOSHF 1

/* Define to 1 if you have the `acoshf128' function. */
/* #undef HAVE_ACOSHF128 */

/* Define to 1 if you have the `acoshl' function. */
#define HAVE_ACOSHL 1

/* Define to 1 if you have the `acosl' function. */
#define HAVE_ACOSL 1

/* Define to 1 if you have the `alarm' function. */
#define HAVE_ALARM 1

/* Define to 1 if you have the `asin' function. */
#define HAVE_ASIN 1

/* Define to 1 if you have the `asinf' function. */
#define HAVE_ASINF 1

/* Define to 1 if you have the `asinf128' function. */
/* #undef HAVE_ASINF128 */

/* Define to 1 if you have the `asinh' function. */
#define HAVE_ASINH 1

/* Define to 1 if you have the `asinhf' function. */
#define HAVE_ASINHF 1

/* Define to 1 if you have the `asinhf128' function. */
/* #undef HAVE_ASINHF128 */

/* Define to 1 if you have the `asinhl' function. */
#define HAVE_ASINHL 1

/* Define to 1 if you have the `asinl' function. */
#define HAVE_ASINL 1

/* Define to 1 if you have the `atan' function. */
#define HAVE_ATAN 1

/* Define to 1 if you have the `atan2' function. */
#define HAVE_ATAN2 1

/* Define to 1 if you have the `atan2f' function. */
#define HAVE_ATAN2F 1

/* Define to 1 if you have the `atan2f128' function. */
/* #undef HAVE_ATAN2F128 */

/* Define to 1 if you have the `atan2l' function. */
#define HAVE_ATAN2L 1

/* Define to 1 if you have the `atanf' function. */
#define HAVE_ATANF 1

/* Define to 1 if you have the `atanf128' function. */
/* #undef HAVE_ATANF128 */

/* Define to 1 if you have the `atanh' function. */
#define HAVE_ATANH 1

/* Define to 1 if you have the `atanhf' function. */
#define HAVE_ATANHF 1

/* Define to 1 if you have the `atanhf128' function. */
/* #undef HAVE_ATANHF128 */

/* Define to 1 if you have the `atanhl' function. */
#define HAVE_ATANHL 1

/* Define to 1 if you have the `atanl' function. */
#define HAVE_ATANL 1

/* Define to 1 if the target supports __atomic_fetch_add */
#define HAVE_ATOMIC_FETCH_ADD 1

/* Define to 1 if the target supports __attribute__((alias(...))). */
#define HAVE_ATTRIBUTE_ALIAS 1

/* Define to 1 if the target supports __attribute__((visibility(...))). */
#define HAVE_ATTRIBUTE_VISIBILITY 1

/* Define if AVX instructions can be compiled. */
/* #undef HAVE_AVX */

/* Define if -mprefer-avx128 is supported. */
/* #undef HAVE_AVX128 */

/* Define if AVX2 instructions can be compiled. */
/* #undef HAVE_AVX2 */

/* Define if AVX512f instructions can be compiled. */
/* #undef HAVE_AVX512F */

/* Define to 1 if you have the `cabs' function. */
#define HAVE_CABS 1

/* Define to 1 if you have the `cabsf' function. */
#define HAVE_CABSF 1

/* Define to 1 if you have the `cabsf128' function. */
/* #undef HAVE_CABSF128 */

/* Define to 1 if you have the `cabsl' function. */
#define HAVE_CABSL 1

/* Define to 1 if you have the `cacos' function. */
#define HAVE_CACOS 1

/* Define to 1 if you have the `cacosf' function. */
#define HAVE_CACOSF 1

/* Define to 1 if you have the `cacosf128' function. */
/* #undef HAVE_CACOSF128 */

/* Define to 1 if you have the `cacosh' function. */
#define HAVE_CACOSH 1

/* Define to 1 if you have the `cacoshf' function. */
#define HAVE_CACOSHF 1

/* Define to 1 if you have the `cacoshf128' function. */
/* #undef HAVE_CACOSHF128 */

/* Define to 1 if you have the `cacoshl' function. */
#define HAVE_CACOSHL 1

/* Define to 1 if you have the `cacosl' function. */
#define HAVE_CACOSL 1

/* Define to 1 if you have the `carg' function. */
#define HAVE_CARG 1

/* Define to 1 if you have the `cargf' function. */
#define HAVE_CARGF 1

/* Define to 1 if you have the `cargf128' function. */
/* #undef HAVE_CARGF128 */

/* Define to 1 if you have the `cargl' function. */
#define HAVE_CARGL 1

/* Define to 1 if you have the `casin' function. */
#define HAVE_CASIN 1

/* Define to 1 if you have the `casinf' function. */
#define HAVE_CASINF 1

/* Define to 1 if you have the `casinf128' function. */
/* #undef HAVE_CASINF128 */

/* Define to 1 if you have the `casinh' function. */
#define HAVE_CASINH 1

/* Define to 1 if you have the `casinhf' function. */
#define HAVE_CASINHF 1

/* Define to 1 if you have the `casinhf128' function. */
/* #undef HAVE_CASINHF128 */

/* Define to 1 if you have the `casinhl' function. */
#define HAVE_CASINHL 1

/* Define to 1 if you have the `casinl' function. */
#define HAVE_CASINL 1

/* Define to 1 if you have the `catan' function. */
#define HAVE_CATAN 1

/* Define to 1 if you have the `catanf' function. */
#define HAVE_CATANF 1

/* Define to 1 if you have the `catanf128' function. */
/* #undef HAVE_CATANF128 */

/* Define to 1 if you have the `catanh' function. */
#define HAVE_CATANH 1

/* Define to 1 if you have the `catanhf' function. */
#define HAVE_CATANHF 1

/* Define to 1 if you have the `catanhf128' function. */
/* #undef HAVE_CATANHF128 */

/* Define to 1 if you have the `catanhl' function. */
#define HAVE_CATANHL 1

/* Define to 1 if you have the `catanl' function. */
#define HAVE_CATANL 1

/* Define to 1 if you have the `ccos' function. */
#define HAVE_CCOS 1

/* Define to 1 if you have the `ccosf' function. */
#define HAVE_CCOSF 1

/* Define to 1 if you have the `ccosf128' function. */
/* #undef HAVE_CCOSF128 */

/* Define to 1 if you have the `ccosh' function. */
#define HAVE_CCOSH 1

/* Define to 1 if you have the `ccoshf' function. */
#define HAVE_CCOSHF 1

/* Define to 1 if you have the `ccoshf128' function. */
/* #undef HAVE_CCOSHF128 */

/* Define to 1 if you have the `ccoshl' function. */
#define HAVE_CCOSHL 1

/* Define to 1 if you have the `ccosl' function. */
#define HAVE_CCOSL 1

/* Define to 1 if you have the `ceil' function. */
#define HAVE_CEIL 1

/* Define to 1 if you have the `ceilf' function. */
#define HAVE_CEILF 1

/* Define to 1 if you have the `ceilf128' function. */
/* #undef HAVE_CEILF128 */

/* Define to 1 if you have the `ceill' function. */
#define HAVE_CEILL 1

/* Define to 1 if you have the `cexp' function. */
#define HAVE_CEXP 1

/* Define to 1 if you have the `cexpf' function. */
#define HAVE_CEXPF 1

/* Define to 1 if you have the `cexpf128' function. */
/* #undef HAVE_CEXPF128 */

/* Define to 1 if you have the `cexpl' function. */
#define HAVE_CEXPL 1

/* Define to 1 if you have the `chdir' function. */
#define HAVE_CHDIR 1

/* Define to 1 if you have the `chsize' function. */
/* #undef HAVE_CHSIZE */

/* Define to 1 if you have the `clock_gettime' function. */
#define HAVE_CLOCK_GETTIME 1

/* Define to 1 if you have the `clock_gettime' function in librt. */
/* #undef HAVE_CLOCK_GETTIME_LIBRT */

/* libm includes clog */
#define HAVE_CLOG 1

/* Define to 1 if you have the `clog10' function. */
/* #undef HAVE_CLOG10 */

/* Define to 1 if you have the `clog10f' function. */
/* #undef HAVE_CLOG10F */

/* Define to 1 if you have the `clog10f128' function. */
/* #undef HAVE_CLOG10F128 */

/* Define to 1 if you have the `clog10l' function. */
/* #undef HAVE_CLOG10L */

/* Define to 1 if you have the `clogf' function. */
#define HAVE_CLOGF 1

/* Define to 1 if you have the `clogf128' function. */
/* #undef HAVE_CLOGF128 */

/* Define to 1 if you have the `clogl' function. */
#define HAVE_CLOGL 1

/* Define to 1 if you have the <complex.h> header file. */
#define HAVE_COMPLEX_H 1

/* Define to 1 if you have the `copysign' function. */
#define HAVE_COPYSIGN 1

/* Define to 1 if you have the `copysignf' function. */
#define HAVE_COPYSIGNF 1

/* Define to 1 if you have the `copysignf128' function. */
/* #undef HAVE_COPYSIGNF128 */

/* Define to 1 if you have the `copysignl' function. */
#define HAVE_COPYSIGNL 1

/* Define to 1 if you have the `cos' function. */
#define HAVE_COS 1

/* Define to 1 if you have the `cosf' function. */
#define HAVE_COSF 1

/* Define to 1 if you have the `cosf128' function. */
/* #undef HAVE_COSF128 */

/* Define to 1 if you have the `cosh' function. */
#define HAVE_COSH 1

/* Define to 1 if you have the `coshf' function. */
#define HAVE_COSHF 1

/* Define to 1 if you have the `coshf128' function. */
/* #undef HAVE_COSHF128 */

/* Define to 1 if you have the `coshl' function. */
#define HAVE_COSHL 1

/* Define to 1 if you have the `cosl' function. */
#define HAVE_COSL 1

/* Define to 1 if you have the `cpow' function. */
#define HAVE_CPOW 1

/* Define to 1 if you have the `cpowf' function. */
#define HAVE_CPOWF 1

/* Define to 1 if you have the `cpowf128' function. */
/* #undef HAVE_CPOWF128 */

/* Define to 1 if you have the `cpowl' function. */
#define HAVE_CPOWL 1

/* Define if CRLF is line terminator. */
/* #undef HAVE_CRLF */

/* Define to 1 if you have the `csin' function. */
#define HAVE_CSIN 1

/* Define to 1 if you have the `csinf' function. */
#define HAVE_CSINF 1

/* Define to 1 if you have the `csinf128' function. */
/* #undef HAVE_CSINF128 */

/* Define to 1 if you have the `csinh' function. */
#define HAVE_CSINH 1

/* Define to 1 if you have the `csinhf' function. */
#define HAVE_CSINHF 1

/* Define to 1 if you have the `csinhf128' function. */
/* #undef HAVE_CSINHF128 */

/* Define to 1 if you have the `csinhl' function. */
#define HAVE_CSINHL 1

/* Define to 1 if you have the `csinl' function. */
#define HAVE_CSINL 1

/* Define to 1 if you have the `csqrt' function. */
#define HAVE_CSQRT 1

/* Define to 1 if you have the `csqrtf' function. */
#define HAVE_CSQRTF 1

/* Define to 1 if you have the `csqrtf128' function. */
/* #undef HAVE_CSQRTF128 */

/* Define to 1 if you have the `csqrtl' function. */
#define HAVE_CSQRTL 1

/* Define to 1 if you have the `ctan' function. */
#define HAVE_CTAN 1

/* Define to 1 if you have the `ctanf' function. */
#define HAVE_CTANF 1

/* Define to 1 if you have the `ctanf128' function. */
/* #undef HAVE_CTANF128 */

/* Define to 1 if you have the `ctanh' function. */
#define HAVE_CTANH 1

/* Define to 1 if you have the `ctanhf' function. */
#define HAVE_CTANHF 1

/* Define to 1 if you have the `ctanhf128' function. */
/* #undef HAVE_CTANHF128 */

/* Define to 1 if you have the `ctanhl' function. */
#define HAVE_CTANHL 1

/* Define to 1 if you have the `ctanl' function. */
#define HAVE_CTANL 1

/* Define to 1 if you have the <dlfcn.h> header file. */
#define HAVE_DLFCN_H 1

/* Define to 1 if you have the `dup' function. */
#define HAVE_DUP 1

/* Define to 1 if you have the `erf' function. */
#define HAVE_ERF 1

/* Define to 1 if you have the `erfc' function. */
#define HAVE_ERFC 1

/* Define to 1 if you have the `erfcf' function. */
#define HAVE_ERFCF 1

/* Define to 1 if you have the `erfcf128' function. */
/* #undef HAVE_ERFCF128 */

/* Define to 1 if you have the `erfcl' function. */
#define HAVE_ERFCL 1

/* Define to 1 if you have the `erff' function. */
#define HAVE_ERFF 1

/* Define to 1 if you have the `erff128' function. */
/* #undef HAVE_ERFF128 */

/* Define to 1 if you have the `exp' function. */
#define HAVE_EXP 1

/* Define to 1 if you have the `expf' function. */
#define HAVE_EXPF 1

/* Define to 1 if you have the `expf128' function. */
/* #undef HAVE_EXPF128 */

/* Define to 1 if you have the `expl' function. */
#define HAVE_EXPL 1

/* Define to 1 if you have the `fabs' function. */
#define HAVE_FABS 1

/* Define to 1 if you have the `fabsf' function. */
#define HAVE_FABSF 1

/* Define to 1 if you have the `fabsf128' function. */
/* #undef HAVE_FABSF128 */

/* Define to 1 if you have the `fabsl' function. */
#define HAVE_FABSL 1

/* Define to 1 if you have the `fcntl' function. */
#define HAVE_FCNTL 1

/* libm includes feenableexcept */
#define HAVE_FEENABLEEXCEPT 1

/* Define to 1 if you have the <fenv.h> header file. */
#define HAVE_FENV_H 1

/* Define if target has usable _Float128 and __float128 types. */
#define HAVE_FLOAT128 1

/* Define to 1 if you have the <floatingpoint.h> header file. */
/* #undef HAVE_FLOATINGPOINT_H */

/* Define to 1 if you have the `floor' function. */
#define HAVE_FLOOR 1

/* Define to 1 if you have the `floorf' function. */
#define HAVE_FLOORF 1

/* Define to 1 if you have the `floorf128' function. */
/* #undef HAVE_FLOORF128 */

/* Define to 1 if you have the `floorl' function. */
#define HAVE_FLOORL 1

/* Define to 1 if you have the `fma' function. */
/* #undef HAVE_FMA */

/* Define if FMA3 instructions can be compiled. */
/* #undef HAVE_FMA3 */

/* Define if FMA4 instructions can be compiled. */
/* #undef HAVE_FMA4 */

/* Define to 1 if you have the `fmaf' function. */
/* #undef HAVE_FMAF */

/* Define to 1 if you have the `fmaf128' function. */
/* #undef HAVE_FMAF128 */

/* Define to 1 if you have the `fmal' function. */
/* #undef HAVE_FMAL */

/* Define to 1 if you have the `fmod' function. */
#define HAVE_FMOD 1

/* Define to 1 if you have the `fmodf' function. */
#define HAVE_FMODF 1

/* Define to 1 if you have the `fmodf128' function. */
/* #undef HAVE_FMODF128 */

/* Define to 1 if you have the `fmodl' function. */
#define HAVE_FMODL 1

/* Define to 1 if you have the `fork' function. */
#define HAVE_FORK 1

/* fpresetsticky is present */
/* #undef HAVE_FPRESETSTICKY */

/* Define if you have fpsetmask. */
#define HAVE_FPSETMASK 1

/* fpsetsticky is present */
#define HAVE_FPSETSTICKY 1

/* Define to 1 if you have the <fptrap.h> header file. */
/* #undef HAVE_FPTRAP_H */

/* Define to 1 if you have the <fpxcp.h> header file. */
/* #undef HAVE_FPXCP_H */

/* fp_enable is present */
/* #undef HAVE_FP_ENABLE */

/* Define to 1 if the system has the type `fp_except'. */
#define HAVE_FP_EXCEPT 1

/* Define to 1 if the system has the type `fp_except_t'. */
#define HAVE_FP_EXCEPT_T 1

/* Define to 1 if the system has the type `fp_rnd'. */
#define HAVE_FP_RND 1

/* Define to 1 if the system has the type `fp_rnd_t'. */
#define HAVE_FP_RND_T 1

/* fp_trap is present */
/* #undef HAVE_FP_TRAP */

/* Define to 1 if you have the `freelocale' function. */
#define HAVE_FREELOCALE 1

/* Define to 1 if you have the `frexp' function. */
#define HAVE_FREXP 1

/* Define to 1 if you have the `frexpf' function. */
#define HAVE_FREXPF 1

/* Define to 1 if you have the `frexpf128' function. */
/* #undef HAVE_FREXPF128 */

/* Define to 1 if you have the `frexpl' function. */
#define HAVE_FREXPL 1

/* Define to 1 if you have the `fstat' function. */
#define HAVE_FSTAT 1

/* Define to 1 if you have the `ftruncate' function. */
#define HAVE_FTRUNCATE 1

/* Define to 1 if you have the `getcwd' function. */
#define HAVE_GETCWD 1

/* Define to 1 if you have the `getegid' function. */
#define HAVE_GETEGID 1

/* Define to 1 if you have the `getentropy' function. */
#define HAVE_GETENTROPY 1

/* Define to 1 if you have the `geteuid' function. */
#define HAVE_GETEUID 1

/* Define to 1 if you have the `getgid' function. */
#define HAVE_GETGID 1

/* Define to 1 if you have the `gethostname' function. */
#define HAVE_GETHOSTNAME 1

/* Define to 1 if you have the `getlogin' function. */
#define HAVE_GETLOGIN 1

/* Define to 1 if you have the `getpid' function. */
#define HAVE_GETPID 1

/* Define to 1 if you have the `getpwuid' function. */
#define HAVE_GETPWUID 1

/* Define to 1 if you have the `getpwuid_r' function. */
#define HAVE_GETPWUID_R 1

/* Define to 1 if you have the `getrusage' function. */
#define HAVE_GETRUSAGE 1

/* Define to 1 if you have the `gettimeofday' function. */
#define HAVE_GETTIMEOFDAY 1

/* Define to 1 if you have the `getuid' function. */
#define HAVE_GETUID 1

/* Define to 1 if you have the `gmtime_r' function. */
#define HAVE_GMTIME_R 1

/* Define to 1 if you have the `hypot' function. */
#define HAVE_HYPOT 1

/* Define to 1 if you have the `hypotf' function. */
#define HAVE_HYPOTF 1

/* Define to 1 if you have the `hypotf128' function. */
/* #undef HAVE_HYPOTF128 */

/* Define to 1 if you have the `hypotl' function. */
#define HAVE_HYPOTL 1

/* Define to 1 if you have the <ieeefp.h> header file. */
#define HAVE_IEEEFP_H 1

/* Define to 1 if `__builtin_copysign' is expanded inline. */
/* #undef HAVE_INLINE_BUILTIN_COPYSIGN */

/* Define to 1 if `__builtin_copysignl' is expanded inline. */
/* #undef HAVE_INLINE_BUILTIN_COPYSIGNL */

/* Define to 1 if `__builtin_fabs' is expanded inline. */
/* #undef HAVE_INLINE_BUILTIN_FABS */

/* Define to 1 if `__builtin_fabsl' is expanded inline. */
/* #undef HAVE_INLINE_BUILTIN_FABSL */

/* Define to 1 if the system has the type `intptr_t'. */
#define HAVE_INTPTR_T 1

/* Define to 1 if you have the <inttypes.h> header file. */
#define HAVE_INTTYPES_H 1

/* Define to 1 if you have the `j0' function. */
#define HAVE_J0 1

/* Define to 1 if you have the `j0f' function. */
#define HAVE_J0F 1

/* Define to 1 if you have the `j0f128' function. */
/* #undef HAVE_J0F128 */

/* Define to 1 if you have the `j1' function. */
#define HAVE_J1 1

/* Define to 1 if you have the `j1f' function. */
#define HAVE_J1F 1

/* Define to 1 if you have the `j1f128' function. */
/* #undef HAVE_J1F128 */

/* Define to 1 if you have the `jn' function. */
#define HAVE_JN 1

/* Define to 1 if you have the `jnf' function. */
#define HAVE_JNF 1

/* Define to 1 if you have the `jnf128' function. */
/* #undef HAVE_JNF128 */

/* Define to 1 if you have the `jnl' function. */
/* #undef HAVE_JNL */

/* Define to 1 if you have the `kill' function. */
#define HAVE_KILL 1

/* Define to 1 if you have the `ldexp' function. */
#define HAVE_LDEXP 1

/* Define to 1 if you have the `ldexpf' function. */
#define HAVE_LDEXPF 1

/* Define to 1 if you have the `ldexpf128' function. */
/* #undef HAVE_LDEXPF128 */

/* Define to 1 if you have the `ldexpl' function. */
#define HAVE_LDEXPL 1

/* Define to 1 if you have the `lgamma' function. */
#define HAVE_LGAMMA 1

/* Define to 1 if you have the `lgammaf' function. */
#define HAVE_LGAMMAF 1

/* Define to 1 if you have the `lgammaf128' function. */
/* #undef HAVE_LGAMMAF128 */

/* Define to 1 if you have the `m' library (-lm). */
#define HAVE_LIBM 1

/* Define to 1 if you have the `link' function. */
#define HAVE_LINK 1

/* Define to 1 if you have the `llround' function. */
#define HAVE_LLROUND 1

/* Define to 1 if you have the `llroundf' function. */
#define HAVE_LLROUNDF 1

/* Define to 1 if you have the `llroundf128' function. */
/* #undef HAVE_LLROUNDF128 */

/* Define to 1 if you have the `llroundl' function. */
#define HAVE_LLROUNDL 1

/* Define to 1 if you have the `localtime_r' function. */
#define HAVE_LOCALTIME_R 1

/* Define to 1 if you have the `log' function. */
#define HAVE_LOG 1

/* Define to 1 if you have the `log10' function. */
#define HAVE_LOG10 1

/* Define to 1 if you have the `log10f' function. */
#define HAVE_LOG10F 1

/* Define to 1 if you have the `log10f128' function. */
/* #undef HAVE_LOG10F128 */

/* Define to 1 if you have the `log10l' function. */
#define HAVE_LOG10L 1

/* Define to 1 if you have the `logf' function. */
#define HAVE_LOGF 1

/* Define to 1 if you have the `logf128' function. */
/* #undef HAVE_LOGF128 */

/* Define to 1 if you have the `logl' function. */
#define HAVE_LOGL 1

/* Define to 1 if you have the `lround' function. */
#define HAVE_LROUND 1

/* Define to 1 if you have the `lroundf' function. */
#define HAVE_LROUNDF 1

/* Define to 1 if you have the `lroundf128' function. */
/* #undef HAVE_LROUNDF128 */

/* Define to 1 if you have the `lroundl' function. */
#define HAVE_LROUNDL 1

/* Define to 1 if you have the `lstat' function. */
#define HAVE_LSTAT 1

/* Define to 1 if you have the <math.h> header file. */
#define HAVE_MATH_H 1

/* Define to 1 if you have the <memory.h> header file. */
#define HAVE_MEMORY_H 1

/* Define if you have __mingw_snprintf. */
/* #undef HAVE_MINGW_SNPRINTF */

/* Define to 1 if you have the `mkostemp' function. */
#define HAVE_MKOSTEMP 1

/* Define to 1 if you have the `mkstemp' function. */
#define HAVE_MKSTEMP 1

/* Define to 1 if you have the `newlocale' function. */
#define HAVE_NEWLOCALE 1

/* Define to 1 if you have the `nextafter' function. */
#define HAVE_NEXTAFTER 1

/* Define to 1 if you have the `nextafterf' function. */
#define HAVE_NEXTAFTERF 1

/* Define to 1 if you have the `nextafterf128' function. */
/* #undef HAVE_NEXTAFTERF128 */

/* Define to 1 if you have the `nextafterl' function. */
#define HAVE_NEXTAFTERL 1

/* Define to 1 if we have POSIX getpwuid_r which takes 5 arguments. */
#define HAVE_POSIX_GETPWUID_R 1

/* Define to 1 if you have the `posix_spawn' function. */
#define HAVE_POSIX_SPAWN 1

/* Define to 1 if you have the `pow' function. */
#define HAVE_POW 1

/* Define to 1 if you have the `powf' function. */
#define HAVE_POWF 1

/* Define to 1 if you have the `powf128' function. */
/* #undef HAVE_POWF128 */

/* Define to 1 if the system has the type `ptrdiff_t'. */
#define HAVE_PTRDIFF_T 1

/* Define to 1 if you have the <pwd.h> header file. */
#define HAVE_PWD_H 1

/* Define to 1 if you have REAL(KIND=17) */
/* #undef HAVE_REAL_17 */

/* Define to 1 if you have the `round' function. */
#define HAVE_ROUND 1

/* Define to 1 if you have the `roundf' function. */
#define HAVE_ROUNDF 1

/* Define to 1 if you have the `roundf128' function. */
/* #undef HAVE_ROUNDF128 */

/* Define to 1 if you have the `roundl' function. */
#define HAVE_ROUNDL 1

/* Define to 1 if you have the `scalbn' function. */
#define HAVE_SCALBN 1

/* Define to 1 if you have the `scalbnf' function. */
#define HAVE_SCALBNF 1

/* Define to 1 if you have the `scalbnf128' function. */
/* #undef HAVE_SCALBNF128 */

/* Define to 1 if you have the `scalbnl' function. */
#define HAVE_SCALBNL 1

/* Define to 1 if you have the `secure_getenv' function. */
/* #undef HAVE_SECURE_GETENV */

/* Define to 1 if you have the `setmode' function. */
#define HAVE_SETMODE 1

/* Define to 1 if you have the `sigaction' function. */
/* #undef HAVE_SIGACTION */

/* Define to 1 if you have the `sin' function. */
#define HAVE_SIN 1

/* Define to 1 if you have the `sinf' function. */
#define HAVE_SINF 1

/* Define to 1 if you have the `sinf128' function. */
/* #undef HAVE_SINF128 */

/* Define to 1 if you have the `sinh' function. */
#define HAVE_SINH 1

/* Define to 1 if you have the `sinhf' function. */
#define HAVE_SINHF 1

/* Define to 1 if you have the `sinhf128' function. */
/* #undef HAVE_SINHF128 */

/* Define to 1 if you have the `sinhl' function. */
#define HAVE_SINHL 1

/* Define to 1 if you have the `sinl' function. */
#define HAVE_SINL 1

/* Define to 1 if you have the `sleep' function. */
#define HAVE_SLEEP 1

/* Define to 1 if you have the `snprintf' function. */
#define HAVE_SNPRINTF 1

/* Define to 1 if you have the `sqrt' function. */
#define HAVE_SQRT 1

/* Define to 1 if you have the `sqrtf' function. */
#define HAVE_SQRTF 1

/* Define to 1 if you have the `sqrtf128' function. */
/* #undef HAVE_SQRTF128 */

/* Define to 1 if you have the `sqrtl' function. */
#define HAVE_SQRTL 1

/* Define to 1 if you have the `stat' function. */
#define HAVE_STAT 1

/* Define to 1 if you have the <stdint.h> header file. */
#define HAVE_STDINT_H 1

/* Define to 1 if you have the <stdlib.h> header file. */
#define HAVE_STDLIB_H 1

/* Define to 1 if you have the `strerror_l' function. */
#define HAVE_STRERROR_L 1

/* Define if strerror_r is available in <string.h>. */
#define HAVE_STRERROR_R 1

/* Define if strerror_r takes two arguments and is available in <string.h>. */
/* #undef HAVE_STRERROR_R_2ARGS */

/* Define to 1 if you have the `strfromf128' function. */
/* #undef HAVE_STRFROMF128 */

/* Define to 1 if you have the <strings.h> header file. */
#define HAVE_STRINGS_H 1

/* Define to 1 if you have the <string.h> header file. */
#define HAVE_STRING_H 1

/* Define to 1 if you have the `strndup' function. */
#define HAVE_STRNDUP 1

/* Define to 1 if you have the `strnlen' function. */
#define HAVE_STRNLEN 1

/* Define to 1 if you have the `strtof' function. */
#define HAVE_STRTOF 1

/* Define to 1 if you have the `strtof128' function. */
/* #undef HAVE_STRTOF128 */

/* Define to 1 if you have the `strtold' function. */
#define HAVE_STRTOLD 1

/* Define to 1 if `st_blksize' is a member of `struct stat'. */
#define HAVE_STRUCT_STAT_ST_BLKSIZE 1

/* Define to 1 if `st_blocks' is a member of `struct stat'. */
#define HAVE_STRUCT_STAT_ST_BLOCKS 1

/* Define to 1 if `st_rdev' is a member of `struct stat'. */
#define HAVE_STRUCT_STAT_ST_RDEV 1

/* Define to 1 if you have the `symlink' function. */
#define HAVE_SYMLINK 1

/* Define to 1 if you have the <sys/random.h> header file. */
#define HAVE_SYS_RANDOM_H 1

/* Define to 1 if you have the <sys/resource.h> header file. */
#define HAVE_SYS_RESOURCE_H 1

/* Define to 1 if you have the <sys/stat.h> header file. */
#define HAVE_SYS_STAT_H 1

/* Define to 1 if you have the <sys/times.h> header file. */
#define HAVE_SYS_TIMES_H 1

/* Define to 1 if you have the <sys/time.h> header file. */
#define HAVE_SYS_TIME_H 1

/* Define to 1 if you have the <sys/types.h> header file. */
#define HAVE_SYS_TYPES_H 1

/* Define to 1 if you have the <sys/uio.h> header file. */
#define HAVE_SYS_UIO_H 1

/* Define to 1 if you have the <sys/wait.h> header file. */
#define HAVE_SYS_WAIT_H 1

/* Define to 1 if you have the `tan' function. */
#define HAVE_TAN 1

/* Define to 1 if you have the `tanf' function. */
#define HAVE_TANF 1

/* Define to 1 if you have the `tanf128' function. */
/* #undef HAVE_TANF128 */

/* Define to 1 if you have the `tanh' function. */
#define HAVE_TANH 1

/* Define to 1 if you have the `tanhf' function. */
#define HAVE_TANHF 1

/* Define to 1 if you have the `tanhf128' function. */
/* #undef HAVE_TANHF128 */

/* Define to 1 if you have the `tanhl' function. */
#define HAVE_TANHL 1

/* Define to 1 if you have the `tanl' function. */
#define HAVE_TANL 1

/* Define to 1 if you have the `tgamma' function. */
#define HAVE_TGAMMA 1

/* Define to 1 if you have the `tgammaf' function. */
#define HAVE_TGAMMAF 1

/* Define to 1 if you have the `tgammaf128' function. */
/* #undef HAVE_TGAMMAF128 */

/* Define to 1 if you have the `times' function. */
#define HAVE_TIMES 1

/* Define to 1 if you have the `trunc' function. */
#define HAVE_TRUNC 1

/* Define to 1 if you have the `truncf' function. */
#define HAVE_TRUNCF 1

/* Define to 1 if you have the `truncf128' function. */
/* #undef HAVE_TRUNCF128 */

/* Define to 1 if you have the `truncl' function. */
#define HAVE_TRUNCL 1

/* Define to 1 if you have the `ttyname' function. */
#define HAVE_TTYNAME 1

/* Define to 1 if you have the `ttyname_r' function. */
#define HAVE_TTYNAME_R 1

/* Define to 1 if the system has the type `uintptr_t'. */
#define HAVE_UINTPTR_T 1

/* Define to 1 if you have the `umask' function. */
#define HAVE_UMASK 1

/* Define to 1 if you have the <unistd.h> header file. */
#define HAVE_UNISTD_H 1

/* Define if target can unlink open files. */
#define HAVE_UNLINK_OPEN_FILE 1

/* Define to 1 if you have the `uselocale' function. */
/* #undef HAVE_USELOCALE */

/* Define to 1 if you have the `vsnprintf' function. */
#define HAVE_VSNPRINTF 1

/* Define to 1 if you have the `waitpid' function. */
#define HAVE_WAITPID 1

/* Define if target has a reliable stat. */
#define HAVE_WORKING_STAT 1

/* Define to 1 if you have the `writev' function. */
#define HAVE_WRITEV 1

/* Define to 1 if you have the <xlocale.h> header file. */
/* #undef HAVE_XLOCALE_H */

/* Define to 1 if you have the `y0' function. */
#define HAVE_Y0 1

/* Define to 1 if you have the `y0f' function. */
#define HAVE_Y0F 1

/* Define to 1 if you have the `y0f128' function. */
/* #undef HAVE_Y0F128 */

/* Define to 1 if you have the `y1' function. */
#define HAVE_Y1 1

/* Define to 1 if you have the `y1f' function. */
#define HAVE_Y1F 1

/* Define to 1 if you have the `y1f128' function. */
/* #undef HAVE_Y1F128 */

/* Define to 1 if you have the `yn' function. */
#define HAVE_YN 1

/* Define to 1 if you have the `ynf' function. */
#define HAVE_YNF 1

/* Define to 1 if you have the `ynf128' function. */
/* #undef HAVE_YNF128 */

/* Define to 1 if you have the `ynl' function. */
/* #undef HAVE_YNL */

/* Define to 1 if you have the `__acoshieee128' function. */
/* #undef HAVE___ACOSHIEEE128 */

/* Define to 1 if you have the `__acosieee128' function. */
/* #undef HAVE___ACOSIEEE128 */

/* Define to 1 if you have the `__asinhieee128' function. */
/* #undef HAVE___ASINHIEEE128 */

/* Define to 1 if you have the `__asinieee128' function. */
/* #undef HAVE___ASINIEEE128 */

/* Define to 1 if you have the `__atan2ieee128' function. */
/* #undef HAVE___ATAN2IEEE128 */

/* Define to 1 if you have the `__atanhieee128' function. */
/* #undef HAVE___ATANHIEEE128 */

/* Define to 1 if you have the `__atanieee128' function. */
/* #undef HAVE___ATANIEEE128 */

/* Define to 1 if you have the `__coshieee128' function. */
/* #undef HAVE___COSHIEEE128 */

/* Define to 1 if you have the `__cosieee128' function. */
/* #undef HAVE___COSIEEE128 */

/* Define to 1 if you have the `__erfieee128' function. */
/* #undef HAVE___ERFIEEE128 */

/* Define to 1 if you have the `__expieee128' function. */
/* #undef HAVE___EXPIEEE128 */

/* Define to 1 if you have the `__fabsieee128' function. */
/* #undef HAVE___FABSIEEE128 */

/* Define to 1 if you have the `__jnieee128' function. */
/* #undef HAVE___JNIEEE128 */

/* Define to 1 if you have the `__log10ieee128' function. */
/* #undef HAVE___LOG10IEEE128 */

/* Define to 1 if you have the `__logieee128' function. */
/* #undef HAVE___LOGIEEE128 */

/* Define to 1 if you have the `__powieee128' function. */
/* #undef HAVE___POWIEEE128 */

/* Define to 1 if you have the `__secure_getenv' function. */
/* #undef HAVE___SECURE_GETENV */

/* Define to 1 if you have the `__sinhieee128' function. */
/* #undef HAVE___SINHIEEE128 */

/* Define to 1 if you have the `__sinieee128' function. */
/* #undef HAVE___SINIEEE128 */

/* Define to 1 if you have the `__sqrtieee128' function. */
/* #undef HAVE___SQRTIEEE128 */

/* Define to 1 if you have the `__tanhieee128' function. */
/* #undef HAVE___TANHIEEE128 */

/* Define to 1 if you have the `__tanieee128' function. */
/* #undef HAVE___TANIEEE128 */

/* Define to 1 if you have the `__ynieee128' function. */
/* #undef HAVE___YNIEEE128 */

/* Define to the sub-directory in which libtool stores uninstalled libraries.
   */
#define LT_OBJDIR ".libs/"

/* Define to the address where bug reports for this package should be sent. */
#define PACKAGE_BUGREPORT ""

/* Define to the full name of this package. */
#define PACKAGE_NAME "GNU Fortran Runtime Library"

/* Define to the full name and version of this package. */
#define PACKAGE_STRING "GNU Fortran Runtime Library 0.3"

/* Define to the one symbol short name of this package. */
#define PACKAGE_TARNAME "libgfortran"

/* Define to the home page for this package. */
#define PACKAGE_URL "http://www.gnu.org/software/libgfortran/"

/* Define to the version of this package. */
#define PACKAGE_VERSION "0.3"

/* The size of `char', as computed by sizeof. */
/* #undef SIZEOF_CHAR */

/* The size of `int', as computed by sizeof. */
/* #undef SIZEOF_INT */

/* The size of `long', as computed by sizeof. */
/* #undef SIZEOF_LONG */

/* The size of `short', as computed by sizeof. */
/* #undef SIZEOF_SHORT */

/* The size of `void *', as computed by sizeof. */
/* #undef SIZEOF_VOID_P */

/* Define to 1 if you have the ANSI C header files. */
#define STDC_HEADERS 1

/* Define to 1 if the target supports #pragma weak */
#define SUPPORTS_WEAK 1

/* Define to 1 if the target supports weakref */
#define SUPPORTS_WEAKREF 1

/* Define if IEC 60559 *f128 APIs should be used for _Float128. */
/* #undef USE_IEC_60559 */

/* Enable extensions on AIX 3, Interix.  */
#ifndef _ALL_SOURCE
# define _ALL_SOURCE 1
#endif
/* Enable GNU extensions on systems that have them.  */
#ifndef _GNU_SOURCE
# define _GNU_SOURCE 1
#endif
/* Enable threading extensions on Solaris.  */
#ifndef _POSIX_PTHREAD_SEMANTICS
# define _POSIX_PTHREAD_SEMANTICS 1
#endif
/* Enable extensions on HP NonStop.  */
#ifndef _TANDEM_SOURCE
# define _TANDEM_SOURCE 1
#endif
/* Enable general extensions on Solaris.  */
#ifndef __EXTENSIONS__
# define __EXTENSIONS__ 1
#endif


/* Enable large inode numbers on Mac OS X 10.5.  */
#ifndef _DARWIN_USE_64_BIT_INODE
# define _DARWIN_USE_64_BIT_INODE 1
#endif

/* Number of bits in a file offset, on hosts where this is settable. */
/* #undef _FILE_OFFSET_BITS */

/* Define for large files, on AIX-style hosts. */
/* #undef _LARGE_FILES */

/* Define to 1 if on MINIX. */
/* #undef _MINIX */

/* Define to 2 if the system does not provide POSIX.1 features except with
   this defined. */
/* #undef _POSIX_1_SOURCE */

/* Define to 1 if you need to in order for `stat' and other things to work. */
/* #undef _POSIX_SOURCE */

/* Define to the type of a signed integer type wide enough to hold a pointer,
   if such a type exists, and if the system does not define it. */
/* #undef intptr_t */

/* Define to `long int' if <sys/types.h> does not define. */
/* #undef off_t */

/* Define to the type of an unsigned integer type wide enough to hold a
   pointer, if such a type exists, and if the system does not define it. */
/* #undef uintptr_t */
