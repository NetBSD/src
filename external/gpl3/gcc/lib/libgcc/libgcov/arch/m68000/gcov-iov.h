/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.89 2016/10/05 19:25:49 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `5.4.0 (5 4) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x3530342a)  /* 504* */
