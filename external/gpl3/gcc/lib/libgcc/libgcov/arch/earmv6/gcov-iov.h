/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.86 2016/03/16 11:16:05 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `5.3.0 (5 3) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x3530332a)  /* 503* */
