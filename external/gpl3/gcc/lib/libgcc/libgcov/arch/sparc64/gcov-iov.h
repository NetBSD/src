/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.108 2020/09/05 10:58:08 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `9.3.0 (9 3) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x4139332a)  /* A93* */
