/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gcc,v 1.101 2019/02/23 06:54:45 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `7.4.0 (7 4) and  (*)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x4137342a)  /* A74* */
