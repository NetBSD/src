/* THIS FILE IS GENERATED.  -*- buffer-read-only: t -*- vi:set ro:
  Original: 32bit-csr.xml */

#include "common/tdesc.h"

static int
create_feature_riscv_32bit_csr (struct target_desc *result, long regnum)
{
  struct tdesc_feature *feature;

  feature = tdesc_create_feature (result, "org.gnu.gdb.riscv.csr");
  tdesc_create_reg (feature, "ustatus", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "uie", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "utvec", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "uscratch", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "uepc", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "ucause", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "utval", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "uip", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "fflags", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "frm", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "fcsr", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "cycle", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "time", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "instret", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter3", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter4", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter5", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter6", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter7", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter8", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter9", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter10", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter11", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter12", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter13", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter14", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter15", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter16", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter17", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter18", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter19", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter20", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter21", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter22", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter23", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter24", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter25", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter26", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter27", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter28", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter29", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter30", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter31", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "cycleh", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "timeh", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "instreth", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter3h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter4h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter5h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter6h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter7h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter8h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter9h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter10h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter11h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter12h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter13h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter14h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter15h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter16h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter17h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter18h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter19h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter20h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter21h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter22h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter23h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter24h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter25h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter26h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter27h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter28h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter29h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter30h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hpmcounter31h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sstatus", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sedeleg", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sideleg", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sie", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "stvec", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "scounteren", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sscratch", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sepc", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "scause", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "stval", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "sip", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "satp", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mvendorid", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "marchid", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mimpid", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhartid", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mstatus", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "misa", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "medeleg", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mideleg", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mie", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mtvec", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mcounteren", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mscratch", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mepc", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mcause", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mtval", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mip", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpcfg0", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpcfg1", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpcfg2", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpcfg3", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr0", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr1", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr2", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr3", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr4", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr5", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr6", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr7", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr8", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr9", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr10", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr11", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr12", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr13", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr14", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "pmpaddr15", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mcycle", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "minstret", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter3", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter4", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter5", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter6", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter7", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter8", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter9", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter10", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter11", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter12", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter13", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter14", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter15", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter16", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter17", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter18", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter19", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter20", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter21", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter22", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter23", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter24", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter25", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter26", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter27", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter28", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter29", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter30", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter31", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mcycleh", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "minstreth", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter3h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter4h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter5h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter6h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter7h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter8h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter9h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter10h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter11h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter12h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter13h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter14h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter15h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter16h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter17h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter18h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter19h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter20h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter21h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter22h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter23h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter24h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter25h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter26h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter27h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter28h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter29h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter30h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmcounter31h", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent3", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent4", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent5", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent6", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent7", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent8", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent9", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent10", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent11", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent12", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent13", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent14", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent15", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent16", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent17", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent18", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent19", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent20", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent21", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent22", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent23", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent24", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent25", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent26", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent27", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent28", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent29", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent30", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhpmevent31", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "tselect", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "tdata1", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "tdata2", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "tdata3", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "dcsr", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "dpc", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "dscratch", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hstatus", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hedeleg", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hideleg", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hie", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "htvec", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hscratch", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hepc", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hcause", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hbadaddr", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "hip", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mbase", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mbound", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mibase", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mibound", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mdbase", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mdbound", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mucounteren", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mscounteren", regnum++, 1, NULL, 32, "int");
  tdesc_create_reg (feature, "mhcounteren", regnum++, 1, NULL, 32, "int");
  return regnum;
}
