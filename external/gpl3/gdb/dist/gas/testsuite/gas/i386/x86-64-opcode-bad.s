	.text
# All the followings are bad opcodes for x86-64.
	.byte 0xc5
	.byte 0xac
	.byte 0x46
	.byte 0xf5
	.byte 0xc5
	.byte 0x2c
	.byte 0x46
	.byte 0xf5
