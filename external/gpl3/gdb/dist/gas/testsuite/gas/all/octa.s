 .data
 .octa ~0x112233445566778899aabbcc0000
 .octa -347510587133311339321256747728896
