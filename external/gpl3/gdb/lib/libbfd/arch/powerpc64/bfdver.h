/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.6 2013/10/03 18:58:37 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.8 2006/05/26 19:17:21 mrg Exp  */

#define BFD_VERSION_DATE 20130312
#define BFD_VERSION 223520000
#define BFD_VERSION_STRING  "(GNU Binutils)" "2.23.52.20130312"
#define REPORT_BUGS_TO "<http://www.sourceware.org/bugzilla/>"
