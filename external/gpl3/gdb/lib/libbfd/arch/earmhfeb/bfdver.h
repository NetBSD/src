/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.5 2011/11/06 19:46:12 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

#define BFD_VERSION_DATE 20110403
#define BFD_VERSION 221510000
#define BFD_VERSION_STRING  "(GNU Binutils)" "2.21.51.20110403"
#define REPORT_BUGS_TO "<http://www.sourceware.org/bugzilla/>"
