/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.8 2019/05/29 01:56:06 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "common/version.h"
const char version[] = "8.3";
const char host_name[] = "sh--netbsdelf";
const char target_name[] = "sh--netbsdelf";
