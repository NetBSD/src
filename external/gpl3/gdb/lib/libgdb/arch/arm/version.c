/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.15 2020/12/05 21:27:31 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

#include "gdbsupport/version.h"
const char version[] = "11.0.50.20200914-git";
const char host_name[] = "arm--netbsdelf-eabi";
const char target_name[] = "arm--netbsdelf-eabi";
