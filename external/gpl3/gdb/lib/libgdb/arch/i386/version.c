/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.3 2011/09/26 02:36:20 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

#include "version.h"
const char version[] = "7.3.1";
const char host_name[] = "i486--netbsdelf";
const char target_name[] = "i486--netbsdelf";
