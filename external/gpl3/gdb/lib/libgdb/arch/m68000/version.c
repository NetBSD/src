/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.4 2011/10/09 02:03:30 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

#include "version.h"
const char version[] = "7.3.1";
const char host_name[] = "m68010--netbsdelf";
const char target_name[] = "m68010--netbsdelf";
