/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.6 2013/10/03 18:58:37 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.8 2006/05/26 19:17:21 mrg Exp  */

#include "version.h"
const char version[] = "7.6.1";
const char host_name[] = "powerpc64--netbsd";
const char target_name[] = "powerpc64--netbsd";
