/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-gdb,v 1.6 2013/10/03 18:58:37 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.11 2014/02/17 21:39:43 christos Exp  */

#include "version.h"
const char version[] = "7.7.1";
const char host_name[] = "arm--netbsdelf-eabi";
const char target_name[] = "arm--netbsdelf-eabi";
