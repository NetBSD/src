_CTF_STR (ECTF_FMT, "File is not in CTF or ELF format")
_CTF_STR (ECTF_BFDERR, "BFD error")
_CTF_STR (ECTF_CTFVERS, "CTF dict version is too new for libctf")
_CTF_STR (ECTF_BFD_AMBIGUOUS, "Ambiguous BFD target")
_CTF_STR (ECTF_SYMTAB, "Symbol table uses invalid entry size")
_CTF_STR (ECTF_SYMBAD, "Symbol table data buffer is not valid")
_CTF_STR (ECTF_STRBAD, "String table data buffer is not valid")
_CTF_STR (ECTF_CORRUPT, "File data structure corruption detected")
_CTF_STR (ECTF_NOCTFDATA, "File does not contain CTF data")
_CTF_STR (ECTF_NOCTFBUF, "Buffer does not contain CTF data")
_CTF_STR (ECTF_NOSYMTAB, "Symbol table information is not available")
_CTF_STR (ECTF_NOPARENT, "The parent CTF dictionary is unavailable")
_CTF_STR (ECTF_DMODEL, "Data model mismatch")
_CTF_STR (ECTF_LINKADDEDLATE, "File added to link too late")
_CTF_STR (ECTF_ZALLOC, "Failed to allocate (de)compression buffer")
_CTF_STR (ECTF_DECOMPRESS, "Failed to decompress CTF data")
_CTF_STR (ECTF_STRTAB, "External string table is not available")
_CTF_STR (ECTF_BADNAME, "String name offset is corrupt")
_CTF_STR (ECTF_BADID, "Invalid type identifier")
_CTF_STR (ECTF_NOTSOU, "Type is not a struct or union")
_CTF_STR (ECTF_NOTENUM, "Type is not an enum")
_CTF_STR (ECTF_NOTSUE, "Type is not a struct, union, or enum")
_CTF_STR (ECTF_NOTINTFP, "Type is not an integer, float, or enum")
_CTF_STR (ECTF_NOTARRAY, "Type is not an array")
_CTF_STR (ECTF_NOTREF, "Type does not reference another type")
_CTF_STR (ECTF_NAMELEN, "Buffer is too small to hold type name")
_CTF_STR (ECTF_NOTYPE, "No type found corresponding to name")
_CTF_STR (ECTF_SYNTAX, "Syntax error in type name")
_CTF_STR (ECTF_NOTFUNC, "Symbol table entry or type is not a function")
_CTF_STR (ECTF_NOFUNCDAT, "No function information available for function")
_CTF_STR (ECTF_NOTDATA, "Symbol table entry does not refer to a data object")
_CTF_STR (ECTF_NOTYPEDAT, "No type information available for symbol")
_CTF_STR (ECTF_NOLABEL, "No label found corresponding to name")
_CTF_STR (ECTF_NOLABELDATA, "File does not contain any labels")
_CTF_STR (ECTF_NOTSUP, "Feature not supported")
_CTF_STR (ECTF_NOENUMNAM, "Enum element name not found")
_CTF_STR (ECTF_NOMEMBNAM, "Member name not found")
_CTF_STR (ECTF_RDONLY, "CTF container is read-only")
_CTF_STR (ECTF_DTFULL, "CTF type is full (no more members allowed)")
_CTF_STR (ECTF_FULL, "CTF container is full")
_CTF_STR (ECTF_DUPLICATE, "Duplicate member or variable name")
_CTF_STR (ECTF_CONFLICT, "Conflicting type is already defined")
_CTF_STR (ECTF_OVERROLLBACK, "Attempt to roll back past a ctf_update")
_CTF_STR (ECTF_COMPRESS, "Failed to compress CTF data")
_CTF_STR (ECTF_ARCREATE, "Error creating CTF archive")
_CTF_STR (ECTF_ARNNAME, "Name not found in CTF archive")
_CTF_STR (ECTF_SLICEOVERFLOW, "Overflow of type bitness or offset in slice")
_CTF_STR (ECTF_DUMPSECTUNKNOWN, "Unknown section number in dump")
_CTF_STR (ECTF_DUMPSECTCHANGED, "Section changed in middle of dump")
_CTF_STR (ECTF_NOTYET, "Feature not yet implemented")
_CTF_STR (ECTF_INTERNAL, "Internal error: assertion failure")
_CTF_STR (ECTF_NONREPRESENTABLE, "Type not representable in CTF")
_CTF_STR (ECTF_NEXT_END, "End of iteration")
_CTF_STR (ECTF_NEXT_WRONGFUN, "Wrong iteration function called")
_CTF_STR (ECTF_NEXT_WRONGFP, "Iteration entity changed in mid-iterate")
_CTF_STR (ECTF_FLAGS, "CTF header contains flags unknown to libctf")
_CTF_STR (ECTF_NEEDSBFD, "This feature needs a libctf with BFD support")


