#	$NetBSD: Makefile.inc,v 1.9 2024/06/29 16:36:03 christos Exp $

BINDIR?=	/usr/bin
NOGCCERROR=	# defined
.include "${.PARSEDIR}/../Makefile.inc"
