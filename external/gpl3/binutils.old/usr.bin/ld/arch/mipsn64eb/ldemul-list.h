/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: NetBSD: mknative-binutils,v 1.13 2020/04/04 01:34:53 christos Exp  */
/* Generated from: NetBSD: mknative.common,v 1.16 2018/04/15 15:13:37 christos Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf64btsmip_emulation;
extern ld_emulation_xfer_type ld_elf64ltsmip_emulation;
extern ld_emulation_xfer_type ld_elf32ltsmip_emulation;
extern ld_emulation_xfer_type ld_elf32btsmip_emulation;
extern ld_emulation_xfer_type ld_elf32ltsmipn32_emulation;
extern ld_emulation_xfer_type ld_elf32btsmipn32_emulation;

#define EMULATION_LIST \
  &ld_elf64btsmip_emulation, \
  &ld_elf64ltsmip_emulation, \
  &ld_elf32ltsmip_emulation, \
  &ld_elf32btsmip_emulation, \
  &ld_elf32ltsmipn32_emulation, \
  &ld_elf32btsmipn32_emulation, \
  0
