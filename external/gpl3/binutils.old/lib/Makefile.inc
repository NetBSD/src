# $NetBSD: Makefile.inc,v 1.8 2024/06/29 16:35:54 christos Exp $
.include "${.PARSEDIR}/../Makefile.inc"
