# $NetBSD: Makefile.inc,v 1.10 2024/06/29 16:35:40 christos Exp $
.include <bsd.own.mk>
TOP:=	${.PARSEDIR}
DIST:=	${TOP}/dist
