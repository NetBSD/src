	.text
start:
	lvepxl   3,0,28
	lvepxl   19,4,18
	lvepx    27,0,19
	lvepx    1,25,18
	lvexbx   31,0,27
	lvexbx   28,1,12
	lvexhx   31,0,14
	lvexhx   17,16,31
	lvexwx   22,0,29
	lvexwx   23,25,5
	lvsm     3,0,12
	lvsm     27,29,1
	lvswxl   7,0,6
	lvswxl   7,16,8
	lvswx    14,0,18
	lvswx    28,28,16
	lvtlxl   27,0,12
	lvtlxl   27,28,0
	lvtlx    23,0,25
	lvtlx    1,25,14
	lvtrxl   20,0,24
	lvtrxl   22,29,24
	lvtrx    24,0,8
	lvtrx    13,23,28
	mvidsplt 12,28,12
	mviwsplt 10,27,0
	stvepxl  27,0,13
	stvepxl  2,2,31
	stvepx   3,0,10
	stvepx   27,28,0
	stvexbx  13,0,6
	stvexbx  13,25,3
	stvexhx  22,0,1
	stvexhx  17,14,10
	stvexwx  21,0,27
	stvexwx  31,18,1
	stvflxl  26,0,13
	stvflxl  22,13,21
	stvflx   5,0,9
	stvflx   21,24,1
	stvfrxl  13,0,10
	stvfrxl  13,17,25
	stvfrx   17,0,10
	stvfrx   8,12,31
	stvswxl  18,0,29
	stvswxl  26,14,8
	stvswx   0,0,15
	stvswx   13,23,7
	vabsdub  6,17,16
	vabsduh  21,18,4
	vabsduw  25,20,9
	vpermxor 6,17,20,26
	vaddeuqm 29,26,15,28
	vaddecuq 15,8,7,24
	vsubeuqm 2,6,21,1
	vsubecuq 29,6,0,4
	vmulouw  14,9,3
	vmuluwm  24,16,18
	vaddudm  10,17,17
	vmaxud   30,25,4
	vrld     10,6,28
	vcmpequd 27,7,7
	vadduqm  22,16,25
	vaddcuq  1,21,29
	vmulosw  20,11,19
	vmaxsd   24,19,1
	vmuleuw  13,27,30
	vminud   9,24,17
	vcmpgtud 10,18,28
	vmulesw  0,29,22
	vminsd   13,28,1
	vsrad    10,20,5
	vcmpgtsd 27,21,5
	bcdadd.  0,23,30,1
	vpmsumb  25,24,26
	bcdsub.  8,4,4,1
	vpmsumh  16,14,26
	vpkudum  27,2,26
	vpmsumw  6,23,17
	vpmsumd  20,6,25
	vpkudus  27,22,16
	vsubudm  21,20,18
	vsubuqm  21,20,18
	vcipher  29,29,6
	vcipherlast 2,13,20
	vgbbd    20,18
	vsubcuq  19,8,25
	vorc     9,26,29
	vncipher 20,20,13
	vncipherlast 15,5,27
	vbpermq  3,19,6
	vpksdus  30,4,28
	vnand    0,4,14
	vsld     17,8,29
	vsbox    29,20
	vpksdss  11,7,11
	vcmpequd. 3,19,16
	vupkhsw  18,17
	vshasigmaw 29,8,0,13
	veqv     23,28,26
	vmrgew   29,0,2
	vmrgow   29,0,2
	vshasigmad 27,19,0,0
	vsrd     20,28,28
	vupklsw  18,21
	vclzb    30,7
	vpopcntb 29,21
	vclzh    25,21
	vpopcnth 16,30
	vclzw    28,3
	vpopcntw 10,9
	vclzd    22,9
	vpopcntd 15,30
	vcmpgtud. 2,31,6
	vcmpgtsd. 20,15,2
