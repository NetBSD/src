
#line 2 "ldlex.c"

#define  YY_INT_ALIGNED short int

/* A lexical scanner generated by flex */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 6
#define YY_FLEX_SUBMINOR_VERSION 4
#if YY_FLEX_SUBMINOR_VERSION > 0
#define FLEX_BETA
#endif

/* First, we deal with  platform-specific or compiler-specific issues. */

/* begin standard C headers. */
#include <stdio.h>
#include <string.h>
#include <errno.h>
#include <stdlib.h>

/* end standard C headers. */

/* flex integer type definitions */

#ifndef FLEXINT_H
#define FLEXINT_H

/* C99 systems have <inttypes.h>. Non-C99 systems may or may not. */

#if defined (__STDC_VERSION__) && __STDC_VERSION__ >= 199901L

/* C99 says to define __STDC_LIMIT_MACROS before including stdint.h,
 * if you want the limit (max/min) macros for int types. 
 */
#ifndef __STDC_LIMIT_MACROS
#define __STDC_LIMIT_MACROS 1
#endif

#include <inttypes.h>
typedef int8_t flex_int8_t;
typedef uint8_t flex_uint8_t;
typedef int16_t flex_int16_t;
typedef uint16_t flex_uint16_t;
typedef int32_t flex_int32_t;
typedef uint32_t flex_uint32_t;
#else
typedef signed char flex_int8_t;
typedef short int flex_int16_t;
typedef int flex_int32_t;
typedef unsigned char flex_uint8_t; 
typedef unsigned short int flex_uint16_t;
typedef unsigned int flex_uint32_t;

/* Limits of integral types. */
#ifndef INT8_MIN
#define INT8_MIN               (-128)
#endif
#ifndef INT16_MIN
#define INT16_MIN              (-32767-1)
#endif
#ifndef INT32_MIN
#define INT32_MIN              (-2147483647-1)
#endif
#ifndef INT8_MAX
#define INT8_MAX               (127)
#endif
#ifndef INT16_MAX
#define INT16_MAX              (32767)
#endif
#ifndef INT32_MAX
#define INT32_MAX              (2147483647)
#endif
#ifndef UINT8_MAX
#define UINT8_MAX              (255U)
#endif
#ifndef UINT16_MAX
#define UINT16_MAX             (65535U)
#endif
#ifndef UINT32_MAX
#define UINT32_MAX             (4294967295U)
#endif

#ifndef SIZE_MAX
#define SIZE_MAX               (~(size_t)0)
#endif

#endif /* ! C99 */

#endif /* ! FLEXINT_H */

/* begin standard C++ headers. */

/* TODO: this is always defined, so inline it */
#define yyconst const

#if defined(__GNUC__) && __GNUC__ >= 3
#define yynoreturn __attribute__((__noreturn__))
#else
#define yynoreturn
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an
 *   integer in range [0..255] for use as an array index.
 */
#define YY_SC_TO_UI(c) ((YY_CHAR) (c))

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN (yy_start) = 1 + 2 *
/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START (((yy_start) - 1) / 2)
#define YYSTATE YY_START
/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)
/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( yyin  )
#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#ifndef YY_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k.
 * Moreover, YY_BUF_SIZE is 2*YY_READ_BUF_SIZE in the general case.
 * Ditto for the __ia64__ case accordingly.
 */
#define YY_BUF_SIZE 32768
#else
#define YY_BUF_SIZE 16384
#endif /* __ia64__ */
#endif

/* The state buf must be large enough to hold one state per character in the main buffer.
 */
#define YY_STATE_BUF_SIZE   ((YY_BUF_SIZE + 2) * sizeof(yy_state_type))

#ifndef YY_TYPEDEF_YY_BUFFER_STATE
#define YY_TYPEDEF_YY_BUFFER_STATE
typedef struct yy_buffer_state *YY_BUFFER_STATE;
#endif

#ifndef YY_TYPEDEF_YY_SIZE_T
#define YY_TYPEDEF_YY_SIZE_T
typedef size_t yy_size_t;
#endif

extern int yyleng;

extern FILE *yyin, *yyout;

#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2
    
    #define YY_LESS_LINENO(n)
    #define YY_LINENO_REWIND_TO(ptr)
    
/* Return all but the first "n" matched characters back to the input stream. */
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		*yy_cp = (yy_hold_char); \
		YY_RESTORE_YY_MORE_OFFSET \
		(yy_c_buf_p) = yy_cp = yy_bp + yyless_macro_arg - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )
#define unput(c) yyunput( c, (yytext_ptr)  )

#ifndef YY_STRUCT_YY_BUFFER_STATE
#define YY_STRUCT_YY_BUFFER_STATE
struct yy_buffer_state
	{
	FILE *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	int yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	int yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether this is an "interactive" input source; if so, and
	 * if we're using stdio for input, then we want to use getc()
	 * instead of fread(), to make sure we stop fetching input after
	 * each newline.
	 */
	int yy_is_interactive;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

    int yy_bs_lineno; /**< The line count. */
    int yy_bs_column; /**< The column count. */

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;

#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2

	};
#endif /* !YY_STRUCT_YY_BUFFER_STATE */

/* Stack of input buffers. */
static size_t yy_buffer_stack_top = 0; /**< index of top of stack. */
static size_t yy_buffer_stack_max = 0; /**< capacity of stack. */
static YY_BUFFER_STATE * yy_buffer_stack = NULL; /**< Stack as an array. */

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 *
 * Returns the top of the stack, or NULL.
 */
#define YY_CURRENT_BUFFER ( (yy_buffer_stack) \
                          ? (yy_buffer_stack)[(yy_buffer_stack_top)] \
                          : NULL)
/* Same as previous macro, but useful when we know that the buffer stack is not
 * NULL or when we need an lvalue. For internal use only.
 */
#define YY_CURRENT_BUFFER_LVALUE (yy_buffer_stack)[(yy_buffer_stack_top)]

/* yy_hold_char holds the character lost when yytext is formed. */
static char yy_hold_char;
static int yy_n_chars;		/* number of characters read into yy_ch_buf */
int yyleng;

/* Points to current character in buffer. */
static char *yy_c_buf_p = NULL;
static int yy_init = 0;		/* whether we need to initialize */
static int yy_start = 0;	/* start state number */

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
static int yy_did_buffer_switch_on_eof;

void yyrestart ( FILE *input_file  );
void yy_switch_to_buffer ( YY_BUFFER_STATE new_buffer  );
YY_BUFFER_STATE yy_create_buffer ( FILE *file, int size  );
void yy_delete_buffer ( YY_BUFFER_STATE b  );
void yy_flush_buffer ( YY_BUFFER_STATE b  );
void yypush_buffer_state ( YY_BUFFER_STATE new_buffer  );
void yypop_buffer_state ( void );

static void yyensure_buffer_stack ( void );
static void yy_load_buffer_state ( void );
static void yy_init_buffer ( YY_BUFFER_STATE b, FILE *file  );
#define YY_FLUSH_BUFFER yy_flush_buffer( YY_CURRENT_BUFFER )

YY_BUFFER_STATE yy_scan_buffer ( char *base, yy_size_t size  );
YY_BUFFER_STATE yy_scan_string ( const char *yy_str  );
YY_BUFFER_STATE yy_scan_bytes ( const char *bytes, int len  );

void *yyalloc ( yy_size_t  );
void *yyrealloc ( void *, yy_size_t  );
void yyfree ( void *  );

#define yy_new_buffer yy_create_buffer
#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){ \
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_is_interactive = is_interactive; \
	}
#define yy_set_bol(at_bol) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){\
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_at_bol = at_bol; \
	}
#define YY_AT_BOL() (YY_CURRENT_BUFFER_LVALUE->yy_at_bol)

/* Begin user sect3 */

#define yywrap() (/*CONSTCOND*/1)
#define YY_SKIP_YYWRAP
typedef flex_uint8_t YY_CHAR;

FILE *yyin = NULL, *yyout = NULL;

typedef int yy_state_type;

extern int yylineno;
int yylineno = 1;

extern char *yytext;
#ifdef yytext_ptr
#undef yytext_ptr
#endif
#define yytext_ptr yytext

static yy_state_type yy_get_previous_state ( void );
static yy_state_type yy_try_NUL_trans ( yy_state_type current_state  );
static int yy_get_next_buffer ( void );
static void yynoreturn yy_fatal_error ( const char* msg  );

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	(yytext_ptr) = yy_bp; \
	yyleng = (int) (yy_cp - yy_bp); \
	(yy_hold_char) = *yy_cp; \
	*yy_cp = '\0'; \
	(yy_c_buf_p) = yy_cp;
#define YY_NUM_RULES 200
#define YY_END_OF_BUFFER 201
/* This struct is not used in this scanner,
   but its presence is necessary. */
struct yy_trans_info
	{
	flex_int32_t yy_verify;
	flex_int32_t yy_nxt;
	};
static const flex_int16_t yy_accept[1236] =
    {   0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
      182,  182,    0,    0,    0,    0,    0,    0,  201,  200,
      198,  185,  184,   29,  198,  186,  177,  198,   42,   41,
      198,   32,   25,   33,  177,  177,    4,    4,   43,   44,
      198,   38,   24,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  198,  123,  121,   40,  198,   39,   28,  185,  200,
      177,   42,   41,   25,  200,  177,  200,  177,  199,  185,
       29,  199,  186,  180,   35,   26,   42,   41,   31,   32,
       25,   33,  180,   34,    4,    4,   43,   44,   36,   38,

       24,   30,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,   37,   40,   27,
       39,   28,  138,   29,  137,  176,   35,   26,   31,  176,
       34,    4,    4,   44,   36,   38,   24,   30,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,    6,    5,   37,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,   27,   28,  182,   26,  182,
      182,  182,  182,   38,  198,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  182,  182,  182,  182,    6,    5,
      182,  198,  193,  192,  187,  194,  195,  191,  191,  191,

      191,  196,  197,  185,    0,  183,  186,  177,    4,   20,
       18,   16,   17,    1,   19,    4,    4,    0,    0,    0,
      177,  177,  177,  177,  177,  128,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,   22,  177,  177,   21,    0,  178,  177,
       11,  180,    2,   23,   19,    0,    4,    0,    3,    3,
        3,   14,   13,   10,   12,   15,  180,    3,    3,    3,
      180,  180,  128,    3,  180,  180,    3,  180,  180,  180,

      180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,    9,  137,
      137,  176,    2,  139,   18,  140,  176,    3,    3,    3,
      176,  176,  176,    3,  176,    3,    3,  176,  176,  176,
      176,  176,  176,  176,  176,  176,    3,  176,  176,  176,
        3,  176,    3,    3,  176,  176,  176,  176,  176,  176,
      176,  176,  182,   18,   16,   17,   19,  182,  128,  182,
      182,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  182,   22,  192,  191,    0,  191,
      191,  191,    4,    4,    7,    8,  177,  177,  177,  177,

      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,   92,  177,  177,  177,  177,  177,  177,
      177,  177,   70,   61,  177,   62,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  124,  122,  179,  178,
      177,    4,    0,  180,    3,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
       61,   62,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  180,  180,    4,  176,  176,  176,  176,
      176,  141,  176,  176,  176,  176,  176,  176,  176,  176,

      176,  176,  176,  176,  176,  176,  176,  176,  158,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  182,
      182,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  182,  182,  182,  182,  191,  191,
      191,  177,   57,  177,  177,  177,  177,   51,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,   67,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,    0,  180,
       57,  180,  180,   51,  180,  180,  115,  180,  180,  180,

      180,  180,  116,  180,  180,  180,   67,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  117,  176,
      176,  176,  146,  154,  145,  176,  176,  176,  156,  149,
      152,  176,  176,  157,  176,  176,  176,  176,  176,  163,
      171,  162,  176,  176,  174,  166,  169,  176,  176,  175,
      176,  176,  182,  182,   99,  182,  182,  182,   88,  182,
      182,  182,  134,  182,   97,  182,   95,  182,  182,  108,
      182,  191,  191,  191,  177,   86,   53,  177,  177,   50,
      177,  177,  177,   65,  177,   94,  177,   76,  177,  177,
      177,   75,  177,  177,  177,  177,  177,  177,  177,  177,

      177,  177,  177,  177,  127,  177,  177,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,    0,  180,
       53,  180,   50,  180,  180,  180,  114,  180,  180,  180,
      180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
      180,  180,  180,  176,  147,  144,  176,  176,  176,  156,
      156,  151,  176,  155,  176,  176,  164,  161,  176,  176,
      174,  174,  168,  176,  173,  176,  100,  182,  182,  182,
      182,  182,  182,  182,  182,  182,  182,   98,  182,   96,
      191,  191,  189,  177,  177,  177,   64,   87,  177,  177,
      177,   66,  177,  131,  177,  177,   85,  177,   52,  177,

      177,   45,  177,  177,  177,   48,   74,  177,  177,  177,
      177,  177,  177,   71,  177,  177,  177,   93,   72,  177,
      177,    0,  180,  180,  180,   64,  180,  180,  180,  131,
      180,   52,  180,  180,  180,  112,  180,   48,  180,  180,
      180,  180,   71,  180,  180,  176,  176,   66,  153,  176,
      150,  176,  176,  176,  172,  170,  167,  176,   64,  182,
      182,  182,  131,  182,  182,  182,  182,  182,  182,  182,
      190,  188,  177,   59,  177,  177,  177,   78,  177,  177,
      126,  177,  177,  177,  177,  177,  102,  177,  177,  105,
      132,  177,  177,  177,  177,  177,  120,   89,  177,   49,

      177,    0,  180,   59,  180,  180,  180,   78,  126,  180,
      180,  180,  180,  105,  132,  180,  180,  180,  120,  180,
      176,  176,  126,  176,  176,  176,  176,  182,  182,  182,
      126,  182,  182,  132,  111,  182,  182,   60,  177,  136,
      177,  177,  177,  177,  177,   58,   63,  177,  177,  177,
      177,  177,  177,  177,   84,  177,  177,  130,  177,    0,
       60,  180,  136,  180,   58,   63,  180,  180,  180,  113,
      180,  180,  130,  142,  143,  148,  159,  160,  165,  182,
      182,  182,  182,  182,  182,  182,  182,  177,  177,  177,
      177,  177,  177,  177,  177,  177,  177,  177,  177,  177,

      177,  177,   77,  181,  180,  180,  180,  180,  180,  180,
      180,  182,  182,  182,  182,  182,  182,  182,  182,  182,
      110,  177,  177,  177,  177,  177,   47,  177,  118,  119,
      177,  177,  177,  177,   73,  177,  177,  180,  180,  180,
      118,  119,  180,  180,  180,  182,  182,  182,  182,  182,
      182,  182,  182,  182,  177,  177,  177,  177,  177,  103,
       91,  177,  177,  177,  177,  177,  180,  180,  103,  180,
      180,  180,  182,  182,  182,  182,  182,  182,  182,  182,
      182,  177,  177,  177,  177,  177,  177,  177,  177,   46,
      177,  177,  180,  180,  180,  180,  180,  180,   80,  182,

      135,  182,  182,  182,  182,  182,  106,  177,  177,  177,
      177,  177,  177,   90,  177,   69,  177,  180,  180,  180,
      180,   69,  180,  182,  182,  182,  182,  182,  182,  177,
      177,  177,  177,  177,  177,  177,  104,  133,   68,  180,
      180,  180,  180,  104,  133,   68,  182,  182,  101,  133,
      182,  182,  177,  177,  177,  177,  177,  177,  177,  180,
      180,  180,  180,  182,  182,  182,  182,  129,  177,   56,
      177,  177,  177,  177,  129,  180,   56,  180,  182,  182,
      182,  182,  177,  177,  177,  177,  177,  180,  180,  182,
      182,  107,  182,   54,  177,  177,  177,  177,   54,  180,

      182,  182,  182,  177,  177,  177,  177,  180,  182,  125,
      182,  177,  177,  177,  177,  180,  182,  182,  177,  177,
      177,  177,  180,   79,  109,   55,  177,   82,  177,   55,
       81,  177,  177,   83,    0
    } ;

static const YY_CHAR yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    2,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    2,    4,    5,    6,    7,    8,    9,    1,   10,
       11,   12,   13,   14,   15,   16,   17,   18,   19,   20,
       19,   19,   19,   19,   19,   19,   19,   21,   22,   23,
       24,   25,   26,    1,   27,   28,   29,   30,   31,   32,
       33,   34,   35,   36,   37,   38,   39,   40,   41,   42,
       43,   44,   45,   46,   47,   48,   49,   50,   51,   52,
       53,   54,   55,   56,   57,    1,   58,   59,   60,   61,

       62,   63,   64,   65,   66,   16,   67,   68,   69,   70,
       71,   72,   16,   73,   74,   75,   76,   16,   16,   77,
       16,   16,   78,   79,   80,   81,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,

        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1
    } ;

static const YY_CHAR yy_meta[82] =
    {   0,
        1,    1,    2,    3,    1,    1,    4,    1,    1,    1,
        1,    3,    5,    6,    7,    8,    9,   10,   10,   10,
        7,    1,    1,    6,    1,    3,   11,   11,   11,   11,
       11,   11,    8,    8,    8,    8,    8,    8,    8,    8,
        8,    8,    8,    8,    8,    8,    8,    8,    8,    8,
        8,    8,    7,    4,    7,    3,    8,   11,   11,   11,
       11,   11,   11,    8,    8,    8,    8,    8,    8,    8,
        8,    8,    8,    8,    8,    8,    8,    1,    1,    1,
        9
    } ;

static const flex_int16_t yy_base[1260] =
    {   0,
        0,    0,    0,    0,   81,  161,  241,    0,  322,    0,
      403,    0,  111,  113,  484,  565,  646,  727, 2144, 2145,
     2145, 2141, 2145, 2145, 2137,    0,  791, 2117, 2145, 2145,
     2116, 2115, 2145, 2114,    0,   85,  654,  735, 2145, 2145,
     2114, 2145, 2111,   93,   89, 2094,   91,   92,   88, 2090,
      105, 2093,  114,  119,  110,  109,  114, 2101,  159, 2104,
     2099, 2105, 2066, 2054, 2145, 2102, 2145,    0, 2123, 2119,
        0, 2145, 2145, 2145, 2055, 2110,    0, 2076, 2145, 2118,
     2095, 2113,    0,  837, 2145,  168, 2145, 2145, 2093, 2092,
     2145, 2091,    0,  183,  883,  143, 2145, 2145,   87, 2090,

      172, 2145,  943,  191,  483,  487,  506, 2078, 2072,  167,
      176,  168,  183, 2067, 2079,  488, 2058, 2084, 2145,  123,
     2145, 2145, 2145, 2083, 2103, 1003, 2145,  191, 2081,    0,
     2080,    0,  450,    0,  201, 2079,  208, 2145, 1049,  515,
      520,  184,  564,  518, 2062,  193, 2074, 2056, 2052,  485,
     2054, 2145, 2145, 2073,  565,  567,  569,  612,  484,  164,
     2038, 2022, 2018,  519, 2020,  517,    0,    0, 2068, 2067,
     2066, 2065, 2064,    0, 2062,  504, 2035,  516, 2035, 2049,
     2048, 2042, 2050,  485, 2036, 2032, 2047,  565,    0,    0,
     2053, 2064, 2145,    0, 2145, 2145, 2145, 2054,   91,   67,

      540, 2145, 2145, 2072, 2068, 2145,    0,    0, 1109, 2145,
     2145, 2145, 2145, 2145,    0,  745, 2145,    0, 2048, 2047,
     2025, 2039, 2022, 2032, 2021,    0, 2033, 2024, 2022, 2022,
     2015, 2028, 2013, 2012, 2016, 2012, 2014, 2024, 2015,  581,
     1995, 2011,  589,  559, 2011, 2009, 1998,  599, 2009, 2011,
     1999, 2013, 2013, 2001, 2008,  603, 1988, 2008, 2011, 2009,
     1991, 1991, 1990, 2145, 1963, 1968, 2145,    0,    0, 1974,
     2145,    0, 1161, 2145, 2145, 1995,  495,  748,    0, 2145,
        0, 2005, 2145, 2145, 2145, 2004,  649,  660,  671,    0,
     1992, 1981,    0,  731, 1985, 1983,  558,  796,  799, 1992,

     1992,  606, 1981,  648, 1970, 1979, 1968,  624, 1979, 1981,
     1984, 1973, 1986, 1979, 1959, 1979, 1981, 1966, 2145, 2004,
     2145,    0, 1213,    0,    0,    0,  601,  658,  664,    0,
     1971,  743,  745, 1970, 1974, 1957, 1958, 1972, 1955, 1972,
     1959, 1967, 1968, 1966, 1967, 1946,  669, 1926,  684,  742,
     1925, 1929, 1914, 1915, 1913, 1928, 1916, 1923, 1924, 1922,
     1923, 1904,    0,    0,    0,    0,    0,  613,    0, 1933,
     1938, 1946, 1947, 1937, 1944,  671, 1942, 1932, 1931, 1929,
     1942, 1920, 1926, 1922, 1918,    0,    0, 1943, 1942,  640,
      663,  616,    0,  791, 2145, 2145, 1921, 1917, 1929, 1926,

     1927, 1916, 1926, 1926, 1909, 1926, 1917, 1907, 1919, 1922,
     1919, 1900, 1916,    0, 1907, 1909, 1896, 1911, 1909, 1907,
     1909, 1918,    0,    0, 1896,    0, 1890, 1891, 1896, 1882,
     1899, 1889, 1886, 1885, 1880, 1892, 1882, 1879, 1885, 1892,
     1893, 1877, 1893, 1881, 1885, 1872,    0,    0,    0,    0,
     1876,    0, 1870, 1873,  833, 1880, 1881, 1881, 1881, 1864,
     1857, 1880,  845, 1877, 1875, 1866, 1862, 1869, 1871, 1880,
        0,    0, 1853, 1854, 1856, 1845, 1862, 1850, 1845, 1862,
     1852, 1859, 1860, 1861, 1856,    0, 1845,  729, 1854, 1853,
     1841,    0, 1851, 1842, 1842, 1833, 1848, 1846, 1845, 1837,

     1828, 1829, 1832, 1800,  728, 1808, 1807, 1796,    0, 1805,
     1797, 1790, 1803, 1801, 1800, 1793, 1785, 1786, 1788, 1822,
     1825, 1824, 1809, 1826, 1814, 1813, 1820, 1811, 1801, 1805,
     1809, 1812, 1796, 1813, 1811, 1797, 1794, 1812,  657,  659,
      662, 1800,    0, 1793, 1796, 1791, 1790,    0, 1796, 1786,
     1774, 1790, 1778, 1775, 1762, 1766, 1744, 1733, 1714, 1732,
     1709, 1691, 1693, 1671, 1672, 1669, 1653,    0, 1653, 1650,
     1633, 1654, 1623, 1561, 1553, 1562, 1555, 1566, 1559, 1562,
     1551, 1556, 1544, 1551, 1553, 1556, 1551, 1554, 1555, 1545,
        0, 1542, 1537,    0, 1543, 1533,    0, 1520, 1536, 1529,

     1543, 1526,    0, 1526, 1544, 1541,    0, 1528, 1541, 1510,
     1531, 1527, 1529, 1522, 1531, 1520, 1525, 1521,    0, 1520,
     1512, 1516,    0,    0,    0, 1511, 1527, 1506, 1282,    0,
        0, 1508, 1516,    0, 1504, 1520, 1475, 1468, 1471,    0,
        0,    0, 1467, 1481, 1362,    0,    0, 1465, 1471,    0,
     1460, 1469, 1473, 1475,    0, 1472, 1471, 1469,    0, 1484,
     1467, 1467,    0, 1481,    0, 1476,    0, 1466, 1463, 1451,
     1477,  131,  721,  772, 1459,    0,  737, 1459, 1473,    0,
     1476, 1457, 1470,    0, 1460,    0, 1442,    0, 1457, 1466,
     1460,    0, 1448, 1466, 1458, 1461, 1459, 1438, 1443, 1460,

     1451, 1445, 1438, 1456,    0, 1452, 1441, 1446, 1438, 1438,
     1445, 1449, 1428, 1439, 1445, 1426, 1430, 1439, 1442, 1416,
      756, 1416,    0, 1434, 1415, 1428,    0, 1418, 1427, 1421,
     1419, 1414, 1394, 1408, 1402, 1396, 1408, 1404, 1393, 1392,
     1399, 1403, 1394, 1381,    0, 1388, 1386, 1379, 1394,    0,
     1442,    0, 1394,    0, 1395, 1345,    0, 1351, 1349, 1342,
        0, 1522,    0, 1356,    0, 1357,    0, 1368, 1369, 1381,
     1381, 1370, 1379, 1351, 1363, 1376, 1360,    0,  807,    0,
      690,  775, 1383, 1357, 1370, 1352,    0,    0, 1360, 1368,
     1368,    0,  584,    0, 1366, 1350,    0, 1349,    0,  103,

      183,    0,  193,  445,  580,    0,  584,  634,  708,  700,
      718,  759,  754,  744,  765,  790,  800,    0,    0,  796,
      808,  795,  800,  816,  810,    0,  822,  839,  842,    0,
      843,    0,  846,  846,  837,    0,  852,    0,  834,  855,
      849,  842,  832,  854,  860,  848,  863,    0,    0,  874,
        0,  860,  832,  837,    0,    0,    0,  834,    0,  869,
      861,  888,    0,  890,  878,  868,  895,  896,  877,  888,
      909,  910,  901,    0,  899,  889,  903,    0,  896,  894,
        0,  882,  893,  903,  911,  907,    0,  896,  932,    0,
      898,  929,  927,  913,  908,  932,    0,    0,  927,    0,

      937,  939,  945,    0,  943,  933,  947,    0,    0,  938,
      945,  941,  929,    0,  930,  939,  934,  958,    0,  954,
      964,  966,    0,  966,  936,  938,  938,  978,  968,  953,
        0,  980,  964,  956,    0,  958,  976,    0,  971,    0,
      979,  980,  983,  996,  982,    0,    0,  996,  984,  985,
      995, 1003, 1000, 1004,    0,  995, 1010,    0, 1012, 1026,
        0,  998,    0, 1006,    0,    0, 1015, 1003, 1014,    0,
     1004, 1019,    0,    0,    0,    0,    0,    0,    0, 1005,
     1024, 1021, 1025, 1024, 1022, 1057, 1026, 1024, 1028, 1021,
     1023, 1030, 1041, 1041, 1033, 1046, 1041, 1051, 1053, 1045,

     1045, 1066,    0, 2145, 1060, 1064, 1064, 1057, 1065, 1055,
     1075, 1062, 1068, 1070, 1067, 1071, 1081, 1079, 1078, 1092,
        0, 1064, 1082, 1082, 1082, 1086,    0, 1085,    0,    0,
     1097, 1093, 1103, 1107,    0, 1108, 1112, 1086, 1104, 1100,
        0,    0, 1117, 1122, 1120, 1107, 1121, 1115, 1119, 1110,
     1126, 1122, 1123, 1120, 1125, 1115, 1122, 1106, 1125, 1108,
        0, 1139, 1143, 1129, 1131, 1146, 1147, 1137, 1127, 1155,
     1142, 1156, 1149, 1166, 1165, 1156, 1164, 1171, 1169, 1157,
     1173, 1165, 1149, 1150, 1181, 1168, 1164, 1165, 1181,    0,
     1167, 1170, 1175, 1159, 1171, 1187, 1179, 1182,    0, 1181,

        0, 1189, 1193, 1204, 1196, 1180,    0, 1196, 1220, 1212,
     1208, 1208, 1208,    0, 1213,    0, 1209, 1213, 1234, 1215,
     1217,    0, 1213, 1202, 1203, 1222, 1223, 1227, 1225, 1221,
     1231, 1230, 1246, 1241, 1243, 1228,    0,    0,    0, 1242,
     1257, 1257, 1267,    0,    0,    0, 1254, 1268,    0,    0,
     1270, 1258, 1257, 1274, 1280, 1273, 1274, 1272, 1287, 1269,
     1281, 1287, 1280, 1268, 1282, 1281, 1287,    0, 1290,    0,
     1280, 1284, 1297, 1289,    0, 1295,    0, 1285, 1291, 1304,
     1286, 1292, 1294, 1294, 1307, 1310, 1301, 1300, 1300, 1314,
     1310,    0, 1300,    0, 1288, 1319, 1301, 1307,    0, 1292,

     1309, 1306, 1317, 1322, 1308, 1320, 1327, 1326, 1320,    0,
     1313, 1325, 1334, 1334, 1350, 1338, 1334, 1329, 1351, 1341,
     1343, 1343, 1360,    0,    0,    0, 1351,    0, 1357,    0,
        0, 1352, 1354,    0, 2145, 1602, 1613, 1624, 1635, 1646,
     1657, 1668, 1676, 1684, 1692, 1703, 1711, 1722, 1733, 1742,
     1746, 1755, 1757, 1765, 1773, 1784, 1795, 1806, 1817
    } ;

static const flex_int16_t yy_def[1260] =
    {   0,
     1236, 1236, 1235,    3, 1237, 1237, 1235,    7, 1235,    9,
     1235,   11, 1238, 1238, 1239, 1239, 1240, 1240, 1235, 1235,
     1235, 1235, 1235, 1235, 1241, 1242, 1243, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1243, 1243, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1235, 1243, 1243, 1235, 1235, 1235, 1243, 1235, 1241,
     1243, 1235, 1235, 1235, 1235, 1243, 1244, 1243, 1235, 1235,
     1235, 1241, 1242, 1245, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1245, 1235, 1235,   95, 1235, 1235, 1235, 1235,

     1235, 1235, 1245,  103,  103,  103,  103, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1246, 1247, 1235, 1235, 1248, 1247,
     1247,   95,   95, 1249, 1235, 1235, 1235, 1235, 1247,  139,
      139,  139,  139,  139, 1247, 1247, 1247, 1247, 1247, 1247,
     1247, 1235, 1235, 1235,  139,  139,  139,  139,  139, 1247,
     1247, 1247, 1247, 1247, 1247, 1235, 1247, 1250, 1235, 1250,
     1250, 1250, 1250, 1250, 1235, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1235, 1235, 1251, 1235, 1235, 1235, 1252, 1252, 1252,

     1252, 1235, 1235, 1235, 1241, 1235, 1242, 1243, 1243, 1235,
     1235, 1235, 1235, 1235, 1243, 1235, 1235, 1253, 1235, 1235,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1235, 1243, 1243, 1235, 1254, 1255, 1243,
     1235, 1245, 1245, 1235, 1235, 1235,   95,   95,  278, 1235,
     1253, 1235, 1235, 1235, 1235, 1235,  103,  103,  103, 1245,
     1245, 1245, 1245,  103, 1245, 1245, 1245,  103,  103, 1245,

     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1235, 1246,
     1235, 1247, 1247, 1248, 1248, 1249,  139,  139,  139, 1247,
     1247,  139,  139, 1247, 1247, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1247, 1247, 1247, 1247,  139, 1247,  139,  139,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1251, 1252, 1235, 1252,
     1252, 1252, 1243, 1253, 1235, 1235, 1243, 1243, 1243, 1243,

     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1254, 1255,
     1243, 1245, 1235, 1245,  103, 1245, 1245, 1245, 1245, 1245,
     1245, 1245,  103, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247,

     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1252, 1252,
     1252, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1235, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,

     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1247,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1256, 1247,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1247, 1247, 1257, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1252, 1252, 1252, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,

     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1235, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1247, 1247, 1247, 1247, 1247, 1247, 1258,
     1256, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247,
     1259, 1257, 1247, 1247, 1247, 1247, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1252, 1252, 1252, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,

     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1235, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1247, 1247, 1247, 1247, 1247,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1247, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1252, 1252, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,

     1243, 1235, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1247, 1247, 1247, 1247, 1247, 1247, 1247, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1235,
     1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1245, 1245, 1247, 1247, 1247, 1247, 1247, 1247, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,

     1243, 1243, 1243, 1235, 1245, 1245, 1245, 1245, 1245, 1245,
     1245, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1245, 1245, 1245,
     1245, 1245, 1245, 1245, 1245, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1250, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1245, 1245, 1245, 1245,
     1245, 1245, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243,
     1243, 1243, 1245, 1245, 1245, 1245, 1245, 1245, 1250, 1250,

     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1245, 1245, 1245,
     1245, 1245, 1245, 1250, 1250, 1250, 1250, 1250, 1250, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1245,
     1245, 1245, 1245, 1245, 1245, 1245, 1250, 1250, 1250, 1250,
     1250, 1250, 1243, 1243, 1243, 1243, 1243, 1243, 1243, 1245,
     1245, 1245, 1245, 1250, 1250, 1250, 1250, 1243, 1243, 1243,
     1243, 1243, 1243, 1243, 1245, 1245, 1245, 1245, 1250, 1250,
     1250, 1250, 1243, 1243, 1243, 1243, 1243, 1245, 1245, 1250,
     1250, 1250, 1250, 1243, 1243, 1243, 1243, 1243, 1245, 1245,

     1250, 1250, 1250, 1243, 1243, 1243, 1243, 1245, 1250, 1250,
     1250, 1243, 1243, 1243, 1243, 1245, 1250, 1250, 1243, 1243,
     1243, 1243, 1245, 1250, 1250, 1243, 1243, 1243, 1243, 1245,
     1243, 1243, 1243, 1243,    0, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235
    } ;

static const flex_int16_t yy_nxt[2227] =
    {   0,
       21,   22,   23,   24,   25,   26,   27,   21,   28,   29,
       30,   31,   32,   33,   34,   35,   36,   37,   38,   38,
       39,   40,   41,   42,   43,   21,   44,   45,   46,   47,
       48,   49,   50,   51,   52,   35,   35,   53,   54,   55,
       56,   57,   35,   58,   59,   60,   35,   61,   35,   35,
       35,   35,   21,   35,   21,   62,   35,   35,   35,   35,
       35,   35,   35,   35,   35,   35,   35,   63,   35,   35,
       64,   35,   35,   35,   35,   35,   35,   65,   66,   67,
       68,   20,   69,   23,   20,   70,   20,  389,   20,   20,
       72,   73,   20,   20,   74,   75,  214,   76,   20,   20,

       20,   20,   20,   20,   77,   20,   20,   78,  215,  282,
      283,  389,   22,   23,   22,   23,   26,  231,   26,  227,
      221,  232,  222,  228,  223,  235,  229,  192,  236,  192,
      224,  233,  884,   20,  391,   20,   20,  225,  226,  238,
      247,  234,  239,  241,  242,  244,  267,  253,  249,  245,
      248,  389,  250,  246,  243,  251,  252,  254,   20,   20,
       20,   20,   69,   23,   20,   70,   20,  390,   20,   20,
       72,   73,   20,   20,   74,   75,  274,   76,   20,   20,
       20,   20,   20,   20,   77,   20,   20,   78,  193,  256,
      193,  210,  280,  257,  214,  285,  286,  303,  307,  274,

      258,  319,  305,  781,  259,  260,  275,  304,  308,  261,
      306,  329,  276,   20,  210,   20,   20,  885,  294,  280,
      294,  322,  309,  282,  283,  295,  310,  339,  296,  355,
      311,  285,  286,  340,  356,  272,  272,  886,   20,   20,
       20,   79,   80,   23,   81,   82,   83,   84,   85,   86,
       87,   88,   89,   90,   91,   92,   93,   94,   95,   96,
       96,   97,   98,   99,  100,  101,  102,  103,  104,  105,
      106,  107,  107,   93,  108,  109,   93,   93,  110,  111,
      112,  113,  114,   93,  115,  116,  117,   93,   93,   93,
       93,   93,   93,   79,   93,   79,  118,   93,  107,  107,

      107,  107,  107,  107,   93,   93,   93,   93,   93,   93,
       93,   93,   93,   93,   93,   93,   93,   93,  119,  120,
      121,  122,   21,   22,  123,  124,   21,  125,  126,  127,
      128,   29,   30,  129,   32,   33,   34,  130,  131,  132,
      133,  133,   39,  134,  135,  136,  137,  138,  139,  140,
      141,  142,  143,  144,  130,  130,  145,  130,  130,  146,
      130,  147,  148,  149,  130,  130,  150,  151,  130,  130,
      130,  130,  130,  130,  152,  130,  153,  154,  130,  155,
      156,  157,  142,  158,  159,  130,  130,  130,  130,  160,
      130,  161,  162,  163,  130,  164,  165,  130,  130,   65,

      166,   67,  167,   21,   22,   23,  168,   25,   26,  168,
       21,  169,   29,   30,  170,  171,  168,  172,  168,  173,
      168,  168,  168,  168,   40,   41,  174,  175,  168,  176,
      177,  178,  168,  179,  180,  168,  181,  182,  168,  183,
      184,  168,  168,  168,  185,  186,  187,  188,  168,  168,
      168,  168,  168,  168,  168,  189,  168,  190,  191,  168,
      168,  168,  168,  168,  168,  168,  168,  168,  168,  168,
      168,  168,  168,  168,  168,  168,  168,  168,  168,  168,
       65,   66,   67,  168,   21,   22,   23,   21,   21,   26,
      887,   21,   21,   21,   21,   21,   21,  195,   21,  280,

      192,   21,   21,   21,  195,  195,   21,   21,   21,   21,
      294,  329,  294,  298,  294,  344,  294,  299,  314,  378,
      272,  322,  315,  297,  272,  379,  280,  272,  272,  316,
      345,  300,  272,  294,  317,  294,   21,   21,   21,   21,
      267,  332,  329,  272,  280,  329,  333,  329,  368,  369,
      272,  272,  322,  334,  354,  322,  371,  322,  337,  372,
      389,  196,   21,  197,   21,   21,   22,   23,   21,   21,
       26,  280,   21,   21,   21,   21,   21,   21,  195,   21,
      360,  192,   21,   21,   21,  195,  195,   21,   21,   21,
       21,  329,  329,  361,  329,  319,  329,  460,  383,  461,

      423,  322,  322,  335,  322,  384,  322,  385,  424,  415,
      392,  888,  879,  336,  416,  421,  880,   21,   21,   21,
       21,  422,  417,  347,  349,  418,  350,  428,  329,  437,
      429,  438,  348,  351,  466,  439,  389,  467,  322,  329,
      889,  520,  196,   21,  197,   21,   21,   22,   23,  322,
       25,   26,  474,   21,   21,   21,   21,  521,   21,  195,
      389,  475,  192,   21,   21,   21,  195,  195,   21,   21,
       21,  216,  216,  216,  469,  541,  294,  389,  294,  389,
      470,  352,  389,  389,  890,  329,  272,  294,  353,  294,
      217,  329,  217,  272,  272,  322,  329,  272,  294,  528,

      455,  322,  487,  218,  454,  272,  322,  199,  272,  200,
      389,  329,  529,  201,  539,  272,  272,  673,  672,  674,
      217,  322,  217,  202,   21,  203,   21,   21,   22,   23,
      218,   25,   26,  540,   21,   21,   21,   21,  891,   21,
      195,  389,  504,  192,   21,   21,   21,  195,  195,   21,
       21,   21,  216,  216,  216,  621,  892,  506,  294,  871,
      294,  622,  216,  216,  216,  278,  278,  278,  272,  329,
      329,  217,  329,  217,  893,  272,  272,  785,  782,  322,
      322,  217,  322,  217, 1235,  638, 1235,  489,  199,  490,
      200,  639,  389,  786,  201,  389,  824,  280,  894,  895,

      896,  217,  897,  217,  202,   21,  203,   21,  209,  209,
      209,  217,  825,  217, 1235,  507, 1235,  209,  209,  209,
      209,  209,  209,  294,  280,  294,  294,  217,  294,  217,
      463,  898,  899,  272,  869,  900,  272,  901,  902,  783,
      272,  462,  872,  272,  272,  903,  870,  904,  209,  209,
      209,  209,  209,  209,  273,  273,  273,  217,  905,  217,
      294,  906,  294,  273,  273,  273,  273,  273,  273,  907,
      272,  908,  294,  909,  294,  910,  591,  272,  272,  599,
      911,  912,  272,  913,  914,  915,  916,  917,  918,  272,
      272,  919,  920,  921,  273,  273,  273,  273,  273,  273,

      277,  277,  277,  922,  923,  924,  925,  926,  927,  278,
      279,  278,  279,  278,  278,  928,  280,  929,  930,  217,
      931,  217,  932,  280,  933,  934,  935,  936,  937,  389,
      389,  938,  281,  939,  940,  941,  942,  943,  944,  945,
      278,  279,  278,  279,  278,  278,  946,  280,  947,  217,
      948,  217,  949,  280,  952,  953,  954,  955,  950,  281,
      287,  287,  287,  951,  956,  957,  958,  959,  960,  287,
      288,  287,  289,  287,  287,  961,  290,  962,  963,  964,
      291,  965,  966,  290,  967,  968,  969,  292,  293,  970,
      971,  972,  290,  973,  974,  975,  976,  977,  978,  979,

      287,  294,  287,  294,  287,  287,  980,  290,  981,  982,
      983,  984,  985,  290,  986,  987,  988,  989,  990,  290,
      323,  323,  323,  991,  992,  993,  994,  995,  996,  323,
      323,  323,  323,  323,  323,  997,  998,  999, 1000, 1001,
     1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011,
     1012, 1013, 1014, 1015, 1016, 1017, 1021, 1022, 1023, 1024,
      323,  323,  323,  323,  323,  323,  327,  327,  327, 1025,
     1026, 1027, 1028, 1029, 1031,  327,  328,  327,  329,  327,
      327, 1030,  330, 1018, 1032, 1033,  331, 1034, 1035,  330,
     1036, 1019, 1037, 1038, 1039, 1040, 1020, 1041,  330, 1043,

     1044, 1045, 1046, 1047, 1048, 1042,  327,  329,  327,  329,
      327,  327, 1049,  330, 1050, 1051, 1052, 1053, 1054,  330,
     1055, 1056, 1057, 1058, 1059,  330,  209,  209,  209, 1060,
     1061, 1062, 1063, 1064, 1065,  209,  209,  209,  209,  209,
      209, 1066, 1067, 1068, 1069,  393, 1070,  393, 1071, 1072,
     1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082,
     1083, 1084, 1085, 1086, 1087, 1088,  209,  209,  209,  209,
      209,  209, 1089, 1090, 1091,  393, 1092,  393,  273,  273,
      273, 1093, 1094, 1095, 1096, 1097, 1098,  273,  273,  273,
      273,  273,  273, 1099, 1100, 1101, 1102,  452, 1103,  452,

     1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113,
     1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121,  273,  273,
      273,  273,  273,  273, 1122, 1123, 1124,  452, 1125,  452,
      323,  323,  323, 1126, 1127, 1128, 1129, 1130, 1134,  323,
      323,  323,  323,  323,  323, 1135, 1131, 1136, 1137,  486,
     1132,  486, 1138, 1139, 1140, 1144, 1145, 1146, 1147, 1148,
     1141, 1149, 1150, 1133, 1142, 1151, 1152, 1153, 1154, 1155,
      323,  323,  323,  323,  323,  323, 1156, 1143, 1157,  486,
     1158,  486,  750,  750, 1159,  750,  750,  750, 1160,  750,
      750,  750,  750,  750, 1161,  750, 1162, 1163, 1164, 1165,

     1166, 1167, 1168,  750,  750,  750,  750,  750, 1169, 1170,
     1171, 1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180,
     1181, 1182, 1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190,
     1191, 1192, 1193, 1194, 1195, 1196, 1197,  750, 1198, 1199,
     1200, 1201, 1202, 1203, 1204, 1205, 1206, 1207, 1208, 1209,
     1210, 1211, 1212, 1213, 1214, 1215, 1216, 1217, 1218,  750,
      750,  750,  761,  761, 1219,  761,  761,  761, 1220,  761,
      761,  761,  761,  761, 1221,  761, 1222, 1223, 1224, 1225,
     1226, 1227, 1228,  761,  761,  761,  761,  761, 1229, 1230,
     1231, 1232, 1233, 1234,  883,  882,  881,  878,  877,  876,

      875,  874,  873,  389,  868,  867,  866,  865,  864,  863,
      862,  861,  860,  859,  858,  857,  856,  761,  855,  854,
      853,  852,  851,  850,  849,  848,  847,  846,  845,  844,
      843,  842,  841,  840,  839,  838,  837,  836,  835,  761,
      761,  761,  750,  750,  834,  750,  750,  750,  833,  750,
      750,  750,  750,  750,  832,  750,  831,  830,  829,  828,
      827,  826,  823,  750,  750,  750,  750,  750,  822,  821,
      820,  819,  818,  817,  816,  815,  814,  813,  812,  811,
      810,  809,  808,  807,  806,  805,  804,  803,  802,  801,
      800,  799,  798,  797,  796,  795,  794,  750,  793,  792,

      791,  790,  789,  788,  787,  784,  780,  779,  778,  777,
      776,  775,  774,  773,  772,  771,  770,  769,  768,  750,
      750,  750,  761,  761,  767,  761,  761,  761,  766,  761,
      761,  761,  761,  761,  765,  761,  764,  763,  760,  759,
      758,  757,  756,  761,  761,  761,  761,  761,  755,  754,
      753,  752,  749,  748,  747,  746,  745,  744,  743,  742,
      741,  740,  739,  738,  737,  736,  735,  734,  733,  732,
      731,  730,  729,  728,  727,  726,  725,  761,  724,  723,
      722,  721,  720,  719,  718,  717,  716,  715,  714,  713,
      712,  711,  710,  709,  708,  707,  706,  705,  704,  761,

      761,  761,   20,   20,   20,   20,   20,   20,   20,   20,
       20,   20,   20,   71,   71,   71,   71,   71,   71,   71,
       71,   71,   71,   71,   21,   21,   21,   21,   21,   21,
       21,   21,   21,   21,   21,  194,  194,  194,  194,  194,
      194,  194,  194,  194,  194,  194,  198,  198,  198,  198,
      198,  198,  198,  198,  198,  198,  198,  205,  205,  205,
      205,  205,  205,  205,  205,  205,  205,  205,  207,  703,
      207,  207,  207,  207,  207,  207,  207,  207,  207,  208,
      208,  208,  208,  208,  208,  208,  208,  269,  702,  701,
      700,  269,  269,  699,  269,  272,  698,  697,  696,  272,

      272,  272,  272,  320,  320,  320,  320,  320,  320,  320,
      320,  320,  320,  320,  322,  322,  695,  322,  322,  322,
      322,  322,  324,  694,  324,  324,  324,  324,  324,  324,
      324,  324,  324,  326,  693,  326,  326,  326,  326,  326,
      326,  326,  326,  326,  363,  363,  363,  363,  363,  363,
      363,  363,  363,  387,  692,  387,  387,  388,  388,  691,
      690,  388,  388,  689,  388,  388,  394,  394,  449,  449,
      449,  449,  449,  449,  449,  449,  450,  450,  450,  450,
      450,  450,  450,  450,  751,  688,  751,  751,  751,  751,
      751,  751,  751,  751,  751,  762,  687,  762,  762,  762,

      762,  762,  762,  762,  762,  762,  750,  686,  750,  750,
      750,  750,  750,  750,  750,  750,  750,  761,  685,  761,
      761,  761,  761,  761,  761,  761,  761,  761,  684,  683,
      682,  681,  680,  679,  678,  677,  676,  675,  671,  670,
      669,  668,  667,  666,  665,  664,  663,  662,  661,  660,
      659,  658,  657,  656,  655,  654,  653,  652,  651,  650,
      649,  648,  647,  646,  645,  644,  643,  642,  641,  640,
      637,  636,  635,  634,  633,  632,  631,  630,  629,  628,
      627,  626,  625,  624,  623,  620,  619,  618,  617,  616,
      615,  614,  613,  612,  611,  610,  609,  608,  607,  606,

      605,  604,  603,  602,  601,  600,  598,  597,  596,  595,
      594,  593,  592,  590,  589,  588,  587,  586,  585,  584,
      583,  582,  581,  580,  579,  578,  577,  576,  575,  574,
      573,  572,  571,  570,  569,  568,  567,  566,  565,  564,
      563,  562,  561,  560,  559,  558,  557,  556,  555,  554,
      553,  552,  551,  550,  549,  548,  547,  546,  545,  544,
      543,  542,  388,  389,  538,  537,  536,  535,  534,  533,
      532,  531,  530,  527,  526,  525,  524,  523,  522,  519,
      518,  517,  516,  515,  514,  513,  512,  511,  510,  509,
      508,  505,  503,  502,  501,  500,  499,  498,  497,  496,

      495,  494,  493,  492,  491,  488,  321,  485,  484,  483,
      482,  481,  480,  479,  478,  477,  476,  473,  472,  471,
      468,  465,  464,  459,  458,  457,  456,  396,  395,  453,
      451,  448,  447,  446,  445,  444,  443,  442,  441,  440,
      436,  435,  434,  433,  432,  431,  430,  427,  426,  425,
      420,  419,  414,  413,  412,  411,  410,  409,  408,  407,
      406,  405,  404,  403,  402,  401,  400,  399,  398,  397,
      396,  395,  206,  204,  389,  214,  386,  382,  381,  380,
      377,  376,  375,  374,  373,  370,  220,  367,  366,  365,
      364,  210,  362,  359,  358,  357,  264,  346,  343,  342,

      341,  338,  284,  275,  325,  321,  271,  264,  318,  313,
      312,  302,  301,  284,  213,  212,  211,  206,  271,  204,
      270,  214,  268,  206,  204,  267,  266,  265,  264,  263,
      262,  255,  240,  237,  230,  220,  219,  213,  212,  211,
      210,  206,  204, 1235,   19, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,

     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235
    } ;

static const flex_int16_t yy_chk[2227] =
    {   0,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    5,    5,    5,    5,    5,    5,  200,    5,    5,
        5,    5,    5,    5,    5,    5,   36,    5,    5,    5,

        5,    5,    5,    5,    5,    5,    5,    5,   36,   99,
       99,  199,   13,   13,   14,   14,   13,   47,   14,   45,
       44,   47,   44,   45,   44,   49,   45,   13,   49,   14,
       44,   48,  800,    5,  200,    5,    5,   44,   44,   51,
       55,   48,   51,   53,   53,   54,  120,   57,   56,   54,
       55,  672,   56,   54,   53,   56,   56,   57,    5,    5,
        5,    6,    6,    6,    6,    6,    6,  199,    6,    6,
        6,    6,    6,    6,    6,    6,   86,    6,    6,    6,
        6,    6,    6,    6,    6,    6,    6,    6,   13,   59,
       14,   86,   96,   59,   94,  101,  101,  110,  112,  128,

       59,  120,  111,  672,   59,   59,   94,  110,  112,   59,
      111,  142,   94,    6,  128,    6,    6,  801,  104,   96,
      104,  142,  113,  135,  135,  104,  113,  146,  104,  160,
      113,  137,  137,  146,  160,  104,  104,  803,    6,    6,
        6,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,

        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
        7,    7,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,

        9,    9,    9,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   15,   15,   15,   15,   15,   15,
      804,   15,   15,   15,   15,   15,   15,   15,   15,  133,

       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
      105,  159,  105,  106,  106,  150,  106,  106,  116,  184,
      105,  159,  116,  105,  106,  184,  133,  105,  105,  116,
      150,  106,  106,  107,  116,  107,   15,   15,   15,   15,
      166,  140,  140,  107,  277,  144,  141,  141,  176,  176,
      107,  107,  140,  141,  159,  144,  178,  141,  144,  178,
      201,   15,   15,   15,   15,   16,   16,   16,   16,   16,
       16,  277,   16,   16,   16,   16,   16,   16,   16,   16,
      164,   16,   16,   16,   16,   16,   16,   16,   16,   16,
       16,  143,  155,  164,  156,  166,  157,  297,  188,  297,

      244,  143,  155,  143,  156,  188,  157,  188,  244,  240,
      201,  805,  793,  143,  240,  243,  793,   16,   16,   16,
       16,  243,  240,  155,  156,  240,  157,  248,  327,  256,
      248,  256,  155,  157,  302,  256,  392,  302,  327,  158,
      807,  368,   16,   16,   16,   16,   17,   17,   17,  158,
       17,   17,  308,   17,   17,   17,   17,  368,   17,   17,
      390,  308,   17,   17,   17,   17,   17,   17,   17,   17,
       17,   37,   37,   37,  304,  392,  287,  539,  287,  540,
      304,  158,  541,  391,  808,  328,  287,  288,  158,  288,
       37,  329,   37,  287,  287,  328,  347,  288,  289,  376,

      289,  329,  328,   37,  288,  288,  347,   17,  289,   17,
      781,  349,  376,   17,  390,  289,  289,  540,  539,  541,
       37,  349,   37,   17,   17,   17,   17,   18,   18,   18,
       37,   18,   18,  391,   18,   18,   18,   18,  809,   18,
       18,  673,  347,   18,   18,   18,   18,   18,   18,   18,
       18,   18,   38,   38,   38,  488,  810,  349,  294,  781,
      294,  488,  216,  216,  216,  278,  278,  278,  294,  350,
      332,   38,  333,   38,  811,  294,  294,  677,  673,  350,
      332,  216,  333,  216,  278,  505,  278,  332,   18,  333,
       18,  505,  674,  677,   18,  782,  721,  278,  812,  813,

      814,   38,  815,   38,   18,   18,   18,   18,   27,   27,
       27,  216,  721,  216,  278,  350,  278,   27,   27,   27,
       27,   27,   27,  298,  278,  298,  299,  394,  299,  394,
      299,  816,  817,  298,  779,  820,  299,  821,  822,  674,
      298,  298,  782,  299,  299,  823,  779,  824,   27,   27,
       27,   27,   27,   27,   84,   84,   84,  394,  825,  394,
      455,  827,  455,   84,   84,   84,   84,   84,   84,  828,
      455,  829,  463,  831,  463,  833,  455,  455,  455,  463,
      834,  835,  463,  837,  839,  840,  841,  842,  843,  463,
      463,  844,  845,  846,   84,   84,   84,   84,   84,   84,

       95,   95,   95,  847,  850,  852,  853,  854,  858,   95,
       95,   95,   95,   95,   95,  860,   95,  861,  862,   95,
      864,   95,  865,   95,  866,  867,  868,  869,  870,  871,
      872,  873,   95,  875,  876,  877,  879,  880,  882,  883,
       95,   95,   95,   95,   95,   95,  884,   95,  885,   95,
      886,   95,  888,   95,  891,  892,  893,  894,  889,   95,
      103,  103,  103,  889,  895,  896,  899,  901,  902,  103,
      103,  103,  103,  103,  103,  903,  103,  905,  906,  907,
      103,  910,  911,  103,  912,  913,  915,  103,  103,  916,
      917,  918,  103,  920,  921,  922,  924,  925,  926,  927,

      103,  103,  103,  103,  103,  103,  928,  103,  929,  930,
      932,  933,  934,  103,  936,  937,  939,  941,  942,  103,
      126,  126,  126,  943,  944,  945,  948,  949,  950,  126,
      126,  126,  126,  126,  126,  951,  952,  953,  954,  956,
      957,  959,  960,  962,  964,  967,  968,  969,  971,  972,
      980,  981,  982,  983,  984,  985,  987,  988,  989,  990,
      126,  126,  126,  126,  126,  126,  139,  139,  139,  991,
      992,  993,  994,  995,  996,  139,  139,  139,  139,  139,
      139,  995,  139,  986,  997,  998,  139,  999, 1000,  139,
     1001,  986, 1002, 1005, 1006, 1007,  986, 1008,  139, 1009,

     1010, 1011, 1012, 1013, 1014, 1008,  139,  139,  139,  139,
      139,  139, 1015,  139, 1016, 1017, 1018, 1019, 1020,  139,
     1022, 1023, 1024, 1025, 1026,  139,  209,  209,  209, 1028,
     1031, 1032, 1033, 1034, 1036,  209,  209,  209,  209,  209,
      209, 1037, 1038, 1039, 1040,  209, 1043,  209, 1044, 1045,
     1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 1055,
     1056, 1057, 1058, 1059, 1060, 1062,  209,  209,  209,  209,
      209,  209, 1063, 1064, 1065,  209, 1066,  209,  273,  273,
      273, 1067, 1068, 1069, 1070, 1071, 1072,  273,  273,  273,
      273,  273,  273, 1073, 1074, 1075, 1076,  273, 1077,  273,

     1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087,
     1088, 1089, 1091, 1092, 1093, 1094, 1095, 1096,  273,  273,
      273,  273,  273,  273, 1097, 1098, 1100,  273, 1102,  273,
      323,  323,  323, 1103, 1104, 1105, 1106, 1108, 1110,  323,
      323,  323,  323,  323,  323, 1111, 1109, 1112, 1113,  323,
     1109,  323, 1115, 1117, 1118, 1120, 1121, 1123, 1124, 1125,
     1119, 1126, 1127, 1109, 1119, 1128, 1129, 1130, 1131, 1132,
      323,  323,  323,  323,  323,  323, 1133, 1119, 1134,  323,
     1135,  323,  629,  629, 1136,  629,  629,  629, 1140,  629,
      629,  629,  629,  629, 1141,  629, 1142, 1143, 1147, 1148,

     1151, 1152, 1153,  629,  629,  629,  629,  629, 1154, 1155,
     1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 1165,
     1166, 1167, 1169, 1171, 1172, 1173, 1174, 1176, 1178, 1179,
     1180, 1181, 1182, 1183, 1184, 1185, 1186,  629, 1187, 1188,
     1189, 1190, 1191, 1193, 1195, 1196, 1197, 1198, 1200, 1201,
     1202, 1203, 1204, 1205, 1206, 1207, 1208, 1209, 1211,  629,
      629,  629,  645,  645, 1212,  645,  645,  645, 1213,  645,
      645,  645,  645,  645, 1214,  645, 1215, 1216, 1217, 1218,
     1219, 1220, 1221,  645,  645,  645,  645,  645, 1222, 1223,
     1227, 1229, 1232, 1233,  798,  796,  795,  791,  790,  789,

      786,  785,  784,  783,  777,  776,  775,  774,  773,  772,
      771,  770,  769,  768,  766,  764,  760,  645,  759,  758,
      756,  755,  753,  749,  748,  747,  746,  744,  743,  742,
      741,  740,  739,  738,  737,  736,  735,  734,  733,  645,
      645,  645,  751,  751,  732,  751,  751,  751,  731,  751,
      751,  751,  751,  751,  730,  751,  729,  728,  726,  725,
      724,  722,  720,  751,  751,  751,  751,  751,  719,  718,
      717,  716,  715,  714,  713,  712,  711,  710,  709,  708,
      707,  706,  704,  703,  702,  701,  700,  699,  698,  697,
      696,  695,  694,  693,  691,  690,  689,  751,  687,  685,

      683,  682,  681,  679,  678,  675,  671,  670,  669,  668,
      666,  664,  662,  661,  660,  658,  657,  656,  654,  751,
      751,  751,  762,  762,  653,  762,  762,  762,  652,  762,
      762,  762,  762,  762,  651,  762,  649,  648,  644,  643,
      639,  638,  637,  762,  762,  762,  762,  762,  636,  635,
      633,  632,  628,  627,  626,  622,  621,  620,  618,  617,
      616,  615,  614,  613,  612,  611,  610,  609,  608,  606,
      605,  604,  602,  601,  600,  599,  598,  762,  596,  595,
      593,  592,  590,  589,  588,  587,  586,  585,  584,  583,
      582,  581,  580,  579,  578,  577,  576,  575,  574,  762,

      762,  762, 1236, 1236, 1236, 1236, 1236, 1236, 1236, 1236,
     1236, 1236, 1236, 1237, 1237, 1237, 1237, 1237, 1237, 1237,
     1237, 1237, 1237, 1237, 1238, 1238, 1238, 1238, 1238, 1238,
     1238, 1238, 1238, 1238, 1238, 1239, 1239, 1239, 1239, 1239,
     1239, 1239, 1239, 1239, 1239, 1239, 1240, 1240, 1240, 1240,
     1240, 1240, 1240, 1240, 1240, 1240, 1240, 1241, 1241, 1241,
     1241, 1241, 1241, 1241, 1241, 1241, 1241, 1241, 1242,  573,
     1242, 1242, 1242, 1242, 1242, 1242, 1242, 1242, 1242, 1243,
     1243, 1243, 1243, 1243, 1243, 1243, 1243, 1244,  572,  571,
      570, 1244, 1244,  569, 1244, 1245,  567,  566,  565, 1245,

     1245, 1245, 1245, 1246, 1246, 1246, 1246, 1246, 1246, 1246,
     1246, 1246, 1246, 1246, 1247, 1247,  564, 1247, 1247, 1247,
     1247, 1247, 1248,  563, 1248, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1249,  562, 1249, 1249, 1249, 1249, 1249,
     1249, 1249, 1249, 1249, 1250, 1250, 1250, 1250, 1250, 1250,
     1250, 1250, 1250, 1251,  561, 1251, 1251, 1252, 1252,  560,
      559, 1252, 1252,  558, 1252, 1252, 1253, 1253, 1254, 1254,
     1254, 1254, 1254, 1254, 1254, 1254, 1255, 1255, 1255, 1255,
     1255, 1255, 1255, 1255, 1256,  557, 1256, 1256, 1256, 1256,
     1256, 1256, 1256, 1256, 1256, 1257,  556, 1257, 1257, 1257,

     1257, 1257, 1257, 1257, 1257, 1257, 1258,  555, 1258, 1258,
     1258, 1258, 1258, 1258, 1258, 1258, 1258, 1259,  554, 1259,
     1259, 1259, 1259, 1259, 1259, 1259, 1259, 1259,  553,  552,
      551,  550,  549,  547,  546,  545,  544,  542,  538,  537,
      536,  535,  534,  533,  532,  531,  530,  529,  528,  527,
      526,  525,  524,  523,  522,  521,  520,  519,  518,  517,
      516,  515,  514,  513,  512,  511,  510,  508,  507,  506,
      504,  503,  502,  501,  500,  499,  498,  497,  496,  495,
      494,  493,  491,  490,  489,  487,  485,  484,  483,  482,
      481,  480,  479,  478,  477,  476,  475,  474,  473,  470,

      469,  468,  467,  466,  465,  464,  462,  461,  460,  459,
      458,  457,  456,  454,  453,  451,  446,  445,  444,  443,
      442,  441,  440,  439,  438,  437,  436,  435,  434,  433,
      432,  431,  430,  429,  428,  427,  425,  422,  421,  420,
      419,  418,  417,  416,  415,  413,  412,  411,  410,  409,
      408,  407,  406,  405,  404,  403,  402,  401,  400,  399,
      398,  397,  389,  388,  385,  384,  383,  382,  381,  380,
      379,  378,  377,  375,  374,  373,  372,  371,  370,  362,
      361,  360,  359,  358,  357,  356,  355,  354,  353,  352,
      351,  348,  346,  345,  344,  343,  342,  341,  340,  339,

      338,  337,  336,  335,  334,  331,  320,  318,  317,  316,
      315,  314,  313,  312,  311,  310,  309,  307,  306,  305,
      303,  301,  300,  296,  295,  292,  291,  286,  282,  276,
      270,  266,  265,  263,  262,  261,  260,  259,  258,  257,
      255,  254,  253,  252,  251,  250,  249,  247,  246,  245,
      242,  241,  239,  238,  237,  236,  235,  234,  233,  232,
      231,  230,  229,  228,  227,  225,  224,  223,  222,  221,
      220,  219,  205,  204,  198,  192,  191,  187,  186,  185,
      183,  182,  181,  180,  179,  177,  175,  173,  172,  171,
      170,  169,  165,  163,  162,  161,  154,  151,  149,  148,

      147,  145,  136,  131,  129,  125,  124,  118,  117,  115,
      114,  109,  108,  100,   92,   90,   89,   82,   81,   80,
       78,   76,   75,   70,   69,   66,   64,   63,   62,   61,
       60,   58,   52,   50,   46,   43,   41,   34,   32,   31,
       28,   25,   22,   19, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,

     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235, 1235,
     1235, 1235, 1235, 1235, 1235, 1235
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

extern int yy_flex_debug;
int yy_flex_debug = 0;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
#define yymore() yymore_used_but_not_detected
#define YY_MORE_ADJ 0
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#line 1 "ldlex.l"
#line 4 "ldlex.l"

/* Copyright (C) 1991-2024 Free Software Foundation, Inc.
   Written by Steve Chamberlain of Cygnus Support.

   This file is part of the GNU Binutils.

   This program is free software; you can redistribute it and/or modify
   it under the terms of the GNU General Public License as published by
   the Free Software Foundation; either version 3 of the License, or
   (at your option) any later version.

   This program is distributed in the hope that it will be useful,
   but WITHOUT ANY WARRANTY; without even the implied warranty of
   MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
   GNU General Public License for more details.

   You should have received a copy of the GNU General Public License
   along with this program; if not, write to the Free Software
   Foundation, Inc., 51 Franklin Street - Fifth Floor, Boston,
   MA 02110-1301, USA.  */

#include "bfd.h"
#include "safe-ctype.h"
#include "bfdlink.h"
#include "ctf-api.h"
#include "ld.h"
#include "ldmisc.h"
#include "ldexp.h"
#include "ldlang.h"
#include <ldgram.h>
#include "ldfile.h"
#include "ldlex.h"
#include "ldmain.h"
#include "libiberty.h"

/* The type of top-level parser input.
   yylex and yyparse (indirectly) both check this.  */
input_type parser_input;

/* Line number in the current input file.  */
unsigned int lineno;

/* The string we are currently lexing, or NULL if we are reading a
   file.  */
const char *lex_string = NULL;

/* Support for flex reading from more than one input file (stream).
   `include_stack' is flex's input state for each open file;
   `file_name_stack' is the file names.  `lineno_stack' is the current
   line numbers.

   If `include_stack_ptr' is 0, we haven't started reading anything yet.
   Otherwise, stack elements 0 through `include_stack_ptr - 1' are valid.  */

#undef YY_INPUT
#define YY_INPUT(buf,result,max_size) result = yy_input (buf, max_size)

#ifndef YY_NO_UNPUT
#define YY_NO_UNPUT
#endif

#define MAX_INCLUDE_DEPTH 10
static YY_BUFFER_STATE include_stack[MAX_INCLUDE_DEPTH];
static const char *file_name_stack[MAX_INCLUDE_DEPTH];
static unsigned int lineno_stack[MAX_INCLUDE_DEPTH];
static unsigned int sysrooted_stack[MAX_INCLUDE_DEPTH];
static unsigned int include_stack_ptr = 0;
static int vers_node_nesting = 0;

static int yy_input (char *, int);
static void comment (void);
static void lex_warn_invalid (char *where, char *what);

/* STATES
	EXPRESSION	in an expression
	SCRIPT		in a script
	INPUTLIST	in a script, a filename-list
	MRI		in an MRI script
	WILD		inside the braces of an output section or overlay,
			for input section wildcards
	VERS_START	starting a Sun style mapfile
	VERS_SCRIPT	a Sun style mapfile
	VERS_NODE	a node within a Sun style mapfile
*/
#define RTOKEN(x)  {  yylval.token = x; return x; }

#line 1435 "ldlex.c"

#line 1437 "ldlex.c"

#define INITIAL 0
#define SCRIPT 1
#define INPUTLIST 2
#define EXPRESSION 3
#define MRI 4
#define WILD 5
#define VERS_START 6
#define VERS_SCRIPT 7
#define VERS_NODE 8

#ifndef YY_NO_UNISTD_H
/* Special case for "unistd.h", since it is non-ANSI. We include it way
 * down here because we want the user's section 1 to have been scanned first.
 * The user has a chance to override it with an option.
 */
#include <unistd.h>
#endif

#ifndef YY_EXTRA_TYPE
#define YY_EXTRA_TYPE void *
#endif

static int yy_init_globals ( void );

/* Accessor methods to globals.
   These are made visible to non-reentrant scanners for convenience. */

int yylex_destroy ( void );

int yyget_debug ( void );

void yyset_debug ( int debug_flag  );

YY_EXTRA_TYPE yyget_extra ( void );

void yyset_extra ( YY_EXTRA_TYPE user_defined  );

FILE *yyget_in ( void );

void yyset_in  ( FILE * _in_str  );

FILE *yyget_out ( void );

void yyset_out  ( FILE * _out_str  );

			int yyget_leng ( void );

char *yyget_text ( void );

int yyget_lineno ( void );

void yyset_lineno ( int _line_number  );

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap ( void );
#else
extern int yywrap ( void );
#endif
#endif

#ifndef YY_NO_UNPUT
    
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy ( char *, const char *, int );
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen ( const char * );
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int yyinput ( void );
#else
static int input ( void );
#endif

#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k */
#define YY_READ_BUF_SIZE 16384
#else
#define YY_READ_BUF_SIZE 8192
#endif /* __ia64__ */
#endif

/* Copy whatever the last rule matched to the standard output. */
#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO do { if (fwrite( yytext, (size_t) yyleng, 1, yyout )) {} } while (0)
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( YY_CURRENT_BUFFER_LVALUE->yy_is_interactive ) \
		{ \
		int c = '*'; \
		int n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else \
		{ \
		errno=0; \
		while ( (result = (int) fread(buf, 1, (yy_size_t) max_size, yyin)) == 0 && ferror(yyin)) \
			{ \
			if( errno != EINTR) \
				{ \
				YY_FATAL_ERROR( "input in flex scanner failed" ); \
				break; \
				} \
			errno=0; \
			clearerr(yyin); \
			} \
		}\
\

#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif

/* end tables serialization structures and prototypes */

/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL_IS_OURS 1

extern int yylex (void);

#define YY_DECL int yylex (void)
#endif /* !YY_DECL */

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK /*LINTED*/break;
#endif

#define YY_RULE_SETUP \
	YY_USER_ACTION

/** The main scanner function which does all the work.
 */
YY_DECL
{
	yy_state_type yy_current_state;
	char *yy_cp, *yy_bp;
	int yy_act;
    
	if ( !(yy_init) )
		{
		(yy_init) = 1;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! (yy_start) )
			(yy_start) = 1;	/* first start state */

		if ( ! yyin )
			yyin = stdin;

		if ( ! yyout )
			yyout = stdout;

		if ( ! YY_CURRENT_BUFFER ) {
			yyensure_buffer_stack ();
			YY_CURRENT_BUFFER_LVALUE =
				yy_create_buffer( yyin, YY_BUF_SIZE );
		}

		yy_load_buffer_state(  );
		}

	{
#line 114 "ldlex.l"


#line 117 "ldlex.l"
  if (parser_input != input_selected)
    {
      /* The first token of the input determines the initial parser state.  */
      input_type t = parser_input;
      parser_input = input_selected;
      switch (t)
	{
	case input_script: return INPUT_SCRIPT; break;
	case input_mri_script: return INPUT_MRI_SCRIPT; break;
	case input_version_script: return INPUT_VERSION_SCRIPT; break;
	case input_dynamic_list: return INPUT_DYNAMIC_LIST; break;
	case input_defsym: return INPUT_DEFSYM; break;
	default: abort ();
	}
    }

#line 1680 "ldlex.c"

	while ( /*CONSTCOND*/1 )		/* loops until end-of-file is reached */
		{
		yy_cp = (yy_c_buf_p);

		/* Support of yytext. */
		*yy_cp = (yy_hold_char);

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = (yy_start);
yy_match:
		do
			{
			YY_CHAR yy_c = yy_ec[YY_SC_TO_UI(*yy_cp)] ;
			if ( yy_accept[yy_current_state] )
				{
				(yy_last_accepting_state) = yy_current_state;
				(yy_last_accepting_cpos) = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 1236 )
					yy_c = yy_meta[yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 2145 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;

do_action:	/* This label is used only to access EOF actions. */

		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = (yy_hold_char);
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			goto yy_find_action;

case 1:
YY_RULE_SETUP
#line 133 "ldlex.l"
{
				comment (); }
	YY_BREAK
case 2:
YY_RULE_SETUP
#line 136 "ldlex.l"
{
				yylval.integer = strtoull (yytext + 1, 0, 16);
				yylval.bigint.str = NULL;
				return INT;
			}
	YY_BREAK
case 3:
YY_RULE_SETUP
#line 142 "ldlex.l"
{
				   int ibase ;
				   switch (yytext[yyleng - 1]) {
				    case 'X':
				    case 'x':
				    case 'H':
				    case 'h':
				     ibase = 16;
				     break;
				    case 'O':
				    case 'o':
				     ibase = 8;
				     break;
				    case 'B':
				    case 'b':
				     ibase = 2;
				     break;
				    default:
				     ibase = 10;
				   }
				   yylval.integer = strtoull (yytext, 0, ibase);
				   yylval.bigint.str = NULL;
				   return INT;
				 }
	YY_BREAK
case 4:
YY_RULE_SETUP
#line 166 "ldlex.l"
{
				  char *s = yytext;
				  int ibase = 0;

				  if (*s == '$')
				    {
				      ++s;
				      ibase = 16;
				    }
				  yylval.integer = strtoull (s, 0, ibase);
				  yylval.bigint.str = NULL;
				  if (yytext[yyleng - 1] == 'M'
				      || yytext[yyleng - 1] == 'm')
				    {
				      yylval.integer *= 1024 * 1024;
				    }
				  else if (yytext[yyleng - 1] == 'K'
				      || yytext[yyleng - 1]=='k')
				    {
				      yylval.integer *= 1024;
				    }
				  else if (yytext[0] == '0'
					   && (yytext[1] == 'x'
					       || yytext[1] == 'X'))
				    {
				      yylval.bigint.str = xstrdup (yytext + 2);
				    }
				  return INT;
				}
	YY_BREAK
/* Some tokens that only appear in expressions must be enabled for
     states other than EXPRESSION, since parser lookahead means they
     must be recognised before the parser switches the lexer out of
     SCRIPT or WILD state into EXPRESSION state.

     This sort of thing happens for example with NAME in ldgram.y
     "section" rule, which is immediately followed by ldlex_expression.
     However, if you follow the grammar from "sec_or_group_p1" you see
     "assignment" appearing in "statement_anywhere".  Now,
     "assignment" also has NAME as its first token, just like
     "section".  So the parser can't know whether it is in the
     "section" or the "assignment" rule until it has scanned the next
     token to find an assignment operator.  Thus the next token after
     NAME in the "section" rule may be lexed before the lexer is
     switched to EXPRESSION state, and there are quite a number of
     optional components.  The first token in all those components
     must be able to be lexed in SCRIPT state, as well as the
     assignment operators.  In fact, due to "opt_exp_with_type",
     anything that can appear on the left hand side of "exp" might
     need to be lexed in SCRIPT state.

     MRI mode tends to cover everything in MRI scripts.
  */
case 5:
YY_RULE_SETUP
#line 219 "ldlex.l"
{ RTOKEN(']'); }
	YY_BREAK
case 6:
YY_RULE_SETUP
#line 220 "ldlex.l"
{ RTOKEN('['); }
	YY_BREAK
case 7:
YY_RULE_SETUP
#line 221 "ldlex.l"
{ RTOKEN(LSHIFTEQ); }
	YY_BREAK
case 8:
YY_RULE_SETUP
#line 222 "ldlex.l"
{ RTOKEN(RSHIFTEQ); }
	YY_BREAK
case 9:
YY_RULE_SETUP
#line 223 "ldlex.l"
{ RTOKEN(OROR); }
	YY_BREAK
case 10:
YY_RULE_SETUP
#line 224 "ldlex.l"
{ RTOKEN(EQ); }
	YY_BREAK
case 11:
YY_RULE_SETUP
#line 225 "ldlex.l"
{ RTOKEN(NE); }
	YY_BREAK
case 12:
YY_RULE_SETUP
#line 226 "ldlex.l"
{ RTOKEN(GE); }
	YY_BREAK
case 13:
YY_RULE_SETUP
#line 227 "ldlex.l"
{ RTOKEN(LE); }
	YY_BREAK
case 14:
YY_RULE_SETUP
#line 228 "ldlex.l"
{ RTOKEN(LSHIFT); }
	YY_BREAK
case 15:
YY_RULE_SETUP
#line 229 "ldlex.l"
{ RTOKEN(RSHIFT); }
	YY_BREAK
case 16:
YY_RULE_SETUP
#line 230 "ldlex.l"
{ RTOKEN(PLUSEQ); }
	YY_BREAK
case 17:
YY_RULE_SETUP
#line 231 "ldlex.l"
{ RTOKEN(MINUSEQ); }
	YY_BREAK
case 18:
YY_RULE_SETUP
#line 232 "ldlex.l"
{ RTOKEN(MULTEQ); }
	YY_BREAK
case 19:
YY_RULE_SETUP
#line 233 "ldlex.l"
{ RTOKEN(DIVEQ); }
	YY_BREAK
case 20:
YY_RULE_SETUP
#line 234 "ldlex.l"
{ RTOKEN(ANDEQ); }
	YY_BREAK
case 21:
YY_RULE_SETUP
#line 235 "ldlex.l"
{ RTOKEN(OREQ); }
	YY_BREAK
case 22:
YY_RULE_SETUP
#line 236 "ldlex.l"
{ RTOKEN(XOREQ); }
	YY_BREAK
case 23:
YY_RULE_SETUP
#line 237 "ldlex.l"
{ RTOKEN(ANDAND); }
	YY_BREAK
case 24:
YY_RULE_SETUP
#line 238 "ldlex.l"
{ RTOKEN('>'); }
	YY_BREAK
case 25:
YY_RULE_SETUP
#line 239 "ldlex.l"
{ RTOKEN(','); }
	YY_BREAK
case 26:
YY_RULE_SETUP
#line 240 "ldlex.l"
{ RTOKEN('&'); }
	YY_BREAK
case 27:
YY_RULE_SETUP
#line 241 "ldlex.l"
{ RTOKEN('|'); }
	YY_BREAK
case 28:
YY_RULE_SETUP
#line 242 "ldlex.l"
{ RTOKEN('~'); }
	YY_BREAK
case 29:
YY_RULE_SETUP
#line 243 "ldlex.l"
{ RTOKEN('!'); }
	YY_BREAK
case 30:
YY_RULE_SETUP
#line 244 "ldlex.l"
{ RTOKEN('?'); }
	YY_BREAK
case 31:
YY_RULE_SETUP
#line 245 "ldlex.l"
{ RTOKEN('*'); }
	YY_BREAK
case 32:
YY_RULE_SETUP
#line 246 "ldlex.l"
{ RTOKEN('+'); }
	YY_BREAK
case 33:
YY_RULE_SETUP
#line 247 "ldlex.l"
{ RTOKEN('-'); }
	YY_BREAK
case 34:
YY_RULE_SETUP
#line 248 "ldlex.l"
{ RTOKEN('/'); }
	YY_BREAK
case 35:
YY_RULE_SETUP
#line 249 "ldlex.l"
{ RTOKEN('%'); }
	YY_BREAK
case 36:
YY_RULE_SETUP
#line 250 "ldlex.l"
{ RTOKEN('<'); }
	YY_BREAK
case 37:
YY_RULE_SETUP
#line 251 "ldlex.l"
{ RTOKEN('^'); }
	YY_BREAK
case 38:
YY_RULE_SETUP
#line 252 "ldlex.l"
{ RTOKEN('='); }
	YY_BREAK
case 39:
YY_RULE_SETUP
#line 253 "ldlex.l"
{ RTOKEN('}'); }
	YY_BREAK
case 40:
YY_RULE_SETUP
#line 254 "ldlex.l"
{ RTOKEN('{'); }
	YY_BREAK
case 41:
YY_RULE_SETUP
#line 255 "ldlex.l"
{ RTOKEN(')'); }
	YY_BREAK
case 42:
YY_RULE_SETUP
#line 256 "ldlex.l"
{ RTOKEN('('); }
	YY_BREAK
case 43:
YY_RULE_SETUP
#line 257 "ldlex.l"
{ RTOKEN(':'); }
	YY_BREAK
case 44:
YY_RULE_SETUP
#line 258 "ldlex.l"
{ RTOKEN(';'); }
	YY_BREAK
case 45:
YY_RULE_SETUP
#line 259 "ldlex.l"
{ RTOKEN(MEMORY); }
	YY_BREAK
case 46:
YY_RULE_SETUP
#line 260 "ldlex.l"
{ RTOKEN(REGION_ALIAS); }
	YY_BREAK
case 47:
YY_RULE_SETUP
#line 261 "ldlex.l"
{ RTOKEN(LD_FEATURE); }
	YY_BREAK
case 48:
YY_RULE_SETUP
#line 262 "ldlex.l"
{ RTOKEN(ORIGIN); }
	YY_BREAK
case 49:
YY_RULE_SETUP
#line 263 "ldlex.l"
{ RTOKEN(VERSIONK); }
	YY_BREAK
case 50:
YY_RULE_SETUP
#line 264 "ldlex.l"
{ RTOKEN(BLOCK); }
	YY_BREAK
case 51:
YY_RULE_SETUP
#line 265 "ldlex.l"
{ RTOKEN(BIND); }
	YY_BREAK
case 52:
YY_RULE_SETUP
#line 266 "ldlex.l"
{ RTOKEN(LENGTH); }
	YY_BREAK
case 53:
YY_RULE_SETUP
#line 267 "ldlex.l"
{ RTOKEN(ALIGN_K); }
	YY_BREAK
case 54:
YY_RULE_SETUP
#line 268 "ldlex.l"
{ RTOKEN(DATA_SEGMENT_ALIGN); }
	YY_BREAK
case 55:
YY_RULE_SETUP
#line 269 "ldlex.l"
{ RTOKEN(DATA_SEGMENT_RELRO_END); }
	YY_BREAK
case 56:
YY_RULE_SETUP
#line 270 "ldlex.l"
{ RTOKEN(DATA_SEGMENT_END); }
	YY_BREAK
case 57:
YY_RULE_SETUP
#line 271 "ldlex.l"
{ RTOKEN(ADDR); }
	YY_BREAK
case 58:
YY_RULE_SETUP
#line 272 "ldlex.l"
{ RTOKEN(LOADADDR); }
	YY_BREAK
case 59:
YY_RULE_SETUP
#line 273 "ldlex.l"
{ RTOKEN(ALIGNOF); }
	YY_BREAK
case 60:
YY_RULE_SETUP
#line 274 "ldlex.l"
{ RTOKEN(ABSOLUTE); }
	YY_BREAK
case 61:
YY_RULE_SETUP
#line 275 "ldlex.l"
{ RTOKEN(MAX_K); }
	YY_BREAK
case 62:
YY_RULE_SETUP
#line 276 "ldlex.l"
{ RTOKEN(MIN_K); }
	YY_BREAK
case 63:
YY_RULE_SETUP
#line 277 "ldlex.l"
{ RTOKEN(LOG2CEIL); }
	YY_BREAK
case 64:
YY_RULE_SETUP
#line 278 "ldlex.l"
{ RTOKEN(ASSERT_K); }
	YY_BREAK
case 65:
YY_RULE_SETUP
#line 279 "ldlex.l"
{ RTOKEN(ENTRY); }
	YY_BREAK
case 66:
YY_RULE_SETUP
#line 280 "ldlex.l"
{ RTOKEN(EXTERN); }
	YY_BREAK
case 67:
YY_RULE_SETUP
#line 281 "ldlex.l"
{ RTOKEN(NEXT); }
	YY_BREAK
case 68:
YY_RULE_SETUP
#line 282 "ldlex.l"
{ RTOKEN(SIZEOF_HEADERS); }
	YY_BREAK
case 69:
YY_RULE_SETUP
#line 283 "ldlex.l"
{ RTOKEN(SEGMENT_START); }
	YY_BREAK
case 70:
YY_RULE_SETUP
#line 284 "ldlex.l"
{ RTOKEN(MAP); }
	YY_BREAK
case 71:
YY_RULE_SETUP
#line 285 "ldlex.l"
{ RTOKEN(SIZEOF); }
	YY_BREAK
case 72:
YY_RULE_SETUP
#line 286 "ldlex.l"
{ RTOKEN(TARGET_K); }
	YY_BREAK
case 73:
YY_RULE_SETUP
#line 287 "ldlex.l"
{ RTOKEN(SEARCH_DIR); }
	YY_BREAK
case 74:
YY_RULE_SETUP
#line 288 "ldlex.l"
{ RTOKEN(OUTPUT); }
	YY_BREAK
case 75:
YY_RULE_SETUP
#line 289 "ldlex.l"
{ RTOKEN(INPUT); }
	YY_BREAK
case 76:
YY_RULE_SETUP
#line 290 "ldlex.l"
{ RTOKEN(GROUP); }
	YY_BREAK
case 77:
YY_RULE_SETUP
#line 291 "ldlex.l"
{ RTOKEN(AS_NEEDED); }
	YY_BREAK
case 78:
YY_RULE_SETUP
#line 292 "ldlex.l"
{ RTOKEN(DEFINED); }
	YY_BREAK
case 79:
YY_RULE_SETUP
#line 293 "ldlex.l"
{ RTOKEN(CREATE_OBJECT_SYMBOLS); }
	YY_BREAK
case 80:
YY_RULE_SETUP
#line 294 "ldlex.l"
{ RTOKEN(CONSTRUCTORS); }
	YY_BREAK
case 81:
YY_RULE_SETUP
#line 295 "ldlex.l"
{ RTOKEN(FORCE_COMMON_ALLOCATION); }
	YY_BREAK
case 82:
YY_RULE_SETUP
#line 296 "ldlex.l"
{ RTOKEN(FORCE_GROUP_ALLOCATION); }
	YY_BREAK
case 83:
YY_RULE_SETUP
#line 297 "ldlex.l"
{ RTOKEN(INHIBIT_COMMON_ALLOCATION); }
	YY_BREAK
case 84:
YY_RULE_SETUP
#line 298 "ldlex.l"
{ RTOKEN(SECTIONS); }
	YY_BREAK
case 85:
YY_RULE_SETUP
#line 299 "ldlex.l"
{ RTOKEN(INSERT_K); }
	YY_BREAK
case 86:
YY_RULE_SETUP
#line 300 "ldlex.l"
{ RTOKEN(AFTER); }
	YY_BREAK
case 87:
YY_RULE_SETUP
#line 301 "ldlex.l"
{ RTOKEN(BEFORE); }
	YY_BREAK
case 88:
YY_RULE_SETUP
#line 302 "ldlex.l"
{ RTOKEN(FILL); }
	YY_BREAK
case 89:
YY_RULE_SETUP
#line 303 "ldlex.l"
{ RTOKEN(STARTUP); }
	YY_BREAK
case 90:
YY_RULE_SETUP
#line 304 "ldlex.l"
{ RTOKEN(OUTPUT_FORMAT); }
	YY_BREAK
case 91:
YY_RULE_SETUP
#line 305 "ldlex.l"
{ RTOKEN(OUTPUT_ARCH); }
	YY_BREAK
case 92:
YY_RULE_SETUP
#line 306 "ldlex.l"
{ RTOKEN(HLL); }
	YY_BREAK
case 93:
YY_RULE_SETUP
#line 307 "ldlex.l"
{ RTOKEN(SYSLIB); }
	YY_BREAK
case 94:
YY_RULE_SETUP
#line 308 "ldlex.l"
{ RTOKEN(FLOAT); }
	YY_BREAK
case 95:
YY_RULE_SETUP
#line 309 "ldlex.l"
{ RTOKEN(QUAD); }
	YY_BREAK
case 96:
YY_RULE_SETUP
#line 310 "ldlex.l"
{ RTOKEN(SQUAD); }
	YY_BREAK
case 97:
YY_RULE_SETUP
#line 311 "ldlex.l"
{ RTOKEN(LONG); }
	YY_BREAK
case 98:
YY_RULE_SETUP
#line 312 "ldlex.l"
{ RTOKEN(SHORT); }
	YY_BREAK
case 99:
YY_RULE_SETUP
#line 313 "ldlex.l"
{ RTOKEN(BYTE); }
	YY_BREAK
case 100:
YY_RULE_SETUP
#line 314 "ldlex.l"
{ RTOKEN(ASCIZ); }
	YY_BREAK
case 101:
YY_RULE_SETUP
#line 315 "ldlex.l"
{ RTOKEN(LINKER_VERSION); }
	YY_BREAK
case 102:
YY_RULE_SETUP
#line 316 "ldlex.l"
{ RTOKEN(NOFLOAT); }
	YY_BREAK
case 103:
YY_RULE_SETUP
#line 317 "ldlex.l"
{ RTOKEN(NOCROSSREFS); }
	YY_BREAK
case 104:
YY_RULE_SETUP
#line 318 "ldlex.l"
{ RTOKEN(NOCROSSREFS_TO); }
	YY_BREAK
case 105:
YY_RULE_SETUP
#line 319 "ldlex.l"
{ RTOKEN(OVERLAY); }
	YY_BREAK
case 106:
YY_RULE_SETUP
#line 320 "ldlex.l"
{ RTOKEN(SORT_BY_NAME); }
	YY_BREAK
case 107:
YY_RULE_SETUP
#line 321 "ldlex.l"
{ RTOKEN(SORT_BY_ALIGNMENT); }
	YY_BREAK
case 108:
YY_RULE_SETUP
#line 322 "ldlex.l"
{ RTOKEN(SORT_BY_NAME); }
	YY_BREAK
case 109:
YY_RULE_SETUP
#line 323 "ldlex.l"
{ RTOKEN(SORT_BY_INIT_PRIORITY); }
	YY_BREAK
case 110:
YY_RULE_SETUP
#line 324 "ldlex.l"
{ RTOKEN(SORT_NONE); }
	YY_BREAK
case 111:
YY_RULE_SETUP
#line 325 "ldlex.l"
{ RTOKEN(REVERSE); }
	YY_BREAK
case 112:
YY_RULE_SETUP
#line 326 "ldlex.l"
{ RTOKEN(NOLOAD); }
	YY_BREAK
case 113:
YY_RULE_SETUP
#line 327 "ldlex.l"
{ RTOKEN(READONLY); }
	YY_BREAK
case 114:
YY_RULE_SETUP
#line 328 "ldlex.l"
{ RTOKEN(DSECT); }
	YY_BREAK
case 115:
YY_RULE_SETUP
#line 329 "ldlex.l"
{ RTOKEN(COPY); }
	YY_BREAK
case 116:
YY_RULE_SETUP
#line 330 "ldlex.l"
{ RTOKEN(INFO); }
	YY_BREAK
case 117:
YY_RULE_SETUP
#line 331 "ldlex.l"
{ RTOKEN(TYPE); }
	YY_BREAK
case 118:
YY_RULE_SETUP
#line 332 "ldlex.l"
{ RTOKEN(ONLY_IF_RO); }
	YY_BREAK
case 119:
YY_RULE_SETUP
#line 333 "ldlex.l"
{ RTOKEN(ONLY_IF_RW); }
	YY_BREAK
case 120:
YY_RULE_SETUP
#line 334 "ldlex.l"
{ RTOKEN(SPECIAL); }
	YY_BREAK
case 121:
YY_RULE_SETUP
#line 335 "ldlex.l"
{ RTOKEN(ORIGIN); }
	YY_BREAK
case 122:
YY_RULE_SETUP
#line 336 "ldlex.l"
{ RTOKEN(ORIGIN); }
	YY_BREAK
case 123:
YY_RULE_SETUP
#line 337 "ldlex.l"
{ RTOKEN(LENGTH); }
	YY_BREAK
case 124:
YY_RULE_SETUP
#line 338 "ldlex.l"
{ RTOKEN(LENGTH); }
	YY_BREAK
case 125:
YY_RULE_SETUP
#line 339 "ldlex.l"
{ RTOKEN(INPUT_SECTION_FLAGS); }
	YY_BREAK
case 126:
YY_RULE_SETUP
#line 340 "ldlex.l"
{ RTOKEN(INCLUDE);}
	YY_BREAK
case 127:
YY_RULE_SETUP
#line 341 "ldlex.l"
{ RTOKEN(PHDRS); }
	YY_BREAK
case 128:
YY_RULE_SETUP
#line 342 "ldlex.l"
{ RTOKEN(AT);}
	YY_BREAK
case 129:
YY_RULE_SETUP
#line 343 "ldlex.l"
{ RTOKEN(ALIGN_WITH_INPUT);}
	YY_BREAK
case 130:
YY_RULE_SETUP
#line 344 "ldlex.l"
{ RTOKEN(SUBALIGN);}
	YY_BREAK
case 131:
YY_RULE_SETUP
#line 345 "ldlex.l"
{ RTOKEN(HIDDEN); }
	YY_BREAK
case 132:
YY_RULE_SETUP
#line 346 "ldlex.l"
{ RTOKEN(PROVIDE); }
	YY_BREAK
case 133:
YY_RULE_SETUP
#line 347 "ldlex.l"
{ RTOKEN(PROVIDE_HIDDEN); }
	YY_BREAK
case 134:
YY_RULE_SETUP
#line 348 "ldlex.l"
{ RTOKEN(KEEP); }
	YY_BREAK
case 135:
YY_RULE_SETUP
#line 349 "ldlex.l"
{ RTOKEN(EXCLUDE_FILE); }
	YY_BREAK
case 136:
YY_RULE_SETUP
#line 350 "ldlex.l"
{ RTOKEN(CONSTANT);}
	YY_BREAK
case 137:
/* rule 137 can match eol */
YY_RULE_SETUP
#line 352 "ldlex.l"
{ ++ lineno; }
	YY_BREAK
case 138:
/* rule 138 can match eol */
YY_RULE_SETUP
#line 353 "ldlex.l"
{ ++ lineno;  RTOKEN(NEWLINE); }
	YY_BREAK
case 139:
YY_RULE_SETUP
#line 354 "ldlex.l"
{ /* Mri comment line */ }
	YY_BREAK
case 140:
YY_RULE_SETUP
#line 355 "ldlex.l"
{ /* Mri comment line */ }
	YY_BREAK
case 141:
YY_RULE_SETUP
#line 356 "ldlex.l"
{ RTOKEN(ENDWORD); }
	YY_BREAK
case 142:
YY_RULE_SETUP
#line 357 "ldlex.l"
{ RTOKEN(ABSOLUTE); }
	YY_BREAK
case 143:
YY_RULE_SETUP
#line 358 "ldlex.l"
{ RTOKEN(ALIGNMOD);}
	YY_BREAK
case 144:
YY_RULE_SETUP
#line 359 "ldlex.l"
{ RTOKEN(ALIGN_K);}
	YY_BREAK
case 145:
YY_RULE_SETUP
#line 360 "ldlex.l"
{ RTOKEN(CHIP); }
	YY_BREAK
case 146:
YY_RULE_SETUP
#line 361 "ldlex.l"
{ RTOKEN(BASE); }
	YY_BREAK
case 147:
YY_RULE_SETUP
#line 362 "ldlex.l"
{ RTOKEN(ALIAS); }
	YY_BREAK
case 148:
YY_RULE_SETUP
#line 363 "ldlex.l"
{ RTOKEN(TRUNCATE); }
	YY_BREAK
case 149:
YY_RULE_SETUP
#line 364 "ldlex.l"
{ RTOKEN(LOAD); }
	YY_BREAK
case 150:
YY_RULE_SETUP
#line 365 "ldlex.l"
{ RTOKEN(PUBLIC); }
	YY_BREAK
case 151:
YY_RULE_SETUP
#line 366 "ldlex.l"
{ RTOKEN(ORDER); }
	YY_BREAK
case 152:
YY_RULE_SETUP
#line 367 "ldlex.l"
{ RTOKEN(NAMEWORD); }
	YY_BREAK
case 153:
YY_RULE_SETUP
#line 368 "ldlex.l"
{ RTOKEN(FORMAT); }
	YY_BREAK
case 154:
YY_RULE_SETUP
#line 369 "ldlex.l"
{ RTOKEN(CASE); }
	YY_BREAK
case 155:
YY_RULE_SETUP
#line 370 "ldlex.l"
{ RTOKEN(START); }
	YY_BREAK
case 156:
YY_RULE_SETUP
#line 371 "ldlex.l"
{ RTOKEN(LIST); /* LIST and ignore to end of line */ }
	YY_BREAK
case 157:
YY_RULE_SETUP
#line 372 "ldlex.l"
{ RTOKEN(SECT); }
	YY_BREAK
case 158:
YY_RULE_SETUP
#line 373 "ldlex.l"
{ RTOKEN(ENDWORD); }
	YY_BREAK
case 159:
YY_RULE_SETUP
#line 374 "ldlex.l"
{ RTOKEN(ABSOLUTE); }
	YY_BREAK
case 160:
YY_RULE_SETUP
#line 375 "ldlex.l"
{ RTOKEN(ALIGNMOD);}
	YY_BREAK
case 161:
YY_RULE_SETUP
#line 376 "ldlex.l"
{ RTOKEN(ALIGN_K);}
	YY_BREAK
case 162:
YY_RULE_SETUP
#line 377 "ldlex.l"
{ RTOKEN(CHIP); }
	YY_BREAK
case 163:
YY_RULE_SETUP
#line 378 "ldlex.l"
{ RTOKEN(BASE); }
	YY_BREAK
case 164:
YY_RULE_SETUP
#line 379 "ldlex.l"
{ RTOKEN(ALIAS); }
	YY_BREAK
case 165:
YY_RULE_SETUP
#line 380 "ldlex.l"
{ RTOKEN(TRUNCATE); }
	YY_BREAK
case 166:
YY_RULE_SETUP
#line 381 "ldlex.l"
{ RTOKEN(LOAD); }
	YY_BREAK
case 167:
YY_RULE_SETUP
#line 382 "ldlex.l"
{ RTOKEN(PUBLIC); }
	YY_BREAK
case 168:
YY_RULE_SETUP
#line 383 "ldlex.l"
{ RTOKEN(ORDER); }
	YY_BREAK
case 169:
YY_RULE_SETUP
#line 384 "ldlex.l"
{ RTOKEN(NAMEWORD); }
	YY_BREAK
case 170:
YY_RULE_SETUP
#line 385 "ldlex.l"
{ RTOKEN(FORMAT); }
	YY_BREAK
case 171:
YY_RULE_SETUP
#line 386 "ldlex.l"
{ RTOKEN(CASE); }
	YY_BREAK
case 172:
YY_RULE_SETUP
#line 387 "ldlex.l"
{ RTOKEN(EXTERN); }
	YY_BREAK
case 173:
YY_RULE_SETUP
#line 388 "ldlex.l"
{ RTOKEN(START); }
	YY_BREAK
case 174:
YY_RULE_SETUP
#line 389 "ldlex.l"
{ RTOKEN(LIST); /* LIST and ignore to end of line */ }
	YY_BREAK
case 175:
YY_RULE_SETUP
#line 390 "ldlex.l"
{ RTOKEN(SECT); }
	YY_BREAK
case 176:
YY_RULE_SETUP
#line 392 "ldlex.l"
{
/* Filename without commas, needed to parse mri stuff */
				  yylval.name = xstrdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 177:
YY_RULE_SETUP
#line 399 "ldlex.l"
{
				  yylval.name = xstrdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 178:
YY_RULE_SETUP
#line 403 "ldlex.l"
{
/* Filename to be prefixed by --sysroot or when non-sysrooted, nothing.  */
				  yylval.name = xstrdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 179:
YY_RULE_SETUP
#line 408 "ldlex.l"
{
				  yylval.name = xstrdup (yytext + 2);
				  return LNAME;
				}
	YY_BREAK
case 180:
YY_RULE_SETUP
#line 412 "ldlex.l"
{
				  yylval.name = xstrdup (yytext);
				  return NAME;
				}
	YY_BREAK
/* The following rule is to prevent a fill expression on the output
     section before /DISCARD/ interpreting the '/' as a divide.  */
case 181:
YY_RULE_SETUP
#line 418 "ldlex.l"
{
				  yylval.name = xstrdup (yytext);
				  return NAME;
				}
	YY_BREAK
case 182:
YY_RULE_SETUP
#line 422 "ldlex.l"
{
		/* Annoyingly, this pattern can match comments, and we have
		   longest match issues to consider.  So if the first two
		   characters are a comment opening, put the input back and
		   try again.  */
		if (yytext[0] == '/' && yytext[1] == '*')
		  {
		    yyless (2);
		    comment ();
		  }
		else
		  {
		    yylval.name = xstrdup (yytext);
		    return NAME;
		  }
	}
	YY_BREAK
case 183:
/* rule 183 can match eol */
YY_RULE_SETUP
#line 439 "ldlex.l"
{
		/* No matter the state, quotes give what's inside.  */
		yylval.name = xmemdup (yytext + 1, yyleng - 2, yyleng - 1);
		return NAME;
	}
	YY_BREAK
case 184:
/* rule 184 can match eol */
YY_RULE_SETUP
#line 445 "ldlex.l"
{
				lineno++; }
	YY_BREAK
case 185:
YY_RULE_SETUP
#line 447 "ldlex.l"
{
				/* Eat up whitespace */ }
	YY_BREAK
case 186:
YY_RULE_SETUP
#line 449 "ldlex.l"
{
				/* Eat up comments */ }
	YY_BREAK
case 187:
YY_RULE_SETUP
#line 452 "ldlex.l"
{ return *yytext; }
	YY_BREAK
case 188:
YY_RULE_SETUP
#line 454 "ldlex.l"
{ RTOKEN(GLOBAL); }
	YY_BREAK
case 189:
YY_RULE_SETUP
#line 456 "ldlex.l"
{ RTOKEN(LOCAL); }
	YY_BREAK
case 190:
YY_RULE_SETUP
#line 458 "ldlex.l"
{ RTOKEN(EXTERN); }
	YY_BREAK
case 191:
YY_RULE_SETUP
#line 460 "ldlex.l"
{ yylval.name = xstrdup (yytext);
				  return VERS_IDENTIFIER; }
	YY_BREAK
case 192:
YY_RULE_SETUP
#line 463 "ldlex.l"
{ yylval.name = xstrdup (yytext);
				  return VERS_TAG; }
	YY_BREAK
case 193:
YY_RULE_SETUP
#line 466 "ldlex.l"
{ BEGIN(VERS_SCRIPT); return *yytext; }
	YY_BREAK
case 194:
YY_RULE_SETUP
#line 468 "ldlex.l"
{ BEGIN(VERS_NODE);
				  vers_node_nesting = 0;
				  return *yytext;
				}
	YY_BREAK
case 195:
YY_RULE_SETUP
#line 472 "ldlex.l"
{ return *yytext; }
	YY_BREAK
case 196:
YY_RULE_SETUP
#line 473 "ldlex.l"
{ vers_node_nesting++; return *yytext; }
	YY_BREAK
case 197:
YY_RULE_SETUP
#line 474 "ldlex.l"
{ if (--vers_node_nesting < 0)
				    BEGIN(VERS_SCRIPT);
				  return *yytext;
				}
	YY_BREAK
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(SCRIPT):
case YY_STATE_EOF(INPUTLIST):
case YY_STATE_EOF(EXPRESSION):
case YY_STATE_EOF(MRI):
case YY_STATE_EOF(WILD):
case YY_STATE_EOF(VERS_START):
case YY_STATE_EOF(VERS_SCRIPT):
case YY_STATE_EOF(VERS_NODE):
#line 479 "ldlex.l"
{
  include_stack_ptr--;
  if (include_stack_ptr == 0)
    {
      lineno = 0;
      yyterminate ();
    }
  else
    yy_switch_to_buffer (include_stack[include_stack_ptr]);

  lineno = lineno_stack[include_stack_ptr];
  input_flags.sysrooted = sysrooted_stack[include_stack_ptr];

  return END;
}
	YY_BREAK
case 198:
YY_RULE_SETUP
#line 495 "ldlex.l"
lex_warn_invalid (_(" in script"), yytext);
	YY_BREAK
case 199:
YY_RULE_SETUP
#line 496 "ldlex.l"
lex_warn_invalid (_(" in expression"), yytext);
	YY_BREAK
case 200:
YY_RULE_SETUP
#line 498 "ldlex.l"
ECHO;
	YY_BREAK
#line 2898 "ldlex.c"

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - (yytext_ptr)) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = (yy_hold_char);
		YY_RESTORE_YY_MORE_OFFSET

		if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between YY_CURRENT_BUFFER and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
			YY_CURRENT_BUFFER_LVALUE->yy_input_file = yyin;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( (yy_c_buf_p) <= &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			(yy_c_buf_p) = (yytext_ptr) + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state(  );

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state );

			yy_bp = (yytext_ptr) + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++(yy_c_buf_p);
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = (yy_c_buf_p);
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer(  ) )
			{
			case EOB_ACT_END_OF_FILE:
				{
				(yy_did_buffer_switch_on_eof) = 0;

				if ( yywrap(  ) )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					(yy_c_buf_p) = (yytext_ptr) + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				(yy_c_buf_p) =
					(yytext_ptr) + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				(yy_c_buf_p) =
				&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)];

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of user's declarations */
} /* end of yylex */

/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */
static int yy_get_next_buffer (void)
{
    	char *dest = YY_CURRENT_BUFFER_LVALUE->yy_ch_buf;
	char *source = (yytext_ptr);
	int number_to_move, i;
	int ret_val;

	if ( (yy_c_buf_p) > &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( YY_CURRENT_BUFFER_LVALUE->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( (yy_c_buf_p) - (yytext_ptr) - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (int) ((yy_c_buf_p) - (yytext_ptr) - 1);

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars) = 0;

	else
		{
			int num_to_read =
			YY_CURRENT_BUFFER_LVALUE->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = YY_CURRENT_BUFFER_LVALUE;

			int yy_c_buf_p_offset =
				(int) ((yy_c_buf_p) - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				int new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yyrealloc( (void *) b->yy_ch_buf,
							 (yy_size_t) (b->yy_buf_size + 2)  );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = NULL;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			(yy_c_buf_p) = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = YY_CURRENT_BUFFER_LVALUE->yy_buf_size -
						number_to_move - 1;

			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[number_to_move]),
			(yy_n_chars), num_to_read );

		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	if ( (yy_n_chars) == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( yyin  );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	if (((yy_n_chars) + number_to_move) > YY_CURRENT_BUFFER_LVALUE->yy_buf_size) {
		/* Extend the array by 50%, plus the number we really need. */
		int new_size = (yy_n_chars) + number_to_move + ((yy_n_chars) >> 1);
		YY_CURRENT_BUFFER_LVALUE->yy_ch_buf = (char *) yyrealloc(
			(void *) YY_CURRENT_BUFFER_LVALUE->yy_ch_buf, (yy_size_t) new_size  );
		if ( ! YY_CURRENT_BUFFER_LVALUE->yy_ch_buf )
			YY_FATAL_ERROR( "out of dynamic memory in yy_get_next_buffer()" );
		/* "- 2" to take care of EOB's */
		YY_CURRENT_BUFFER_LVALUE->yy_buf_size = (int) (new_size - 2);
	}

	(yy_n_chars) += number_to_move;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] = YY_END_OF_BUFFER_CHAR;

	(yytext_ptr) = &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[0];

	return ret_val;
}

/* yy_get_previous_state - get the state just before the EOB char was reached */

    static yy_state_type yy_get_previous_state (void)
{
	yy_state_type yy_current_state;
	char *yy_cp;
    
	yy_current_state = (yy_start);

	for ( yy_cp = (yytext_ptr) + YY_MORE_ADJ; yy_cp < (yy_c_buf_p); ++yy_cp )
		{
		YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 1);
		if ( yy_accept[yy_current_state] )
			{
			(yy_last_accepting_state) = yy_current_state;
			(yy_last_accepting_cpos) = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 1236 )
				yy_c = yy_meta[yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
		}

	return yy_current_state;
}

/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */
    static yy_state_type yy_try_NUL_trans  (yy_state_type yy_current_state )
{
	int yy_is_jam;
    	char *yy_cp = (yy_c_buf_p);

	YY_CHAR yy_c = 1;
	if ( yy_accept[yy_current_state] )
		{
		(yy_last_accepting_state) = yy_current_state;
		(yy_last_accepting_cpos) = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 1236 )
			yy_c = yy_meta[yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
	yy_is_jam = (yy_current_state == 1235);

		return yy_is_jam ? 0 : yy_current_state;
}

#ifndef YY_NO_UNPUT

#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
    static int yyinput (void)
#else
    static int input  (void)
#endif

{
	int c;
    
	*(yy_c_buf_p) = (yy_hold_char);

	if ( *(yy_c_buf_p) == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( (yy_c_buf_p) < &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			/* This was really a NUL. */
			*(yy_c_buf_p) = '\0';

		else
			{ /* need more input */
			int offset = (int) ((yy_c_buf_p) - (yytext_ptr));
			++(yy_c_buf_p);

			switch ( yy_get_next_buffer(  ) )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( yyin );

					/*FALLTHROUGH*/

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap(  ) )
						return 0;

					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput();
#else
					return input();
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					(yy_c_buf_p) = (yytext_ptr) + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) (yy_c_buf_p);	/* cast for 8-bit char's */
	*(yy_c_buf_p) = '\0';	/* preserve yytext */
	(yy_hold_char) = *++(yy_c_buf_p);

	return c;
}
#endif	/* ifndef YY_NO_INPUT */

/** Immediately switch to a different input stream.
 * @param input_file A readable stream.
 * 
 * @note This function does not reset the start condition to @c INITIAL .
 */
    void yyrestart  (FILE * input_file )
{
    
	if ( ! YY_CURRENT_BUFFER ){
        yyensure_buffer_stack ();
		YY_CURRENT_BUFFER_LVALUE =
            yy_create_buffer( yyin, YY_BUF_SIZE );
	}

	yy_init_buffer( YY_CURRENT_BUFFER, input_file );
	yy_load_buffer_state(  );
}

/** Switch to a different input buffer.
 * @param new_buffer The new input buffer.
 * 
 */
    void yy_switch_to_buffer  (YY_BUFFER_STATE  new_buffer )
{
    
	/* TODO. We should be able to replace this entire function body
	 * with
	 *		yypop_buffer_state();
	 *		yypush_buffer_state(new_buffer);
     */
	yyensure_buffer_stack ();
	if ( YY_CURRENT_BUFFER == new_buffer )
		return;

	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	YY_CURRENT_BUFFER_LVALUE = new_buffer;
	yy_load_buffer_state(  );

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	(yy_did_buffer_switch_on_eof) = 1;
}

static void yy_load_buffer_state  (void)
{
    	(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
	(yytext_ptr) = (yy_c_buf_p) = YY_CURRENT_BUFFER_LVALUE->yy_buf_pos;
	yyin = YY_CURRENT_BUFFER_LVALUE->yy_input_file;
	(yy_hold_char) = *(yy_c_buf_p);
}

/** Allocate and initialize an input buffer state.
 * @param file A readable stream.
 * @param size The character buffer size in bytes. When in doubt, use @c YY_BUF_SIZE.
 * 
 * @return the allocated buffer state.
 */
    YY_BUFFER_STATE yy_create_buffer  (FILE * file, int  size )
{
	YY_BUFFER_STATE b;
    
	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yyalloc( (yy_size_t) (b->yy_buf_size + 2)  );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file );

	return b;
}

/** Destroy the buffer.
 * @param b a buffer created with yy_create_buffer()
 * 
 */
    void yy_delete_buffer (YY_BUFFER_STATE  b )
{
    
	if ( ! b )
		return;

	if ( b == YY_CURRENT_BUFFER ) /* Not sure if we should pop here. */
		YY_CURRENT_BUFFER_LVALUE = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yyfree( (void *) b->yy_ch_buf  );

	yyfree( (void *) b  );
}

/* Initializes or reinitializes a buffer.
 * This function is sometimes called more than once on the same buffer,
 * such as during a yyrestart() or at EOF.
 */
    static void yy_init_buffer  (YY_BUFFER_STATE  b, FILE * file )

{
	int oerrno = errno;
    
	yy_flush_buffer( b );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

    /* If b is the current buffer, then yy_init_buffer was _probably_
     * called from yyrestart() or through yy_get_next_buffer.
     * In that case, we don't want to reset the lineno or column.
     */
    if (b != YY_CURRENT_BUFFER){
        b->yy_bs_lineno = 1;
        b->yy_bs_column = 0;
    }

        b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
    
	errno = oerrno;
}

/** Discard all buffered characters. On the next scan, YY_INPUT will be called.
 * @param b the buffer state to be flushed, usually @c YY_CURRENT_BUFFER.
 * 
 */
    void yy_flush_buffer (YY_BUFFER_STATE  b )
{
    	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == YY_CURRENT_BUFFER )
		yy_load_buffer_state(  );
}

/** Pushes the new state onto the stack. The new state becomes
 *  the current state. This function will allocate the stack
 *  if necessary.
 *  @param new_buffer The new state.
 *  
 */
void yypush_buffer_state (YY_BUFFER_STATE new_buffer )
{
    	if (new_buffer == NULL)
		return;

	yyensure_buffer_stack();

	/* This block is copied from yy_switch_to_buffer. */
	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	/* Only push if top exists. Otherwise, replace top. */
	if (YY_CURRENT_BUFFER)
		(yy_buffer_stack_top)++;
	YY_CURRENT_BUFFER_LVALUE = new_buffer;

	/* copied from yy_switch_to_buffer. */
	yy_load_buffer_state(  );
	(yy_did_buffer_switch_on_eof) = 1;
}

/** Removes and deletes the top of the stack, if present.
 *  The next element becomes the new top.
 *  
 */
void yypop_buffer_state (void)
{
    	if (!YY_CURRENT_BUFFER)
		return;

	yy_delete_buffer(YY_CURRENT_BUFFER );
	YY_CURRENT_BUFFER_LVALUE = NULL;
	if ((yy_buffer_stack_top) > 0)
		--(yy_buffer_stack_top);

	if (YY_CURRENT_BUFFER) {
		yy_load_buffer_state(  );
		(yy_did_buffer_switch_on_eof) = 1;
	}
}

/* Allocates the stack if it does not exist.
 *  Guarantees space for at least one push.
 */
static void yyensure_buffer_stack (void)
{
	yy_size_t num_to_alloc;
    
	if (!(yy_buffer_stack)) {

		/* First allocation is just for 2 elements, since we don't know if this
		 * scanner will even need a stack. We use 2 instead of 1 to avoid an
		 * immediate realloc on the next call.
         */
      num_to_alloc = 1; /* After all that talk, this was set to 1 anyways... */
		(yy_buffer_stack) = (struct yy_buffer_state**)yyalloc
								(num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		memset((yy_buffer_stack), 0, num_to_alloc * sizeof(struct yy_buffer_state*));

		(yy_buffer_stack_max) = num_to_alloc;
		(yy_buffer_stack_top) = 0;
		return;
	}

	if ((yy_buffer_stack_top) >= ((yy_buffer_stack_max)) - 1){

		/* Increase the buffer to prepare for a possible push. */
		yy_size_t grow_size = 8 /* arbitrary grow size */;

		num_to_alloc = (yy_buffer_stack_max) + grow_size;
		(yy_buffer_stack) = (struct yy_buffer_state**)yyrealloc
								((yy_buffer_stack),
								num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		/* zero only the new slots.*/
		memset((yy_buffer_stack) + (yy_buffer_stack_max), 0, grow_size * sizeof(struct yy_buffer_state*));
		(yy_buffer_stack_max) = num_to_alloc;
	}
}

/** Setup the input buffer state to scan directly from a user-specified character buffer.
 * @param base the character buffer
 * @param size the size in bytes of the character buffer
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_buffer  (char * base, yy_size_t  size )
{
	YY_BUFFER_STATE b;
    
	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return NULL;

	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = (int) (size - 2);	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = NULL;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_is_interactive = 0;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b  );

	return b;
}

/** Setup the input buffer state to scan a string. The next call to yylex() will
 * scan from a @e copy of @a str.
 * @param yystr a NUL-terminated string to scan
 * 
 * @return the newly allocated buffer state object.
 * @note If you want to scan bytes that may contain NUL values, then use
 *       yy_scan_bytes() instead.
 */
YY_BUFFER_STATE yy_scan_string (const char * yystr )
{
    
	return yy_scan_bytes( yystr, (int) strlen(yystr) );
}

/** Setup the input buffer state to scan the given bytes. The next call to yylex() will
 * scan from a @e copy of @a bytes.
 * @param yybytes the byte buffer to scan
 * @param _yybytes_len the number of bytes in the buffer pointed to by @a bytes.
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_bytes  (const char * yybytes, int  _yybytes_len )
{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	int i;
    
	/* Get memory for full buffer, including space for trailing EOB's. */
	n = (yy_size_t) (_yybytes_len + 2);
	buf = (char *) yyalloc( n  );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < _yybytes_len; ++i )
		buf[i] = yybytes[i];

	buf[_yybytes_len] = buf[_yybytes_len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n );
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
}

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

static void yynoreturn yy_fatal_error (const char* msg )
{
			fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
}

/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		yytext[yyleng] = (yy_hold_char); \
		(yy_c_buf_p) = yytext + yyless_macro_arg; \
		(yy_hold_char) = *(yy_c_buf_p); \
		*(yy_c_buf_p) = '\0'; \
		yyleng = yyless_macro_arg; \
		} \
	while ( 0 )

/* Accessor  methods (get/set functions) to struct members. */

/** Get the current line number.
 * 
 */
int yyget_lineno  (void)
{
    
    return yylineno;
}

/** Get the input stream.
 * 
 */
FILE *yyget_in  (void)
{
        return yyin;
}

/** Get the output stream.
 * 
 */
FILE *yyget_out  (void)
{
        return yyout;
}

/** Get the length of the current token.
 * 
 */
int yyget_leng  (void)
{
        return yyleng;
}

/** Get the current token.
 * 
 */

char *yyget_text  (void)
{
        return yytext;
}

/** Set the current line number.
 * @param _line_number line number
 * 
 */
void yyset_lineno (int  _line_number )
{
    
    yylineno = _line_number;
}

/** Set the input stream. This does not discard the current
 * input buffer.
 * @param _in_str A readable stream.
 * 
 * @see yy_switch_to_buffer
 */
void yyset_in (FILE *  _in_str )
{
        yyin = _in_str ;
}

void yyset_out (FILE *  _out_str )
{
        yyout = _out_str ;
}

int yyget_debug  (void)
{
        return yy_flex_debug;
}

void yyset_debug (int  _bdebug )
{
        yy_flex_debug = _bdebug ;
}

static int yy_init_globals (void)
{
        /* Initialization is the same as for the non-reentrant scanner.
     * This function is called from yylex_destroy(), so don't allocate here.
     */

    (yy_buffer_stack) = NULL;
    (yy_buffer_stack_top) = 0;
    (yy_buffer_stack_max) = 0;
    (yy_c_buf_p) = NULL;
    (yy_init) = 0;
    (yy_start) = 0;

/* Defined in main.c */
#ifdef YY_STDINIT
    yyin = stdin;
    yyout = stdout;
#else
    yyin = NULL;
    yyout = NULL;
#endif

    /* For future reference: Set errno on error, since we are called by
     * yylex_init()
     */
    return 0;
}

/* yylex_destroy is for both reentrant and non-reentrant scanners. */
int yylex_destroy  (void)
{
    
    /* Pop the buffer stack, destroying each element. */
	while(YY_CURRENT_BUFFER){
		yy_delete_buffer( YY_CURRENT_BUFFER  );
		YY_CURRENT_BUFFER_LVALUE = NULL;
		yypop_buffer_state();
	}

	/* Destroy the stack itself. */
	yyfree((yy_buffer_stack) );
	(yy_buffer_stack) = NULL;

    /* Reset the globals. This is important in a non-reentrant scanner so the next time
     * yylex() is called, initialization will occur. */
    yy_init_globals( );

    return 0;
}

/*
 * Internal utility routines.
 */

#ifndef yytext_ptr
static void yy_flex_strncpy (char* s1, const char * s2, int n )
{
		
	int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
}
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen (const char * s )
{
	int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
}
#endif

void *yyalloc (yy_size_t  size )
{
			return malloc(size);
}

void *yyrealloc  (void * ptr, yy_size_t  size )
{
		
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return realloc(ptr, size);
}

void yyfree (void * ptr )
{
			free( (char *) ptr );	/* see yyrealloc() for (char *) cast */
}

#define YYTABLES_NAME "yytables"

#line 498 "ldlex.l"



/* Switch flex to reading script file NAME, open on FILE,
   saving the current input info on the include stack.  */

void
lex_push_file (FILE *file, const char *name, unsigned int sysrooted)
{
  if (include_stack_ptr >= MAX_INCLUDE_DEPTH)
    {
      einfo (_("%F:includes nested too deeply\n"));
    }
  file_name_stack[include_stack_ptr] = name;
  lineno_stack[include_stack_ptr] = lineno;
  sysrooted_stack[include_stack_ptr] = input_flags.sysrooted;
  include_stack[include_stack_ptr] = YY_CURRENT_BUFFER;

  include_stack_ptr++;
  lineno = 1;
  input_flags.sysrooted = sysrooted;
  yyin = file;
  yy_switch_to_buffer (yy_create_buffer (yyin, YY_BUF_SIZE));
}

/* Return a newly created flex input buffer containing STRING,
   which is SIZE bytes long.  */

static YY_BUFFER_STATE
yy_create_string_buffer (const char *string, size_t size)
{
  YY_BUFFER_STATE b;

  b = xmalloc (sizeof (struct yy_buffer_state));
  b->yy_input_file = 0;
  b->yy_buf_size = size;

  /* yy_ch_buf has to be 2 characters longer than the size given because
     we need to put in 2 end-of-buffer characters.  */
  b->yy_ch_buf = xmalloc ((size_t) b->yy_buf_size + 3);

  b->yy_ch_buf[0] = '\n';
  strcpy (b->yy_ch_buf+1, string);
  b->yy_ch_buf[size+1] = YY_END_OF_BUFFER_CHAR;
  b->yy_ch_buf[size+2] = YY_END_OF_BUFFER_CHAR;
  b->yy_n_chars = size+1;
  b->yy_buf_pos = &b->yy_ch_buf[1];

  b->yy_is_our_buffer = 1;
  b->yy_is_interactive = 0;
  b->yy_at_bol = 1;
  b->yy_fill_buffer = 0;

  /* flex 2.4.7 changed the interface.  FIXME: We should not be using
     a flex internal interface in the first place!  */
#ifdef YY_BUFFER_NEW
  b->yy_buffer_status = YY_BUFFER_NEW;
#else
  b->yy_eof_status = EOF_NOT_SEEN;
#endif

  return b;
}

/* Switch flex to reading from STRING, saving the current input info
   on the include stack.  */

void
lex_redirect (const char *string, const char *fake_filename, unsigned int count)
{
  YY_BUFFER_STATE tmp;

  yy_init = 0;
  if (include_stack_ptr >= MAX_INCLUDE_DEPTH)
    {
      einfo (_("%F: macros nested too deeply\n"));
    }
  file_name_stack[include_stack_ptr] = fake_filename;
  lineno_stack[include_stack_ptr] = lineno;
  include_stack[include_stack_ptr] = YY_CURRENT_BUFFER;
  include_stack_ptr++;
  lineno = count;
  tmp = yy_create_string_buffer (string, strlen (string));
  yy_switch_to_buffer (tmp);
}

/* Functions to switch to a different flex start condition,
   saving the current start condition on `state_stack'.  */

static int state_stack[MAX_INCLUDE_DEPTH * 2];
static int *state_stack_p = state_stack;

void
ldlex_script (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (SCRIPT);
}

void
ldlex_inputlist (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (INPUTLIST);
}

void
ldlex_mri_script (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (MRI);
}

void
ldlex_version_script (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (VERS_START);
}

void
ldlex_version_file (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (VERS_SCRIPT);
}

void
ldlex_expression (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (EXPRESSION);
}

void
ldlex_wild (void)
{
  *(state_stack_p)++ = yy_start;
  BEGIN (WILD);
}

void
ldlex_popstate (void)
{
  yy_start = *(--state_stack_p);
}

/* In cases where the parser needs to look ahead and the context
   changes from expression to script or vice-versa, throw away a
   NAME.  What constitutes a NAME depends on context.  */

void
ldlex_backup (void)
{
  yyless (0);
}

/* Return the current file name, or the previous file if no file is
   current.  */

const char*
ldlex_filename (void)
{
  return file_name_stack[include_stack_ptr - (include_stack_ptr != 0)];
}


/* Place up to MAX_SIZE characters in BUF and return
   either the number of characters read, or 0 to indicate EOF.  */

static int
yy_input (char *buf, int max_size)
{
  int result = 0;
  if (YY_CURRENT_BUFFER != NULL && YY_CURRENT_BUFFER->yy_input_file)
    {
      if (yyin)
	{
	  result = fread (buf, 1, max_size, yyin);
	  if (result < max_size && ferror (yyin))
	    einfo (_("%F%P: read in flex scanner failed\n"));
	}
    }
  return result;
}

/* Eat the rest of a C-style comment.  */

static void
comment (void)
{
  int c;

  while (1)
    {
      c = input();
      while (c != '*' && c != 0)
	{
	  if (c == '\n')
	    lineno++;
	  c = input();
	}

      if (c == '*')
	{
	  c = input();
	  while (c == '*')
	    c = input();
	  if (c == '/')
	    break;			/* found the end */
	}

      if (c == '\n')
	lineno++;

      if (c == 0)
	{
	  einfo (_("%F%P: EOF in comment\n"));
	  break;
	}
    }
}

/* Warn the user about a garbage character WHAT in the input
   in context WHERE.  */

static void
lex_warn_invalid (char *where, char *what)
{
  char buf[5];

  /* If we have found an input file whose format we do not recognize,
     and we are therefore treating it as a linker script, and we find
     an invalid character, then most likely this is a real object file
     of some different format.  Treat it as such.  */
  if (ldfile_assumed_script)
    {
      bfd_set_error (bfd_error_file_not_recognized);
      einfo (_("%F%s: file not recognized: %E\n"), ldlex_filename ());
    }

  if (! ISPRINT (*what))
    {
      sprintf (buf, "\\%03o", *(unsigned char *) what);
      what = buf;
    }

  einfo (_("%P:%pS: ignoring invalid character `%s'%s\n"), NULL, what, where);
}

