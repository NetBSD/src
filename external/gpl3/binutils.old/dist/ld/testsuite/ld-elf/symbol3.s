	 .comm badsym,4
