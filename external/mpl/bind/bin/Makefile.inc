#	$NetBSD: Makefile.inc,v 1.1.4.2 2019/06/10 22:02:52 christos Exp $

.include "${.PARSEDIR}/../Makefile.inc"
WARNS?=		2
