/*
 * Generated by dtrace(1M).
 */

#ifndef	_PROBES_H
#define	_PROBES_H

#include <unistd.h>

#ifdef	__cplusplus
extern "C" {
#endif

#include <sys/sdt.h>

#if defined(DTRACE) && _DTRACE_VERSION

#define	LIBDNS_XFRIN_AXFR_FINALIZE_BEGIN(arg0, arg1) \
	__dtrace_libdns___xfrin_axfr_finalize_begin(arg0, arg1)
#ifndef	__sparc
#define	LIBDNS_XFRIN_AXFR_FINALIZE_BEGIN_ENABLED() \
	__dtraceenabled_libdns___xfrin_axfr_finalize_begin()
#else
#define	LIBDNS_XFRIN_AXFR_FINALIZE_BEGIN_ENABLED() \
	__dtraceenabled_libdns___xfrin_axfr_finalize_begin(0)
#endif
#define	LIBDNS_XFRIN_AXFR_FINALIZE_END(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_axfr_finalize_end(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_AXFR_FINALIZE_END_ENABLED() \
	__dtraceenabled_libdns___xfrin_axfr_finalize_end()
#else
#define	LIBDNS_XFRIN_AXFR_FINALIZE_END_ENABLED() \
	__dtraceenabled_libdns___xfrin_axfr_finalize_end(0)
#endif
#define	LIBDNS_XFRIN_CONNECTED(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_connected(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_CONNECTED_ENABLED() \
	__dtraceenabled_libdns___xfrin_connected()
#else
#define	LIBDNS_XFRIN_CONNECTED_ENABLED() \
	__dtraceenabled_libdns___xfrin_connected(0)
#endif
#define	LIBDNS_XFRIN_DONE_CALLBACK_BEGIN(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_done_callback_begin(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_DONE_CALLBACK_BEGIN_ENABLED() \
	__dtraceenabled_libdns___xfrin_done_callback_begin()
#else
#define	LIBDNS_XFRIN_DONE_CALLBACK_BEGIN_ENABLED() \
	__dtraceenabled_libdns___xfrin_done_callback_begin(0)
#endif
#define	LIBDNS_XFRIN_DONE_CALLBACK_END(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_done_callback_end(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_DONE_CALLBACK_END_ENABLED() \
	__dtraceenabled_libdns___xfrin_done_callback_end()
#else
#define	LIBDNS_XFRIN_DONE_CALLBACK_END_ENABLED() \
	__dtraceenabled_libdns___xfrin_done_callback_end(0)
#endif
#define	LIBDNS_XFRIN_READ(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_read(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_READ_ENABLED() \
	__dtraceenabled_libdns___xfrin_read()
#else
#define	LIBDNS_XFRIN_READ_ENABLED() \
	__dtraceenabled_libdns___xfrin_read(0)
#endif
#define	LIBDNS_XFRIN_RECV_ANSWER(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_recv_answer(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_ANSWER_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_answer()
#else
#define	LIBDNS_XFRIN_RECV_ANSWER_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_answer(0)
#endif
#define	LIBDNS_XFRIN_RECV_DONE(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_recv_done(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_DONE_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_done()
#else
#define	LIBDNS_XFRIN_RECV_DONE_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_done(0)
#endif
#define	LIBDNS_XFRIN_RECV_PARSED(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_recv_parsed(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_PARSED_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_parsed()
#else
#define	LIBDNS_XFRIN_RECV_PARSED_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_parsed(0)
#endif
#define	LIBDNS_XFRIN_RECV_QUESTION(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_recv_question(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_QUESTION_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_question()
#else
#define	LIBDNS_XFRIN_RECV_QUESTION_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_question(0)
#endif
#define	LIBDNS_XFRIN_RECV_SEND_REQUEST(arg0, arg1) \
	__dtrace_libdns___xfrin_recv_send_request(arg0, arg1)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_SEND_REQUEST_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_send_request()
#else
#define	LIBDNS_XFRIN_RECV_SEND_REQUEST_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_send_request(0)
#endif
#define	LIBDNS_XFRIN_RECV_START(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_recv_start(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_START_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_start()
#else
#define	LIBDNS_XFRIN_RECV_START_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_start(0)
#endif
#define	LIBDNS_XFRIN_RECV_TRY_AXFR(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_recv_try_axfr(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_RECV_TRY_AXFR_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_try_axfr()
#else
#define	LIBDNS_XFRIN_RECV_TRY_AXFR_ENABLED() \
	__dtraceenabled_libdns___xfrin_recv_try_axfr(0)
#endif
#define	LIBDNS_XFRIN_SENT(arg0, arg1, arg2) \
	__dtrace_libdns___xfrin_sent(arg0, arg1, arg2)
#ifndef	__sparc
#define	LIBDNS_XFRIN_SENT_ENABLED() \
	__dtraceenabled_libdns___xfrin_sent()
#else
#define	LIBDNS_XFRIN_SENT_ENABLED() \
	__dtraceenabled_libdns___xfrin_sent(0)
#endif
#define	LIBDNS_XFRIN_START(arg0, arg1) \
	__dtrace_libdns___xfrin_start(arg0, arg1)
#ifndef	__sparc
#define	LIBDNS_XFRIN_START_ENABLED() \
	__dtraceenabled_libdns___xfrin_start()
#else
#define	LIBDNS_XFRIN_START_ENABLED() \
	__dtraceenabled_libdns___xfrin_start(0)
#endif


extern void __dtrace_libdns___xfrin_axfr_finalize_begin(void *, char *);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_axfr_finalize_begin(void);
#else
extern int __dtraceenabled_libdns___xfrin_axfr_finalize_begin(long);
#endif
extern void __dtrace_libdns___xfrin_axfr_finalize_end(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_axfr_finalize_end(void);
#else
extern int __dtraceenabled_libdns___xfrin_axfr_finalize_end(long);
#endif
extern void __dtrace_libdns___xfrin_connected(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_connected(void);
#else
extern int __dtraceenabled_libdns___xfrin_connected(long);
#endif
extern void __dtrace_libdns___xfrin_done_callback_begin(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_done_callback_begin(void);
#else
extern int __dtraceenabled_libdns___xfrin_done_callback_begin(long);
#endif
extern void __dtrace_libdns___xfrin_done_callback_end(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_done_callback_end(void);
#else
extern int __dtraceenabled_libdns___xfrin_done_callback_end(long);
#endif
extern void __dtrace_libdns___xfrin_read(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_read(void);
#else
extern int __dtraceenabled_libdns___xfrin_read(long);
#endif
extern void __dtrace_libdns___xfrin_recv_answer(void *, char *, void *);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_answer(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_answer(long);
#endif
extern void __dtrace_libdns___xfrin_recv_done(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_done(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_done(long);
#endif
extern void __dtrace_libdns___xfrin_recv_parsed(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_parsed(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_parsed(long);
#endif
extern void __dtrace_libdns___xfrin_recv_question(void *, char *, void *);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_question(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_question(long);
#endif
extern void __dtrace_libdns___xfrin_recv_send_request(void *, char *);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_send_request(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_send_request(long);
#endif
extern void __dtrace_libdns___xfrin_recv_start(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_start(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_start(long);
#endif
extern void __dtrace_libdns___xfrin_recv_try_axfr(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_recv_try_axfr(void);
#else
extern int __dtraceenabled_libdns___xfrin_recv_try_axfr(long);
#endif
extern void __dtrace_libdns___xfrin_sent(void *, char *, int);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_sent(void);
#else
extern int __dtraceenabled_libdns___xfrin_sent(long);
#endif
extern void __dtrace_libdns___xfrin_start(void *, char *);
#ifndef	__sparc
extern int __dtraceenabled_libdns___xfrin_start(void);
#else
extern int __dtraceenabled_libdns___xfrin_start(long);
#endif

#else

#define	LIBDNS_XFRIN_AXFR_FINALIZE_BEGIN(arg0, arg1)
#define	LIBDNS_XFRIN_AXFR_FINALIZE_BEGIN_ENABLED() (0)
#define	LIBDNS_XFRIN_AXFR_FINALIZE_END(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_AXFR_FINALIZE_END_ENABLED() (0)
#define	LIBDNS_XFRIN_CONNECTED(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_CONNECTED_ENABLED() (0)
#define	LIBDNS_XFRIN_DONE_CALLBACK_BEGIN(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_DONE_CALLBACK_BEGIN_ENABLED() (0)
#define	LIBDNS_XFRIN_DONE_CALLBACK_END(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_DONE_CALLBACK_END_ENABLED() (0)
#define	LIBDNS_XFRIN_READ(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_READ_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_ANSWER(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_RECV_ANSWER_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_DONE(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_RECV_DONE_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_PARSED(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_RECV_PARSED_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_QUESTION(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_RECV_QUESTION_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_SEND_REQUEST(arg0, arg1)
#define	LIBDNS_XFRIN_RECV_SEND_REQUEST_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_START(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_RECV_START_ENABLED() (0)
#define	LIBDNS_XFRIN_RECV_TRY_AXFR(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_RECV_TRY_AXFR_ENABLED() (0)
#define	LIBDNS_XFRIN_SENT(arg0, arg1, arg2)
#define	LIBDNS_XFRIN_SENT_ENABLED() (0)
#define	LIBDNS_XFRIN_START(arg0, arg1)
#define	LIBDNS_XFRIN_START_ENABLED() (0)


#ifdef	__cplusplus
}
#endif
#endif

#endif	/* _PROBES_H */
