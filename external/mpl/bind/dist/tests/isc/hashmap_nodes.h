/*	$NetBSD: hashmap_nodes.h,v 1.1.1.1 2025/01/26 16:12:37 christos Exp $	*/

/*
 * Copyright (C) Internet Systems Consortium,
 *
 * SPDX-License-Identifier: MPL-2.0
 *
 * This Source Code Form is subject to the terms of the Mozilla Public
 * License,
 * file,
 *
 * See the COPYRIGHT file distributed with this work for additional
 * information regarding copyright ownership.
 */

static uint32_t test_hashvals[7600] = {
	3841102673, 1809541028, 1903637429, 1046245187, 1149327226, 1901291864,
	3563857243, 3294439795, 2911777134, 299109939,	18888681,   2027082724,
	498063085,  531937216,	2448274142, 1811775719, 734835041,  2969987588,
	3308224020, 3999015521, 3284930853, 719784202,	370628116,  3795202094,
	3121256171, 2411602759, 3905809221, 3406797703, 2484712322, 2197033566,
	86385420,   1190197206, 3332487341, 3602391954, 3388878825, 1346796421,
	1532403251, 89875263,	1353426976, 3134481644, 469959502,  2243166999,
	1780892742, 3408583,	2474395433, 3818469105, 4149416712, 2277905622,
	469859298,  3573143905, 2394883001, 3744113994, 3777037522, 3263386576,
	2890883303, 1719207568, 2597710166, 1515838230, 1544293506, 1700566823,
	2368861266, 1658491065, 245685344,  1466341878, 2073584873, 1820848033,
	2621339547, 1591237059, 241569807,  3751895861, 1991696053, 3093039851,
	785928797,  2298032443, 2600370299, 2566637836, 3575126318, 3037484030,
	3870054109, 984217248,	3109146942, 2790679370, 1176133362, 3274972579,
	2100992062, 4217966852, 944284447,  893632538,	3353517904, 2916464,
	627398567,  2966328244, 4078221389, 1178173140, 1035333972, 1927138714,
	3851427445, 1712147432, 450854730,  826697784,	1674930493, 4075345481,
	35011757,   1145644671, 3570992459, 2572347601, 3911109760, 631152617,
	1048250612, 3270264982, 2024291700, 3377814302, 2451971626, 3316846161,
	1303469565, 65739751,	3179420285, 2780600870, 625804384,  1144716197,
	1072418826, 3768817264, 1807951406, 42677674,	1475845100, 1330453409,
	3005968320, 82053832,	150023478,  225599003,	1306112944, 81581763,
	2121566960, 1310277435, 1090382288, 1464778816, 498171106,  972647404,
	3665136733, 2449324294, 2359895954, 1764704299, 241860468,  1843132952,
	1028541192, 1367399366, 3845792910, 3909298529, 1834234695, 3322076843,
	2411387414, 4168124313, 3101250345, 21644345,	697130874,  4144166039,
	2803524683, 1525213238, 914511452,  515065891,	457885431,  697579427,
	3484032772, 2415290094, 279495174,  1324748129, 3714489123, 19861365,
	2281715783, 736077013,	3298489539, 1548290976, 1784601242, 1738185054,
	334641407,  1919367279, 1153259783, 489169500,	3060370500, 1658999745,
	2623453673, 574604636,	2966239027, 763676942,	1985611170, 1023014778,
	2483586781, 1087771823, 3471673963, 2759104492, 2521385881, 80961653,
	2336795290, 623676298,	1341845069, 3014231570, 3729068031, 2580438613,
	335681213,  3273746491, 602461434,  443835916,	1781559377, 66304553,
	3970114159, 3493460385, 714000295,  2421423356, 3177775021, 1022839776,
	492264970,  2738431967, 966172587,  2248108039, 3295392314, 1534214730,
	156434855,  3355253601, 316212055,  2710049597, 448734073,  481168241,
	3362926696, 3755953413, 3306420585, 887493973,	511514548,  914802316,
	1396437607, 2346020455, 932167855,  3858281260, 39468201,   510577313,
	269537133,  3054526667, 2101981083, 3140842852, 1701089741, 46477045,
	158819974,  1796403269, 325655649,  1569204146, 3087094678, 1762903302,
	814590579,  2361657112, 1237231553, 4253018518, 3592803641, 219735038,
	803744014,  2730768572, 2155042364, 774002380,	2799393296, 1804150751,
	4199879641, 1601059336, 2217711207, 1984444104, 2094149197, 4064660124,
	3779535204, 2961230883, 2981458119, 650206357,	2564824771, 4225029547,
	3781706210, 1597725737, 506538139,  1183431757, 2956393285, 985394861,
	2761304801, 1077256678, 2151821915, 133032229,	1606672465, 2627520418,
	2770565873, 871496594,	3982569514, 3107137880, 1262146205, 3864720621,
	3730189263, 3738306603, 3251394761, 3270573507, 3565352865, 3525792609,
	1660423514, 3582477287, 2424390534, 2544447204, 179290813,  4305674,
	2160509121, 732101291,	1368750158, 1683299046, 1311425445, 1546454351,
	3375472179, 4100827442, 3618218499, 969608271,	3755963933, 4018087479,
	1974595081, 2055417862, 532467033,  637621727,	1724322004, 911706369,
	2331731546, 2582351102, 1136465413, 2340999748, 3300596621, 1178177232,
	3163825331, 3639806741, 635193853,  907362204,	4019337088, 154255368,
	783766169,  2112386904, 1977539225, 3934462903, 1788346884, 1490978145,
	2391617835, 3148766088, 3499128109, 134430500,	2250853372, 944033245,
	2134771872, 2940782639, 1773230033, 3454496985, 2359771631, 2531234360,
	4039362013, 472034694,	3792297650, 1631704336, 3506786153, 4133606327,
	678333834,  2853127224, 3517910309, 2999990469, 2761656087, 2034271640,
	1506856981, 3782107927, 662440266,  1523451614, 3401986268, 487989167,
	473318313,  185032904,	1155206240, 3669878361, 414739018,  3529306871,
	4071715253, 2227459242, 446279459,  876422699,	264013555,  853192683,
	808262991,  447329281,	1244065056, 871617536,	1420637576, 710107369,
	1160189650, 2346425175, 349178618,  1495228393, 1928576977, 1990301709,
	3437371705, 2939018789, 3033728948, 576629871,	4235274334, 999010266,
	305073187,  23647531,	2970509440, 2493199598, 2792238114, 3460925880,
	1400930509, 3458115440, 2993245353, 3629769755, 2543525108, 919693111,
	3013552885, 163710992,	1950458789, 2329668102, 1848813229, 928104121,
	3456723818, 2212085382, 2829948216, 199557795,	2878428840, 2965725125,
	3589499862, 2276234424, 3266822273, 4133575596, 3030777184, 2484123036,
	2971605683, 1638399791, 2455213622, 1240271140, 2149338562, 2730135368,
	3745277446, 3839698550, 3179859270, 1252677633, 2513230695, 2972782263,
	1409504368, 3528436589, 31091184,   1656693061, 4018247831, 2325307040,
	2377834806, 3856121254, 548228247,  583738771,	874660888,  1969130267,
	1842979597, 800680441,	2485895810, 1877411344, 278069112,  3342115327,
	3180389942, 504833327,	1234388843, 2661953037, 998553508,  3129539484,
	3760911539, 54264925,	1777694431, 2435783901, 165626970,  944205832,
	2791896658, 416143833,	1633648999, 1719402143, 776809583,  816453053,
	2236649856, 3950386579, 809364972,  1239912644, 549489737,  1861220431,
	3307813949, 2531005387, 2792136166, 1106090492, 3128424896, 1380858864,
	3151871571, 1785583784, 612017645,  1619323089, 638260510,  3945744034,
	821667310,  45707937,	3705071373, 3363506493, 2347396464, 1491256231,
	1900548721, 2802392700, 1536771943, 328330323,	2475842166, 4056125865,
	4192900589, 2926839299, 3641185212, 1451813778, 42565090,   695100657,
	3764718948, 3607619707, 250952812,  2046087503, 2143566249, 2440254607,
	3039861528, 1544024576, 3127655166, 3892510063, 2662108809, 406400712,
	1308988949, 2012308641, 1512885756, 4069357934, 1996983172, 1113882883,
	2525724192, 483913556,	2901938094, 216741840,	1479112490, 2673574272,
	2339642128, 3033420598, 508970632,  4216392984, 1624462114, 4146155033,
	1235775801, 3571106309, 153406062,  1077382985, 831262796,  3924491469,
	898474640,  1835453815, 2168656091, 2139054232, 2842594524, 865057798,
	3521485790, 706589184,	3630275351, 442654525,	3649132231, 4064892721,
	770914765,  2911656231, 1466160580, 1392799864, 1754326154, 3008584681,
	2786486379, 4185203471, 3481456939, 2453640024, 1002731146, 3903135995,
	2780515401, 3638130482, 176280973,  4185852537, 1312974557, 3365150586,
	1242396703, 2316124851, 2850112627, 2435716207, 2431940276, 1774980217,
	2406939914, 3201886928, 2372640845, 329501575,	3723619115, 4188987422,
	1896461401, 2526631490, 2624542397, 996130499,	1016207628, 2206451744,
	3116285744, 1964260089, 90314482,   1524882094, 1691851795, 4023135584,
	3988278405, 2429051063, 3968501083, 3795801619, 2768679781, 1344902708,
	1536628020, 2238192130, 3301290946, 2301267049, 727425117,  2200250416,
	804749203,  80858401,	1111020492, 2586255515, 4253955356, 420933653,
	597476258,  2849290935, 3857423560, 3767905973, 565981007,  2924199740,
	2506842469, 617472914,	2118442894, 1897226275, 1177802909, 1233977289,
	2408492386, 1377989092, 1000773207, 3727792827, 1102026419, 3370093241,
	2247890921, 1510805837, 692708428,  1545229490, 1152168117, 1300759859,
	2150116058, 2032539693, 523863863,  1912198114, 2448348916, 2080600047,
	1927396425, 3827002006, 4092540409, 2478116920, 3385622598, 4274114794,
	2710367315, 2464603161, 1643726698, 445436705,	2615629956, 3698180677,
	2376044868, 134514343,	1076894708, 1246267069, 3087608137, 222499211,
	2718842682, 263113721,	3411424997, 2896964295, 3730940396, 2452559470,
	4132690712, 1647679701, 4165004547, 417500981,	3841406985, 1576569542,
	3145425743, 276204989,	2828672609, 122349394,	838476047,  3069159772,
	3143861343, 4264814689, 3453479886, 3597013151, 3578484119, 1055483663,
	3812825531, 1965428134, 3643760591, 1271675789, 3383496436, 1038674687,
	594848492,  3950667705, 1332454765, 4070524344, 3970317816, 254214559,
	2308220963, 1360142732, 864078057,  2814280032, 1947155572, 3901289318,
	637735404,  3671693468, 689138761,  1249369854, 3048303257, 1865656388,
	1648675187, 2458982936, 3538224427, 2088574085, 2330602517, 3288598607,
	278951126,  3032710787, 3889538380, 4279883752, 1288418,    85098533,
	1254008652, 1087779055, 2337573732, 3223716696, 3832242523, 1084846064,
	1845533309, 175150645,	3935990964, 3356412665, 1396878213, 2139320393,
	2616885256, 3293286720, 2011142165, 3303655545, 2079367120, 3521657256,
	681782127,  2098824716, 4261637498, 2735704386, 1656400050, 2508921950,
	3929330925, 3733864821, 3333890978, 417190854,	2701253854, 569959074,
	1804770002, 2196477714, 1499921244, 3109307237, 342287209,  143811474,
	1299146602, 4013321247, 1471680095, 3217014207, 3599282976, 3211482135,
	1100137289, 4286821680, 121858409,  2005122076, 3622359261, 3724585473,
	2202909816, 841710233,	2267217040, 739356292,	3531054287, 860808402,
	2317887193, 2054377711, 166898562,  2400420110, 1291515048, 2839246718,
	431433426,  3315468892, 1753551485, 635396429,	1611040690, 2705106063,
	650303826,  199431520,	447003644,  1514630220, 3189537575, 2814586421,
	3913784524, 2565030506, 1388459299, 3341242648, 2062717685, 1672455967,
	2420531258, 3475924396, 3149501490, 463416941,	1265031974, 3001755980,
	829795567,  3512201124, 2483114037, 981414890,	81169346,   2428745406,
	2323395971, 1679652975, 2883331384, 4203834393, 2818118889, 3280041053,
	3782148899, 1725018191, 1838876017, 624154748,	2346650431, 598757673,
	3134273647, 423786434,	2001474029, 3566690892, 473909958,  2746698562,
	1017676321, 3926027142, 654186429,  115832717,	1902716731, 837842790,
	2524599484, 1233399784, 947234637,  1400725218, 241911819,  2888912415,
	2630333347, 314247513,	1552855844, 161784709,	4259505964, 161302879,
	1761795699, 4227743070, 2643583749, 1009462962, 2837679379, 2292687482,
	1524921061, 2002349128, 3551432244, 4247785564, 4224569883, 1881084367,
	302577177,  3609374778, 4269614890, 371976819,	80597769,   1983702172,
	1640507643, 3838562913, 2681361190, 3465651157, 2622023614, 4170996626,
	402908527,  3845731029, 1019841963, 3650604013, 1764426416, 4020734395,
	3589000660, 205349209,	3273462246, 4062061133, 471994328,  2464940282,
	3094950909, 2335508094, 3188702215, 2119712661, 175691120,  3782417834,
	1889007352, 919494514,	2945977817, 2177795336, 822593106,  410598614,
	985679818,  2029528388, 3566066624, 806219373,	4038768001, 958857572,
	386107996,  1122255528, 2027796791, 3013407245, 1685022259, 2960833010,
	1929038372, 3592392401, 1970865976, 196799153,	1903434251, 2686387201,
	3335960511, 3869903089, 1707294138, 3087364545, 2042985395, 3865958665,
	1950979774, 2988340752, 1138670612, 2429724004, 257711046,  2992412953,
	210799910,  1698566823, 232918156,  3506890361, 3678888726, 2122395994,
	1487163103, 3630069756, 1796528494, 33938526,	1931523595, 2970196334,
	1350973250, 1703095262, 903781334,  2797751145, 4237416395, 2884889903,
	3989888868, 1691161749, 2679987646, 1177111602, 2773820019, 1097222833,
	4121515552, 4252781290, 294272091,  1228548662, 425528687,  2691309503,
	2294784449, 3428729884, 2704653411, 719806147,	4159046882, 2147108324,
	528483975,  1868761238, 3973546247, 4076292572, 1165111472, 2573884277,
	735182898,  364013246,	1187050302, 2665935650, 587130181,  276909462,
	4219783885, 2417289261, 2645184204, 2318748379, 4225219928, 4075674143,
	3422999749, 3078265788, 1160389850, 1757035396, 1100292747, 1304830539,
	1579940255, 3990552671, 1791744138, 1835739052, 75419540,   2967894520,
	1375851385, 4018657431, 4169815177, 3752877079, 591632260,  1411421064,
	3239307082, 287590311,	2806741810, 1417701916, 929652993,  3674142745,
	1507409856, 1960050050, 3693057344, 505448392,	3706896141, 2544219154,
	3362715770, 3901348412, 2009153879, 3367073066, 1144175642, 1652633542,
	1924645647, 3128814731, 3005995156, 3520763810, 1595093578, 50663753,
	78410154,   296694241,	517197026,  3280468439, 2294176963, 3435872564,
	582232201,  2363967240, 2399382280, 3804440293, 1616807861, 342642392,
	2057100922, 2845125878, 3806078363, 2416507650, 3215669518, 3153162988,
	2123611618, 3025829271, 3062728042, 1835586909, 2409673962, 3486185799,
	693135004,  744010106,	4134094043, 1338311268, 3931924519, 3840802640,
	501654538,  4161150589, 3393630013, 4194196673, 3269401230, 3002265930,
	1440575031, 1890458027, 3380373200, 1043919582, 2325763271, 3027198716,
	1231922459, 1778640081, 2177649613, 3208189911, 2865751904, 2282552258,
	2709693265, 1261398200, 3715638737, 2191703751, 2413774057, 2310836425,
	2282112477, 2991579041, 4128479518, 811872009,	849918207,  2579553343,
	335944142,  1919511924, 2219918593, 3959810228, 1036914474, 3050888330,
	3404468108, 61762196,	3708233560, 1173431401, 1109453474, 4020124129,
	3079151515, 969502420,	2480448075, 1780987223, 4157470948, 3671968239,
	1578829917, 3710561451, 2707389717, 2086725897, 422812810,  3947071967,
	1670696660, 2999047448, 2004974950, 4062222765, 1497286424, 3700202138,
	1458350591, 1023140994, 1345230292, 867249011,	581530861,  3647359684,
	2047640287, 2493342663, 2284059645, 843988755,	1629067107, 1072942298,
	4236843970, 3634604572, 265124981,  211114535,	2557932126, 770391461,
	3399081071, 2391251649, 4278736896, 3889337202, 1942383332, 3581948865,
	3531102137, 3361040109, 2409792049, 2469281502, 39185479,   1720440279,
	3498795546, 3148165803, 2033041228, 3491262137, 1604874755, 1665030401,
	3622828712, 697246118,	3440012837, 2834476334, 3790112481, 2993858667,
	2937994754, 3265641241, 2806230692, 481161941,	3296818189, 3633820438,
	2576774436, 1513586344, 3853457711, 2906906425, 3078581426, 377424773,
	3253061966, 850523621,	1154401861, 3189906270, 822612644,  618098671,
	2802813932, 97256773,	2025070804, 3360626682, 4273007788, 635464009,
	3156516761, 2752992342, 1311656213, 770004434,	4221153677, 3326382212,
	1718734423, 3154471056, 2998590606, 1247871614, 796833276,  1302892009,
	4188703579, 1580337102, 2442239830, 2452750273, 2787669952, 775702700,
	3144072047, 1460431310, 3043719526, 3843546397, 3664717995, 3407453774,
	4117176433, 423651228,	2944887842, 3670332150, 3792287034, 1060055986,
	365516667,  290183738,	2779327062, 1940922231, 3531107427, 672366866,
	741844724,  1649844318, 2217148486, 4121000130, 2375179562, 2795101011,
	2423411080, 1016843136, 2465562990, 1098200704, 2579522806, 713910433,
	2842005952, 3121650401, 3053476380, 3129429639, 572604069,  202257368,
	4063576317, 3227484138, 2949209107, 49658363,	3605265366, 1249875199,
	687384386,  2410321314, 3093641588, 1995619890, 3172811966, 2776464952,
	691132615,  4069334693, 1667234746, 1929917468, 3641115039, 3888952050,
	789032786,  888460560,	33154737,   1154617358, 2741811346, 328803525,
	469856511,  1949552615, 1640902853, 1779751612, 1500676373, 1966072017,
	823086703,  3496410763, 2261211282, 2259279773, 3358260687, 1075637175,
	4260486903, 2655824349, 3193761716, 4045020985, 618819461,  3774790937,
	1006302721, 497608962,	2464742377, 3376587040, 749482890,  2740921763,
	2492637094, 2758347813, 1646618650, 406564185,	2845699764, 1498129053,
	3824164185, 3751039283, 1102694358, 908952139,	3114840270, 3520924492,
	4029170460, 34892899,	377465357,  361479905,	1027483029, 1089541121,
	3469941073, 1864570609, 2783353053, 4087573329, 3493261741, 864394001,
	2236177318, 1819350424, 1976804882, 3916366289, 4215684553, 2316557517,
	933866731,  2202330561, 231616456,  3233032950, 558132986,  3548991533,
	113658038,  2745086085, 2158268372, 101371561,	1628277635, 3625683603,
	1980261826, 64850814,	3867932185, 2043970171, 3572523776, 855815182,
	1930092696, 188836976,	2083591353, 234898009,	3394977180, 1906707483,
	1034021975, 1873997587, 2058044494, 1103008618, 480220648,  523516433,
	3947053702, 1591872407, 2728498535, 1880962670, 3933265080, 3936111081,
	2938071208, 419929525,	540677529,  505981737,	2470646357, 4055847747,
	1857586502, 650904914,	4259608978, 2641572288, 3396999057, 3936700372,
	2421884572, 842813209,	4010790683, 1194242862, 496213490,  1634855598,
	3384243606, 4251527388, 781095375,  2914172699, 3533289639, 4181384384,
	3421071512, 30110877,	1232684786, 1432667915, 4238661133, 652930883,
	2038025140, 3526454787, 100000257,  2230265692, 528595144,  2734698281,
	4069934981, 1900223889, 2906228993, 2381936281, 3771457101, 3115011762,
	2072000799, 100418654,	1512258405, 156632564,	1896988970, 12112266,
	752757667,  252690003,	3993733658, 1460380040, 1067536539, 3069387708,
	934326525,  1730468497, 593861553,  1489019591, 2979573014, 2740312283,
	311870489,  3321767841, 2841938347, 1971823514, 830183982,  2334383066,
	2375986063, 1207140630, 1795049956, 2074058747, 2505422421, 3612929295,
	1207086284, 3436709843, 3605876309, 2774933362, 2569865527, 3546020970,
	1692624931, 2370714578, 2085776532, 3553690699, 4148612262, 1836849836,
	768346167,  1975813163, 3658900413, 4283484419, 4257621252, 190663083,
	583363111,  863820295,	1088618846, 2593622820, 4014531953, 1379323178,
	3749581056, 1873055644, 2659700825, 1565721466, 2852039680, 6153408,
	369186892,  3188753508, 3644831184, 3159619678, 4041034980, 2959443170,
	2761006981, 3928350101, 732527099,  245885966,	4124102525, 2739006630,
	1934963683, 181825741,	1437417821, 2110585949, 1935722519, 2742928180,
	654994751,  2172202533, 1449045202, 1172668545, 4286496078, 2683801211,
	3176298386, 2784176974, 932544882,  2560290857, 1052463627, 1287214665,
	3171089245, 2696058955, 1621221711, 2519561587, 3031375384, 1469762752,
	4190651429, 1562719023, 518414963,  614405141,	2426675946, 2742376346,
	3993556436, 147202257,	4213093203, 4188267096, 1922408649, 3117528408,
	1098252267, 2509217135, 1350524806, 2061077460, 481702112,  710045225,
	4017395934, 367234624,	3512119638, 1131664675, 2671144310, 2505303119,
	171399834,  63524904,	2075822352, 3097952311, 3311531039, 2722042716,
	241409836,  2935119155, 910673520,  3982923845, 216719600,  3303447601,
	1709305024, 3171969361, 629120093,  3775096024, 2726790837, 1536429514,
	3732754105, 1977906656, 3734540638, 3889810174, 2705977845, 416756425,
	3030566462, 1279211375, 1229529146, 507570666,	2935720806, 3851437379,
	16637351,   225703575,	1400282257, 2503632649, 1961124510, 2864596314,
	1610822319, 2236708679, 2607772065, 3069639244, 476357714,  3232018815,
	493883651,  379070731,	4091088861, 3416808943, 2099477556, 1517273032,
	1265927008, 299828581,	2624405899, 1321176803, 3859636258, 2059055997,
	4044520086, 3039710574, 1745451773, 2391112769, 3036526636, 3841983725,
	419322686,  3624616102, 638522148,  2698799928, 4091494365, 1119175393,
	495975864,  1828774256, 4016521109, 947324358,	1440105375, 1518516745,
	2189470124, 2383580030, 2640751033, 2575466509, 2237527091, 3151065418,
	1852399248, 2973887924, 434950595,  4182370718, 1529820924, 944538166,
	2283311446, 2491278811, 2277640977, 1173496447, 995029210,  3423991981,
	4027085538, 1582599287, 4234604264, 2962654672, 3591036270, 796093829,
	3509226333, 1201124011, 1315065131, 674286814,	1807691000, 2902187857,
	1945445019, 591689989,	4005280025, 606732744,	1669651108, 1693451543,
	716126885,  3838258730, 3461369455, 3267708761, 725662870,  2359364916,
	3626249582, 4081175129, 1238326342, 2084278189, 1646504114, 1062974566,
	670204090,  1122088747, 1525690008, 237915115,	1496906413, 2805101727,
	4139358047, 118934047,	2353579390, 671137543,	4147545066, 3622730489,
	221383949,  3573027701, 3631047039, 3409649215, 3352307107, 1930679966,
	2637353311, 1704594612, 3207050189, 4117638607, 2961971979, 3010550685,
	2468165685, 446952908,	1733243184, 579867370,	430741734,  416347823,
	67040833,   1350211811, 3667752766, 4139677878, 3824307237, 3737084336,
	551772008,  1429469983, 2625134699, 1143634034, 519546273,  443362649,
	3137066665, 2349763153, 971991937,  3958184114, 1688706804, 1524789035,
	1405212908, 2114627150, 3737147990, 360338909,	988920244,  3345313619,
	3197725788, 2069060654, 3470268872, 3756791619, 4119037286, 1119759686,
	1012799707, 1915022845, 1054010174, 588088406,	1321888171, 726670186,
	2985758135, 2647966225, 3283792942, 857457752,	2511372412, 1419322113,
	771559576,  3922237062, 1684868933, 2794556982, 1737460258, 1618986311,
	1750512819, 1257794466, 373664749,  1800098554, 2959908531, 1787114226,
	1477031571, 3375156890, 49944656,   889919308,	280045420,  4169888909,
	1915972827, 3349707527, 3754857461, 3540804299, 4213914198, 3599370794,
	3025806645, 3374907010, 624409456,  1464810439, 3101480693, 4187205328,
	3336794985, 1533015305, 1680180542, 583084201,	3640191926, 2717597709,
	3510455192, 687590641,	3193745849, 2180194445, 3342592586, 2260155148,
	3166541938, 3524996913, 3156133925, 400127623,	4031225610, 4122938550,
	3272456269, 3653454637, 4028768316, 2617746608, 2672912367, 952756645,
	909944669,  3924715810, 459810388,  696606788,	592243432,  1551744095,
	3468650714, 520152847,	1862536140, 3092493949, 1453950861, 3404324565,
	1393033657, 567483964,	2989602660, 3927579502, 620437875,  2057608455,
	2041898185, 1656731317, 2806417945, 1068681561, 2426146327, 3028279952,
	3386506762, 287744257,	672969309,  3861873477, 1387506970, 1669804224,
	3398880852, 323458826,	2929882772, 199960517,	4195947207, 2512203118,
	2978190606, 2746214669, 3930037240, 3506771544, 3704885225, 1666257048,
	2007458634, 3501128524, 40001762,   3353117012, 565488106,  2534592505,
	3010648135, 786150688,	3406586395, 2280673514, 1107057030, 1736384772,
	3193295922, 3114333842, 3810284270, 1092128042, 1752223840, 3436795043,
	1982616899, 3217625931, 97632841,   3517179257, 1672277104, 3383482613,
	2306288378, 84188798,	1186776829, 2476968506, 3661044679, 777298881,
	1310427609, 333777275,	2492238728, 2437580174, 2070218269, 3144334705,
	689632874,  2549452256, 1775026822, 3171355073, 2893081682, 4225255273,
	28450616,   1312771946, 3699699506, 3885860684, 772375360,  2202088932,
	2392172380, 3370326695, 3326195833, 175521234,	770204893,  1829923999,
	4079033221, 2075897375, 1641958148, 46561528,	1756410686, 3981289804,
	37996290,   1040141450, 2392390185, 161449870,	657983637,  2530890692,
	3007589827, 1339037115, 2592771733, 2677913514, 2682395516, 3256569237,
	68215815,   2223554629, 4001612547, 3485321292, 2462226572, 3752927217,
	2667819069, 56922143,	4198446649, 1127603911, 2488797033, 2290894582,
	1339314761, 1885604583, 1063059031, 3993558978, 61523396,   895328975,
	706555186,  1787544368, 2850624229, 521578924,	1601074947, 3189969072,
	3838887977, 3974365158, 4280166914, 1120093033, 3667064175, 2922558758,
	2010415038, 4094628758, 2026923760, 561040076,	2387767361, 2876970628,
	1212755736, 3526137659, 359562240,  3918363570, 1790138694, 1159522263,
	3879064735, 1342894548, 3987040376, 3081994749, 4192194853, 267492040,
	1098034128, 1160442289, 891215562,  2716252572, 1344454753, 2490854338,
	1284396316, 1831816681, 3275641299, 1035092262, 1368123878, 2585468478,
	3113740557, 133544448,	4201239874, 3210353058, 4196437729, 2836184718,
	922528020,  1719619856, 1741222766, 3460630631, 2340981343, 2116659398,
	576854434,  1843513762, 2975420428, 2007261572, 1233590422, 871423248,
	3935214292, 4074390090, 2239723964, 4143024057, 3132881852, 3814491416,
	3974939824, 2131898709, 772911014,  347306761,	2537289128, 991055947,
	1698074211, 3811805358, 4076696081, 2171060098, 4168713126, 1635937373,
	1302895842, 3708862716, 585177218,  4279695730, 1644086001, 2520207123,
	2262600691, 3559166730, 2119640665, 1062006721, 3063190750, 804696969,
	826052585,  4088254366, 4118912703, 1369940909, 2531991918, 3811087403,
	4076788381, 2350513178, 3410036285, 3282598806, 2563381336, 1015810248,
	3086753101, 1500753580, 3299904959, 3136159338, 4254272286, 1276555914,
	3861331829, 3257188494, 4086192705, 1702888916, 3455086728, 269925164,
	1639243448, 1030927882, 3343802893, 4049527711, 2182215399, 608425381,
	300595559,  3566546198, 1748785724, 542590984,	2154437097, 4017486891,
	848010810,  2896012659, 1482341823, 408636059,	981914952,  1503070338,
	3658581250, 916692233,	1726710320, 2885081185, 3019579191, 68828513,
	782332725,  954137201,	1046538683, 2857679141, 769388570,  343008221,
	3706377304, 2780077882, 350423482,  1932356482, 4215749901, 254746688,
	3406423277, 1412229227, 4191569716, 3877130258, 552048075,  1668731743,
	1320756516, 797054289,	2918016397, 2952677918, 2530465051, 3951316420,
	2478406724, 3107890309, 187237922,  3818059087, 365367216,  709008563,
	1998638899, 4259807205, 3866394622, 1274631035, 3535376096, 4143885801,
	1286678932, 2572653837, 2422923602, 1730636411, 827576620,  2559713427,
	3204160163, 2252726101, 4248670495, 174714594,	1557635664, 2968922761,
	769217608,  416887710,	3728035669, 226027636,	2829694300, 4207335250,
	430251432,  2061786821, 2617428402, 1990772687, 1885446710, 864103618,
	2141286844, 3573788373, 3837717467, 3425924397, 1709664881, 4103389596,
	1187010497, 1685742337, 2360491937, 2165293079, 1401403118, 1075151460,
	417557633,  4290445214, 1683772133, 402050631,	1397742866, 3720352861,
	2671575895, 1553129682, 1610970389, 1619544113, 1548693015, 559536649,
	3222425017, 128364191,	3135569588, 728050040,	2878581725, 3205879734,
	637778826,  2956874364, 676106212,  3141902176, 3143776368, 3837624275,
	1593701482, 1657434205, 2916172162, 1222239468, 3870312259, 2096371393,
	4256674271, 1915443679, 2182473167, 2969395688, 1500530870, 2822540271,
	2314572492, 644429558,	1763681231, 1787008202, 3358961736, 3080104652,
	453536469,  3843211450, 3146447579, 4122630799, 4268909504, 530990432,
	2810713899, 358477943,	2378594175, 2432721227, 3354659534, 3476266274,
	657597060,  1884064693, 2507580628, 691258548,	3456303873, 3730727154,
	3269470397, 1333288621, 4181008763, 1175159058, 3118780971, 1701054615,
	1604141652, 3702649653, 2937552224, 158511743,	1698234126, 1717526777,
	1295753432, 91212172,	487531383,  2728884253, 2221664372, 1216727231,
	1885252743, 484331365,	316265601,  1156870047, 3305832132, 230904463,
	2355437322, 268751341,	4020034315, 1213920186, 4222986465, 4174181696,
	605140555,  2341341344, 1666016848, 1695483864, 216682061,  1929539217,
	4140354495, 982818444,	2696368317, 510216107,	4127498592, 1017967177,
	2363901978, 3238037507, 2698142546, 277538526,	4196324259, 3182828343,
	4098083618, 3468482258, 3894008595, 3036487568, 423958483,  3068907395,
	1927379242, 469816076,	2100944769, 553574309,	3403405943, 3517862636,
	3045898234, 696470183,	1479911748, 3722138059, 3555995824, 2723734203,
	1102397458, 27478603,	101321763,  3210702577, 1142127886, 506252915,
	748517652,  3577111089, 4179727331, 3863435821, 2001930978, 3459907361,
	3730810708, 914013430,	3539607466, 3221469133, 1378282415, 2132496780,
	2910705559, 203387498,	2601611582, 2231861840, 50792354,   2075394826,
	4116523697, 3770059180, 2770139175, 3705072594, 507547007,  4190601806,
	358117170,  659284731,	1397776158, 698984128,	273303752,  2087801697,
	37256462,   2402650767, 532650957,  525586930,	3059434913, 3949443930,
	3381485652, 1324118727, 589198179,  1603535512, 3559563665, 3330693864,
	2847192694, 1461843877, 1425778726, 3676662331, 784522397,  3919894589,
	1624244506, 343102805,	480464347,  3697878000, 3445022492, 1161021219,
	3083331037, 1459733970, 1193554997, 108385676,	2163284679, 2724968435,
	758099652,  1731522502, 3824854034, 3989582338, 1139222774, 2510572520,
	1504488787, 1609389586, 2182974347, 238136875,	3776597815, 934850340,
	2488770901, 3167501400, 2729745805, 1880452127, 1817379293, 2068671481,
	3123101415, 3974789339, 1215832557, 2073816692, 2798008325, 2652954619,
	2756618149, 3059392799, 3570600118, 526320370,	1154419775, 2714457952,
	226483925,  2323378682, 3679504144, 2555408844, 3467261822, 3601318485,
	1339289326, 3363587222, 2513514081, 1520444344, 2336443727, 2885592729,
	2322463250, 4150321658, 3969567480, 3880181099, 3163573703, 3870088463,
	2033477354, 3145454746, 2032441906, 1109343863, 2827734085, 895521802,
	3820373196, 3228832558, 1855244156, 1402542232, 2935714785, 1188085907,
	4213864881, 2415938239, 2147212441, 513153267,	3449344634, 1668596594,
	1026486738, 1585695275, 1034929825, 1850574693, 4006804095, 769370775,
	806702943,  1617091513, 312496386,  405882624,	1558182488, 751208494,
	253871629,  1781981871, 3678097802, 367656309,	406466248,  1180867701,
	4205624187, 2860743445, 2634895093, 2258843868, 1338114583, 2665143402,
	3664730082, 3581590220, 598840034,  1619793914, 2029040406, 3693838583,
	3513801509, 742758521,	1349634386, 2552243875, 1344137279, 1208820231,
	3161637262, 123319955,	2021798757, 3643165343, 4226608635, 1575895558,
	1902537868, 2523982710, 91194851,   1594028862, 1503288448, 2180252896,
	252032256,  3827281009, 2404223566, 3187290340, 3414760991, 2745754497,
	3653228469, 2315498444, 1853333900, 2873326984, 2126457092, 3715819927,
	3616065109, 584460796,	1800713014, 3364642482, 3245147050, 3036478728,
	2500912887, 692957388,	1509264291, 4085414294, 1510481240, 2018302391,
	2082137463, 3512688669, 7036785,    2492462136, 3369042255, 898266133,
	3774679143, 704667941,	2420116565, 2751551192, 3515578803, 1227025968,
	929146248,  4070917224, 1791098003, 3064743232, 877829443,  2551100194,
	3714187001, 3836416767, 1618789597, 685566682,	675326807,  916114403,
	835762719,  56490570,	782206110,  3419318967, 3404803890, 3108784475,
	921781763,  3055952181, 3707178549, 3906713970, 55797800,   20091951,
	3908669208, 3490452327, 463730914,  1524916293, 2463451140, 2308718860,
	1370282301, 2917375048, 207596913,  4130705143, 2354221938, 1366586738,
	3235367514, 2005764708, 2737244156, 2723753614, 3893066555, 648153944,
	4207231964, 2842744044, 777047178,  571864061,	437075372,  2612625478,
	1202175581, 871652250,	3184969537, 1947440974, 3351862687, 3114882940,
	3757524164, 1169201328, 3492447210, 2667674200, 1283821519, 3103587572,
	2898879211, 2265286657, 3556540480, 3047616359, 2421693469, 2340636136,
	373998893,  737079706,	3310123616, 1460742213, 1768298743, 1437466417,
	2033770483, 1726372523, 4082818396, 528480046,	3031310464, 4085697553,
	3643975941, 899890126,	3199563906, 1754344299, 2820359528, 3229894038,
	516976913,  2170311035, 3613898245, 1460134051, 118372465,  3410070613,
	2453901873, 3807205499, 3512071548, 2664266037, 1181590522, 3083990446,
	2332953537, 496367056,	591126645,  3185567651, 3128214662, 160172513,
	3246378518, 1674291509, 4141623465, 796089008,	709055219,  1793499460,
	969733316,  2200322835, 2369577569, 3271757603, 711337273,  1161545254,
	106429521,  3575223173, 3673316925, 1365189686, 1570306318, 2375211963,
	3304923380, 193649680,	549982640,  605746073,	1034504344, 20548247,
	3870114541, 1688567639, 3606444054, 996350918,	1839691030, 1416857216,
	2613053983, 1994304003, 4116474934, 2085218888, 2267152961, 1801261144,
	1405691201, 873671932,	3575472666, 1662331116, 960788030,  1143893989,
	640652973,  3986692042, 3110340919, 4204756140, 2455647246, 2104047725,
	1631004304, 2092823831, 2933808912, 3629430280, 794191664,  1504192527,
	825536623,  589175691,	2131867993, 2541768010, 3349288684, 4180666551,
	2539342822, 3198241183, 2943024150, 2460736607, 677970252,  3734549184,
	340928250,  1172868724, 2576891165, 1382779464, 1952180882, 3576606775,
	1826525038, 21659116,	1012374596, 1477662466, 2190260677, 2879569288,
	226759437,  598981742,	2005876840, 4253140927, 1882162093, 1239214638,
	999001115,  810610757,	838607703,  1171900736, 2698536714, 886401240,
	1470260921, 3580394420, 2710815853, 3780615698, 3798080528, 3388938429,
	2831866337, 397025700,	2180611611, 1126995110, 3973464856, 4192318123,
	2974801307, 2115260262, 2893957276, 607920206,	523574878,  1376963125,
	4248369837, 3558269586, 3733896397, 4267814318, 294037997,  4273265356,
	3859323541, 2267498467, 2130714191, 2041917545, 2457543937, 2548810383,
	3135786348, 2153405397, 1915013844, 3862450670, 1200970951, 2069357426,
	377342728,  1549923146, 1635603863, 1773413708, 3039032528, 310622875,
	1534458054, 4080525089, 1940295122, 1670738016, 1220052801, 1942277474,
	3168245203, 3263989950, 1729559602, 548916165,	1100564907, 2958376300,
	3965765631, 4043660483, 2236829092, 110041484,	2208067134, 2836474463,
	562392555,  3770037907, 3093679115, 3461555069, 1812965765, 3272929682,
	3447426238, 3402643929, 3378564048, 907387924,	613843730,  2832046559,
	1404178479, 2268707334, 109256274,  1685628978, 2947045417, 1164659206,
	2098465704, 2566804420, 1766161892, 759257835,	3329652798, 2065991866,
	2126495371, 3434967712, 2721493360, 2309757089, 2082430705, 898924079,
	2041160371, 2844211783, 694215968,  1864139599, 2160135641, 2580537932,
	1215346417, 2828221298, 3232105638, 4091727443, 3055998634, 1216622651,
	484389658,  3463142045, 556012879,  4040524883, 1374136216, 1282222568,
	2231450944, 1268211988, 1059170417, 2148284735, 3637730734, 1591851547,
	1583337016, 3087251667, 2539404103, 4186481834, 2883718888, 3069120467,
	3873658372, 3792165545, 2932754765, 3119064753, 3627353647, 1863654271,
	1845713182, 3238955810, 2652469889, 1158622277, 2214001944, 3918177759,
	2934451278, 3633863749, 780832290,  2715603040, 366492070,  3111631543,
	1799446115, 2986429626, 372231759,  2994479332, 770788877,  1502389678,
	2248206608, 395625474,	3483747196, 1026671636, 3297571880, 1718107246,
	3140759859, 4218688121, 3165318980, 4276563024, 283165368,  3076891984,
	4195797881, 1124225161, 1521933957, 2186495127, 3188027672, 86738489,
	846824404,  3959295736, 277790295,  203528311,	3248044941, 2774399414,
	898136793,  218569803,	2886080496, 2021614320, 3429240470, 1862666213,
	4173507955, 722791257,	2968992910, 965439537,	1431291420, 3804591819,
	292817400,  1420749310, 1802528672, 2632805370, 1682488271, 3279716586,
	953721505,  3660271394, 471003138,  385317777,	1277189818, 4250392821,
	1006830144, 2959500180, 1376908117, 4022691672, 3718093350, 1217029428,
	952658684,  3757314041, 4071404654, 3562364791, 1087263802, 2668496818,
	3251389050, 3706572468, 165999962,  3427106734, 1679889599, 386289966,
	1473930135, 3950489973, 1814141090, 1084350154, 2278768510, 650037173,
	3120630549, 3303753216, 3992997737, 3570819027, 3242943681, 438855744,
	1497972174, 4223755218, 1669251964, 3111503258, 922208636,  1434122799,
	2902193855, 4277166994, 1612992672, 1760256701, 653311493,  1253249575,
	4058163930, 3788322326, 1365233457, 2368836664, 466355392,  3641161560,
	2333435697, 2539217459, 3737922228, 146281369,	3996563918, 2642942199,
	566190829,  673638967,	923994912,  2796011157, 472271687,  2202792601,
	1117178203, 3242997805, 3148119820, 2949819656, 877198328,  2986626880,
	1278975232, 855475585,	3595309307, 2609737221, 4162635387, 2655246668,
	2504484283, 481398488,	2593431045, 338921910,	731080130,  61446051,
	2452057794, 2521061297, 2319459953, 2358621421, 167652570,  350781262,
	158913390,  1637841700, 3067905970, 2000344393, 264521717,  682717368,
	1873547329, 833238160,	3249806538, 2645726224, 2370706799, 2820749878,
	2824640401, 1958972700, 1329900639, 1172268016, 3362156683, 3144223478,
	278533671,  4108923006, 2460614464, 695709454,	1511569265, 293727317,
	145417130,  3325224566, 1217148729, 3588533830, 3999042080, 984216845,
	848291399,  165471477,	892817921,  2267435346, 2310449337, 1088601195,
	1736923539, 1877158234, 1836841526, 2055041488, 611542192,  2422126626,
	1319930108, 3024225160, 1171215055, 967726098,	616625640,  3760196041,
	3011048623, 2380393515, 1211189820, 3215722837, 3114263514, 49034513,
	1340233199, 3961547069, 646845,	    2453486134, 2293533080, 2611787700,
	4263386759, 3796827989, 4224448036, 4191296966, 884633139,  2787897360,
	1847816010, 3415657716, 2330886918, 3207253363, 3969217272, 3748972090,
	2330541496, 3601695677, 3992401610, 4001446971, 2135842693, 3668800653,
	1027761356, 131498122,	3310167946, 2652052200, 1428703740, 1830205583,
	1671704218, 1624890909, 770261479,  526535252,	2615365007, 1509530917,
	1983083516, 1341727266, 508230215,  590656964,	4147763133, 821552368,
	919178469,  1178384312, 336474099,  1786912521, 1795833215, 4278300749,
	204434231,  2094282807, 3985840608, 336723098,	3104355930, 3489601534,
	325089721,  3013058757, 3515442815, 3877782256, 3121725860, 4124412010,
	2402980210, 380826716,	1526534608, 1453124801, 3213819978, 3812526741,
	449851434,  543432143,	1106251035, 1938909642, 2712075665, 2813210027,
	2638710154, 3914278864, 2285684597, 3935048545, 2017609273, 965494909,
	1920550766, 514787642,	1752297641, 3310017204, 421591093,  2759088195,
	2128549212, 4219322368, 3683372006, 1347659774, 1654091848, 3920718135,
	3366598727, 3169102643, 2637259681, 2861621769, 2344718001, 3047946365,
	189783687,  409636852,	3558343316, 871706953,	812364198,  1659745369,
	3496989473, 2539281346, 433525604,  253917530,	189367979,  1322187685,
	3312104048, 1047494011, 3703632206, 2706670419, 957309431,  1183661326,
	1784220677, 3673300414, 3279983725, 2226577876, 2190315592, 3230198174,
	2285705485, 2749573302, 2150846382, 4104222729, 3719786574, 1583781314,
	949378113,  3377380175, 785986219,  2425346078, 3361419521, 935310015,
	3334026288, 3350100990, 396505626,  287425599,	2371580761, 2520841590,
	2528376820, 1956413968, 1942012658, 3436842982, 355396965,  1678603830,
	3051806064, 2697580036, 4223585868, 198976017,	1703749918, 2739597874,
	2346704965, 3115918949, 3573324009, 900233402,	3941031822, 2970153973,
	3897738881, 1442139949, 3488705432, 2985308519, 3653386304, 2907969347,
	606375645,  3929656969, 530082153,  3730457425, 408060054,  84969433,
	2858839383, 2382654286, 2522504417, 1795325245, 3474147520, 1389488800,
	631083828,  1290760134, 2027901199, 3437369196, 2174981315, 322450968,
	645256925,  3036937683, 1847766736, 2624080485, 121679324,  1358143819,
	3934846078, 1937473317, 3665594051, 2528289845, 3068034718, 1496695719,
	81361930,   3550584941, 2111329317, 1938122677, 2452541527, 1177208631,
	799334130,  1735370938, 3663115382, 3480947472, 1084818007, 60745797,
	481505107,  1876895571, 1239880582, 3137492762, 1856549891, 1794539186,
	2191282441, 3060670460, 1156740720, 490784415,	1107059784, 3282246271,
	218984831,  321264087,	523388770,  4246439800, 3261152281, 813545481,
	1580866758, 3844739055, 3378645570, 3595340843, 1740075024, 3987862508,
	2968071125, 2750797284, 4101790283, 2649960187, 3303806598, 992583258,
	2601424094, 2924696720, 1611724168, 960631298,	3886787139, 42356450,
	86889215,   1422358882, 1842750518, 3328153016, 3678587960, 434179121,
	640949941,  3083454860, 2801683122, 3840642545, 303810840,  1548848055,
	4126553307, 2994016053, 2099728926, 2285137757, 1548414497, 2698096079,
	2813011514, 2758785974, 884693182,  3882622804, 4243090267, 3566774884,
	2708073746, 1984942915, 1072844051, 3722366863, 3118743147, 646594814,
	16863306,   1182387032, 107310982,  1803503435, 1426554497, 2592756850,
	627355360,  339575718,	2810495319, 2679575210, 1019666446, 2632352550,
	3248653891, 1029694290, 3380833619, 777290680,	832195633,  4034799511,
	3929858520, 1729986274, 2264188349, 2203879816, 2803721972, 23932895,
	3693988949, 1183792648, 2084875541, 1299174626, 3502842829, 1084857836,
	3403674750, 1125755536, 4031741147, 544536859,	1117859529, 2095028771,
	2549689223, 2457080386, 57852191,   1571279351, 4218801040, 1197818132,
	1249699722, 3592854592, 4216793585, 2213255891, 773562687,  1021806252,
	1194845945, 446638762,	1815748132, 3236394120, 812094220,  3895252877,
	750392277,  478849014,	3185405281, 1491692635, 2072676451, 1597917555,
	3239848563, 2569799933, 1902200698, 1316203509, 240708173,  129725741,
	1340069986, 1392425822, 2460066791, 558025239,	2563798516, 684799503,
	2949380525, 3835588357, 4145920211, 1536859628, 3291682757, 420651263,
	4171126221, 2966439572, 3686246845, 2340467195, 3988970134, 1341403402,
	4113336858, 281537389,	3319214030, 997704236,	3316027238, 713533840,
	3487397971, 1554340405, 744013793,  1538721848, 2725475258, 1679581807,
	4039558193, 2751087058, 20148346,   513121702,	4045218864, 3054750253,
	4227118000, 701968603,	3321937783, 867941717,	4273951756, 3356455229,
	4076334402, 1389654771, 2862959969, 1207009832, 3441609618, 1123361814,
	3927093730, 3962603716, 3176226433, 1967876602, 1567040836, 3547136483,
	952875242,  3745825171, 1673808683, 704787307,	887650329,  2511105970,
	3090823389, 2357179268, 3750959513, 3894158610, 617643653,  938987506,
	1630670640, 2878371054, 2113391258, 3911079328, 755770778,  4292747547,
	21439071,   1515316285, 3929069806, 1222311907, 4213513349, 1565460848,
	3104354413, 4072751843, 2638380040, 3246219119, 1388696533, 3566118293,
	2682962133, 2010094545, 1383715541, 1775796128, 582318654,  969146381,
	2305041933, 4166561313, 674833765,  4169041181, 1503122840, 2637069477,
	232275428,  2694886189, 2841382908, 1195023178, 2890779958, 701011397,
	1079667868, 2078840225, 3794697688, 3587123312, 2014002790, 898538004,
	3127494059, 264237826,	584522562,  4271629721, 3592491688, 2587531927,
	143457516,  4186973927, 2335880110, 3259685390, 405496302,  3331765206,
	2699295098, 381379541,	440921246,  864110590,	3373118772, 7467264,
	1021869870, 947886780,	238203126,  1953007492, 1813104326, 873228191,
	3217951226, 936174,	2505220835, 2076824652, 1934276614, 406929306,
	647455730,  3886158327, 347467251,  570468150,	2648959771, 1566210828,
	4126832561, 4086072549, 1492068710, 2550216443, 3982587747, 487770655,
	3243897161, 3910759745, 482138272,  438427545,	2056686885, 1404952466,
	3868856074, 3007278432, 195117862,  16590856,	1816685656, 2402625878,
	3317589137, 1991085908, 2590924051, 3133544707, 2469147144, 1713715494,
	1985937436, 2016420339, 3151429451, 2329565535, 3262361070, 549468622,
	2173327136, 2112536339, 622151817,  883345868,	1365276168, 4046173273,
	3748825663, 321906738,	3161763561, 1035442972, 146422569,  1610781437,
	1777111916, 3786747259, 2626354494, 866197010,	1652479953, 76883878,
	3902721334, 2760994024, 3270561211, 1783061001, 2286811878, 156534122,
	3941155532, 2707937880, 918533183,  2224755296, 1710545698, 4142842855,
	1838722238, 4098742448, 3153103517, 968031567,	2098219227, 1181541140,
	3257617595, 2558535815, 2720495795, 881449073,	3451238016, 862000413,
	1536679180, 405541813,	2776998107, 1173433064, 1342265678, 2130639818,
	579813511,  442346522,	2085563605, 723122984,	2915487949, 1195453103,
	595789188,  4071043614, 625309562,  574162367,	4227190603, 2860504358,
	2749768601, 712780301,	3457208752, 3294551007, 2646402141, 2211003203,
	4213381410, 1205308934, 3547182133, 320728441,	693133796,  2187045069,
	1172613361, 691779741,	2149437638, 2148125034, 2857580442, 3913804261,
	2386981616, 2352907922, 2311299644, 441055081,	3826395891, 700059395,
	1866003642, 747650621,	853155391,  347742641,	1131548746, 2280473359,
	3576411992, 4149237058, 3104313037, 2711501173, 3246245033, 4146374722,
	2207206118, 3865229356, 2919303147, 3321735914, 3463894897, 3953756319,
	272114208,  3107222107, 3697689350, 713996422,	254493773,  1834833193,
	3638680346, 3604469219, 1173228011, 1894150756, 2860420138, 3296659802,
	1973660449, 3609132336, 881991622,  298533804,	1570826014, 280109152,
	1499515350, 1333638097, 2328315347, 3334890179, 959312044,  1014171065,
	1281392199, 3145580520, 3796876948, 883397907,	1577743901, 3290589150,
	1737663397, 20809893,	1263463737, 1433352492, 2123379824, 2303170787,
	1285994936, 757480060,	1612855963, 1554800498, 2740057652, 1304958864,
	2828763228, 1873150887, 148348811,  3729894049, 3862083324, 3520680565,
	3043056810, 3395650193, 956814286,  2083330849, 198154416,  1934211094,
	4065438912, 1386866800, 694140471,  2921196839, 1434324551, 2880270347,
	3898478701, 2973116600, 486777636,  5706733,	777431930,  3703324519,
	4154222782, 3507897486, 2615465743, 3327892972, 2102737508, 3300698159,
	358408148,  1160822199, 168729244,  675910172,	1251072194, 2525328865,
	245493738,  447399939,	223334766,  2476431696, 3876832018, 3063393221,
	66019972,   3549207192, 1085494710, 2346503199, 1570508846, 3667061479,
	3196225053, 361824446,	85169148,   2995744829, 2874218627, 695540317,
	764336148,  2542459192, 3554812739, 3849294722, 2138807064, 1879226786,
	915923108,  3363303369, 1828666902, 2051517319, 1179339233, 888471623,
	1510285756, 190937155,	3582459295, 3992889035, 1489255397, 1813180719,
	742152770,  2640806328, 1831364292, 1277038657, 3013513591, 3445006462,
	4121205151, 2471745280, 2043059701, 260318962,	1873881703, 2956451204,
	2837866114, 3030089619, 273987924,  461675743,	2008050165, 2813549448,
	2812984665, 734913824,	2778793378, 754555645,	396520012,  3838088537,
	3135548697, 1612734305, 3080811735, 1819065072, 2830022858, 717785397,
	612689123,  2140292595, 2753417053, 4156883899, 3616280740, 2804721662,
	2107300036, 1830552390, 1600769969, 4292814595, 2299753642, 2453611788,
	3207153136, 3617889246, 664704735,  1074899341, 2447029157, 1697518523,
	2093996431, 597303344,	889633321,  3732305424, 77048428,   1911734536,
	980546186,  1296812331, 2112854876, 3887197415, 3177261032, 2277386034,
	2392257975, 1066431423, 1498330231, 200492196,	73508042,   30581289,
	1425093864, 1389524340, 1410866670, 393168196,	1442167556, 3777493278,
	2018453896, 3087548150, 3171546421, 814620515,	3973631387, 453349289,
	3946363103, 1367779805, 1447202258, 3095224378, 3828078211, 3755050657,
	728023295,  2375775690, 2083433182, 1463288673, 892340940,  4076558981,
	1800048757, 2529274956, 2953945656, 1536043699, 3176771606, 2484412677,
	3652182607, 3136565401, 717005647,  2213573930, 118620106,  2928452803,
	391592265,  3962515664, 1934310456, 810671880,	1899942539, 3241824936,
	1387511389, 2631150457, 1481675324, 815560560,	4037582383, 3352580671,
	1757441118, 1786292906, 235364194,  2263772813, 2016822610, 3554096602,
	2583722437, 1376659951, 1716269095, 3437025389, 1222339414, 2598403107,
	2095481495, 4246770029, 677515352,  11981819,	2116347733, 2569390334,
	921208675,  1179740834, 701745831,  2215653637, 157280489,  2575594401,
	616195218,  1077451257, 1549763173, 2992592836, 2517748283, 3569851455,
	3636284337, 3508245400, 2334385570, 3326700096, 157360924,  4183039140,
	3341872572, 250051469,	3637287069, 1648519871, 3110278716, 2143843017,
	1748587103, 643648261,	285340348,  179414968,	599094155,  1071162371,
	148502561,  932488731,	1137358338, 1576477061, 2702113166, 2479760008,
	3468235595, 3259843224, 2099971706, 1334888884, 1857302990, 2983429742,
	1115571257, 2944315581, 2715628886, 1906509210, 3441689767, 1296360467,
	2371352130, 188508551,	3055553779, 938173106,	853100172,  401426835,
	3806376766, 1119913867, 3647169703, 1397835116, 1218044666, 359696897,
	2982083207, 1484028586, 916326469,  2622766134, 3840627603, 407253443,
	3312744250, 1155589806, 981372333,  2648587599, 2892274716, 533043253,
	3661360925, 2022860172, 1031400510, 2788709451, 2501641150, 2750044976,
	3601594259, 1598814688, 3806065491, 3745806526, 1993961922, 3075122442,
	1834993497, 3268044715, 602098221,  108840781,	603602362,  3951135896,
	795801225,  1628972439, 2293205724, 1030474073, 4101050725, 3993073677,
	3437557819, 428633157,	1187290081, 4059012628, 3963477284, 1068212301,
	4004464010, 758714725,	3486416127, 1894136423, 2040261871, 695376511,
	2696881921, 3432947193, 1021180068, 1666967484, 21024292,   1369470089,
	120272167,  4086933029, 46199553,   1538923689, 3405980651, 3707277235,
	89238729,   3189366317, 431949839,  3383031750, 270909873,  684922983,
	3087479730, 3742631573, 62245888,   265071726,	2874643342, 3231383808,
	1248037486, 3501968040, 240923843,  1818575986, 531040488,  2089806309,
	78156843,   1094266598, 2811396908, 1206721819, 1789644301, 4131833096,
	3848519295, 2572076580, 1374102533, 1394632040, 3808745002, 944623242,
	784836192,  3775907851, 2236642333, 4007691859, 2681589302, 302671438,
	4174526145, 3390424827, 4266987708, 3946629900, 1028534326, 487170210,
	1952877575, 3591600489, 3854080005, 3122488201, 1792483581, 38900689,
	4120931419, 1026049450, 4058656739, 1813756750, 2614210426, 735039858,
	497898241,  3245766405, 347876737,  977718361,	2666110820, 1685073709,
	3317305849, 3191942487, 2994009727, 282741585,	1609418993, 2101057951,
	2492458966, 943914052,	2521645218, 505154276,	556718189,  744253623,
	2830653525, 3121621697, 1628192030, 89299212,	165377109,  4162675920,
	3450042888, 1631865761, 521307901,  46182200,	2284090081, 4244970352,
	713055660,  4012080080, 1496466542, 3458892347, 1117329308, 586377741,
	2967114257, 2778181555, 1716599374, 1648735121, 3220684600, 1291960383,
	1437203837, 2803249070, 1791453699, 3311100645, 1491925382, 3111105603,
	1032314081, 119623121,	2220909465, 1153636635, 2267359277, 2123359932,
	2926095188, 3168363991, 3864838104, 389680300,	4278929177, 2437072273,
	1049463107, 2436105563, 687121721,  3969841713, 31825262,   4007383028,
	573237561,  4119206502, 1065820986, 3126319639, 2737027162, 4178715112,
	3492893485, 3751241538, 3578660225, 1437416012, 2838926437, 3958798300,
	4274058912, 1679333952, 209371864,  3694223262, 3182815935, 2269276979,
	1939094038, 2705298728, 1016867055, 4002194250, 3730465948, 1955649118,
	3021819573, 2395718900, 751766793,  2818475904, 3708651973, 4041367796,
	8946527,    1374808605, 3114136819, 2948946526, 555953677,  2367624242,
	518557152,  481620859,	2008034802, 2419565161, 1192566154, 1218402182,
	2120541601, 854742420,	1247689006, 743279245,	477114869,  4045830821,
	2707786232, 1067884394, 349375545,  2752289539, 2213316260, 1203136178,
	2048170262, 1403465527, 1359604475, 2087023501, 953002859,  4035521421,
	2476786767, 1816140300, 325895038,  2862022689, 824391977,  3191960319,
	3323386769, 1240700791, 2773096012, 131895271,	2531409165, 78703782,
	12036540,   1814996511, 113173720,  3207419480, 888767484,  3712481254,
	2589393674, 3092708142, 66688564,   2868745347, 278630432,  3042487901,
	2100274041, 3601844849, 969498173,  756602371,	1988433116, 3444882833,
	2759149702, 3219357036, 2365302739, 3808836086, 2332252182, 3014412592,
	3901537741, 3497986897, 3620235522, 2820141550, 850375565,  3930341919,
	2816569743, 3983785686, 1499398702, 833779448,	335602090,  2703668477,
	50012247,   473457073,	2871591881, 2296478699, 3979843592, 4150219790,
	982425383,  2166682388, 3018992633, 1499274078, 2085462562, 3164128235,
	3788477124, 797080244,	2087340080, 3380138307, 2442795320, 2459390007,
	3527468806, 477587661,	2454265028, 821316322,	1226116708, 1835684730,
	3387970979, 2295993645, 4108527997, 1964451462, 1873526519, 3804506066,
	1489295367, 3288487846, 3063071465, 2816939951, 1307611803, 4194689386,
	1115884501, 1546364623, 2322559234, 2268025580, 3685106033, 3469268611,
	1814428439, 380954347,	3807429731, 1947730482, 2071784141, 3381827211,
	3147661399, 63906297,	4204517810, 403266583,	2129426602, 1129889881,
	1359837204, 3106158372, 3835699288, 948437068,	2337564625, 3002059037,
	1347468387, 2192281791, 4243827939, 644927265,	3300946712, 1233489797,
	1761469827, 3077130745, 1975233669, 3652238176, 2414034191, 3951311224,
	3000395935, 150791564,	680788748,  2418607059, 2878139768, 1237637790,
	1805480705, 1340922997, 2913727665, 3082928439, 1465930862, 2585973433,
	2606412540, 2666241768, 2991944478, 1253488375, 378583912,  331767702,
	1443923879, 2291658306, 2251861159, 1751469051, 3457218255, 3661685583,
	92561441,   1854722968, 2130887992, 3238785048, 1744025637, 3761519496,
	3032791714, 3069228969, 3264358007, 3306526753, 978316563,  3537880053,
	2368937682, 4077121607, 848858543,  1928881882, 1648581861, 395402780,
	3536902149, 2923362846, 1956115042, 2476977515, 1835331948, 1510752742,
	311492094,  501478378,	2634310048, 3769545235, 2035202468, 1608594486,
	64148382,   1058362960, 320583013,  3126195397, 618429402,  3313084955,
	950139526,  3533980535, 3120290706, 3977637810, 3793929545, 992847032,
	3682701326, 912562152,	407319996,  4130729847, 3807771368, 131380754,
	23673642,   289667130,	1809045995, 2777910846, 1420272604, 369527188,
	1750890583, 1772857469, 1591455988, 2337893655, 3059433355, 289365844,
	3752296023, 2326109229, 2241080025, 1936018978, 888670440,  1078500090,
	2655628877, 578177845,	22479531,   4079308357, 1424414583, 506673292,
	507142301,  2404917564, 2667654777, 918095925,	3248986302, 4207495511,
	59931018,   3018051800, 3495713861, 1679666587, 660736982,  4233415640,
	2902151490, 2703328024, 2980258734, 3347925189, 485688082,  1775196878,
	1449050918, 1833581744, 862931905,  161454464,	1537177639, 4271045246,
	2533692595, 2618183,	4289922482, 2955481372, 2401393390, 1387373104,
	916612738,  350775632,	3539191883, 1758911426, 2864780649, 839213857,
	2486382463, 690965528,	1752942063, 3223307680, 1497726422, 3960926066,
	585626287,  2317278202, 1577788003, 1741966741, 3914007205, 3897234626,
	1208309968, 4132838230, 4030396184, 1350619463, 2174987482, 3491961407,
	1843845611, 4202891697, 1460163008, 1817364076, 4134786959, 3624572106,
	1276812531, 1365804449, 2289733199, 3339331265, 1267433128, 1525069124,
	2239838039, 3926191055, 3169644224, 2612144124, 3447749026, 930195910,
	2006944264, 1690609122, 2780585090, 4004572800, 2823713812, 2860041714,
	2431603292, 3689404627, 2108201395, 149964341,	739856866,  523875229,
	94008315,   855614428,	2303901422, 756441424,	1242996893, 4021300491,
	3416920326, 3548598118, 2770824841, 4021423059, 4045375255, 3875516275,
	3901397229, 2971668679, 54199600,   955209558,	2601007907, 3528497554,
	1447931373, 266557275,	540951799,  2524284486, 932259061,  4277676036,
	3381559233, 2334945468, 1319722209, 369450645,	162366682,  3363021761,
	3221599750, 2189710522, 760963431,  3929606857, 3789373987, 1056858898,
	272304593,  198974972,	2469263862, 1434639016, 2237187310, 4051114612,
	3999429353, 332016233,	3638386366, 2892324454, 2455477910, 97079510,
	2707037447, 2722329548, 2254331611, 1713145351, 3317322016, 2354489271,
	1171212389, 96367615,	588894430,  3286827223, 4245874109, 1088078163,
	1130770946, 1973949249, 2305999695, 2245503311, 908408769,  3664787012,
	1134407650, 807594726,	520455954,  1107056774, 1063153250, 3472640405,
	3874453658, 3040670535, 46560627,   427718933,	19867766,   229971951,
	3730382528, 684365756,	3471393074, 2553941260, 2845943297, 2143155403,
	3189432598, 4114965877, 3871365648, 1175868792, 3174534140, 3244599173,
	1904776903, 1173512973, 1041955721, 3044112325, 390194951,  2055777242,
	3085812303, 4130336539, 4266388568, 2108685577, 1559922651, 611769291,
	2148423288, 953886176,	3556963278, 2202209757, 1014836123, 3774525001,
	3696488670, 842357976,	166021422,  3937173318, 1114393210, 860891562,
	3639491556, 3194641482, 829860,	    1581933204, 3027987973, 1054556779,
	4129724614, 3034928980, 1928590434, 2220872189, 606801439,  824838332,
	289938243,  4242314779, 1106130641, 3854068513, 2790852387, 2385804077,
	120955535,  2311943438, 2045192800, 2131823383, 2861569724, 2371685832,
	2849403459, 953278542,	2861154083, 3887443989, 385414475,  3776533004,
	2396040700, 1428310035, 2460415195, 584339669,	2670127436, 2888562890,
	2887779846, 1922590304, 548282514,  3468615204, 1076405305, 2198200402,
	2232688458, 539223369,	1314320521, 1525935273, 127873300,  4097969786,
	2846536093, 269143379,	3620817308, 1740625278, 3269711139, 2128599981,
	3536890711, 2160843166, 10821257,   1981373164, 1593792846, 1520850347,
	433237822,  2691093150, 3013147482, 3031797608, 3986185945, 3981934051,
	4223578635, 4264197795, 491142669,  2624724347, 1946970396, 240265967,
	2971290978, 2711358204, 3511232687, 1060362464, 3529375769, 1133234893,
	4008809057, 3468935560, 3373154701, 1272124333, 2233457662, 3044181284,
	3059688939, 64902200,	2163094726, 2852503076, 3037074966, 1868353275,
	875887631,  4165533905, 3308182181, 783159981,	4156510563, 3222960477,
	610919648,  3537312873, 1256024758, 2449466819, 2469231064, 2985057514,
	78456456,   1684774979, 3822747500, 1079714185, 3049020516, 3449140775,
	228076859,  3194325013, 1401042480, 3970880832, 3698493022, 3182852260,
	408007076,  1115574300, 1765158761, 3246663616, 91378964,   384271107,
	3294025199, 2434806566, 477715941,  4245853500, 4202838978, 1754845040,
	4092845417, 500965601,	1341769483, 1051883250, 3294321503, 1191243349,
	223997223,  4256301598, 1144006243, 2850970969, 1764455631, 3672445484,
	2688543202, 513697179,	1104012477, 1287839761, 4192272870, 2453305969,
	1504199727, 1890001241, 2074978201, 3859627185, 1909268116, 3348114790,
	2560162368, 2127897993, 2364287628, 16695378,	2947253472, 723696087,
	472603616,  3416877504, 609845746,  3627572579, 367894750,  2903060689,
	1161115852, 763696601,	2810708482, 3522981859, 4225789670, 3180319122,
	1422699935, 2860502340, 4000562835, 2458125829, 3493687635, 3342889581,
	2921131328, 3534554875, 2887992669, 3883236874, 3745649257, 2331692183,
	1583547212, 696815054,	3487380479, 2333741961, 1150055836, 1166008756,
	2039665261, 2493624867, 1086082405, 3881352540, 4128993324, 1499646146,
	980729012,  3872072074, 46734372,   737024332,	1367631695, 3188221579,
	2188721676, 1030598593, 3463434014, 1708521075, 2235202025, 4030662151,
	1770361260, 3192971872, 1887338426, 2776327107, 536176104,  3848287624,
	1619566106, 4139539014, 3306974480, 3543692443, 395390345,  1271210179,
	2301635449, 2631064470, 1255881876, 261767710,	2563323835, 737028782,
	1932069385, 2850771649, 3356919807, 2307779796, 193659678,  3116545540,
	653970776,  698839513,	1102626803, 393061352,	1813649240, 2524540527,
	2285339487, 3674688311, 1167089136, 3063801682, 3010863265, 4150264974,
	3310098994, 1326863523, 3822495047, 2790799997, 66080994,   3835475129,
	866656722,  504685086,	2830683567, 896398880,	2766059209, 1501301470,
	3212664038, 3215512889, 3036768766, 1724706505, 3378570767, 3549673835,
	3787838561, 820507767,	1270923653, 4227740507, 1978681809, 340671698,
	506903732,  47819027,	1991465090, 152757179,	3566255675, 1055587740,
	3754657888, 388378494,	612323484,  2899316241, 4108846912, 2842678522,
	1299851602, 6713462,	1781961790, 240397294,	2328649373, 116826803,
	2254060286, 4076140993, 982289047,  632370634,	1368922077, 3885686779,
	1240952669, 3306000614, 3933474652, 996122230,	4258230854, 3656582227,
	1972189590, 1506585955, 2101864012, 346563263,	238717322,  747289977,
	1733025786, 3288416978, 2964820251, 3015829719, 3172832655, 2704903309,
	34402194,   2420666828, 1923255355, 2796495863, 2577442948, 3612654081,
	1617871774, 2393478566, 1470566483, 3244346933, 3623277079, 942685289,
	2140121304, 1087812987, 2688563742, 2548411204, 442108639,  3730454519,
	1738019950, 3316363120, 3419172892, 1467182103, 2025002351, 1962031054,
	1060646168, 2655556944, 3451857931, 2133085797, 104100601,  371345659,
	1825089911, 3646232545, 1752250720, 535670783,	2111866935, 1641653948,
	4058821116, 3871389255, 1308594228, 3718131832, 2500028271, 9284355,
	4272751071, 550422722,	3244347353, 3190800983, 2289417734, 3299364902,
	1556324373, 968857240,	3268984406, 3978355755, 4141375806, 3096262455,
	1049618000, 1309687524, 262657351,  1368137769, 239456467,  2466735248,
	1790675513, 3041644750, 2708087748, 2196448238, 1035427775, 2755994337,
	2981530289, 1037274408, 871433700,  2024309612, 1728735820, 4113858101,
	1837928277, 1132186558, 3468368624, 436840533,	2101095540, 3011076586,
	1914509619, 2442772659, 1853158593, 3937868131, 1500852060, 3037553241,
	675062330,  2936974607, 2942541137, 875353412,	1125015135, 2765247762,
	2166859435, 1718594534, 2050710941, 337127612,	2102491125, 841510131,
	1836730468, 29706684,	1885600107, 2029267970, 2661794952, 3226540024,
	1349755837, 1041727287, 3658152103, 3273215871, 1498532671, 1881904038,
	4201960820, 4209974757, 3745561830, 123140172,	465539903,  2334930761,
	3472279324, 488012797,	51429922,   1011443408, 1797781533, 1425862290,
	2595797778, 1767229064, 4134130268, 1125553569, 3097376735, 1274952685,
	2947884256, 1011605213, 2087614385, 852002691,	3689770305, 3683617972,
	591797535,  3615337194, 3215286442, 1384565464, 4250368780, 2589189228,
	2590366985, 2303765812, 3329304861, 1574347835, 4287480887, 3289865121,
	2357400162, 3236913423, 2892321643, 2515429332, 752114589,  3877670210,
	154448448,  267867291,	1694147229, 1194473984, 290013954,  3759102509,
	1839385574, 1943629802, 2376079940, 20847494,	1324330710, 550412159,
	527675238,  469189451,	3043159931, 1250558454, 1663496067, 3690337676,
	2688283357, 308553071,	1503106702, 3956654189, 653112564,  1504697882,
	778919400,  1544543107, 3636402460, 697835526,	4066714589, 801426405,
	717844511,  3182353363, 4188676688, 3601117198, 3439494845, 2341781979,
	1766970170, 2877607301, 2067815168, 1328960099, 3743532741, 3280007410,
	2708324659, 323245430,	374228249,  4114719908, 3616473827, 1089596705,
	1001795704, 398313926,	3626783365, 4171075887, 1294879397, 1730856094,
	4201887994, 2575871408, 3779985324, 2031478114, 3512747827, 326882688,
	2022357869, 2913969174, 915805367,  4152340388, 884194685,  946942199,
	2347206724, 100882432,	1631982127, 251418892,	779665387,  2096075729,
	2706088102, 672238418,	743189963,  837545048,	653788598,  4074833000,
	4248367236, 1826116390, 1463872871, 3871126046, 719065043,  1525216878,
	2780525853, 3473285465, 3707165373, 2675771344, 2726669280, 3391147434,
	3476285127, 1081287148, 1763736489, 4164363849, 1640117957, 4134877845,
	1726854041, 3143788538, 2564896259, 1909573091, 2619828518, 1315361932,
	2154424678, 3407895935, 1560292633, 2880533851, 1343236215, 1242636802,
	791908154,  4142007373, 2899474908, 2150608177, 250644335,  539213287,
	2918460076, 2993877873, 3938266525, 255393868,	3094870671, 966160095,
	522401801,  3365939092, 1563726187, 322476918,	810339724,  2237296443,
	243422321,  1002664967, 2956694273, 2385853368, 2488328301, 2868675497,
	1387529392, 4112426471, 4281290782, 218898236,	3336311249, 2012191288,
	4225711927, 261046220,	3027080850, 2997269054, 2635990197, 3261794842,
	171214400,  2457012933, 3118375166, 2439888862, 1038896301, 447102710,
	934689658,  117854165,	1691558374, 1656908437, 510816197,  2443883917,
	923351109,  4071494121, 3431200406, 124745241,	2876191815, 2394999729,
	4109456078, 2347238191, 2995068524, 3078034706, 1318195907, 1793105271,
	1771790697, 4174370790, 4207842261, 872034745,	2028174768, 2691361193,
	145887831,  3982221370, 1306626122, 2465633414, 3604423136, 2193787329,
	649141007,  1492560857, 2399682620, 391101942,	3909250891, 1520945546,
	2141815506, 1096219934, 3685592664, 1559639626, 3350246232, 294815955,
	3648166705, 780517066,	3365839643, 1147216839, 2248426973, 457447142,
	4092499334, 4225770261, 4035470700, 3421217723, 3468751176, 1692674810,
	2884658452, 1659616487, 1448144486, 2103171023, 795215836,  1138887273,
	3291687188, 4264340775, 2870368177, 1077985924, 2698503476, 2136249111,
	1464790294, 1765737245, 2915358502, 2310594532, 41500273,   597402873,
	2276963695, 2678777986, 2349795076, 76027328,	3062252949, 1462574108,
	310092860,  2377143065, 3426377515, 1575875197, 1745049781, 18233345,
	3792508211, 1863958467, 1476629997, 3276563609, 780846600,  1368492595,
	781497921,  1686239346, 3658015808, 2780383537, 3886475224, 1711348957,
	230435614,  495300989,	2159209484, 4269507804, 1132162115, 3714288074,
	3274899058, 922254079,	2777587109, 3884217958, 693437095,  3342302460,
	1172089813, 759443636,	1730896438, 611793341,	756156924,  3589143772,
	66209367,   2330823616, 672728514,  542248737,	1191556637, 2653638647,
	4081618282, 1778104923, 1793979474, 2609406265, 272880933,  2242059374,
	2020484152, 2621498111, 4135999175, 431024039,	4282370249, 3292477343,
	1780662710, 368133383,	3663333908, 842742768,	1530065898, 4154926931,
	1001712238, 2558677715, 100455268,  365667619,	2614248292, 266042478,
	1512833231, 1959155820, 4020664208, 1126818999, 657460036,  1864450970,
	4016749389, 1640157874, 640780196,  1596147440, 2444640216, 1941695006,
	4225673003, 102129538,	2137836280, 3234476618, 3025754671, 892867278,
	508392808,  2158130953, 147105006,  3542872381, 1210594323, 2183079882,
	4269922265, 43044678,	448325889,  1207738803, 855120389,  1837030187,
	1354496851, 4015042237, 3463266375, 2158395691, 947411255,  238110458,
	916303698,  3672433648, 1048132486, 3428446526, 1033606484, 583209893,
	1767276577, 3795934895, 4263952621, 3061405902, 1706835865, 1829837493,
	3041196177, 138501427,	2293471691, 3342449315, 163640769,  1314197026,
	2446344148, 2524153328, 1565425475, 1618137861, 2557112491, 406419110,
	2187348136, 3825965353, 3204035100, 1348236388, 982780673,  2506416813,
	2028898355, 2847694422, 1331716198, 158787867,	1931810838, 1591002302,
	1008682846, 2980065200, 3304544838, 4294408811, 1759082343, 1529527027,
	388335759,  1214215630, 221010159,  307842793,	4038565507, 3571915070,
	1259047480, 3397020152, 3795868710, 3905649350, 1424365576, 2863585766,
	418892421,  1730802888, 3111470762, 1730212949, 424460837,  1885010816,
	1473161735, 2451365289, 2271016772, 2100464006, 3968283237, 3799336636,
	3215615511, 348578965,	3399711365, 3672080728, 1416209598, 45348808,
	731220212,  1947603658, 1222093088, 3271398547, 451963447,  4035975811,
	1572391897, 2598728119, 3111030230, 896861072,	3470840360, 3122497557,
	3049544168, 2488828339, 3788896439, 1262587838, 4114414536, 2237581046,
	670036460,  500830744,	422934802,  3494193558, 56215930,   4263580863,
	2831875261, 1504112445, 3190315528, 172903625,	2477475404, 559697285,
	4212810537, 2150200739, 1557239396, 550817709,	1541428489, 2760467152,
	1090442985, 1507648920, 1744697507, 3385016724, 2969115965, 3789736005,
	271145528,  1339614675, 2774279851, 2110315416, 2610644984, 2034143708,
	1434847152, 930892005,	2150431003, 39619425,	4257300254, 2127065486,
	3782568015, 2051801598, 712226957,  576798182,	997699438,  360923026,
	198182756,  1691160317, 4244924075, 2262445095, 4229922660, 1314083575,
	2721029823, 3031170019, 696711518,  2785634522, 3169742567, 1208339195,
	4272423528, 96876535,	1010690568, 265025721,	1591373260, 162943462,
	1788883171, 737799821,	1395081425, 4062716732, 570865245,  2807678166,
	3686604028, 3582645430, 502157733,  1471760901, 3186324809, 2879558954,
	2675414435, 2301208932, 1537045518, 2781035171, 3650807765, 3994629800,
	4252844271, 3920878186, 1494338897, 2965110378, 2517588765, 1555440528,
	2156910436, 703216054,	1093580081, 817772195,	3896774436, 4200121516,
	4103189568, 154919319,	2446932241, 2503543852, 40215179,   1656569587,
	318231738,  3897924675, 139645274,  4151582775, 535078860,  720301271,
	3543383915, 2045443692, 388589393,  610002884,	610677086,  3349892815,
	3894531084, 255756075,	2125961263, 4268540103, 753280962,  233603823,
	282168577,  114860785,	4281764534, 3690401944, 1625669353, 2610125449,
	345147225,  2506820325, 3811356822, 3028258858, 1015344838, 3470631720,
	1102221877, 1960377547, 3199263518, 927472408,	1220615292, 1212564002,
	2125252519, 1772089712, 2790510278, 1197519365, 2595466689, 1469375769,
	3148667033, 722864963,	186280386,  2433493401, 3754144109, 611137387,
	3428665112, 3856538042, 2415604845, 423300071,	3444380990, 1416556564,
	1795699390, 2042200370, 2927047546, 224087530,	3412688350, 1933279487,
	27067324,   1725391658, 435751111,  4236684862, 4288394579, 3445193964,
	3785126941, 1678573361, 2898231622, 3251677039, 2590629572, 3368011635,
	3548394347, 1965832969, 2025478998, 1718118581, 2456649746, 2530767217,
	1171602351, 1633235419, 2150698942, 4107180524, 3330123926, 3940044747,
	1213043324, 3208658237, 870088038,  2559930667, 3766649344, 3881362155,
	1855630215, 641232946,	982110629,  3358286135, 2189779652, 154151741,
	223376646,  2700149545, 3453817884, 2103096895, 1300063234, 1739903445,
	3412358732, 4222782669, 221285443,  180098121,	3765546779, 2658515322,
	2535571126, 3686083187, 2156549839, 3387333737, 4220622163, 2904410472,
	2580858616, 3011799808, 1267764092, 2454335127, 739987982,  2982110489,
	87490045,   1182356049, 4011462032, 2178989551, 171626495,  1668180706,
	2054945654, 3893299069, 1400093463, 611803583,	2639130943, 2294941835,
	1705089928, 1540993874, 3535226177, 2751230694, 2466764842, 3250358419,
	3316792561, 344202132,	1836690080, 2618052162, 547186625,  1725391065,
	2367847150, 2769253054, 2168743965, 789272297,	3677236634, 809555215,
	1815727422, 3324030491, 1423176660, 2096601741, 728864272,  439632035,
	1092315971, 554990855,	1803176062, 1700413204, 3445110426, 2362947249,
	27907572,   333097240,	61061663,   2631943682, 4168073667, 305981018,
	1547311024, 615784850,	1651611911, 3240259634, 3513572414, 3625918215,
	3598529458, 1371915430, 1102481673, 175708727,	4165521474, 2093281816,
	55754872,   1292155391, 246564640,  290451079,	2732291782, 1877489385,
	342907254,  2723135504, 1108299826, 966620595,	40313998,   1642583543,
	1074100141, 2557675545, 64683564,   2241787701, 183814192,  1425147471,
	3516781918, 2646801231, 2072864561, 1830358198, 2125814670, 3932711611,
	3428239203, 1053699930, 1239676436, 2331517968, 1587644462, 1521806956,
	1979067651, 4075888827, 3487821333, 1326757219, 808663445,  1927979587,
	1424557925, 3481695365, 3147753661, 3447860950, 266947387,  952934431,
	2298339433, 906985914,	151689907,  4175581233, 1703078843, 3722773411,
	353679467,  1845852322, 1754186090, 1488025259, 1633517352, 1236857305,
	3030069008, 1423740189, 2742807888, 1574562292, 505732827,  825942525,
	3061000499, 248304967,	569533703,  3629987505, 2219054804, 2146147841,
	2887765093, 3108734788, 3510332735, 1173107841, 1395848260, 3732131692,
	4010684576, 3870523994, 906294496,  268770507,	12124634,   3286467076,
	1628613184, 3196285182, 2855012166, 24074283,	2323010794, 2533498599,
	1697302900, 3155175400, 1117388313, 1254749210, 2479725972, 1516872607,
	2590997244, 2114300989, 3651296400, 3339479541, 3923241433, 2541553739,
	1101116492, 3331561841, 3063382009, 2346968959, 65301547,   1925883139,
	1692637068, 1680760106, 1991205136, 2155540933, 555838292,  556785378,
	2529015702, 3858222480, 2659798339, 3854236059, 2310066859, 113456142,
	2529214482, 1931188558, 3512569489, 738134413,	2747542850, 4014953402,
	1036093185, 2733430683, 364510316,  3329926862, 3375578570, 441262687,
	2180337202, 2581900589, 32405511,   2316562552, 3262724648, 858641065,
	2140419372, 1205970168, 1669892280, 1416178448, 2856629852, 3759114525,
	2493218083, 3654235002, 3332559278, 659476887,	2320280716, 998964963,
	2419434447, 1525187896, 4104294288, 1695528151, 4234840169, 839677038,
	3447813973, 28554127,	1365896093, 408124794,	3198848078, 3531799322,
	1650716483, 484151808,	3382243097, 2467960831, 3473525308, 536124442,
	3433723046, 4275721495, 1840166753, 2535059213, 69588552,   1718093199,
	488910308,  4049451818, 3095875792, 2422541941, 652116104,  3829757330,
	2893289986, 400458029,	2562516608, 2254535338, 2280539706, 259052097,
	908685292,  1298951018, 2425533040, 3882947240, 1042726393, 2650914078,
	2838505951, 2376572581, 4095374684, 2197454627, 959717377,  3795592818,
	3948124282, 2531482235, 28771337,   632346939,	2730214549, 1287555346,
	3974713881, 2894720611, 1536409066, 1293615644, 135415048,  1165382068,
	91132951,   767326641,	1842138663, 1672253215, 1843167080, 1133571423,
	2904917767, 3487875367, 2758919449, 2251400608, 2791758606, 4138785712,
	3219657551, 2298839867, 932543437,  2577712138, 1317206546, 3413659573,
	1821448672, 770852130,	2213613837, 1379174210, 614865932,  2922784086,
	436837427,  1076040449, 157391672,  909693818,	3347640024, 1367791198,
	3457008127, 1849252754, 4080433424, 3007980578, 4259725851, 1231667315,
	2832169995, 846303984,	2161169051, 4070337742, 365278700,  753890901,
	1512836318, 1166842303, 328840781,  2924297962, 3721712556, 2694583599,
	2271000069, 471942180,	1701823397, 3157464766, 2108603951, 454595314,
	3921789906, 2552130163, 445650663,  183099789,	806390940,  1216275755,
	689518584,  2516844979, 3468854615, 2555916531, 679165872,  603187464,
	310530216,  3001249474, 1377055844, 3991729493, 1812454694, 2392766322,
	75836770,   3650414925, 3551367670, 1598704540, 1574519027, 3820936667,
	3596938523, 1535131549, 1828149550, 1187303074, 1517037980, 1920862477,
	3967912666, 178020665,	1885155805, 3270655720, 4068053922, 2351152029,
	207192831,  2695558372, 671901512,  634564228,	3281160328, 169717244,
	945377111,  4118022569, 4023712712, 3723059759, 3945586423, 4289109903,
	3223088929, 2474922066, 3254107942, 1815035728, 698193572,  276397320,
	101692203,  2852484829, 2085873547, 3458405670, 250268123,  1126982808,
	2776747930, 1505625061, 3403405292, 637539770,	1549620360, 1753692544,
	1909994360, 163548516,	3330568325, 1963460969, 4102235296, 525312913,
	2211202879, 622954859,	3827416768, 4206688463, 1712373673, 3976510284,
	1931817711, 3246596196, 2125182513, 182258170,	3199972363, 854492529,
	2480844332, 204197416,	1799592653, 3510327211, 3303746439, 2690308124,
	1844775119, 2591656996, 3216838172, 2285350631, 763217087,  1982043420,
	3937689530, 758888331,	16040363,   1460166630, 2012013762, 528203354,
	3960645815, 322988153,	3328957746, 2187256387, 2173044217, 1871733342,
	942321699,  1395736934, 316675569,  147871982,	2396995216, 1474689088,
	3360341106, 2440125599, 2180330711, 1341922628, 2366001093, 29637780,
	3089220975, 2442201819, 493080374,  4024433312, 2374079468, 676699206,
	2389693303, 4195312556, 215902646,  3657271228, 1165379050, 1709261128,
	897406334,  1861626714, 2771876396, 1363510661, 2609522791, 3605956970,
	3854013175, 300991569,	3557458305, 3087845112, 4241005680, 3473862580,
	844072549,  61256078,	331490987,  2562966084, 2109702929, 2318713943,
	1215517241, 359323957,	3952546579, 3132485418, 559630676,  2348611905,
	878153088,  2948046680, 3493523041, 1897335274, 4095094725, 1869384102,
	1568562859, 1800874008, 1991104679, 1914432421, 1033482757, 1858798876,
	3256394150, 2992438788, 1180288994, 1093817148, 2639464683, 1027064754,
	2708699841, 559643950,	2794205450, 2178053353, 221306151,  3502258710,
	1465839598, 3977542183, 1262347248, 4201585962, 2709528392, 2747204768,
	1083909837, 3552976459, 1754217144, 175828164,	1548179275, 25079780,
	739723949,  3221668107, 1388447346, 2983500818, 683182348,  2373264846,
	1343188070, 3238952677, 2947162762, 2156787634, 3737102930, 2085539979,
	1040743420, 1326484649, 2852586868, 553674813,	3052800267, 1887288738,
	2613501428, 443294992,	3398019350, 3662702318, 1586700020, 598899642,
	4006824066, 3190996518, 1625931618, 3229986115, 2509141644, 4134616162,
	682901733,  638654775,	3021065400, 191408302,	1170328577, 3676083039,
	2877930271, 989180226,	2646859607, 13636147,	1223038268, 1339916018,
	2470037940, 2553871250, 3035468517, 1639417778, 3721735817, 3453965686,
	2580931730, 3245109298, 3072026698, 4281221468, 3585584335, 2863248879,
	2864572347, 4041897978, 3973909206, 803767628,	222164065,  3980235110,
	372470416,  1565461622, 3203995221, 1016840732, 3240206135, 3338313443,
	3246478240, 120742813,	3820404055, 401811029,	928597663,  3173214968,
	743861772,  1463981462, 2370625136, 2304214059, 1261779442, 2971997831,
	561396612,  1254663253, 4264818130, 3140428951, 904853868,  173427758,
	975347138,  3953919377, 63826030,   3574118921, 308362189,  2910440251,
	560067981,  1264582559, 3683923049, 129477985,	1124348731, 811877215,
	2908288823, 493173524,	530886501,  1642357692, 2592609689, 318244647,
	315093110,  2993907904, 615991661,  511475523,	2919591027, 1967116023,
	3607621697, 3128416921, 2328050142, 3648287243, 4215443514, 3305071466,
	468750905,  4233197158, 3302571150, 2069299364, 857793619,  979457503,
	597782001,  3448629042, 990439130,  3049241196, 1577032932, 451701950,
	2084921585, 1174347379, 910731930,  357940475,	298174242,  2769872942,
	1142392100, 2587115396, 2092599363, 3539590296, 266023705,  1405154033,
	4259183463, 4288026395, 778431861,  2102085849, 690689870,  579991756,
	1011819396, 249411945,	754205320,  2808524137, 3966642679, 2885918456,
	2662276256, 1823667683, 2151711830, 1253640680, 2902598743, 1683443535,
	1754844329, 1727753962, 2219144219, 2149753859, 841072813,  181560413,
	1534053520, 624396340,	4014262205, 464036717,	738131484,  2226194301,
	65983688,   1757489697, 438302956,  1124362541, 699110148,  825908083,
	303144138,  2718062478, 2247481552, 1114535143, 3732917800, 3487940154,
	1185665088, 525147603,	2561560109, 3335281881, 1568622290, 1223978397,
	821804726,  1603630723, 2821501353, 1197482507, 3484056982, 603834889,
	99625344,   2401329366, 4213416573, 3889688152, 2268143849, 2121705134,
	2774633849, 3722844301, 2984967119, 1953681267, 677406055,  3789541381,
	3449303138, 550630701,	73894681,   2157439155, 1388935611, 2795545104,
	3932212080, 491677322,	2271141067, 4246430041, 961868193,  3453940671,
	124204183,  958464136,	3575744936, 393779132,	1497776888, 4180653724,
	3173697676, 3677855539, 4023145966, 3096746862, 2061797180, 481726832,
	94961679,   2281303336, 569644405,  1884900607, 416171474,  181880371,
	4027505527, 2382706970, 4158632703, 3845080770, 3873991415, 1673678867,
	2032287257, 1530272658, 1220035941, 2335622024, 1305760568, 2015424306,
	7074891,    1272501684, 4041285179, 3822468108, 1635514567, 438248318,
	583026938,  1922650192, 698435624,  918490110,	2770415261, 2681679133,
	2324182347, 3660316322, 3318388489, 3603013834, 3220268626, 2916251370,
	1007934522, 2239364802, 791864531,  143113469,	2952823007, 3230628690,
	4180225187, 1914971399, 3501658245, 3506110677, 540571480,  3093469290,
	1809057944, 3074632057, 781505146,  2336017574, 2305179341, 4229984537,
	2831602653, 2246794850, 1280818453, 3103270416, 3960803804, 3121089838,
	25701316,   1152328475, 3593300731, 2109184002, 2973287013, 640578744,
	1641463977, 2913314359, 1445340838, 3907840539, 3153005602, 383894822,
	1633919292, 2297262586, 3347980790, 2118216343, 1999362448, 985645264,
	3445610086, 2047224673, 454811337,  3519638192, 2739556656, 1163083751,
	81593482,   4145978823, 929739752,  498622351,	993050141,  1873611005,
	3077959094, 3805310961, 2880144772, 2076064806, 903903687,  4015068286,
	1010957777, 683520870,	2245895614, 1586274002, 1998686699, 2288637319,
	3747405498, 2702809610, 1542675651, 1218156561, 2894641363, 1788573129,
	699496260,  4085750835, 1435625187, 2422614709, 2839317553, 265429693,
	3812829335, 370394879,	1236261525, 976042339,	140270699,  1963989769,
	4119786673, 1408201563, 4248165949, 3057086726, 1782626473, 1881076725,
	2892024429, 3251557000, 2512904790, 3900538135, 2480996978, 1372863540,
	132182743,  3696412564, 19510457,   1530231779, 4077125005, 3269044539,
	325227607,  3781913321, 686228678,  3821828157, 1162534464, 4266274366,
	1811563347, 3169096150, 125278357,  815944642,	4083817383, 1451932480,
	3737803389, 1387292711, 649853731,  1872636837, 1774049685, 2445591692,
	1048052722, 824279589,	351408464,  2888551129, 1120933575, 397481185,
	2099939901, 44600875,	3710562526, 4224984321, 4216264083, 1342537691,
	1801500640, 2458344438, 42216222,   3098559475, 276304276,  3680956686,
	1270767040, 3462482193, 2813156854, 309547834,	2374076819, 2425846188,
	3415378342, 1346725620, 1664886188, 2888891924, 1833635592, 326773024,
	997800132,  609387840,	4022062634, 4253948698, 1257461660, 1121469647,
	2736325125, 1663289548, 449224202,  2126094617, 525628404,  46201493,
	489365497,  2965592440, 2916789764, 1039157635, 3199405660, 3573933601,
	504831295,  1128912169, 1523567357, 2441697962, 1313493748, 2103270319,
	983004604,  3757122105, 249842883,  3251738302, 1781151968, 2278052208,
	1231300358, 4041664268, 3651988464, 2981073144, 2037362421, 3521705113,
	2288839214, 2551467413, 2451124168, 3518947550, 1004530704, 2825903261,
	2778413100, 4100339857, 1243617614, 727416457,	2634190966, 634896433,
	3374213765, 1245126076, 1990603023, 2016168672, 365648129,  114262924,
	3797825958, 2774413541, 2917666694, 1055699044, 3903861554, 1658505285,
	1803419520, 1307672494, 1366648564, 3071773532, 1690949543, 2397214258,
	3645443705, 1346226291, 876850147,  2519162692, 3075936238, 2340163679,
	2873447238, 3681047708, 1034703802, 1608912113, 3449602147, 2391713365,
	3688338645, 3304525197, 2182497511, 92858750,	1297732734, 2661106972,
	89286241,   3924070685, 56994569,   4215520986, 1130164766, 4108023036,
	231048491,  2309265511, 3712065167, 993080326,	258501450,  134989544,
	3196390074, 1971019465, 368485820,  1194931550, 2938178350, 749666162,
	2334373397, 4032577710, 935206585,  1686892559, 1716963951, 185451821,
	1054064425, 37244084,	2374110723, 343113384,	123122065,  929124468,
	3166358967, 2641924229, 948312878,  2708206697, 357899303,  2216014601,
	2143044173, 3124190623, 1224980453, 947584108,	3011549122, 3160571408,
	391811600,  2593897424, 182343813,  3380381401, 194275657,  3696771878,
	2422574050, 1351831320, 3265264817, 144010589,	179304023,  1368198497,
	3623487230, 3572541343, 4070618368, 3170365078, 3671940201, 1174403535,
	2300483344, 1788803876, 628139183,  4112807265, 4034165148, 4140180993,
	1507444360, 1023802585, 3765476162, 1842504663, 3573506261, 806075798,
	2987484948, 344721880,	3232408026, 1550411842, 3075024875, 2870845847,
	2929222715, 1561218529, 225882253,  3467477407, 2652461938, 3161861279,
	1153868734, 1701545208, 1063179939, 2484530193, 4116295200, 2563275675,
	2913423863, 535859643,	1740635921, 2229062650, 3692214606, 2840552749,
	3061540035, 2922621313, 80000454,   1678495909, 1951075534, 3640720822,
	2425078606, 3954268134, 1985886450, 1740979264, 3219853760, 3621432770,
	1113783454, 2146455406, 151914225,  1094069888, 1905321765, 3197360511,
	3504648805, 940550289,	3196711383, 868048332,	1682052294, 2949635656,
	4176360885, 33493576,	3799885736, 4041545771, 1946189726, 100898772,
	1805157135, 4262715642, 2940724227, 2406813446, 2816163163, 3956307002,
	3998914750, 275751734,	3878962487, 449247527,	3026859872, 880864222,
	4140921265, 587228409,	3419312389, 1486229296, 3358275070, 1039770136,
	634720587,  3442578066, 2840236215, 4246103071, 1260425334, 1571006471,
	721975549,  4090351032, 3677876868, 4203675072, 368689901,  3934518978,
	25350604,   2346696882, 899950161,  1072119284, 2614310369, 2817042438,
	1274028963, 3792560994, 3579251976, 611062468,	3471802864, 709001813,
	951086922,  3331069421, 539131659,  3098704557, 4191535698, 998304670,
	1373380247, 2166977103, 3679033640, 2691603671, 1128010787, 1089248972,
	3559128966, 1072349517, 749350973,  3756481771, 4039278932, 2221846245,
	1595415560, 4215517635, 3793283168, 1130608947, 2888680624, 2009116360,
	1855966110, 2462939000, 4230722408, 3538634815, 3054885544, 3343296776,
	2670221393, 4197329384, 3904587584, 474452396,	2886750615, 4053730532,
	3666881048, 1958957365, 1667509114, 782126288,	3554072052, 1123941561,
	3948054280, 991831638,	2831441951, 3837468550, 3341854042, 1706379652,
	3595784377, 908058192,	963763845,  2672895834, 214008558,  354925881,
	3925525442, 1847143881, 2224818929, 3242039262, 2463701840, 3356510728,
	3261895826, 3613004534, 2463009935, 796582477,	950320612,  1555319529,
	602829229,  806592361,	2872052507, 2508377734, 2607796361, 3836347792,
	3266149121, 1120226084, 2534478986, 4175644974, 410277831,  1959269931,
	1677545525, 2081675042, 3156656848, 2854029449, 1056025266, 3198819210,
	406848619,  3683828761, 22083892,   1031613750, 897569057,  4025712204,
	645191013,  1407538935, 606859960,  986311991,	4245860709, 1784313026,
	2184535690, 2066044579, 2265577909, 2564003926, 1640983403, 1867553593,
	1740265879, 2222497184, 2067289167, 71724999,	2196723707, 2333304141,
	2037845464, 1334216070, 3445340579, 746767398,	429840615,  2726195902,
	2469228438, 667395197,	1087828908, 1386708968, 108240427,  205150978,
	3116415921, 3280863259, 317535684,  315377123,	4102330340, 412372864,
	662333088,  280918035,	1124761559, 3777881385, 18223074,   4163566418,
	2847884559, 2549609108, 1852434511, 3427101655, 3368138846, 1184169167,
	2451802804, 4228419679, 2848397952, 3042543080, 3517325904, 3009576574,
	1439977910, 1373397417, 3347971428, 4205416103, 3897277642, 2026204067,
	4214541908, 1224943399, 2725323233, 2755124410, 5380920,    3447956742,
	2393454796, 2273013859, 2591678466, 774395486,	1231652051, 3848884227,
	757786777,  2602043425, 196141247,  1774987527, 3576242053, 499366043,
	4179063635, 584232490,	911554939,  3646095818, 160982334,  1621765914,
	1616140098, 1865001869, 1309116910, 3904862589, 4042687025, 3879908076,
	2581964727, 997782639,	3382270735, 2502272715, 3874382671, 2397561696,
	3622550793, 1625040994, 156813580,  1665824499, 4238245434, 1970059147,
	2025221338, 2752112935, 3470897571, 1216527575, 1882719244, 3021390975,
	789860566,  3060931372, 3646977653, 1826001256, 2992102718, 3333710004,
	1129499883, 3965356653, 1034752195, 2581751851, 1443154874, 1228760096,
	583671880,  3868175946, 4185458087, 2858847732, 232280169,  954896144,
	424191410,  1408429592, 606462964,  1563587697, 2009225958, 1068851229,
	736461799,  2062048283, 2436776615, 3074906033, 3369884611, 564774321,
	333823560,  1044760322, 2358478055, 3536995928, 3590556478, 1444964223,
	3782584268, 2892306003, 125504168,  544861543,	4124598355, 1575487855,
	2533722525, 95502748,	3664188084, 1803442494, 618793107,  1519993256,
	2950934819, 2553705185, 659627622,  2117705273, 1127137597, 1840472385,
	2082402921, 2464677513, 2773151592, 3128619760, 4064967810, 1009837354,
	3682563579, 3560458087, 3030779395, 4134618057, 1884646698, 2111416248,
	4079097516, 3091501141, 1146803911, 335286745,	3186936340, 1948033733,
	760270154,  2664130887, 1957947588, 1629695844, 2071328400, 1989216222,
	4162432124, 1857797846, 1439255650, 3769505256, 3384313617, 2450159909,
	3990226647, 1481083937, 545184222,  3085222317, 3636026152, 1739970255,
	4172465394, 3272634291, 496825421,  1918464871, 2136017966, 69569732,
	662815147,  3100715909, 2274681779, 1517095524, 1214957324, 1350251420,
	1640122384, 3738829574, 3840419957, 3983987294, 1143020869, 698675174,
	1326572301, 1344377784, 1784523880, 2585218510, 2051807170, 3669439979,
	1192268229, 2779652160, 3193373328, 1452424889, 2905474857, 1217260527,
	2924063597, 367468004,	3076986503, 4245604816, 190970354,  1986162981,
	2688256569, 2213463420, 4104595552, 4204451363, 1500988071, 2604887660,
	1390124254, 24705172,	2581972694, 1355044513, 734081749,  2514320489,
	2616408881, 4105525469, 3500073554, 2354349263, 713706312,  3822138887,
	1228424903, 3180449732, 303812950,  1484645590, 2136636053, 2292869754,
	934693339,  2262134479, 4116442081, 508154231,	782788630,  781142324,
	183835525,  2470668488, 3540551093, 521560828,	4257807232, 2352145993,
	1057059616, 556473387,	2282838454, 2746251969, 4022452879, 159829037,
	2692417959, 1019129642, 1688423256, 2631791653, 2774112882, 469308030,
	2786333203, 2597388085, 3075176642, 677524723,	2527472599, 3148938327,
	3531797285, 117561255,	122344092,  511999457,	2313877568, 2169104129,
	3259124422, 3610163943, 2672794016, 600490670,	2149423847, 3211984431,
	196539046,  779397844,	2078133643, 1852444633, 1907143061, 795354765,
	1327702567, 3603687497, 2616550692, 3162525906, 2147603062, 215076890,
	2338744904, 1345072962, 2327178816, 3016623655, 3226226697, 3020987531,
	1311468864, 4177124901, 3855697345, 1829874038, 2156271150, 542282861,
	206390699,  3700053086, 697969918,  224938913,	4030623351, 379170971,
	947107661,  3395403892, 248325160,  2188088206, 3762609236, 1736395095,
	3517845130, 1116189248, 2292771037, 2762234829, 3084341420, 1959872956,
	1850452079, 4229281116, 2285276662, 3062987521, 2805560769, 1974734577,
	2381166977, 1377063511, 3238603383, 3970093763, 1346278837, 3012759460,
	3715660568, 1919757297, 439910048,  609808983,	8400023,    3807219348,
	1364656502, 1171728954, 3303592671, 2461779933, 935689374,  3247414651,
	630969944,  3556475456, 4051970282, 2485698569, 828171201,  689743860,
	3231045618, 1912288534, 4109758064, 1669095299, 1977812757, 898759149,
	1653506284, 1900783543, 1445204150, 21251758,	287085179,  3521512706,
	4018657787, 1942619542, 1277215267, 1847550895, 609322104,  4235351736,
	803218513,  1218165759, 335516756,  590009259,	2214697188, 2590710550,
	3455754268, 1953465858, 980025104,  3184510336, 3111055068, 2373845723,
	392471992,  1731417454, 4182317041, 1441820464, 488885415,  562924742,
	2979505596, 2579501757, 4227151847, 4280943256, 1377532339, 1010179196,
	888173530,  1773332428, 3857093363, 2382327722, 2024283066, 121626213,
	1451507161, 2697519273, 900129592,  3785947725, 478036595,  2905105315,
	1204606562, 3579286699, 1389673095, 2918677642, 2122376149, 3015851700,
	2056595885, 3047235973, 259375335,  2494038808, 3315364361, 1075496683,
	395252388,  1212916800, 3228689406, 2330873044, 3582204672, 2563340456,
	1679395158, 697052673,	2070611722, 1090068225, 547837433,  611612430,
	4254678046, 1055672708, 3074203621, 3131597,	1622146127, 1287642632,
	534407829,  3563297725, 3685498946, 698448553,	3591229382, 1644663574,
	410495940,  251562584,	814100143,  961163727,	3226260882, 1702522597,
	1682831397, 3097468976, 786030301,  2920076080, 2716587154, 3199232584,
	267993344,  975583274,	9231868,    1886298626, 806177678,  3032880489,
	2447173986, 252716124,	849324398,  4230109560, 3026327975, 4180344559,
	445739022,  1889635956, 1875870371, 205084776,	2715172967, 1515803157,
	3980985277, 74093624,	145525669,  4207792125, 2588045692, 3476408157,
	4219263823, 4212676837, 323389131,  68280923,	3662571954, 3261768237,
	1489416718, 443810601,	3554997540, 4213403664, 1392178486, 3557842816,
	855864193,  3578255841, 3882543386, 1920641684, 2531235995, 1633894382,
	773535249,  3532195251, 324476928,  826037527,	2928191898, 3044961941,
	1901055170, 2728860649, 2986159440, 2460728676, 558370445,  2427480991,
	3985338409, 1621759732, 3665143033, 4007845965, 3921859469, 782209153,
	3158088211, 1026705627, 64247695,   1448507618, 1023001524, 4164180786,
	1390953815, 909246039,	3094055124, 1477924000, 450225984,  3286676524,
	2540541980, 1254661528, 2863691633, 4144763599, 2559261718, 1421418258,
	605719919,  2751457455, 1093198082, 485339578,	386218351,  2010144181,
	2103247049, 1170336422, 4118911531, 3018283388, 1989746398, 130056490,
	1240109903, 1424929169, 1426688542, 3960558685, 1779307771, 20359020,
	3287358340, 1801671981, 4042385637, 3619967880, 3479535431, 1994385787,
	3383488166, 1546552321, 3987125655, 1866597451, 4042497979, 956485284,
	3554638957, 1822667982, 2315236618, 2840924870, 922095748,  3618159812,
	3910742623, 2995052821, 2329223243, 1854025814, 2771125697, 519488109,
	693284646,  4112324120, 2563870851, 3738963787, 2532232657, 3427949867,
	3800009669, 3094992724, 1206831306, 2337281867, 3796679467, 1626215141,
	1855712257, 1837762030, 3193216314, 3139952980, 2127445901, 3219852468,
	1950456020, 2602087594, 1743691944, 1040996850, 3564861756, 250287151,
	787337295,  836207298,	3092276009, 1734445329, 109624508,  2379496091,
	1022975022, 321471549,	2482334085, 2534712260, 1636840559, 1356540080,
	3160558145, 3639236983, 1682640637, 1804118392, 1192998994, 1215187398,
	2512256774, 2772213401, 518262670,  3542644055, 2004132082, 3411975548,
	1283100547, 1621167171, 4189165542, 2387712173, 3667053861, 1176339986,
	2583941477, 2802809065, 1299073475, 2019788501, 2652137781, 1414723184,
	1425136856, 1709605940, 1736186909, 3269384355, 332569653,  3550363746,
	4125597162, 3174863315, 1759856144, 4234116823, 1257793706, 354712497,
	1046107889, 1840331105, 1111939031, 3393016613, 554930389,  906249146,
	3662505391, 2516624616, 3133483156, 3044114622, 1954648504, 2014546420,
	1228045735, 4044174148, 201812039,  2201692739, 3114972937, 3501592168,
	450038229,  3526689206, 1553332473, 3064416936, 1908111841, 3698073775,
	272749195,  3207686291, 798459885,  1850899734, 3596303267, 1997147543,
	2272902491, 2538507143, 2427591389, 1666123343, 3677949581, 956418212,
	373493222,  2673265506, 1995224672, 3815140444,
};
