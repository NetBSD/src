#	$NetBSD: Makefile.inc,v 1.1.4.2 2024/02/29 11:39:14 martin Exp $

.include "../Makefile.inc"
WARNS?=		2
