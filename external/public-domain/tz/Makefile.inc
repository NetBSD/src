# $NetBSD: Makefile.inc,v 1.1.2.2 2014/08/10 06:51:01 tls Exp $

.include <bsd.own.mk>

TZDISTDIR:=	${.PARSEDIR}/dist
