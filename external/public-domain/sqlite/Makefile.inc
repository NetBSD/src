# $NetBSD: Makefile.inc,v 1.2.2.2 2012/10/30 18:58:14 yamt Exp $

WARNS=		2

SRCDIR:=	${.PARSEDIR}/dist

.PATH: ${SRCDIR}

CPPFLAGS+=	\
		-DHAVE_GMTIME_R=1 \
		-DHAVE_INTTYPES_H=1 \
		-DHAVE_LOCALTIME_R=1 \
		-DHAVE_READLINE=1 \
		-DHAVE_STDINT_H=1 \
		-DHAVE_STRERROR_R=1 \
		-DHAVE_USLEEP=1 \
		-DSQLITE_ENABLE_COLUMN_METADATA \
		-DSQLITE_ENABLE_FTS3_PARENTHESIS \
		-DSQLITE_ENABLE_FTS4 \
		-DSQLITE_ENABLE_LOAD_EXTENSION \
		-DSQLITE_ENABLE_UNLOCK_NOTIFY \
		-DSQLITE_HAVE_ISNAN

CWARNFLAGS+=	-Wno-shadow -Wno-unused
