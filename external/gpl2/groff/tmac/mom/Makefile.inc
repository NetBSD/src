# $NetBSD: Makefile.inc,v 1.1 2016/01/13 19:02:01 christos Exp $

# $FreeBSD: src/gnu/usr.bin/groff/contrib/Makefile.inc,v 1.1 2001/04/17 12:36:32 ru Exp $

.include "${.PARSEDIR}/../Makefile.inc"
