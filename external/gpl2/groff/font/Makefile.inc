# $NetBSD: Makefile.inc,v 1.1 2016/01/13 19:01:59 christos Exp $

# $FreeBSD: src/gnu/usr.bin/groff/font/Makefile.inc,v 2.1 2001/04/17 12:36:42 ru Exp $

.include "../Makefile.inc"
