# $NetBSD: Makefile.inc,v 1.1 2016/01/13 19:01:57 christos Exp $

# $FreeBSD: src/gnu/usr.bin/groff/src/devices/Makefile.inc,v 1.1 2001/04/17 12:37:02 ru Exp $

.include "${.PARSEDIR}/../Makefile.inc"
