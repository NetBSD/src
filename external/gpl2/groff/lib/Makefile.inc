# $NetBSD: Makefile.inc,v 1.1 2016/01/13 19:02:00 christos Exp $
.include "${.PARSEDIR}/../Makefile.inc"
