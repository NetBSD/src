#	$NetBSD: Makefile.inc,v 1.2.4.2 2017/07/18 17:17:52 snj Exp $

BINDIR=		/usr/bin
DTCDIST=	${NETBSDSRCDIR}/external/gpl2/dtc/dist
LIBFDTDIST=	${NETBSDSRCDIR}/sys/external/bsd/libfdt/dist
