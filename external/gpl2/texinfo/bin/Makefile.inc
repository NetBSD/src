# $NetBSD: Makefile.inc,v 1.1 2016/01/14 00:34:52 christos Exp $

.include "${.PARSEDIR}/../Makefile.inc"
