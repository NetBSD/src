# $NetBSD: Makefile.inc,v 1.1 2016/01/14 04:22:38 christos Exp $
.include "${.PARSEDIR}/../Makefile.inc"
