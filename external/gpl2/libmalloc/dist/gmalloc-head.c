/*	$NetBSD: gmalloc-head.c,v 1.1.1.1 2016/01/13 21:42:18 christos Exp $	*/

/* DO NOT EDIT THIS FILE -- it is automagically generated.  -*- C -*- */

#define _MALLOC_INTERNAL

/* The malloc headers and source files from the C library follow here.  */

