# $NetBSD: Makefile.inc,v 1.1 2016/01/13 21:56:38 christos Exp $

DIST=${NETBSDSRCDIR}/external/gpl2/libmalloc/dist
