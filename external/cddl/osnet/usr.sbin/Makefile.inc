#	$NetBSD: Makefile.inc,v 1.2 2016/01/23 21:22:46 christos Exp $

BINDIR?=	/usr/sbin
CPPFLAGS+=	-D_KERNTYPES
