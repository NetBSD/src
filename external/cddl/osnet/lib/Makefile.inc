#	$NetBSD: Makefile.inc,v 1.4 2016/01/23 21:22:45 christos Exp $

MKLINT=no
MKLINTLIB=no
CPPFLAGS+=	-D_KERNTYPES
