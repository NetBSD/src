#	$NetBSD: Makefile.inc,v 1.2 2016/01/23 21:22:45 christos Exp $

BINDIR?=	/sbin
CPPFLAGS+=	-D_KERNTYPES
