# $NetBSD: Makefile.inc,v 1.1.18.1 2014/05/22 14:08:29 yamt Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
