# $NetBSD: Makefile.inc,v 1.1 2021/12/12 20:33:22 maya Exp $

FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}

includes:
clean:
cleandir:
