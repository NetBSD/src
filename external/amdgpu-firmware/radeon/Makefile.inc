#	$NetBSD: Makefile.inc,v 1.1 2022/05/14 20:54:31 mrg Exp $


