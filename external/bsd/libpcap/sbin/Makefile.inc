# $NetBSD: Makefile.inc,v 1.1 2020/03/29 17:12:45 christos Exp $
.include "../Makefile.inc"
