void dummy(void);
