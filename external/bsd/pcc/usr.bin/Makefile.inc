#	$NetBSD: Makefile.inc,v 1.1 2010/01/20 11:45:55 plunky Exp $

.include "../Makefile.inc"

.if exists("../../../../usr.bin/Makefile.inc")
.include "../../../../usr.bin/Makefile.inc"
.endif
