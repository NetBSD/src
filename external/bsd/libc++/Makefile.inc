#	$NetBSD: Makefile.inc,v 1.1.40.1 2021/05/31 22:10:15 cjep Exp $

.include <bsd.own.mk>

LIBCXXRT_SRCDIR:=	${.PARSEDIR}/dist/libcxxrt
LIBCXX_SRCDIR:=		${NETBSDSRCDIR}/external/apache2/llvm/dist/libcxx
