# $NetBSD: Makefile.inc,v 1.2.2.2 2012/04/17 00:03:10 yamt Exp $
.include "../Makefile.inc"

BINDIR?=	/usr/sbin
