#undef foo /* blah */
