#define glop flop
glop
