/*
#define FOO BAR
*/
FOO
