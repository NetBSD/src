/*
 * gloop
 */
