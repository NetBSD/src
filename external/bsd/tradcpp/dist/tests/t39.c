#define m(a,b) a::b
=m(123,
456)
   ------
=m
(123, 456)
   ------
=m(
123, 456)
   ------
=m(
123,
456
)
   ------
=m(123,

456)
   ------
=m(123,
   456)
