#define PACKAGE_REVISION_TYPE_MTN
#define PACKAGE_REVISION_BRANCH "org.NetBSD.atf.src"
#define PACKAGE_REVISION_BASE "bab5e0f99e767de2e6650bf3c1aa7a7aad23a915"
#define PACKAGE_REVISION_DATE "2010-07-02T14:45:21"
