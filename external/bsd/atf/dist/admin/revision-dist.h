#define PACKAGE_REVISION_BASE "b09d335d9fd57ffa7d1e0475dc22a9cc56b05ca5"
#define PACKAGE_REVISION_CACHED 1
