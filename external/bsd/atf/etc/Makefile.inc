# $NetBSD: Makefile.inc,v 1.1.4.2 2014/05/22 15:40:13 yamt Exp $

.include "../Makefile.inc"
