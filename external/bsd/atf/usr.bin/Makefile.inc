# $NetBSD: Makefile.inc,v 1.1.6.2 2013/06/23 06:26:23 tls Exp $

.include "../Makefile.inc"
