# $NetBSD: Makefile.inc,v 1.1.8.2 2014/08/19 23:45:56 tls Exp $

.include "../Makefile.inc"
