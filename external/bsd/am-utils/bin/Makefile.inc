#	$NetBSD: Makefile.inc,v 1.1.2.1 2014/05/22 15:41:06 yamt Exp $

.include "${.CURDIR}/../../Makefile.inc"
