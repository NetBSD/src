#	$NetBSD: Makefile.inc,v 1.1 2021/12/28 17:06:05 christos Exp $

.include "../../openldap.mk"
