# $NetBSD: Makefile.inc,v 1.1 2021/09/21 20:34:37 christos Exp $
.include "${.PARSEDIR}/../Makefile.inc"
