#	$NetBSD: Makefile.inc,v 1.2.8.1 2025/08/02 05:20:51 perseant Exp $

WARNS=6
.if !defined(LIB)
LDADD+=	-lblocklist
DPADD+= ${LIBBLOCKLIST}
.endif
CPPFLAGS+= -I${.CURDIR}/../include
CPPFLAGS+=-DHAVE_STRUCT_SOCKADDR_SA_LEN -DHAVE_UTIL_H -DHAVE_DB_H
CPPFLAGS+=-DHAVE_SYS_CDEFS_H

