#	$NetBSD: Makefile.inc,v 1.1 2009/04/12 03:46:04 christos Exp $

.include "../Makefile.inc"
WARNS?=		2
