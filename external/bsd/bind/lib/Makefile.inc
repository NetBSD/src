#	$NetBSD: Makefile.inc,v 1.1.2.2 2009/05/13 18:51:49 jym Exp $

.include "../Makefile.inc"
WARNS?=		2
