# $NetBSD: Makefile.inc,v 1.1 2014/08/08 19:30:35 apb Exp $

.include <bsd.own.mk>

EKERMITDIST:=  ${.PARSEDIR}/dist
