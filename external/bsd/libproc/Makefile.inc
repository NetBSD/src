# $NetBSD: Makefile.inc,v 1.2 2016/01/23 21:22:45 christos Exp $

LIBPROCDIR:=	${.PARSEDIR}/dist
CPPFLAGS+=	-D_KERNTYPES
