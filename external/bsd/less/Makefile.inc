#	$NetBSD: Makefile.inc,v 1.2 2023/10/06 05:57:16 simonb Exp $

LESS_SRCDIR=	${NETBSDSRCDIR}/external/bsd/less
LESS_DISTDIR=	${LESS_SRCDIR}/dist
.PATH:		${LESS_DISTDIR}
