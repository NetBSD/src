#	$NetBSD: Makefile.inc,v 1.3.32.2 2015/01/07 12:13:03 msaitoh Exp $

.include "../Makefile.inc"
