#define T_Abbrev 257
#define T_Age 258
#define T_All 259
#define T_Allan 260
#define T_Allpeers 261
#define T_Auth 262
#define T_Autokey 263
#define T_Automax 264
#define T_Average 265
#define T_Bclient 266
#define T_Beacon 267
#define T_Broadcast 268
#define T_Broadcastclient 269
#define T_Broadcastdelay 270
#define T_Burst 271
#define T_Calibrate 272
#define T_Ceiling 273
#define T_Clockstats 274
#define T_Cohort 275
#define T_ControlKey 276
#define T_Crypto 277
#define T_Cryptostats 278
#define T_Ctl 279
#define T_Day 280
#define T_Default 281
#define T_Digest 282
#define T_Disable 283
#define T_Discard 284
#define T_Dispersion 285
#define T_Double 286
#define T_Driftfile 287
#define T_Drop 288
#define T_Dscp 289
#define T_Ellipsis 290
#define T_Enable 291
#define T_End 292
#define T_False 293
#define T_File 294
#define T_Filegen 295
#define T_Filenum 296
#define T_Flag1 297
#define T_Flag2 298
#define T_Flag3 299
#define T_Flag4 300
#define T_Flake 301
#define T_Floor 302
#define T_Freq 303
#define T_Fudge 304
#define T_Host 305
#define T_Huffpuff 306
#define T_Iburst 307
#define T_Ident 308
#define T_Ignore 309
#define T_Incalloc 310
#define T_Incmem 311
#define T_Initalloc 312
#define T_Initmem 313
#define T_Includefile 314
#define T_Integer 315
#define T_Interface 316
#define T_Intrange 317
#define T_Io 318
#define T_Ipv4 319
#define T_Ipv4_flag 320
#define T_Ipv6 321
#define T_Ipv6_flag 322
#define T_Kernel 323
#define T_Key 324
#define T_Keys 325
#define T_Keysdir 326
#define T_Kod 327
#define T_Mssntp 328
#define T_Leapfile 329
#define T_Leapsmearinterval 330
#define T_Limited 331
#define T_Link 332
#define T_Listen 333
#define T_Logconfig 334
#define T_Logfile 335
#define T_Loopstats 336
#define T_Lowpriotrap 337
#define T_Manycastclient 338
#define T_Manycastserver 339
#define T_Mask 340
#define T_Maxage 341
#define T_Maxclock 342
#define T_Maxdepth 343
#define T_Maxdist 344
#define T_Maxmem 345
#define T_Maxpoll 346
#define T_Mdnstries 347
#define T_Mem 348
#define T_Memlock 349
#define T_Minclock 350
#define T_Mindepth 351
#define T_Mindist 352
#define T_Minimum 353
#define T_Minpoll 354
#define T_Minsane 355
#define T_Mode 356
#define T_Mode7 357
#define T_Monitor 358
#define T_Month 359
#define T_Mru 360
#define T_Multicastclient 361
#define T_Nic 362
#define T_Nolink 363
#define T_Nomodify 364
#define T_Nomrulist 365
#define T_None 366
#define T_Nonvolatile 367
#define T_Nopeer 368
#define T_Noquery 369
#define T_Noselect 370
#define T_Noserve 371
#define T_Notrap 372
#define T_Notrust 373
#define T_Ntp 374
#define T_Ntpport 375
#define T_NtpSignDsocket 376
#define T_Orphan 377
#define T_Orphanwait 378
#define T_Panic 379
#define T_Peer 380
#define T_Peerstats 381
#define T_Phone 382
#define T_Pid 383
#define T_Pidfile 384
#define T_Pool 385
#define T_Port 386
#define T_Preempt 387
#define T_Prefer 388
#define T_Protostats 389
#define T_Pw 390
#define T_Randfile 391
#define T_Rawstats 392
#define T_Refid 393
#define T_Requestkey 394
#define T_Reset 395
#define T_Restrict 396
#define T_Revoke 397
#define T_Rlimit 398
#define T_Saveconfigdir 399
#define T_Server 400
#define T_Setvar 401
#define T_Source 402
#define T_Stacksize 403
#define T_Statistics 404
#define T_Stats 405
#define T_Statsdir 406
#define T_Step 407
#define T_Stepback 408
#define T_Stepfwd 409
#define T_Stepout 410
#define T_Stratum 411
#define T_String 412
#define T_Sys 413
#define T_Sysstats 414
#define T_Tick 415
#define T_Time1 416
#define T_Time2 417
#define T_Timer 418
#define T_Timingstats 419
#define T_Tinker 420
#define T_Tos 421
#define T_Trap 422
#define T_True 423
#define T_Trustedkey 424
#define T_Ttl 425
#define T_Type 426
#define T_U_int 427
#define T_UEcrypto 428
#define T_UEcryptonak 429
#define T_UEdigest 430
#define T_Unconfig 431
#define T_Unpeer 432
#define T_Version 433
#define T_WanderThreshold 434
#define T_Week 435
#define T_Wildcard 436
#define T_Xleave 437
#define T_Year 438
#define T_Flag 439
#define T_EOC 440
#define T_Simulate 441
#define T_Beep_Delay 442
#define T_Sim_Duration 443
#define T_Server_Offset 444
#define T_Duration 445
#define T_Freq_Offset 446
#define T_Wander 447
#define T_Jitter 448
#define T_Prop_Delay 449
#define T_Proc_Delay 450
#ifdef YYSTYPE
#undef  YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#endif
#ifndef YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
typedef union {
	char *			String;
	double			Double;
	int			Integer;
	unsigned		U_int;
	gen_fifo *		Generic_fifo;
	attr_val *		Attr_val;
	attr_val_fifo *		Attr_val_fifo;
	int_fifo *		Int_fifo;
	string_fifo *		String_fifo;
	address_node *		Address_node;
	address_fifo *		Address_fifo;
	setvar_node *		Set_var;
	server_info *		Sim_server;
	server_info_fifo *	Sim_server_fifo;
	script_info *		Sim_script;
	script_info_fifo *	Sim_script_fifo;
} YYSTYPE;
#endif /* !YYSTYPE_IS_DECLARED */
extern YYSTYPE yylval;
