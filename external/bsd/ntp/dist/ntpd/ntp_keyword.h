/*
 * ntp_keyword.h
 * 
 * NOTE: edit this file with caution, it is generated by keyword-gen.c
 *	 Generated 2016-05-01 17:15:52 UTC	  diff_ignore_line
 *
 */
#include "ntp_scanner.h"
#include "ntp_parser.h"

#define LOWEST_KEYWORD_ID 257

const char * const keyword_text[194] = {
	/* 0       257                  257 */	"abbrev",
	/* 1       258                  258 */	"age",
	/* 2       259                  259 */	"all",
	/* 3       260                  260 */	"allan",
	/* 4       261                  261 */	"allpeers",
	/* 5       262                  262 */	"auth",
	/* 6       263                  263 */	"autokey",
	/* 7       264                  264 */	"automax",
	/* 8       265                  265 */	"average",
	/* 9       266                  266 */	"bclient",
	/* 10      267                  267 */	"beacon",
	/* 11      268                  268 */	"broadcast",
	/* 12      269                  269 */	"broadcastclient",
	/* 13      270                  270 */	"broadcastdelay",
	/* 14      271                  271 */	"burst",
	/* 15      272                  272 */	"calibrate",
	/* 16      273                  273 */	"ceiling",
	/* 17      274                  274 */	"clockstats",
	/* 18      275                  275 */	"cohort",
	/* 19      276                  276 */	"controlkey",
	/* 20      277                  277 */	"crypto",
	/* 21      278                  278 */	"cryptostats",
	/* 22      279                  279 */	"ctl",
	/* 23      280                  280 */	"day",
	/* 24      281                  281 */	"default",
	/* 25      282                  282 */	"digest",
	/* 26      283                  283 */	"disable",
	/* 27      284                  284 */	"discard",
	/* 28      285                  285 */	"dispersion",
	/* 29      286                  286 */	NULL,
	/* 30      287                  287 */	"driftfile",
	/* 31      288                  288 */	"drop",
	/* 32      289                  289 */	"dscp",
	/* 33      290                  290 */	"...",
	/* 34      291                  291 */	"enable",
	/* 35      292                  292 */	"end",
	/* 36      293                  293 */	NULL,
	/* 37      294                  294 */	"file",
	/* 38      295                  295 */	"filegen",
	/* 39      296                  296 */	"filenum",
	/* 40      297                  297 */	"flag1",
	/* 41      298                  298 */	"flag2",
	/* 42      299                  299 */	"flag3",
	/* 43      300                  300 */	"flag4",
	/* 44      301                  301 */	"flake",
	/* 45      302                  302 */	"floor",
	/* 46      303                  303 */	"freq",
	/* 47      304                  304 */	"fudge",
	/* 48      305                  305 */	"host",
	/* 49      306                  306 */	"huffpuff",
	/* 50      307                  307 */	"iburst",
	/* 51      308                  308 */	"ident",
	/* 52      309                  309 */	"ignore",
	/* 53      310                  310 */	"incalloc",
	/* 54      311                  311 */	"incmem",
	/* 55      312                  312 */	"initalloc",
	/* 56      313                  313 */	"initmem",
	/* 57      314                  314 */	"includefile",
	/* 58      315                  315 */	NULL,
	/* 59      316                  316 */	"interface",
	/* 60      317                  317 */	NULL,
	/* 61      318                  318 */	"io",
	/* 62      319                  319 */	"ipv4",
	/* 63      320                  320 */	"-4",
	/* 64      321                  321 */	"ipv6",
	/* 65      322                  322 */	"-6",
	/* 66      323                  323 */	"kernel",
	/* 67      324                  324 */	"key",
	/* 68      325                  325 */	"keys",
	/* 69      326                  326 */	"keysdir",
	/* 70      327                  327 */	"kod",
	/* 71      328                  328 */	"mssntp",
	/* 72      329                  329 */	"leapfile",
	/* 73      330                  330 */	"leapsmearinterval",
	/* 74      331                  331 */	"limited",
	/* 75      332                  332 */	"link",
	/* 76      333                  333 */	"listen",
	/* 77      334                  334 */	"logconfig",
	/* 78      335                  335 */	"logfile",
	/* 79      336                  336 */	"loopstats",
	/* 80      337                  337 */	"lowpriotrap",
	/* 81      338                  338 */	"manycastclient",
	/* 82      339                  339 */	"manycastserver",
	/* 83      340                  340 */	"mask",
	/* 84      341                  341 */	"maxage",
	/* 85      342                  342 */	"maxclock",
	/* 86      343                  343 */	"maxdepth",
	/* 87      344                  344 */	"maxdist",
	/* 88      345                  345 */	"maxmem",
	/* 89      346                  346 */	"maxpoll",
	/* 90      347                  347 */	"mdnstries",
	/* 91      348                  348 */	"mem",
	/* 92      349                  349 */	"memlock",
	/* 93      350                  350 */	"minclock",
	/* 94      351                  351 */	"mindepth",
	/* 95      352                  352 */	"mindist",
	/* 96      353                  353 */	"minimum",
	/* 97      354                  354 */	"minpoll",
	/* 98      355                  355 */	"minsane",
	/* 99      356                  356 */	"mode",
	/* 100     357                  357 */	"mode7",
	/* 101     358                  358 */	"monitor",
	/* 102     359                  359 */	"month",
	/* 103     360                  360 */	"mru",
	/* 104     361                  361 */	"multicastclient",
	/* 105     362                  362 */	"nic",
	/* 106     363                  363 */	"nolink",
	/* 107     364                  364 */	"nomodify",
	/* 108     365                  365 */	"nomrulist",
	/* 109     366                  366 */	"none",
	/* 110     367                  367 */	"nonvolatile",
	/* 111     368                  368 */	"nopeer",
	/* 112     369                  369 */	"noquery",
	/* 113     370                  370 */	"noselect",
	/* 114     371                  371 */	"noserve",
	/* 115     372                  372 */	"notrap",
	/* 116     373                  373 */	"notrust",
	/* 117     374                  374 */	"ntp",
	/* 118     375                  375 */	"ntpport",
	/* 119     376                  376 */	"ntpsigndsocket",
	/* 120     377                  377 */	"orphan",
	/* 121     378                  378 */	"orphanwait",
	/* 122     379                  379 */	"panic",
	/* 123     380                  380 */	"peer",
	/* 124     381                  381 */	"peerstats",
	/* 125     382                  382 */	"phone",
	/* 126     383                  383 */	"pid",
	/* 127     384                  384 */	"pidfile",
	/* 128     385                  385 */	"pool",
	/* 129     386                  386 */	"port",
	/* 130     387                  387 */	"preempt",
	/* 131     388                  388 */	"prefer",
	/* 132     389                  389 */	"protostats",
	/* 133     390                  390 */	"pw",
	/* 134     391                  391 */	"randfile",
	/* 135     392                  392 */	"rawstats",
	/* 136     393                  393 */	"refid",
	/* 137     394                  394 */	"requestkey",
	/* 138     395                  395 */	"reset",
	/* 139     396                  396 */	"restrict",
	/* 140     397                  397 */	"revoke",
	/* 141     398                  398 */	"rlimit",
	/* 142     399                  399 */	"saveconfigdir",
	/* 143     400                  400 */	"server",
	/* 144     401                  401 */	"setvar",
	/* 145     402                  402 */	"source",
	/* 146     403                  403 */	"stacksize",
	/* 147     404                  404 */	"statistics",
	/* 148     405                  405 */	"stats",
	/* 149     406                  406 */	"statsdir",
	/* 150     407                  407 */	"step",
	/* 151     408                  408 */	"stepback",
	/* 152     409                  409 */	"stepfwd",
	/* 153     410                  410 */	"stepout",
	/* 154     411                  411 */	"stratum",
	/* 155     412                  412 */	NULL,
	/* 156     413                  413 */	"sys",
	/* 157     414                  414 */	"sysstats",
	/* 158     415                  415 */	"tick",
	/* 159     416                  416 */	"time1",
	/* 160     417                  417 */	"time2",
	/* 161     418                  418 */	"timer",
	/* 162     419                  419 */	"timingstats",
	/* 163     420                  420 */	"tinker",
	/* 164     421                  421 */	"tos",
	/* 165     422                  422 */	"trap",
	/* 166     423                  423 */	"true",
	/* 167     424                  424 */	"trustedkey",
	/* 168     425                  425 */	"ttl",
	/* 169     426                  426 */	"type",
	/* 170     427                  427 */	NULL,
	/* 171     428                  428 */	"unpeer_crypto_early",
	/* 172     429                  429 */	"unpeer_crypto_nak_early",
	/* 173     430                  430 */	"unpeer_digest_early",
	/* 174     431                  431 */	"unconfig",
	/* 175     432                  432 */	"unpeer",
	/* 176     433                  433 */	"version",
	/* 177     434                  434 */	NULL,
	/* 178     435                  435 */	"week",
	/* 179     436                  436 */	"wildcard",
	/* 180     437                  437 */	"xleave",
	/* 181     438                  438 */	"year",
	/* 182     439                  439 */	NULL,
	/* 183     440                  440 */	NULL,
	/* 184     441                  441 */	"simulate",
	/* 185     442                  442 */	"beep_delay",
	/* 186     443                  443 */	"simulation_duration",
	/* 187     444                  444 */	"server_offset",
	/* 188     445                  445 */	"duration",
	/* 189     446                  446 */	"freq_offset",
	/* 190     447                  447 */	"wander",
	/* 191     448                  448 */	"jitter",
	/* 192     449                  449 */	"prop_delay",
	/* 193     450                  450 */	"proc_delay"
};

#define SCANNER_INIT_S 887

const scan_state sst[890] = {
/*SS_T( ch,	f-by, match, other ),				 */
  0,				      /*     0                   */
  S_ST( '-',	3,      322,     0 ), /*     1                   */
  S_ST( '.',	3,        3,     1 ), /*     2                   */
  S_ST( '.',	3,      290,     0 ), /*     3 .                 */
  S_ST( 'a',	3,       23,     2 ), /*     4                   */
  S_ST( 'b',	3,        6,     0 ), /*     5 a                 */
  S_ST( 'b',	3,        7,     0 ), /*     6 ab                */
  S_ST( 'r',	3,        8,     0 ), /*     7 abb               */
  S_ST( 'e',	3,      257,     0 ), /*     8 abbr              */
  S_ST( 'g',	3,      258,     5 ), /*     9 a                 */
  S_ST( 'l',	3,      259,     9 ), /*    10 a                 */
  S_ST( 'a',	3,      260,     0 ), /*    11 all               */
  S_ST( 'p',	3,       13,    11 ), /*    12 all               */
  S_ST( 'e',	3,       14,     0 ), /*    13 allp              */
  S_ST( 'e',	3,       15,     0 ), /*    14 allpe             */
  S_ST( 'r',	3,      261,     0 ), /*    15 allpee            */
  S_ST( 'u',	3,       17,    10 ), /*    16 a                 */
  S_ST( 't',	3,       18,     0 ), /*    17 au                */
  S_ST( 'o',	3,       21,   262 ), /*    18 aut               */
  S_ST( 'k',	3,       20,     0 ), /*    19 auto              */
  S_ST( 'e',	3,      263,     0 ), /*    20 autok             */
  S_ST( 'm',	3,       22,    19 ), /*    21 auto              */
  S_ST( 'a',	3,      264,     0 ), /*    22 autom             */
  S_ST( 'v',	3,       24,    16 ), /*    23 a                 */
  S_ST( 'e',	3,       25,     0 ), /*    24 av                */
  S_ST( 'r',	3,       26,     0 ), /*    25 ave               */
  S_ST( 'a',	3,       27,     0 ), /*    26 aver              */
  S_ST( 'g',	3,      265,     0 ), /*    27 avera             */
  S_ST( 'b',	3,       61,     4 ), /*    28                   */
  S_ST( 'c',	3,       30,     0 ), /*    29 b                 */
  S_ST( 'l',	3,       31,     0 ), /*    30 bc                */
  S_ST( 'i',	3,       32,     0 ), /*    31 bcl               */
  S_ST( 'e',	3,       33,     0 ), /*    32 bcli              */
  S_ST( 'n',	3,      266,     0 ), /*    33 bclie             */
  S_ST( 'e',	3,       38,    29 ), /*    34 b                 */
  S_ST( 'a',	3,       36,     0 ), /*    35 be                */
  S_ST( 'c',	3,       37,     0 ), /*    36 bea               */
  S_ST( 'o',	3,      267,     0 ), /*    37 beac              */
  S_ST( 'e',	3,       39,    35 ), /*    38 be                */
  S_ST( 'p',	3,       40,     0 ), /*    39 bee               */
  S_ST( '_',	3,       41,     0 ), /*    40 beep              */
  S_ST( 'd',	3,       42,     0 ), /*    41 beep_             */
  S_ST( 'e',	3,       43,     0 ), /*    42 beep_d            */
  S_ST( 'l',	3,       44,     0 ), /*    43 beep_de           */
  S_ST( 'a',	3,      442,     0 ), /*    44 beep_del          */
  S_ST( 'r',	3,       46,    34 ), /*    45 b                 */
  S_ST( 'o',	3,       47,     0 ), /*    46 br                */
  S_ST( 'a',	3,       48,     0 ), /*    47 bro               */
  S_ST( 'd',	3,       49,     0 ), /*    48 broa              */
  S_ST( 'c',	3,       50,     0 ), /*    49 broad             */
  S_ST( 'a',	3,       51,     0 ), /*    50 broadc            */
  S_ST( 's',	3,      268,     0 ), /*    51 broadca           */
  S_ST( 'c',	3,       53,     0 ), /*    52 broadcast         */
  S_ST( 'l',	3,       54,     0 ), /*    53 broadcastc        */
  S_ST( 'i',	3,       55,     0 ), /*    54 broadcastcl       */
  S_ST( 'e',	3,       56,     0 ), /*    55 broadcastcli      */
  S_ST( 'n',	3,      269,     0 ), /*    56 broadcastclie     */
  S_ST( 'd',	3,       58,    52 ), /*    57 broadcast         */
  S_ST( 'e',	3,       59,     0 ), /*    58 broadcastd        */
  S_ST( 'l',	3,       60,     0 ), /*    59 broadcastde       */
  S_ST( 'a',	3,      270,     0 ), /*    60 broadcastdel      */
  S_ST( 'u',	3,       62,    45 ), /*    61 b                 */
  S_ST( 'r',	3,       63,     0 ), /*    62 bu                */
  S_ST( 's',	3,      271,     0 ), /*    63 bur               */
  S_ST( 'c',	3,      104,    28 ), /*    64                   */
  S_ST( 'a',	3,       66,     0 ), /*    65 c                 */
  S_ST( 'l',	3,       67,     0 ), /*    66 ca                */
  S_ST( 'i',	3,       68,     0 ), /*    67 cal               */
  S_ST( 'b',	3,       69,     0 ), /*    68 cali              */
  S_ST( 'r',	3,       70,     0 ), /*    69 calib             */
  S_ST( 'a',	3,       71,     0 ), /*    70 calibr            */
  S_ST( 't',	3,      272,     0 ), /*    71 calibra           */
  S_ST( 'e',	3,       73,    65 ), /*    72 c                 */
  S_ST( 'i',	3,       74,     0 ), /*    73 ce                */
  S_ST( 'l',	3,       75,     0 ), /*    74 cei               */
  S_ST( 'i',	3,       76,     0 ), /*    75 ceil              */
  S_ST( 'n',	3,      273,     0 ), /*    76 ceili             */
  S_ST( 'l',	3,       78,    72 ), /*    77 c                 */
  S_ST( 'o',	3,       79,     0 ), /*    78 cl                */
  S_ST( 'c',	3,       80,     0 ), /*    79 clo               */
  S_ST( 'k',	3,       81,     0 ), /*    80 cloc              */
  S_ST( 's',	3,       82,     0 ), /*    81 clock             */
  S_ST( 't',	3,       83,     0 ), /*    82 clocks            */
  S_ST( 'a',	3,       84,     0 ), /*    83 clockst           */
  S_ST( 't',	3,      274,     0 ), /*    84 clocksta          */
  S_ST( 'o',	3,       89,    77 ), /*    85 c                 */
  S_ST( 'h',	3,       87,     0 ), /*    86 co                */
  S_ST( 'o',	3,       88,     0 ), /*    87 coh               */
  S_ST( 'r',	3,      275,     0 ), /*    88 coho              */
  S_ST( 'n',	3,       90,    86 ), /*    89 co                */
  S_ST( 't',	3,       91,     0 ), /*    90 con               */
  S_ST( 'r',	3,       92,     0 ), /*    91 cont              */
  S_ST( 'o',	3,       93,     0 ), /*    92 contr             */
  S_ST( 'l',	3,       94,     0 ), /*    93 contro            */
  S_ST( 'k',	3,       95,     0 ), /*    94 control           */
  S_ST( 'e',	3,      276,     0 ), /*    95 controlk          */
  S_ST( 'r',	3,       97,    85 ), /*    96 c                 */
  S_ST( 'y',	3,       98,     0 ), /*    97 cr                */
  S_ST( 'p',	3,       99,     0 ), /*    98 cry               */
  S_ST( 't',	3,      277,     0 ), /*    99 cryp              */
  S_ST( 's',	3,      101,     0 ), /*   100 crypto            */
  S_ST( 't',	3,      102,     0 ), /*   101 cryptos           */
  S_ST( 'a',	3,      103,     0 ), /*   102 cryptost          */
  S_ST( 't',	3,      278,     0 ), /*   103 cryptosta         */
  S_ST( 't',	3,      279,    96 ), /*   104 c                 */
  S_ST( 'd',	3,      139,    64 ), /*   105                   */
  S_ST( 'a',	3,      280,     0 ), /*   106 d                 */
  S_ST( 'e',	3,      108,   106 ), /*   107 d                 */
  S_ST( 'f',	3,      109,     0 ), /*   108 de                */
  S_ST( 'a',	3,      110,     0 ), /*   109 def               */
  S_ST( 'u',	3,      111,     0 ), /*   110 defa              */
  S_ST( 'l',	3,      281,     0 ), /*   111 defau             */
  S_ST( 'i',	3,      116,   107 ), /*   112 d                 */
  S_ST( 'g',	3,      114,     0 ), /*   113 di                */
  S_ST( 'e',	3,      115,     0 ), /*   114 dig               */
  S_ST( 's',	3,      282,     0 ), /*   115 dige              */
  S_ST( 's',	3,      123,   113 ), /*   116 di                */
  S_ST( 'a',	3,      118,     0 ), /*   117 dis               */
  S_ST( 'b',	3,      119,     0 ), /*   118 disa              */
  S_ST( 'l',	3,      283,     0 ), /*   119 disab             */
  S_ST( 'c',	3,      121,   117 ), /*   120 dis               */
  S_ST( 'a',	3,      122,     0 ), /*   121 disc              */
  S_ST( 'r',	3,      284,     0 ), /*   122 disca             */
  S_ST( 'p',	3,      124,   120 ), /*   123 dis               */
  S_ST( 'e',	3,      125,     0 ), /*   124 disp              */
  S_ST( 'r',	3,      126,     0 ), /*   125 dispe             */
  S_ST( 's',	3,      127,     0 ), /*   126 disper            */
  S_ST( 'i',	3,      128,     0 ), /*   127 dispers           */
  S_ST( 'o',	3,      285,     0 ), /*   128 dispersi          */
  S_ST( 'r',	3,      136,   112 ), /*   129 d                 */
  S_ST( 'i',	3,      131,     0 ), /*   130 dr                */
  S_ST( 'f',	3,      132,     0 ), /*   131 dri               */
  S_ST( 't',	3,      133,     0 ), /*   132 drif              */
  S_ST( 'f',	3,      134,     0 ), /*   133 drift             */
  S_ST( 'i',	3,      135,     0 ), /*   134 driftf            */
  S_ST( 'l',	3,      287,     0 ), /*   135 driftfi           */
  S_ST( 'o',	3,      288,   130 ), /*   136 dr                */
  S_ST( 's',	3,      138,   129 ), /*   137 d                 */
  S_ST( 'c',	3,      289,     0 ), /*   138 ds                */
  S_ST( 'u',	3,      140,   137 ), /*   139 d                 */
  S_ST( 'r',	3,      141,     0 ), /*   140 du                */
  S_ST( 'a',	3,      142,     0 ), /*   141 dur               */
  S_ST( 't',	3,      143,     0 ), /*   142 dura              */
  S_ST( 'i',	3,      144,     0 ), /*   143 durat             */
  S_ST( 'o',	3,      445,     0 ), /*   144 durati            */
  S_ST( 'e',	3,      146,   105 ), /*   145                   */
  S_ST( 'n',	3,      292,     0 ), /*   146 e                 */
  S_ST( 'a',	3,      148,     0 ), /*   147 en                */
  S_ST( 'b',	3,      149,     0 ), /*   148 ena               */
  S_ST( 'l',	3,      291,     0 ), /*   149 enab              */
  S_ST( 'f',	3,      171,   145 ), /*   150                   */
  S_ST( 'i',	3,      152,     0 ), /*   151 f                 */
  S_ST( 'l',	3,      294,     0 ), /*   152 fi                */
  S_ST( 'g',	3,      154,     0 ), /*   153 file              */
  S_ST( 'e',	3,      295,     0 ), /*   154 fileg             */
  S_ST( 'n',	3,      156,   153 ), /*   155 file              */
  S_ST( 'u',	3,      296,     0 ), /*   156 filen             */
  S_ST( 'l',	3,      161,   151 ), /*   157 f                 */
  S_ST( 'a',	3,      160,     0 ), /*   158 fl                */
  S_ST( 'g',	3,      300,     0 ), /*   159 fla               */
  S_ST( 'k',	3,      301,   159 ), /*   160 fla               */
  S_ST( 'o',	3,      162,   158 ), /*   161 fl                */
  S_ST( 'o',	3,      302,     0 ), /*   162 flo               */
  S_ST( 'r',	3,      164,   157 ), /*   163 f                 */
  S_ST( 'e',	3,      303,     0 ), /*   164 fr                */
  S_ST( '_',	3,      166,     0 ), /*   165 freq              */
  S_ST( 'o',	3,      167,     0 ), /*   166 freq_             */
  S_ST( 'f',	3,      168,     0 ), /*   167 freq_o            */
  S_ST( 'f',	3,      169,     0 ), /*   168 freq_of           */
  S_ST( 's',	3,      170,     0 ), /*   169 freq_off          */
  S_ST( 'e',	3,      446,     0 ), /*   170 freq_offs         */
  S_ST( 'u',	3,      172,   163 ), /*   171 f                 */
  S_ST( 'd',	3,      173,     0 ), /*   172 fu                */
  S_ST( 'g',	3,      304,     0 ), /*   173 fud               */
  S_ST( 'h',	3,      177,   150 ), /*   174                   */
  S_ST( 'o',	3,      176,     0 ), /*   175 h                 */
  S_ST( 's',	3,      305,     0 ), /*   176 ho                */
  S_ST( 'u',	3,      178,   175 ), /*   177 h                 */
  S_ST( 'f',	3,      179,     0 ), /*   178 hu                */
  S_ST( 'f',	3,      180,     0 ), /*   179 huf               */
  S_ST( 'p',	3,      181,     0 ), /*   180 huff              */
  S_ST( 'u',	3,      182,     0 ), /*   181 huffp             */
  S_ST( 'f',	3,      306,     0 ), /*   182 huffpu            */
  S_ST( 'i',	3,      224,   174 ), /*   183                   */
  S_ST( 'b',	3,      185,     0 ), /*   184 i                 */
  S_ST( 'u',	3,      186,     0 ), /*   185 ib                */
  S_ST( 'r',	3,      187,     0 ), /*   186 ibu               */
  S_ST( 's',	3,      307,     0 ), /*   187 ibur              */
  S_ST( 'd',	3,      189,   184 ), /*   188 i                 */
  S_ST( 'e',	3,      190,     0 ), /*   189 id                */
  S_ST( 'n',	3,      308,     0 ), /*   190 ide               */
  S_ST( 'g',	3,      192,   188 ), /*   191 i                 */
  S_ST( 'n',	3,      193,     0 ), /*   192 ig                */
  S_ST( 'o',	3,      194,     0 ), /*   193 ign               */
  S_ST( 'r',	3,      309,     0 ), /*   194 igno              */
  S_ST( 'n',	3,      218,   191 ), /*   195 i                 */
  S_ST( 'c',	3,      208,     0 ), /*   196 in                */
  S_ST( 'a',	3,      198,     0 ), /*   197 inc               */
  S_ST( 'l',	3,      199,     0 ), /*   198 inca              */
  S_ST( 'l',	3,      200,     0 ), /*   199 incal             */
  S_ST( 'o',	3,      310,     0 ), /*   200 incall            */
  S_ST( 'l',	3,      202,   197 ), /*   201 inc               */
  S_ST( 'u',	3,      203,     0 ), /*   202 incl              */
  S_ST( 'd',	3,      204,     0 ), /*   203 inclu             */
  S_ST( 'e',	3,      205,     0 ), /*   204 includ            */
  S_ST( 'f',	3,      206,     0 ), /*   205 include           */
  S_ST( 'i',	3,      207,     0 ), /*   206 includef          */
  S_ST( 'l',	3,      314,     0 ), /*   207 includefi         */
  S_ST( 'm',	3,      209,   201 ), /*   208 inc               */
  S_ST( 'e',	3,      311,     0 ), /*   209 incm              */
  S_ST( 'i',	3,      211,   196 ), /*   210 in                */
  S_ST( 't',	3,      216,     0 ), /*   211 ini               */
  S_ST( 'a',	3,      213,     0 ), /*   212 init              */
  S_ST( 'l',	3,      214,     0 ), /*   213 inita             */
  S_ST( 'l',	3,      215,     0 ), /*   214 inital            */
  S_ST( 'o',	3,      312,     0 ), /*   215 initall           */
  S_ST( 'm',	3,      217,   212 ), /*   216 init              */
  S_ST( 'e',	3,      313,     0 ), /*   217 initm             */
  S_ST( 't',	3,      219,   210 ), /*   218 in                */
  S_ST( 'e',	3,      220,     0 ), /*   219 int               */
  S_ST( 'r',	3,      221,     0 ), /*   220 inte              */
  S_ST( 'f',	3,      222,     0 ), /*   221 inter             */
  S_ST( 'a',	3,      223,     0 ), /*   222 interf            */
  S_ST( 'c',	3,      316,     0 ), /*   223 interfa           */
  S_ST( 'p',	3,      225,   318 ), /*   224 i                 */
  S_ST( 'v',	3,      321,     0 ), /*   225 ip                */
  S_ST( 'j',	3,      227,   183 ), /*   226                   */
  S_ST( 'i',	3,      228,     0 ), /*   227 j                 */
  S_ST( 't',	3,      229,     0 ), /*   228 ji                */
  S_ST( 't',	3,      230,     0 ), /*   229 jit               */
  S_ST( 'e',	3,      448,     0 ), /*   230 jitt              */
  S_ST( 'k',	3,      238,   226 ), /*   231                   */
  S_ST( 'e',	3,      324,     0 ), /*   232 k                 */
  S_ST( 'r',	3,      234,     0 ), /*   233 ke                */
  S_ST( 'n',	3,      235,     0 ), /*   234 ker               */
  S_ST( 'e',	3,      323,     0 ), /*   235 kern              */
  S_ST( 'd',	3,      237,     0 ), /*   236 keys              */
  S_ST( 'i',	3,      326,     0 ), /*   237 keysd             */
  S_ST( 'o',	3,      327,   232 ), /*   238 k                 */
  S_ST( 'l',	3,      452,   231 ), /*   239                   */
  S_ST( 'e',	3,      241,     0 ), /*   240 l                 */
  S_ST( 'a',	3,      242,     0 ), /*   241 le                */
  S_ST( 'p',	3,      246,     0 ), /*   242 lea               */
  S_ST( 'f',	3,      244,     0 ), /*   243 leap              */
  S_ST( 'i',	3,      245,     0 ), /*   244 leapf             */
  S_ST( 'l',	3,      329,     0 ), /*   245 leapfi            */
  S_ST( 's',	3,      247,   243 ), /*   246 leap              */
  S_ST( 'm',	3,      248,     0 ), /*   247 leaps             */
  S_ST( 'e',	3,      249,     0 ), /*   248 leapsm            */
  S_ST( 'a',	3,      250,     0 ), /*   249 leapsme           */
  S_ST( 'r',	3,      251,     0 ), /*   250 leapsmea          */
  S_ST( 'i',	3,      252,     0 ), /*   251 leapsmear         */
  S_ST( 'n',	3,      253,     0 ), /*   252 leapsmeari        */
  S_ST( 't',	3,      254,     0 ), /*   253 leapsmearin       */
  S_ST( 'e',	3,      255,     0 ), /*   254 leapsmearint      */
  S_ST( 'r',	3,      256,     0 ), /*   255 leapsmearinte     */
  S_ST( 'v',	3,      286,     0 ), /*   256 leapsmearinter    */
  S_ST( 'v',	1,        0,     0 ), /*   257 257               */
  S_ST( 'e',	0,        0,     0 ), /*   258 258               */
  S_ST( 'l',	0,       12,     0 ), /*   259 259               */
  S_ST( 'n',	0,        0,     0 ), /*   260 260               */
  S_ST( 's',	0,        0,     0 ), /*   261 261               */
  S_ST( 'h',	0,        0,     0 ), /*   262 262               */
  S_ST( 'y',	0,        0,     0 ), /*   263 263               */
  S_ST( 'x',	0,        0,     0 ), /*   264 264               */
  S_ST( 'e',	0,        0,     0 ), /*   265 265               */
  S_ST( 't',	0,        0,     0 ), /*   266 266               */
  S_ST( 'n',	0,        0,     0 ), /*   267 267               */
  S_ST( 't',	1,       57,     0 ), /*   268 268               */
  S_ST( 't',	0,        0,     0 ), /*   269 269               */
  S_ST( 'y',	0,        0,     0 ), /*   270 270               */
  S_ST( 't',	0,        0,     0 ), /*   271 271               */
  S_ST( 'e',	0,        0,     0 ), /*   272 272               */
  S_ST( 'g',	0,        0,     0 ), /*   273 273               */
  S_ST( 's',	0,        0,     0 ), /*   274 274               */
  S_ST( 't',	0,        0,     0 ), /*   275 275               */
  S_ST( 'y',	0,        0,     0 ), /*   276 276               */
  S_ST( 'o',	0,      100,     0 ), /*   277 277               */
  S_ST( 's',	0,        0,     0 ), /*   278 278               */
  S_ST( 'l',	0,        0,     0 ), /*   279 279               */
  S_ST( 'y',	0,        0,     0 ), /*   280 280               */
  S_ST( 't',	0,        0,     0 ), /*   281 281               */
  S_ST( 't',	1,        0,     0 ), /*   282 282               */
  S_ST( 'e',	0,        0,     0 ), /*   283 283               */
  S_ST( 'd',	0,        0,     0 ), /*   284 284               */
  S_ST( 'n',	0,        0,     0 ), /*   285 285               */
  S_ST( 'a',	3,      330,     0 ), /*   286 leapsmearinterv   */
  S_ST( 'e',	1,        0,     0 ), /*   287 287               */
  S_ST( 'p',	0,        0,     0 ), /*   288 288               */
  S_ST( 'p',	0,        0,     0 ), /*   289 289               */
  S_ST( '.',	0,        0,     0 ), /*   290 290               */
  S_ST( 'e',	0,        0,     0 ), /*   291 291               */
  S_ST( 'd',	0,        0,   147 ), /*   292 292               */
  S_ST( 'i',	3,      439,   240 ), /*   293 l                 */
  S_ST( 'e',	1,      155,     0 ), /*   294 294               */
  S_ST( 'n',	0,        0,     0 ), /*   295 295               */
  S_ST( 'm',	0,        0,     0 ), /*   296 296               */
  S_ST( '1',	0,        0,     0 ), /*   297 297               */
  S_ST( '2',	0,        0,   297 ), /*   298 298               */
  S_ST( '3',	0,        0,   298 ), /*   299 299               */
  S_ST( '4',	0,        0,   299 ), /*   300 300               */
  S_ST( 'e',	0,        0,     0 ), /*   301 301               */
  S_ST( 'r',	0,        0,     0 ), /*   302 302               */
  S_ST( 'q',	0,      165,     0 ), /*   303 303               */
  S_ST( 'e',	1,        0,     0 ), /*   304 304               */
  S_ST( 't',	1,        0,     0 ), /*   305 305               */
  S_ST( 'f',	0,        0,     0 ), /*   306 306               */
  S_ST( 't',	0,        0,     0 ), /*   307 307               */
  S_ST( 't',	1,        0,     0 ), /*   308 308               */
  S_ST( 'e',	0,        0,     0 ), /*   309 309               */
  S_ST( 'c',	0,        0,     0 ), /*   310 310               */
  S_ST( 'm',	0,        0,     0 ), /*   311 311               */
  S_ST( 'c',	0,        0,     0 ), /*   312 312               */
  S_ST( 'm',	0,        0,     0 ), /*   313 313               */
  S_ST( 'e',	1,        0,     0 ), /*   314 314               */
  S_ST( 'm',	3,      317,     0 ), /*   315 li                */
  S_ST( 'e',	0,        0,     0 ), /*   316 316               */
  S_ST( 'i',	3,      412,     0 ), /*   317 lim               */
  S_ST( 'o',	0,        0,   195 ), /*   318 318               */
  S_ST( '4',	0,        0,     0 ), /*   319 319               */
  S_ST( '4',	0,        0,     0 ), /*   320 320               */
  S_ST( '6',	0,        0,   319 ), /*   321 321               */
  S_ST( '6',	0,        0,   320 ), /*   322 322               */
  S_ST( 'l',	0,        0,     0 ), /*   323 323               */
  S_ST( 'y',	0,      325,   233 ), /*   324 324               */
  S_ST( 's',	1,      236,     0 ), /*   325 325               */
  S_ST( 'r',	1,        0,     0 ), /*   326 326               */
  S_ST( 'd',	0,        0,     0 ), /*   327 327               */
  S_ST( 'p',	0,        0,     0 ), /*   328 328               */
  S_ST( 'e',	1,        0,     0 ), /*   329 329               */
  S_ST( 'l',	0,        0,     0 ), /*   330 330               */
  S_ST( 'd',	0,        0,     0 ), /*   331 331               */
  S_ST( 'k',	0,        0,     0 ), /*   332 332               */
  S_ST( 'n',	0,        0,     0 ), /*   333 333               */
  S_ST( 'g',	2,        0,     0 ), /*   334 334               */
  S_ST( 'e',	1,        0,     0 ), /*   335 335               */
  S_ST( 's',	0,        0,     0 ), /*   336 336               */
  S_ST( 'p',	0,        0,     0 ), /*   337 337               */
  S_ST( 't',	1,        0,     0 ), /*   338 338               */
  S_ST( 'r',	2,        0,     0 ), /*   339 339               */
  S_ST( 'k',	0,        0,     0 ), /*   340 340               */
  S_ST( 'e',	0,        0,     0 ), /*   341 341               */
  S_ST( 'k',	0,        0,     0 ), /*   342 342               */
  S_ST( 'h',	0,        0,     0 ), /*   343 343               */
  S_ST( 't',	0,        0,     0 ), /*   344 344               */
  S_ST( 'm',	0,        0,     0 ), /*   345 345               */
  S_ST( 'l',	0,        0,     0 ), /*   346 346               */
  S_ST( 's',	0,        0,     0 ), /*   347 347               */
  S_ST( 'm',	0,      521,     0 ), /*   348 348               */
  S_ST( 'k',	0,        0,     0 ), /*   349 349               */
  S_ST( 'k',	0,        0,     0 ), /*   350 350               */
  S_ST( 'h',	0,        0,     0 ), /*   351 351               */
  S_ST( 't',	0,        0,     0 ), /*   352 352               */
  S_ST( 'm',	0,        0,     0 ), /*   353 353               */
  S_ST( 'l',	0,        0,     0 ), /*   354 354               */
  S_ST( 'e',	0,        0,     0 ), /*   355 355               */
  S_ST( 'e',	0,      357,     0 ), /*   356 356               */
  S_ST( '7',	0,        0,     0 ), /*   357 357               */
  S_ST( 'r',	0,        0,     0 ), /*   358 358               */
  S_ST( 'h',	0,        0,     0 ), /*   359 359               */
  S_ST( 'u',	0,        0,     0 ), /*   360 360               */
  S_ST( 't',	2,        0,     0 ), /*   361 361               */
  S_ST( 'c',	0,        0,     0 ), /*   362 362               */
  S_ST( 'k',	0,        0,     0 ), /*   363 363               */
  S_ST( 'y',	0,        0,     0 ), /*   364 364               */
  S_ST( 't',	0,        0,     0 ), /*   365 365               */
  S_ST( 'e',	0,        0,     0 ), /*   366 366               */
  S_ST( 'e',	0,        0,     0 ), /*   367 367               */
  S_ST( 'r',	0,        0,     0 ), /*   368 368               */
  S_ST( 'y',	0,        0,     0 ), /*   369 369               */
  S_ST( 't',	0,        0,     0 ), /*   370 370               */
  S_ST( 'e',	0,        0,     0 ), /*   371 371               */
  S_ST( 'p',	0,        0,     0 ), /*   372 372               */
  S_ST( 't',	0,        0,     0 ), /*   373 373               */
  S_ST( 'p',	0,      617,     0 ), /*   374 374               */
  S_ST( 't',	0,        0,     0 ), /*   375 375               */
  S_ST( 't',	1,        0,     0 ), /*   376 376               */
  S_ST( 'n',	0,      632,     0 ), /*   377 377               */
  S_ST( 't',	0,        0,     0 ), /*   378 378               */
  S_ST( 'c',	0,        0,     0 ), /*   379 379               */
  S_ST( 'r',	1,      641,     0 ), /*   380 380               */
  S_ST( 's',	0,        0,     0 ), /*   381 381               */
  S_ST( 'e',	2,        0,     0 ), /*   382 382               */
  S_ST( 'd',	0,      649,     0 ), /*   383 383               */
  S_ST( 'e',	1,        0,     0 ), /*   384 384               */
  S_ST( 'l',	1,        0,     0 ), /*   385 385               */
  S_ST( 't',	0,        0,     0 ), /*   386 386               */
  S_ST( 't',	0,        0,     0 ), /*   387 387               */
  S_ST( 'r',	0,        0,     0 ), /*   388 388               */
  S_ST( 's',	0,        0,     0 ), /*   389 389               */
  S_ST( 'w',	1,        0,   655 ), /*   390 390               */
  S_ST( 'e',	1,        0,     0 ), /*   391 391               */
  S_ST( 's',	0,        0,     0 ), /*   392 392               */
  S_ST( 'd',	1,        0,     0 ), /*   393 393               */
  S_ST( 'y',	0,        0,     0 ), /*   394 394               */
  S_ST( 't',	0,        0,     0 ), /*   395 395               */
  S_ST( 't',	0,        0,     0 ), /*   396 396               */
  S_ST( 'e',	0,        0,     0 ), /*   397 397               */
  S_ST( 't',	0,        0,     0 ), /*   398 398               */
  S_ST( 'r',	1,        0,     0 ), /*   399 399               */
  S_ST( 'r',	1,      732,     0 ), /*   400 400               */
  S_ST( 'r',	1,        0,     0 ), /*   401 401               */
  S_ST( 'e',	0,        0,     0 ), /*   402 402               */
  S_ST( 'e',	0,        0,     0 ), /*   403 403               */
  S_ST( 's',	0,        0,     0 ), /*   404 404               */
  S_ST( 's',	0,      775,   770 ), /*   405 405               */
  S_ST( 'r',	1,        0,     0 ), /*   406 406               */
  S_ST( 'p',	0,      783,     0 ), /*   407 407               */
  S_ST( 'k',	0,        0,     0 ), /*   408 408               */
  S_ST( 'd',	0,        0,     0 ), /*   409 409               */
  S_ST( 't',	0,        0,     0 ), /*   410 410               */
  S_ST( 'm',	0,        0,     0 ), /*   411 411               */
  S_ST( 't',	3,      427,     0 ), /*   412 limi              */
  S_ST( 's',	0,      790,     0 ), /*   413 413               */
  S_ST( 's',	0,        0,     0 ), /*   414 414               */
  S_ST( 'k',	0,        0,     0 ), /*   415 415               */
  S_ST( '1',	0,        0,     0 ), /*   416 416               */
  S_ST( '2',	0,        0,   416 ), /*   417 417               */
  S_ST( 'r',	0,        0,   417 ), /*   418 418               */
  S_ST( 's',	0,        0,     0 ), /*   419 419               */
  S_ST( 'r',	0,        0,     0 ), /*   420 420               */
  S_ST( 's',	0,        0,     0 ), /*   421 421               */
  S_ST( 'p',	1,        0,     0 ), /*   422 422               */
  S_ST( 'e',	0,        0,     0 ), /*   423 423               */
  S_ST( 'y',	0,        0,     0 ), /*   424 424               */
  S_ST( 'l',	0,        0,     0 ), /*   425 425               */
  S_ST( 'e',	0,        0,     0 ), /*   426 426               */
  S_ST( 'e',	3,      331,     0 ), /*   427 limit             */
  S_ST( 'y',	0,        0,     0 ), /*   428 428               */
  S_ST( 'y',	0,        0,     0 ), /*   429 429               */
  S_ST( 'y',	0,        0,     0 ), /*   430 430               */
  S_ST( 'g',	1,        0,     0 ), /*   431 431               */
  S_ST( 'r',	1,      832,     0 ), /*   432 432               */
  S_ST( 'n',	0,        0,     0 ), /*   433 433               */
  S_ST( 'n',	3,      332,   315 ), /*   434 li                */
  S_ST( 'k',	0,        0,     0 ), /*   435 435               */
  S_ST( 'd',	0,        0,     0 ), /*   436 436               */
  S_ST( 'e',	0,        0,     0 ), /*   437 437               */
  S_ST( 'r',	0,        0,     0 ), /*   438 438               */
  S_ST( 's',	3,      440,   434 ), /*   439 li                */
  S_ST( 't',	3,      451,     0 ), /*   440 lis               */
  S_ST( 'e',	0,        0,     0 ), /*   441 441               */
  S_ST( 'y',	0,        0,     0 ), /*   442 442               */
  S_ST( 'n',	0,        0,     0 ), /*   443 443               */
  S_ST( 't',	0,        0,     0 ), /*   444 444               */
  S_ST( 'n',	0,        0,     0 ), /*   445 445               */
  S_ST( 't',	0,        0,     0 ), /*   446 446               */
  S_ST( 'r',	0,        0,     0 ), /*   447 447               */
  S_ST( 'r',	0,        0,     0 ), /*   448 448               */
  S_ST( 'y',	0,        0,     0 ), /*   449 449               */
  S_ST( 'y',	0,        0,     0 ), /*   450 450               */
  S_ST( 'e',	3,      333,     0 ), /*   451 list              */
  S_ST( 'o',	3,      468,   293 ), /*   452 l                 */
  S_ST( 'g',	3,      459,     0 ), /*   453 lo                */
  S_ST( 'c',	3,      455,     0 ), /*   454 log               */
  S_ST( 'o',	3,      456,     0 ), /*   455 logc              */
  S_ST( 'n',	3,      457,     0 ), /*   456 logco             */
  S_ST( 'f',	3,      458,     0 ), /*   457 logcon            */
  S_ST( 'i',	3,      334,     0 ), /*   458 logconf           */
  S_ST( 'f',	3,      460,   454 ), /*   459 log               */
  S_ST( 'i',	3,      461,     0 ), /*   460 logf              */
  S_ST( 'l',	3,      335,     0 ), /*   461 logfi             */
  S_ST( 'o',	3,      463,   453 ), /*   462 lo                */
  S_ST( 'p',	3,      464,     0 ), /*   463 loo               */
  S_ST( 's',	3,      465,     0 ), /*   464 loop              */
  S_ST( 't',	3,      466,     0 ), /*   465 loops             */
  S_ST( 'a',	3,      467,     0 ), /*   466 loopst            */
  S_ST( 't',	3,      336,     0 ), /*   467 loopsta           */
  S_ST( 'w',	3,      469,   462 ), /*   468 lo                */
  S_ST( 'p',	3,      470,     0 ), /*   469 low               */
  S_ST( 'r',	3,      471,     0 ), /*   470 lowp              */
  S_ST( 'i',	3,      472,     0 ), /*   471 lowpr             */
  S_ST( 'o',	3,      473,     0 ), /*   472 lowpri            */
  S_ST( 't',	3,      474,     0 ), /*   473 lowprio           */
  S_ST( 'r',	3,      475,     0 ), /*   474 lowpriot          */
  S_ST( 'a',	3,      337,     0 ), /*   475 lowpriotr         */
  S_ST( 'm',	3,      557,   239 ), /*   476                   */
  S_ST( 'a',	3,      495,     0 ), /*   477 m                 */
  S_ST( 'n',	3,      479,     0 ), /*   478 ma                */
  S_ST( 'y',	3,      480,     0 ), /*   479 man               */
  S_ST( 'c',	3,      481,     0 ), /*   480 many              */
  S_ST( 'a',	3,      482,     0 ), /*   481 manyc             */
  S_ST( 's',	3,      483,     0 ), /*   482 manyca            */
  S_ST( 't',	3,      489,     0 ), /*   483 manycas           */
  S_ST( 'c',	3,      485,     0 ), /*   484 manycast          */
  S_ST( 'l',	3,      486,     0 ), /*   485 manycastc         */
  S_ST( 'i',	3,      487,     0 ), /*   486 manycastcl        */
  S_ST( 'e',	3,      488,     0 ), /*   487 manycastcli       */
  S_ST( 'n',	3,      338,     0 ), /*   488 manycastclie      */
  S_ST( 's',	3,      490,   484 ), /*   489 manycast          */
  S_ST( 'e',	3,      491,     0 ), /*   490 manycasts         */
  S_ST( 'r',	3,      492,     0 ), /*   491 manycastse        */
  S_ST( 'v',	3,      493,     0 ), /*   492 manycastser       */
  S_ST( 'e',	3,      339,     0 ), /*   493 manycastserv      */
  S_ST( 's',	3,      340,   478 ), /*   494 ma                */
  S_ST( 'x',	3,      510,   494 ), /*   495 ma                */
  S_ST( 'a',	3,      497,     0 ), /*   496 max               */
  S_ST( 'g',	3,      341,     0 ), /*   497 maxa              */
  S_ST( 'c',	3,      499,   496 ), /*   498 max               */
  S_ST( 'l',	3,      500,     0 ), /*   499 maxc              */
  S_ST( 'o',	3,      501,     0 ), /*   500 maxcl             */
  S_ST( 'c',	3,      342,     0 ), /*   501 maxclo            */
  S_ST( 'd',	3,      506,   498 ), /*   502 max               */
  S_ST( 'e',	3,      504,     0 ), /*   503 maxd              */
  S_ST( 'p',	3,      505,     0 ), /*   504 maxde             */
  S_ST( 't',	3,      343,     0 ), /*   505 maxdep            */
  S_ST( 'i',	3,      507,   503 ), /*   506 maxd              */
  S_ST( 's',	3,      344,     0 ), /*   507 maxdi             */
  S_ST( 'm',	3,      509,   502 ), /*   508 max               */
  S_ST( 'e',	3,      345,     0 ), /*   509 maxm              */
  S_ST( 'p',	3,      511,   508 ), /*   510 max               */
  S_ST( 'o',	3,      512,     0 ), /*   511 maxp              */
  S_ST( 'l',	3,      346,     0 ), /*   512 maxpo             */
  S_ST( 'd',	3,      514,   477 ), /*   513 m                 */
  S_ST( 'n',	3,      515,     0 ), /*   514 md                */
  S_ST( 's',	3,      516,     0 ), /*   515 mdn               */
  S_ST( 't',	3,      517,     0 ), /*   516 mdns              */
  S_ST( 'r',	3,      518,     0 ), /*   517 mdnst             */
  S_ST( 'i',	3,      519,     0 ), /*   518 mdnstr            */
  S_ST( 'e',	3,      347,     0 ), /*   519 mdnstri           */
  S_ST( 'e',	3,      348,   513 ), /*   520 m                 */
  S_ST( 'l',	3,      522,     0 ), /*   521 mem               */
  S_ST( 'o',	3,      523,     0 ), /*   522 meml              */
  S_ST( 'c',	3,      349,     0 ), /*   523 memlo             */
  S_ST( 'i',	3,      525,   520 ), /*   524 m                 */
  S_ST( 'n',	3,      542,     0 ), /*   525 mi                */
  S_ST( 'c',	3,      527,     0 ), /*   526 min               */
  S_ST( 'l',	3,      528,     0 ), /*   527 minc              */
  S_ST( 'o',	3,      529,     0 ), /*   528 mincl             */
  S_ST( 'c',	3,      350,     0 ), /*   529 minclo            */
  S_ST( 'd',	3,      534,   526 ), /*   530 min               */
  S_ST( 'e',	3,      532,     0 ), /*   531 mind              */
  S_ST( 'p',	3,      533,     0 ), /*   532 minde             */
  S_ST( 't',	3,      351,     0 ), /*   533 mindep            */
  S_ST( 'i',	3,      535,   531 ), /*   534 mind              */
  S_ST( 's',	3,      352,     0 ), /*   535 mindi             */
  S_ST( 'i',	3,      537,   530 ), /*   536 min               */
  S_ST( 'm',	3,      538,     0 ), /*   537 mini              */
  S_ST( 'u',	3,      353,     0 ), /*   538 minim             */
  S_ST( 'p',	3,      540,   536 ), /*   539 min               */
  S_ST( 'o',	3,      541,     0 ), /*   540 minp              */
  S_ST( 'l',	3,      354,     0 ), /*   541 minpo             */
  S_ST( 's',	3,      543,   539 ), /*   542 min               */
  S_ST( 'a',	3,      544,     0 ), /*   543 mins              */
  S_ST( 'n',	3,      355,     0 ), /*   544 minsa             */
  S_ST( 'o',	3,      547,   524 ), /*   545 m                 */
  S_ST( 'd',	3,      356,     0 ), /*   546 mo                */
  S_ST( 'n',	3,      551,   546 ), /*   547 mo                */
  S_ST( 'i',	3,      549,     0 ), /*   548 mon               */
  S_ST( 't',	3,      550,     0 ), /*   549 moni              */
  S_ST( 'o',	3,      358,     0 ), /*   550 monit             */
  S_ST( 't',	3,      359,   548 ), /*   551 mon               */
  S_ST( 'r',	3,      360,   545 ), /*   552 m                 */
  S_ST( 's',	3,      554,   552 ), /*   553 m                 */
  S_ST( 's',	3,      555,     0 ), /*   554 ms                */
  S_ST( 'n',	3,      556,     0 ), /*   555 mss               */
  S_ST( 't',	3,      328,     0 ), /*   556 mssn              */
  S_ST( 'u',	3,      558,   553 ), /*   557 m                 */
  S_ST( 'l',	3,      559,     0 ), /*   558 mu                */
  S_ST( 't',	3,      560,     0 ), /*   559 mul               */
  S_ST( 'i',	3,      561,     0 ), /*   560 mult              */
  S_ST( 'c',	3,      562,     0 ), /*   561 multi             */
  S_ST( 'a',	3,      563,     0 ), /*   562 multic            */
  S_ST( 's',	3,      564,     0 ), /*   563 multica           */
  S_ST( 't',	3,      565,     0 ), /*   564 multicas          */
  S_ST( 'c',	3,      566,     0 ), /*   565 multicast         */
  S_ST( 'l',	3,      567,     0 ), /*   566 multicastc        */
  S_ST( 'i',	3,      568,     0 ), /*   567 multicastcl       */
  S_ST( 'e',	3,      569,     0 ), /*   568 multicastcli      */
  S_ST( 'n',	3,      361,     0 ), /*   569 multicastclie     */
  S_ST( 'n',	3,      613,   476 ), /*   570                   */
  S_ST( 'i',	3,      362,     0 ), /*   571 n                 */
  S_ST( 'o',	3,      608,   571 ), /*   572 n                 */
  S_ST( 'l',	3,      574,     0 ), /*   573 no                */
  S_ST( 'i',	3,      575,     0 ), /*   574 nol               */
  S_ST( 'n',	3,      363,     0 ), /*   575 noli              */
  S_ST( 'm',	3,      581,   573 ), /*   576 no                */
  S_ST( 'o',	3,      578,     0 ), /*   577 nom               */
  S_ST( 'd',	3,      579,     0 ), /*   578 nomo              */
  S_ST( 'i',	3,      580,     0 ), /*   579 nomod             */
  S_ST( 'f',	3,      364,     0 ), /*   580 nomodi            */
  S_ST( 'r',	3,      582,   577 ), /*   581 nom               */
  S_ST( 'u',	3,      583,     0 ), /*   582 nomr              */
  S_ST( 'l',	3,      584,     0 ), /*   583 nomru             */
  S_ST( 'i',	3,      585,     0 ), /*   584 nomrul            */
  S_ST( 's',	3,      365,     0 ), /*   585 nomruli           */
  S_ST( 'n',	3,      587,   576 ), /*   586 no                */
  S_ST( 'v',	3,      588,   366 ), /*   587 non               */
  S_ST( 'o',	3,      589,     0 ), /*   588 nonv              */
  S_ST( 'l',	3,      590,     0 ), /*   589 nonvo             */
  S_ST( 'a',	3,      591,     0 ), /*   590 nonvol            */
  S_ST( 't',	3,      592,     0 ), /*   591 nonvola           */
  S_ST( 'i',	3,      593,     0 ), /*   592 nonvolat          */
  S_ST( 'l',	3,      367,     0 ), /*   593 nonvolati         */
  S_ST( 'p',	3,      595,   586 ), /*   594 no                */
  S_ST( 'e',	3,      596,     0 ), /*   595 nop               */
  S_ST( 'e',	3,      368,     0 ), /*   596 nope              */
  S_ST( 'q',	3,      598,   594 ), /*   597 no                */
  S_ST( 'u',	3,      599,     0 ), /*   598 noq               */
  S_ST( 'e',	3,      600,     0 ), /*   599 noqu              */
  S_ST( 'r',	3,      369,     0 ), /*   600 noque             */
  S_ST( 's',	3,      602,   597 ), /*   601 no                */
  S_ST( 'e',	3,      606,     0 ), /*   602 nos               */
  S_ST( 'l',	3,      604,     0 ), /*   603 nose              */
  S_ST( 'e',	3,      605,     0 ), /*   604 nosel             */
  S_ST( 'c',	3,      370,     0 ), /*   605 nosele            */
  S_ST( 'r',	3,      607,   603 ), /*   606 nose              */
  S_ST( 'v',	3,      371,     0 ), /*   607 noser             */
  S_ST( 't',	3,      609,   601 ), /*   608 no                */
  S_ST( 'r',	3,      611,     0 ), /*   609 not               */
  S_ST( 'a',	3,      372,     0 ), /*   610 notr              */
  S_ST( 'u',	3,      612,   610 ), /*   611 notr              */
  S_ST( 's',	3,      373,     0 ), /*   612 notru             */
  S_ST( 't',	3,      374,   572 ), /*   613 n                 */
  S_ST( 'p',	3,      615,     0 ), /*   614 ntp               */
  S_ST( 'o',	3,      616,     0 ), /*   615 ntpp              */
  S_ST( 'r',	3,      375,     0 ), /*   616 ntppo             */
  S_ST( 's',	3,      618,   614 ), /*   617 ntp               */
  S_ST( 'i',	3,      619,     0 ), /*   618 ntps              */
  S_ST( 'g',	3,      620,     0 ), /*   619 ntpsi             */
  S_ST( 'n',	3,      621,     0 ), /*   620 ntpsig            */
  S_ST( 'd',	3,      622,     0 ), /*   621 ntpsign           */
  S_ST( 's',	3,      623,     0 ), /*   622 ntpsignd          */
  S_ST( 'o',	3,      624,     0 ), /*   623 ntpsignds         */
  S_ST( 'c',	3,      625,     0 ), /*   624 ntpsigndso        */
  S_ST( 'k',	3,      626,     0 ), /*   625 ntpsigndsoc       */
  S_ST( 'e',	3,      376,     0 ), /*   626 ntpsigndsock      */
  S_ST( 'o',	3,      628,   570 ), /*   627                   */
  S_ST( 'r',	3,      629,     0 ), /*   628 o                 */
  S_ST( 'p',	3,      630,     0 ), /*   629 or                */
  S_ST( 'h',	3,      631,     0 ), /*   630 orp               */
  S_ST( 'a',	3,      377,     0 ), /*   631 orph              */
  S_ST( 'w',	3,      633,     0 ), /*   632 orphan            */
  S_ST( 'a',	3,      634,     0 ), /*   633 orphanw           */
  S_ST( 'i',	3,      378,     0 ), /*   634 orphanwa          */
  S_ST( 'p',	3,      390,   627 ), /*   635                   */
  S_ST( 'a',	3,      637,     0 ), /*   636 p                 */
  S_ST( 'n',	3,      638,     0 ), /*   637 pa                */
  S_ST( 'i',	3,      379,     0 ), /*   638 pan               */
  S_ST( 'e',	3,      640,   636 ), /*   639 p                 */
  S_ST( 'e',	3,      380,     0 ), /*   640 pe                */
  S_ST( 's',	3,      642,     0 ), /*   641 peer              */
  S_ST( 't',	3,      643,     0 ), /*   642 peers             */
  S_ST( 'a',	3,      644,     0 ), /*   643 peerst            */
  S_ST( 't',	3,      381,     0 ), /*   644 peersta           */
  S_ST( 'h',	3,      646,   639 ), /*   645 p                 */
  S_ST( 'o',	3,      647,     0 ), /*   646 ph                */
  S_ST( 'n',	3,      382,     0 ), /*   647 pho               */
  S_ST( 'i',	3,      383,   645 ), /*   648 p                 */
  S_ST( 'f',	3,      650,     0 ), /*   649 pid               */
  S_ST( 'i',	3,      651,     0 ), /*   650 pidf              */
  S_ST( 'l',	3,      384,     0 ), /*   651 pidfi             */
  S_ST( 'o',	3,      654,   648 ), /*   652 p                 */
  S_ST( 'o',	3,      385,     0 ), /*   653 po                */
  S_ST( 'r',	3,      386,   653 ), /*   654 po                */
  S_ST( 'r',	3,      662,   652 ), /*   655 p                 */
  S_ST( 'e',	3,      660,     0 ), /*   656 pr                */
  S_ST( 'e',	3,      658,     0 ), /*   657 pre               */
  S_ST( 'm',	3,      659,     0 ), /*   658 pree              */
  S_ST( 'p',	3,      387,     0 ), /*   659 preem             */
  S_ST( 'f',	3,      661,   657 ), /*   660 pre               */
  S_ST( 'e',	3,      388,     0 ), /*   661 pref              */
  S_ST( 'o',	3,      675,   656 ), /*   662 pr                */
  S_ST( 'c',	3,      664,     0 ), /*   663 pro               */
  S_ST( '_',	3,      665,     0 ), /*   664 proc              */
  S_ST( 'd',	3,      666,     0 ), /*   665 proc_             */
  S_ST( 'e',	3,      667,     0 ), /*   666 proc_d            */
  S_ST( 'l',	3,      668,     0 ), /*   667 proc_de           */
  S_ST( 'a',	3,      450,     0 ), /*   668 proc_del          */
  S_ST( 'p',	3,      670,   663 ), /*   669 pro               */
  S_ST( '_',	3,      671,     0 ), /*   670 prop              */
  S_ST( 'd',	3,      672,     0 ), /*   671 prop_             */
  S_ST( 'e',	3,      673,     0 ), /*   672 prop_d            */
  S_ST( 'l',	3,      674,     0 ), /*   673 prop_de           */
  S_ST( 'a',	3,      449,     0 ), /*   674 prop_del          */
  S_ST( 't',	3,      676,   669 ), /*   675 pro               */
  S_ST( 'o',	3,      677,     0 ), /*   676 prot              */
  S_ST( 's',	3,      678,     0 ), /*   677 proto             */
  S_ST( 't',	3,      679,     0 ), /*   678 protos            */
  S_ST( 'a',	3,      680,     0 ), /*   679 protost           */
  S_ST( 't',	3,      389,     0 ), /*   680 protosta          */
  S_ST( 'r',	3,      712,   635 ), /*   681                   */
  S_ST( 'a',	3,      688,     0 ), /*   682 r                 */
  S_ST( 'n',	3,      684,     0 ), /*   683 ra                */
  S_ST( 'd',	3,      685,     0 ), /*   684 ran               */
  S_ST( 'f',	3,      686,     0 ), /*   685 rand              */
  S_ST( 'i',	3,      687,     0 ), /*   686 randf             */
  S_ST( 'l',	3,      391,     0 ), /*   687 randfi            */
  S_ST( 'w',	3,      689,   683 ), /*   688 ra                */
  S_ST( 's',	3,      690,     0 ), /*   689 raw               */
  S_ST( 't',	3,      691,     0 ), /*   690 raws              */
  S_ST( 'a',	3,      692,     0 ), /*   691 rawst             */
  S_ST( 't',	3,      392,     0 ), /*   692 rawsta            */
  S_ST( 'e',	3,      709,   682 ), /*   693 r                 */
  S_ST( 'f',	3,      695,     0 ), /*   694 re                */
  S_ST( 'i',	3,      393,     0 ), /*   695 ref               */
  S_ST( 'q',	3,      697,   694 ), /*   696 re                */
  S_ST( 'u',	3,      698,     0 ), /*   697 req               */
  S_ST( 'e',	3,      699,     0 ), /*   698 requ              */
  S_ST( 's',	3,      700,     0 ), /*   699 reque             */
  S_ST( 't',	3,      701,     0 ), /*   700 reques            */
  S_ST( 'k',	3,      702,     0 ), /*   701 request           */
  S_ST( 'e',	3,      394,     0 ), /*   702 requestk          */
  S_ST( 's',	3,      705,   696 ), /*   703 re                */
  S_ST( 'e',	3,      395,     0 ), /*   704 res               */
  S_ST( 't',	3,      706,   704 ), /*   705 res               */
  S_ST( 'r',	3,      707,     0 ), /*   706 rest              */
  S_ST( 'i',	3,      708,     0 ), /*   707 restr             */
  S_ST( 'c',	3,      396,     0 ), /*   708 restri            */
  S_ST( 'v',	3,      710,   703 ), /*   709 re                */
  S_ST( 'o',	3,      711,     0 ), /*   710 rev               */
  S_ST( 'k',	3,      397,     0 ), /*   711 revo              */
  S_ST( 'l',	3,      713,   693 ), /*   712 r                 */
  S_ST( 'i',	3,      714,     0 ), /*   713 rl                */
  S_ST( 'm',	3,      715,     0 ), /*   714 rli               */
  S_ST( 'i',	3,      398,     0 ), /*   715 rlim              */
  S_ST( 's',	3,      789,   681 ), /*   716                   */
  S_ST( 'a',	3,      718,     0 ), /*   717 s                 */
  S_ST( 'v',	3,      719,     0 ), /*   718 sa                */
  S_ST( 'e',	3,      720,     0 ), /*   719 sav               */
  S_ST( 'c',	3,      721,     0 ), /*   720 save              */
  S_ST( 'o',	3,      722,     0 ), /*   721 savec             */
  S_ST( 'n',	3,      723,     0 ), /*   722 saveco            */
  S_ST( 'f',	3,      724,     0 ), /*   723 savecon           */
  S_ST( 'i',	3,      725,     0 ), /*   724 saveconf          */
  S_ST( 'g',	3,      726,     0 ), /*   725 saveconfi         */
  S_ST( 'd',	3,      727,     0 ), /*   726 saveconfig        */
  S_ST( 'i',	3,      399,     0 ), /*   727 saveconfigd       */
  S_ST( 'e',	3,      738,   717 ), /*   728 s                 */
  S_ST( 'r',	3,      730,     0 ), /*   729 se                */
  S_ST( 'v',	3,      731,     0 ), /*   730 ser               */
  S_ST( 'e',	3,      400,     0 ), /*   731 serv              */
  S_ST( '_',	3,      733,     0 ), /*   732 server            */
  S_ST( 'o',	3,      734,     0 ), /*   733 server_           */
  S_ST( 'f',	3,      735,     0 ), /*   734 server_o          */
  S_ST( 'f',	3,      736,     0 ), /*   735 server_of         */
  S_ST( 's',	3,      737,     0 ), /*   736 server_off        */
  S_ST( 'e',	3,      444,     0 ), /*   737 server_offs       */
  S_ST( 't',	3,      739,   729 ), /*   738 se                */
  S_ST( 'v',	3,      740,     0 ), /*   739 set               */
  S_ST( 'a',	3,      401,     0 ), /*   740 setv              */
  S_ST( 'i',	3,      742,   728 ), /*   741 s                 */
  S_ST( 'm',	3,      743,     0 ), /*   742 si                */
  S_ST( 'u',	3,      744,     0 ), /*   743 sim               */
  S_ST( 'l',	3,      745,     0 ), /*   744 simu              */
  S_ST( 'a',	3,      746,     0 ), /*   745 simul             */
  S_ST( 't',	3,      747,     0 ), /*   746 simula            */
  S_ST( 'i',	3,      748,   441 ), /*   747 simulat           */
  S_ST( 'o',	3,      749,     0 ), /*   748 simulati          */
  S_ST( 'n',	3,      750,     0 ), /*   749 simulatio         */
  S_ST( '_',	3,      751,     0 ), /*   750 simulation        */
  S_ST( 'd',	3,      752,     0 ), /*   751 simulation_       */
  S_ST( 'u',	3,      753,     0 ), /*   752 simulation_d      */
  S_ST( 'r',	3,      754,     0 ), /*   753 simulation_du     */
  S_ST( 'a',	3,      755,     0 ), /*   754 simulation_dur    */
  S_ST( 't',	3,      756,     0 ), /*   755 simulation_dura   */
  S_ST( 'i',	3,      757,     0 ), /*   756 simulation_durat  */
  S_ST( 'o',	3,      443,     0 ), /*   757 simulation_durati */
  S_ST( 'o',	3,      759,   741 ), /*   758 s                 */
  S_ST( 'u',	3,      760,     0 ), /*   759 so                */
  S_ST( 'r',	3,      761,     0 ), /*   760 sou               */
  S_ST( 'c',	3,      402,     0 ), /*   761 sour              */
  S_ST( 't',	3,      785,   758 ), /*   762 s                 */
  S_ST( 'a',	3,      769,     0 ), /*   763 st                */
  S_ST( 'c',	3,      765,     0 ), /*   764 sta               */
  S_ST( 'k',	3,      766,     0 ), /*   765 stac              */
  S_ST( 's',	3,      767,     0 ), /*   766 stack             */
  S_ST( 'i',	3,      768,     0 ), /*   767 stacks            */
  S_ST( 'z',	3,      403,     0 ), /*   768 stacksi           */
  S_ST( 't',	3,      405,   764 ), /*   769 sta               */
  S_ST( 'i',	3,      771,     0 ), /*   770 stat              */
  S_ST( 's',	3,      772,     0 ), /*   771 stati             */
  S_ST( 't',	3,      773,     0 ), /*   772 statis            */
  S_ST( 'i',	3,      774,     0 ), /*   773 statist           */
  S_ST( 'c',	3,      404,     0 ), /*   774 statisti          */
  S_ST( 'd',	3,      776,     0 ), /*   775 stats             */
  S_ST( 'i',	3,      406,     0 ), /*   776 statsd            */
  S_ST( 'e',	3,      407,   763 ), /*   777 st                */
  S_ST( 'b',	3,      779,     0 ), /*   778 step              */
  S_ST( 'a',	3,      780,     0 ), /*   779 stepb             */
  S_ST( 'c',	3,      408,     0 ), /*   780 stepba            */
  S_ST( 'f',	3,      782,   778 ), /*   781 step              */
  S_ST( 'w',	3,      409,     0 ), /*   782 stepf             */
  S_ST( 'o',	3,      784,   781 ), /*   783 step              */
  S_ST( 'u',	3,      410,     0 ), /*   784 stepo             */
  S_ST( 'r',	3,      786,   777 ), /*   785 st                */
  S_ST( 'a',	3,      787,     0 ), /*   786 str               */
  S_ST( 't',	3,      788,     0 ), /*   787 stra              */
  S_ST( 'u',	3,      411,     0 ), /*   788 strat             */
  S_ST( 'y',	3,      413,   762 ), /*   789 s                 */
  S_ST( 's',	3,      791,     0 ), /*   790 sys               */
  S_ST( 't',	3,      792,     0 ), /*   791 syss              */
  S_ST( 'a',	3,      793,     0 ), /*   792 sysst             */
  S_ST( 't',	3,      414,     0 ), /*   793 syssta            */
  S_ST( 't',	3,      820,   716 ), /*   794                   */
  S_ST( 'i',	3,      806,     0 ), /*   795 t                 */
  S_ST( 'c',	3,      415,     0 ), /*   796 ti                */
  S_ST( 'm',	3,      799,   796 ), /*   797 ti                */
  S_ST( 'e',	3,      418,     0 ), /*   798 tim               */
  S_ST( 'i',	3,      800,   798 ), /*   799 tim               */
  S_ST( 'n',	3,      801,     0 ), /*   800 timi              */
  S_ST( 'g',	3,      802,     0 ), /*   801 timin             */
  S_ST( 's',	3,      803,     0 ), /*   802 timing            */
  S_ST( 't',	3,      804,     0 ), /*   803 timings           */
  S_ST( 'a',	3,      805,     0 ), /*   804 timingst          */
  S_ST( 't',	3,      419,     0 ), /*   805 timingsta         */
  S_ST( 'n',	3,      807,   797 ), /*   806 ti                */
  S_ST( 'k',	3,      808,     0 ), /*   807 tin               */
  S_ST( 'e',	3,      420,     0 ), /*   808 tink              */
  S_ST( 'o',	3,      421,   795 ), /*   809 t                 */
  S_ST( 'r',	3,      812,   809 ), /*   810 t                 */
  S_ST( 'a',	3,      422,     0 ), /*   811 tr                */
  S_ST( 'u',	3,      813,   811 ), /*   812 tr                */
  S_ST( 's',	3,      814,   423 ), /*   813 tru               */
  S_ST( 't',	3,      815,     0 ), /*   814 trus              */
  S_ST( 'e',	3,      816,     0 ), /*   815 trust             */
  S_ST( 'd',	3,      817,     0 ), /*   816 truste            */
  S_ST( 'k',	3,      818,     0 ), /*   817 trusted           */
  S_ST( 'e',	3,      424,     0 ), /*   818 trustedk          */
  S_ST( 't',	3,      425,   810 ), /*   819 t                 */
  S_ST( 'y',	3,      821,   819 ), /*   820 t                 */
  S_ST( 'p',	3,      426,     0 ), /*   821 ty                */
  S_ST( 'u',	3,      823,   794 ), /*   822                   */
  S_ST( 'n',	3,      829,     0 ), /*   823 u                 */
  S_ST( 'c',	3,      825,     0 ), /*   824 un                */
  S_ST( 'o',	3,      826,     0 ), /*   825 unc               */
  S_ST( 'n',	3,      827,     0 ), /*   826 unco              */
  S_ST( 'f',	3,      828,     0 ), /*   827 uncon             */
  S_ST( 'i',	3,      431,     0 ), /*   828 unconf            */
  S_ST( 'p',	3,      830,   824 ), /*   829 un                */
  S_ST( 'e',	3,      831,     0 ), /*   830 unp               */
  S_ST( 'e',	3,      432,     0 ), /*   831 unpe              */
  S_ST( '_',	3,      852,     0 ), /*   832 unpeer            */
  S_ST( 'c',	3,      834,     0 ), /*   833 unpeer_           */
  S_ST( 'r',	3,      835,     0 ), /*   834 unpeer_c          */
  S_ST( 'y',	3,      836,     0 ), /*   835 unpeer_cr         */
  S_ST( 'p',	3,      837,     0 ), /*   836 unpeer_cry        */
  S_ST( 't',	3,      838,     0 ), /*   837 unpeer_cryp       */
  S_ST( 'o',	3,      839,     0 ), /*   838 unpeer_crypt      */
  S_ST( '_',	3,      844,     0 ), /*   839 unpeer_crypto     */
  S_ST( 'e',	3,      841,     0 ), /*   840 unpeer_crypto_    */
  S_ST( 'a',	3,      842,     0 ), /*   841 unpeer_crypto_e   */
  S_ST( 'r',	3,      843,     0 ), /*   842 unpeer_crypto_ea  */
  S_ST( 'l',	3,      428,     0 ), /*   843 unpeer_crypto_ear */
  S_ST( 'n',	3,      845,   840 ), /*   844 unpeer_crypto_    */
  S_ST( 'a',	3,      846,     0 ), /*   845 unpeer_crypto_n   */
  S_ST( 'k',	3,      847,     0 ), /*   846 unpeer_crypto_na  */
  S_ST( '_',	3,      848,     0 ), /*   847 unpeer_crypto_nak */
  S_ST( 'e',	3,      849,     0 ), /*   848 unpeer_crypto_nak_ */
  S_ST( 'a',	3,      850,     0 ), /*   849 unpeer_crypto_nak_e */
  S_ST( 'r',	3,      851,     0 ), /*   850 unpeer_crypto_nak_ea */
  S_ST( 'l',	3,      429,     0 ), /*   851 unpeer_crypto_nak_ear */
  S_ST( 'd',	3,      853,   833 ), /*   852 unpeer_           */
  S_ST( 'i',	3,      854,     0 ), /*   853 unpeer_d          */
  S_ST( 'g',	3,      855,     0 ), /*   854 unpeer_di         */
  S_ST( 'e',	3,      856,     0 ), /*   855 unpeer_dig        */
  S_ST( 's',	3,      857,     0 ), /*   856 unpeer_dige       */
  S_ST( 't',	3,      858,     0 ), /*   857 unpeer_diges      */
  S_ST( '_',	3,      859,     0 ), /*   858 unpeer_digest     */
  S_ST( 'e',	3,      860,     0 ), /*   859 unpeer_digest_    */
  S_ST( 'a',	3,      861,     0 ), /*   860 unpeer_digest_e   */
  S_ST( 'r',	3,      862,     0 ), /*   861 unpeer_digest_ea  */
  S_ST( 'l',	3,      430,     0 ), /*   862 unpeer_digest_ear */
  S_ST( 'v',	3,      864,   822 ), /*   863                   */
  S_ST( 'e',	3,      865,     0 ), /*   864 v                 */
  S_ST( 'r',	3,      866,     0 ), /*   865 ve                */
  S_ST( 's',	3,      867,     0 ), /*   866 ver               */
  S_ST( 'i',	3,      868,     0 ), /*   867 vers              */
  S_ST( 'o',	3,      433,     0 ), /*   868 versi             */
  S_ST( 'w',	3,      876,   863 ), /*   869                   */
  S_ST( 'a',	3,      871,     0 ), /*   870 w                 */
  S_ST( 'n',	3,      872,     0 ), /*   871 wa                */
  S_ST( 'd',	3,      873,     0 ), /*   872 wan               */
  S_ST( 'e',	3,      447,     0 ), /*   873 wand              */
  S_ST( 'e',	3,      875,   870 ), /*   874 w                 */
  S_ST( 'e',	3,      435,     0 ), /*   875 we                */
  S_ST( 'i',	3,      877,   874 ), /*   876 w                 */
  S_ST( 'l',	3,      878,     0 ), /*   877 wi                */
  S_ST( 'd',	3,      879,     0 ), /*   878 wil               */
  S_ST( 'c',	3,      880,     0 ), /*   879 wild              */
  S_ST( 'a',	3,      881,     0 ), /*   880 wildc             */
  S_ST( 'r',	3,      436,     0 ), /*   881 wildca            */
  S_ST( 'x',	3,      883,   869 ), /*   882                   */
  S_ST( 'l',	3,      884,     0 ), /*   883 x                 */
  S_ST( 'e',	3,      885,     0 ), /*   884 xl                */
  S_ST( 'a',	3,      886,     0 ), /*   885 xle               */
  S_ST( 'v',	3,      437,     0 ), /*   886 xlea              */
  S_ST( 'y',	3,      888,   882 ), /*   887 [initial state]   */
  S_ST( 'e',	3,      889,     0 ), /*   888 y                 */
  S_ST( 'a',	3,      438,     0 )  /*   889 ye                */
};

