#	$NetBSD: Makefile.inc,v 1.2.32.2 2015/01/07 12:13:43 msaitoh Exp $

.include "../Makefile.inc"
