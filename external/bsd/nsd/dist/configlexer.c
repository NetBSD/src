#include "config.h"

#line 2 "<stdout>"

#define  YY_INT_ALIGNED short int

/* A lexical scanner generated by flex */

#define yy_create_buffer c__create_buffer
#define yy_delete_buffer c__delete_buffer
#define yy_scan_buffer c__scan_buffer
#define yy_scan_string c__scan_string
#define yy_scan_bytes c__scan_bytes
#define yy_init_buffer c__init_buffer
#define yy_flush_buffer c__flush_buffer
#define yy_load_buffer_state c__load_buffer_state
#define yy_switch_to_buffer c__switch_to_buffer
#define yypush_buffer_state c_push_buffer_state
#define yypop_buffer_state c_pop_buffer_state
#define yyensure_buffer_stack c_ensure_buffer_stack
#define yy_flex_debug c__flex_debug
#define yyin c_in
#define yyleng c_leng
#define yylex c_lex
#define yylineno c_lineno
#define yyout c_out
#define yyrestart c_restart
#define yytext c_text
#define yywrap c_wrap
#define yyalloc c_alloc
#define yyrealloc c_realloc
#define yyfree c_free

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 6
#define YY_FLEX_SUBMINOR_VERSION 4
#if YY_FLEX_SUBMINOR_VERSION > 0
#define FLEX_BETA
#endif

#ifdef yy_create_buffer
#define c__create_buffer_ALREADY_DEFINED
#else
#define yy_create_buffer c__create_buffer
#endif

#ifdef yy_delete_buffer
#define c__delete_buffer_ALREADY_DEFINED
#else
#define yy_delete_buffer c__delete_buffer
#endif

#ifdef yy_scan_buffer
#define c__scan_buffer_ALREADY_DEFINED
#else
#define yy_scan_buffer c__scan_buffer
#endif

#ifdef yy_scan_string
#define c__scan_string_ALREADY_DEFINED
#else
#define yy_scan_string c__scan_string
#endif

#ifdef yy_scan_bytes
#define c__scan_bytes_ALREADY_DEFINED
#else
#define yy_scan_bytes c__scan_bytes
#endif

#ifdef yy_init_buffer
#define c__init_buffer_ALREADY_DEFINED
#else
#define yy_init_buffer c__init_buffer
#endif

#ifdef yy_flush_buffer
#define c__flush_buffer_ALREADY_DEFINED
#else
#define yy_flush_buffer c__flush_buffer
#endif

#ifdef yy_load_buffer_state
#define c__load_buffer_state_ALREADY_DEFINED
#else
#define yy_load_buffer_state c__load_buffer_state
#endif

#ifdef yy_switch_to_buffer
#define c__switch_to_buffer_ALREADY_DEFINED
#else
#define yy_switch_to_buffer c__switch_to_buffer
#endif

#ifdef yypush_buffer_state
#define c_push_buffer_state_ALREADY_DEFINED
#else
#define yypush_buffer_state c_push_buffer_state
#endif

#ifdef yypop_buffer_state
#define c_pop_buffer_state_ALREADY_DEFINED
#else
#define yypop_buffer_state c_pop_buffer_state
#endif

#ifdef yyensure_buffer_stack
#define c_ensure_buffer_stack_ALREADY_DEFINED
#else
#define yyensure_buffer_stack c_ensure_buffer_stack
#endif

#ifdef yylex
#define c_lex_ALREADY_DEFINED
#else
#define yylex c_lex
#endif

#ifdef yyrestart
#define c_restart_ALREADY_DEFINED
#else
#define yyrestart c_restart
#endif

#ifdef yylex_init
#define c_lex_init_ALREADY_DEFINED
#else
#define yylex_init c_lex_init
#endif

#ifdef yylex_init_extra
#define c_lex_init_extra_ALREADY_DEFINED
#else
#define yylex_init_extra c_lex_init_extra
#endif

#ifdef yylex_destroy
#define c_lex_destroy_ALREADY_DEFINED
#else
#define yylex_destroy c_lex_destroy
#endif

#ifdef yyget_debug
#define c_get_debug_ALREADY_DEFINED
#else
#define yyget_debug c_get_debug
#endif

#ifdef yyset_debug
#define c_set_debug_ALREADY_DEFINED
#else
#define yyset_debug c_set_debug
#endif

#ifdef yyget_extra
#define c_get_extra_ALREADY_DEFINED
#else
#define yyget_extra c_get_extra
#endif

#ifdef yyset_extra
#define c_set_extra_ALREADY_DEFINED
#else
#define yyset_extra c_set_extra
#endif

#ifdef yyget_in
#define c_get_in_ALREADY_DEFINED
#else
#define yyget_in c_get_in
#endif

#ifdef yyset_in
#define c_set_in_ALREADY_DEFINED
#else
#define yyset_in c_set_in
#endif

#ifdef yyget_out
#define c_get_out_ALREADY_DEFINED
#else
#define yyget_out c_get_out
#endif

#ifdef yyset_out
#define c_set_out_ALREADY_DEFINED
#else
#define yyset_out c_set_out
#endif

#ifdef yyget_leng
#define c_get_leng_ALREADY_DEFINED
#else
#define yyget_leng c_get_leng
#endif

#ifdef yyget_text
#define c_get_text_ALREADY_DEFINED
#else
#define yyget_text c_get_text
#endif

#ifdef yyget_lineno
#define c_get_lineno_ALREADY_DEFINED
#else
#define yyget_lineno c_get_lineno
#endif

#ifdef yyset_lineno
#define c_set_lineno_ALREADY_DEFINED
#else
#define yyset_lineno c_set_lineno
#endif

#ifdef yywrap
#define c_wrap_ALREADY_DEFINED
#else
#define yywrap c_wrap
#endif

#ifdef yyalloc
#define c_alloc_ALREADY_DEFINED
#else
#define yyalloc c_alloc
#endif

#ifdef yyrealloc
#define c_realloc_ALREADY_DEFINED
#else
#define yyrealloc c_realloc
#endif

#ifdef yyfree
#define c_free_ALREADY_DEFINED
#else
#define yyfree c_free
#endif

#ifdef yytext
#define c_text_ALREADY_DEFINED
#else
#define yytext c_text
#endif

#ifdef yyleng
#define c_leng_ALREADY_DEFINED
#else
#define yyleng c_leng
#endif

#ifdef yyin
#define c_in_ALREADY_DEFINED
#else
#define yyin c_in
#endif

#ifdef yyout
#define c_out_ALREADY_DEFINED
#else
#define yyout c_out
#endif

#ifdef yy_flex_debug
#define c__flex_debug_ALREADY_DEFINED
#else
#define yy_flex_debug c__flex_debug
#endif

#ifdef yylineno
#define c_lineno_ALREADY_DEFINED
#else
#define yylineno c_lineno
#endif

/* First, we deal with  platform-specific or compiler-specific issues. */

/* begin standard C headers. */
#include <stdio.h>
#include <string.h>
#include <errno.h>
#include <stdlib.h>

/* end standard C headers. */

/* flex integer type definitions */

#ifndef FLEXINT_H
#define FLEXINT_H

/* C99 systems have <inttypes.h>. Non-C99 systems may or may not. */

#if defined (__STDC_VERSION__) && __STDC_VERSION__ >= 199901L

/* C99 says to define __STDC_LIMIT_MACROS before including stdint.h,
 * if you want the limit (max/min) macros for int types. 
 */
#ifndef __STDC_LIMIT_MACROS
#define __STDC_LIMIT_MACROS 1
#endif

#include <inttypes.h>
typedef int8_t flex_int8_t;
typedef uint8_t flex_uint8_t;
typedef int16_t flex_int16_t;
typedef uint16_t flex_uint16_t;
typedef int32_t flex_int32_t;
typedef uint32_t flex_uint32_t;
#else
typedef signed char flex_int8_t;
typedef short int flex_int16_t;
typedef int flex_int32_t;
typedef unsigned char flex_uint8_t; 
typedef unsigned short int flex_uint16_t;
typedef unsigned int flex_uint32_t;

/* Limits of integral types. */
#ifndef INT8_MIN
#define INT8_MIN               (-128)
#endif
#ifndef INT16_MIN
#define INT16_MIN              (-32767-1)
#endif
#ifndef INT32_MIN
#define INT32_MIN              (-2147483647-1)
#endif
#ifndef INT8_MAX
#define INT8_MAX               (127)
#endif
#ifndef INT16_MAX
#define INT16_MAX              (32767)
#endif
#ifndef INT32_MAX
#define INT32_MAX              (2147483647)
#endif
#ifndef UINT8_MAX
#define UINT8_MAX              (255U)
#endif
#ifndef UINT16_MAX
#define UINT16_MAX             (65535U)
#endif
#ifndef UINT32_MAX
#define UINT32_MAX             (4294967295U)
#endif

#ifndef SIZE_MAX
#define SIZE_MAX               (~(size_t)0)
#endif

#endif /* ! C99 */

#endif /* ! FLEXINT_H */

/* begin standard C++ headers. */

/* TODO: this is always defined, so inline it */
#define yyconst const

#if defined(__GNUC__) && __GNUC__ >= 3
#define yynoreturn __attribute__((__noreturn__))
#else
#define yynoreturn
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an
 *   integer in range [0..255] for use as an array index.
 */
#define YY_SC_TO_UI(c) ((YY_CHAR) (c))

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN (yy_start) = 1 + 2 *
/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START (((yy_start) - 1) / 2)
#define YYSTATE YY_START
/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)
/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( yyin  )
#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#ifndef YY_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k.
 * Moreover, YY_BUF_SIZE is 2*YY_READ_BUF_SIZE in the general case.
 * Ditto for the __ia64__ case accordingly.
 */
#define YY_BUF_SIZE 32768
#else
#define YY_BUF_SIZE 16384
#endif /* __ia64__ */
#endif

/* The state buf must be large enough to hold one state per character in the main buffer.
 */
#define YY_STATE_BUF_SIZE   ((YY_BUF_SIZE + 2) * sizeof(yy_state_type))

#ifndef YY_TYPEDEF_YY_BUFFER_STATE
#define YY_TYPEDEF_YY_BUFFER_STATE
typedef struct yy_buffer_state *YY_BUFFER_STATE;
#endif

#ifndef YY_TYPEDEF_YY_SIZE_T
#define YY_TYPEDEF_YY_SIZE_T
typedef size_t yy_size_t;
#endif

extern int yyleng;

extern FILE *yyin, *yyout;

#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2
    
    #define YY_LESS_LINENO(n)
    #define YY_LINENO_REWIND_TO(ptr)
    
/* Return all but the first "n" matched characters back to the input stream. */
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		*yy_cp = (yy_hold_char); \
		YY_RESTORE_YY_MORE_OFFSET \
		(yy_c_buf_p) = yy_cp = yy_bp + yyless_macro_arg - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )
#define unput(c) yyunput( c, (yytext_ptr)  )

#ifndef YY_STRUCT_YY_BUFFER_STATE
#define YY_STRUCT_YY_BUFFER_STATE
struct yy_buffer_state
	{
	FILE *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	int yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	int yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether this is an "interactive" input source; if so, and
	 * if we're using stdio for input, then we want to use getc()
	 * instead of fread(), to make sure we stop fetching input after
	 * each newline.
	 */
	int yy_is_interactive;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

    int yy_bs_lineno; /**< The line count. */
    int yy_bs_column; /**< The column count. */

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;

#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2

	};
#endif /* !YY_STRUCT_YY_BUFFER_STATE */

/* Stack of input buffers. */
static size_t yy_buffer_stack_top = 0; /**< index of top of stack. */
static size_t yy_buffer_stack_max = 0; /**< capacity of stack. */
static YY_BUFFER_STATE * yy_buffer_stack = NULL; /**< Stack as an array. */

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 *
 * Returns the top of the stack, or NULL.
 */
#define YY_CURRENT_BUFFER ( (yy_buffer_stack) \
                          ? (yy_buffer_stack)[(yy_buffer_stack_top)] \
                          : NULL)
/* Same as previous macro, but useful when we know that the buffer stack is not
 * NULL or when we need an lvalue. For internal use only.
 */
#define YY_CURRENT_BUFFER_LVALUE (yy_buffer_stack)[(yy_buffer_stack_top)]

/* yy_hold_char holds the character lost when yytext is formed. */
static char yy_hold_char;
static int yy_n_chars;		/* number of characters read into yy_ch_buf */
int yyleng;

/* Points to current character in buffer. */
static char *yy_c_buf_p = NULL;
static int yy_init = 0;		/* whether we need to initialize */
static int yy_start = 0;	/* start state number */

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
static int yy_did_buffer_switch_on_eof;

void yyrestart ( FILE *input_file  );
void yy_switch_to_buffer ( YY_BUFFER_STATE new_buffer  );
YY_BUFFER_STATE yy_create_buffer ( FILE *file, int size  );
void yy_delete_buffer ( YY_BUFFER_STATE b  );
void yy_flush_buffer ( YY_BUFFER_STATE b  );
void yypush_buffer_state ( YY_BUFFER_STATE new_buffer  );
void yypop_buffer_state ( void );

static void yyensure_buffer_stack ( void );
static void yy_load_buffer_state ( void );
static void yy_init_buffer ( YY_BUFFER_STATE b, FILE *file  );
#define YY_FLUSH_BUFFER yy_flush_buffer( YY_CURRENT_BUFFER )

YY_BUFFER_STATE yy_scan_buffer ( char *base, yy_size_t size  );
YY_BUFFER_STATE yy_scan_string ( const char *yy_str  );
YY_BUFFER_STATE yy_scan_bytes ( const char *bytes, int len  );

void *yyalloc ( yy_size_t  );
void *yyrealloc ( void *, yy_size_t  );
void yyfree ( void *  );

#define yy_new_buffer yy_create_buffer
#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){ \
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_is_interactive = is_interactive; \
	}
#define yy_set_bol(at_bol) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){\
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_at_bol = at_bol; \
	}
#define YY_AT_BOL() (YY_CURRENT_BUFFER_LVALUE->yy_at_bol)

/* Begin user sect3 */
typedef flex_uint8_t YY_CHAR;

FILE *yyin = NULL, *yyout = NULL;

typedef int yy_state_type;

extern int yylineno;
int yylineno = 1;

extern char *yytext;
#ifdef yytext_ptr
#undef yytext_ptr
#endif
#define yytext_ptr yytext

static yy_state_type yy_get_previous_state ( void );
static yy_state_type yy_try_NUL_trans ( yy_state_type current_state  );
static int yy_get_next_buffer ( void );
static void yynoreturn yy_fatal_error ( const char* msg  );

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	(yytext_ptr) = yy_bp; \
	(yytext_ptr) -= (yy_more_len); \
	yyleng = (int) (yy_cp - (yytext_ptr)); \
	(yy_hold_char) = *yy_cp; \
	*yy_cp = '\0'; \
	(yy_c_buf_p) = yy_cp;
#define YY_NUM_RULES 177
#define YY_END_OF_BUFFER 178
/* This struct is not used in this scanner,
   but its presence is necessary. */
struct yy_trans_info
	{
	flex_int32_t yy_verify;
	flex_int32_t yy_nxt;
	};
static const flex_int16_t yy_accept[1575] =
    {   0,
        1,    1,  165,  165,  169,  169,  173,  173,  178,  176,
        1,  157,  164,    2,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  177,  165,  166,  177,  167,  177,
      172,  169,  170,  171,  177,  173,  174,  175,  177,  176,
        0,    1,    2,    2,    2,    2,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,

      176,  176,  176,  176,  176,  176,  176,  165,    0,  172,
        0,  169,  173,    0,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,   84,  176,  176,  176,  176,  176,
      176,  176,  176,  176,   83,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,   66,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,    4,  176,   23,  176,

      176,  176,   37,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,   49,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,   40,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   95,   18,   19,  176,
      142,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,   55,  176,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   68,  176,  176,    3,
      176,  160,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      141,  176,  176,  176,  176,  176,  176,  176,  176,  176,
       46,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  149,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  168,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,   24,  176,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
       69,   36,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  158,  160,    0,  176,  176,  176,  176,  176,   31,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,   22,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   20,  176,   44,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,

       21,  176,  176,  176,  176,  176,   16,   17,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,   85,
       87,  176,  176,  176,  176,  176,  176,  176,  158,    0,
      176,  176,  176,  176,  176,  176,  176,  176,  176,   61,
      176,  130,  176,  176,   41,  176,  176,  145,  176,  176,
      176,  176,  176,  176,  176,  176,   45,   50,  176,  176,
       42,  176,   67,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,

      176,  176,  176,  176,  176,  176,   98,  176,  176,  176,
      176,  176,  176,  176,  176,  176,    6,  176,  176,  176,
      176,  176,  176,  122,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,   38,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,   27,  176,  176,  176,  176,  176,  176,
      176,  176,  176,   48,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,   51,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,   64,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
       11,  176,  176,  176,  176,  176,  176,   99,  176,  176,
      176,  176,  176,    5,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      115,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,   39,  121,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,   58,  176,  176,  176,  176,  176,   63,

      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      124,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,    8,  176,  176,  176,  123,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   57,  176,  176,  176,
      176,   54,  112,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   30,  176,  176,  176,
      176,   12,  176,  176,  176,  143,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,   52,
      176,  176,  159,  176,  176,  176,  176,  176,  176,  176,

      176,   74,  176,  176,  161,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,   15,  176,   13,  176,  176,
      176,  176,  176,  176,  111,  176,  176,  176,  176,   82,
       81,  176,  176,  176,  176,  176,  176,   56,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,   26,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  144,  176,  176,  176,
      176,  176,  176,  176,  139,  176,  176,  176,   43,  176,
      135,  176,  159,    0,  176,  176,   65,  176,  176,  176,
      176,  176,  176,  136,  176,   96,  176,  176,  176,  176,

      176,  176,  176,  176,  176,   14,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   92,  176,  176,  176,
       86,  176,   91,  176,  176,  176,  176,  176,  176,  176,
      176,  131,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  152,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   72,  176,  176,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  107,
      176,    7,   34,   35,  176,  110,  176,  118,   79,  176,
      176,  176,  119,  176,  176,  176,  176,  176,  176,  176,

       71,  176,  176,  176,  176,  176,  176,  176,   53,  176,
      176,  176,  176,  176,  176,  176,  176,  146,  176,  176,
      155,  156,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  114,  176,  176,  176,  176,  176,  106,
      176,  176,  176,  176,  176,  176,  176,   70,   25,  176,
      176,  120,  176,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  176,   75,  176,   29,  176,
      176,  133,  127,  176,  129,  176,  176,  176,  176,  176,
      176,  176,   93,   94,  176,   62,  176,  176,  176,  176,
       77,  176,  176,  176,  176,  176,  176,  176,  176,  176,

      176,  116,  176,  117,  176,  176,  176,  176,   32,  176,
      176,  176,  176,  176,    9,  176,   76,   33,  176,  176,
      128,  176,  148,  154,  153,  176,  176,  176,  176,  176,
      176,   78,   73,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  176,   80,  113,  176,  176,  176,  176,  176,
      176,  176,  176,  176,  176,  132,  176,  162,  176,  140,
      176,  176,  176,  137,  176,  176,  176,  176,  176,   97,
      176,  176,  176,  176,  125,  176,   59,  176,  176,  176,
      176,  176,  176,  176,  147,  176,   60,  176,  176,  176,
      176,  176,  176,  105,  176,  176,  176,  176,  126,  134,

       10,  176,  176,  176,  176,   28,   47,  176,  176,  176,
      176,  176,  104,  176,  176,  176,  176,  176,  176,  176,
      176,  176,  151,  138,  176,  176,  176,  176,  176,  176,
      176,  176,  176,  163,  150,  176,  176,  101,  176,  176,
      100,   88,   89,  176,  176,  176,  176,  176,   90,  176,
      176,  176,  176,  176,  176,  176,  176,  176,  176,  176,
      102,  176,  176,  103,  176,  176,  176,  176,  108,  176,
      176,  176,  109,    0
    } ;

static const YY_CHAR yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    4,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    2,    1,    5,    6,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    7,    1,    1,    8,    9,    9,
        9,   10,    9,   11,    9,    9,    9,   12,    1,    1,
       13,    1,    1,    1,   14,   15,   16,   17,   18,   19,
       20,   21,   22,   23,   24,   25,   26,   27,   28,   29,
       30,   31,   32,   33,   34,   35,   36,   37,   38,   39,
        1,   40,    1,    1,    1,    1,   41,   42,   43,   44,

       45,   46,   47,   48,   49,   50,   51,   52,   53,   54,
       55,   56,   57,   58,   59,   60,   61,   62,   63,   64,
       65,   66,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,

        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1
    } ;

static const YY_CHAR yy_meta[67] =
    {   0,
        1,    2,    3,    4,    4,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1
    } ;

static const flex_int16_t yy_base[1587] =
    {   0,
        0,    0,   64,   67,   71,   75,   78,   81, 4435, 4394,
       85, 4436, 4436,   88,   72,   73,  123,  168,   62,   74,
      102,   80,   77,  127,  166,  113,  188,  187,  216,  208,
      133,   90,  143,  115,  199, 4393, 4436, 4436, 4436,   96,
     4392, 4429, 4436, 4436,  248, 4390, 4436, 4436,  180, 4389,
      253,  132,    0,  262,    0,    0,  234,  180,  229,  195,
      243,  235,  232,  251,  252,  237,  264,  245,  272,  275,
      261,   87,  256,  285,  291,  292,  300,  312,  284,  289,
      298,  299,  301,  315,  319,  322,  313,  327,  317,  318,
      339,  341,  340,  384,  330,  361,  388,  326,  392,  356,

      357,  382,  389,  377,  410,  409,  416, 4388,  226, 4387,
      421, 4424, 4385,  383,  423,  424,  417,  433,  428,  443,
      444,  434,  437,  457,  448,  204,  451,  455,  460,  474,
      465,  479,  473,  491,  490,  482,  486,  492,  520,  464,
      500,  505,  510,  157,  535,  511,  512,  537,  516,  529,
      524,  538,  543,  525,  548,  539,  552,  553,  557,  556,
      567,  566,  569,  575,  517,  572,  591,  570,  594,  599,
      586,  593,  597,  613, 4384,  614,  626,  616,  619,  607,
      624,  602,  631,  643, 4382,  627,  637,  629,  634,  651,
      639,  656,  666,  653,  675,  661,  676,  678,  669,  687,

      674,  695,  670,  689,  680,  704,  693,  697,  703,  706,
      705,  725,  729, 4374,  719,  717,  709,  731,  723,  730,
      738,  750,  745,  760,  748,  757,  755,  761,  767,  744,
      770,  754,  782,  765,  775,  781,  789,  796,  790,  804,
      794,  802,  807,  809,  820,  850,  855,  808,  810,  813,
      833,  821,  890,  875,  901,  852,  849,  846,  883,  888,
      889,  885,  898,  845,  894,  917,  921,  919,  928,  941,
      930,  926,  940,  931,  938,  950,  951,  957,  956,  967,
      958,  973,  966,  968,  970,  976,  977,  978,  997,  998,
     1007, 1008,  989, 1009, 1016, 1021, 4358,  995, 4357, 1018,

     1024, 1019, 4356, 1022, 1034, 1028, 1025, 1052, 1054, 1041,
     1046, 1038, 1047, 1065, 1055, 1068, 1051, 1070, 1057, 1078,
     1073, 1069, 1107, 1089, 1097, 1090, 1087, 1105, 1102, 1092,
     1115, 1103, 1116, 1098, 1125, 1122, 1119, 1112, 1135, 1142,
     1145, 1138, 1155, 1152, 1149, 4355, 1154, 1165, 1160, 1150,
     1192, 1172, 1181, 1185, 1188,  851, 1204, 1198, 1199, 1210,
     1207, 1216, 1202, 1201, 1205, 1248,  866, 1219, 1208, 1228,
     1235, 1240, 1229, 1247, 1253, 1232, 1255, 1243, 1246, 1251,
     1261, 1264, 1262, 1277, 1281, 1284, 1289, 1292, 1280, 1287,
     1295, 1290, 1318, 1306, 1282, 1313, 1330, 1332, 1320, 1333,

     1324, 1347, 1349, 1326, 1329, 1348, 1328, 1352, 1341, 1360,
     1361, 1353, 1357, 1387, 1382, 1374, 1365, 1380, 1377, 1376,
     1381, 1386, 1392, 1404, 1401, 1393, 1397, 1405, 1407, 1422,
     1427, 1425, 1446, 1429, 1431, 1433, 1419, 1432, 1445, 1450,
     1438, 1457, 1468, 1459, 1456, 1467, 1478, 1472, 1463, 1466,
     1464, 1486, 1484, 1495, 1510, 4354, 1512, 1498, 1507, 1499,
     1508, 1511, 1514, 1506, 1524, 1552, 4353, 4352, 4351, 1527,
     4349, 1535, 1525, 1503, 1566, 1546, 1548, 1567, 1558, 1556,
     1562, 1568, 1576, 1565, 1580, 1575, 1592, 1611, 1541, 1594,
     1617, 1604, 1598, 1602, 1621, 1622, 1608, 1610, 4348, 1625,

     1619, 1631, 1640, 1618, 1647, 1641, 1648, 1653, 1660, 1639,
     1646, 1667, 1665, 1666, 1663, 1662, 4347, 1675, 1707, 4346,
     1536, 4344, 1659, 1686, 1687, 1698, 1680, 1692, 1697, 1696,
     1716, 1709, 1706, 1720, 1708, 1729, 1727, 1731, 1723, 1734,
     4342, 1747, 1746, 1759, 1750, 1756, 1743, 1753, 1768, 1761,
     4341, 1767, 1776, 1779, 1778, 1787, 1775, 1789, 1780, 1786,
     1803, 1788, 1805, 4339, 1812, 1814, 1802, 1847, 1815, 1824,
     1816, 1827, 1830, 1854, 1841, 1860, 1844, 1865, 1857, 1861,
     1871, 1875, 1881, 1874, 1878, 4329, 1890, 1885, 1897, 1893,
     1911, 1912, 1896, 1899, 1917, 1908, 1702, 1920, 4315, 1923,

     1905, 1932, 1907, 1924, 1933, 1935, 1942, 1940, 1938, 1960,
     4313, 4307, 1939, 1956, 1970, 1959, 1962, 1964, 1954, 1974,
     1980, 1990, 1998, 1981, 1975, 1996, 2005, 1997, 2017, 2011,
     2013, 4267, 4243, 2042, 2019, 2024, 2023, 2015, 2031, 4134,
     2014, 2044, 2033, 2058, 2055, 2060, 2052, 2059, 2066, 2042,
     2074, 2057, 4131, 2051, 2071, 2062, 2063, 2083, 2077, 2089,
     2096, 2101, 2099, 2097, 2087, 2103, 2091, 2102, 2094, 2098,
     2108, 2118, 2110, 2104, 2116, 2121, 2126, 2145, 2137, 2138,
     2153, 2140, 2154, 2159, 2147, 2163, 3966, 2161, 3915, 2170,
     2184, 2164, 2168, 2178, 2173, 2180, 2183, 2186, 2188, 2185,

     3904, 2203, 2210, 2195, 2209, 2216, 3880, 3821, 2224, 2226,
     2220, 2228, 2213, 2233, 2219, 2230, 2231, 2235, 2253, 2243,
     2237, 2269, 2261, 2247, 2258, 2257, 2270, 2272, 2262, 2265,
     2275, 2287, 2289, 2285, 2288, 2298, 2292, 2294, 2302, 3819,
     3815, 2312, 2315, 2319, 2358, 2305, 2336, 2306, 3811, 2352,
     2339, 2321, 2342, 2337, 2347, 2351, 2345, 2341, 2355, 3761,
     2368, 3754, 2372, 2363, 3747, 2374, 2388, 3711, 2366, 2383,
     2387, 2390, 2399, 2403, 2410, 2406, 3707, 3647, 2389, 2415,
     3643, 2413, 3598, 2426, 2423, 2407, 2398, 2414, 2436, 2430,
     2433, 2425, 2468, 2450, 2446, 2453, 2438, 2444, 2456, 2460,

     2472, 2441, 2466, 2477, 2480, 2475, 3590, 2492, 2486, 2483,
     2498, 2481, 2507, 2505, 2488, 2502, 3584, 2499, 2516, 2506,
     2504, 2509, 2517, 3532, 2513, 2518, 2527, 2534, 2532, 2547,
     2533, 2536, 2539, 2564, 2559, 2550, 2549, 2566, 2577, 2554,
     2573, 2579, 2574, 2575, 2583, 2586, 2597, 2588, 2593, 3529,
     2598, 2600, 2604, 2594, 2614, 2610, 2613, 2606, 2630, 2638,
     2642, 2643, 2647, 3521, 2649, 2645, 2653, 2631, 2637, 2654,
     2640, 2657, 2655, 3477, 2658, 2663, 2674, 2672, 2675, 2689,
     2693, 2684, 2690, 2699, 2704, 2698, 2706, 2700, 3421, 2708,
     2688, 2723, 2719, 2743, 2733, 2740, 2741, 2744, 2731, 3356,

     2722, 2732, 2749, 2756, 2750, 2737, 2758, 2753, 2766, 2754,
     3354, 2770, 2767, 2772, 2792, 2790, 2793, 3312, 2789, 2783,
     2781, 2797, 2786, 3293, 2804, 2800, 2817, 2821, 2808, 2815,
     2833, 2822, 2827, 2831, 2839, 2838, 2842, 2825, 2835, 2852,
     2847, 2857, 2853, 2858, 2861, 2867, 2862, 2848, 2888, 2875,
     3169, 2883, 2872, 2894, 2896, 2899, 2901, 2898, 2893, 2902,
     2895, 2903, 2915, 2905, 2900, 3155, 3057, 2919, 2922, 2925,
     2942, 2926, 2927, 2933, 2954, 2951, 2934, 2952, 2943, 2966,
     2967, 2960, 2970, 2964, 2953, 2972, 2965, 2961, 2982, 2978,
     2971, 3000, 3007, 3033, 3003, 2997, 1833, 3005, 2992, 2980,

     2991, 3006, 3026, 3017, 3004, 3009, 3027, 3019, 3031, 3044,
     2882, 3020, 3041, 3030, 3052, 3035, 3058, 3054, 3049, 3066,
     3042, 3076, 3068, 2874, 3069, 3072, 3078, 2832, 3075, 3080,
     3081, 3086, 3096, 3099, 3094, 3093, 3116, 3108, 3102, 3105,
     3113, 3125, 3121, 3131, 3129, 3130, 2824, 3126, 3132, 3120,
     3135, 2788, 2777, 3136, 3145, 3140, 3154, 3152, 3172, 3159,
     3176, 3161, 3177, 3163, 3164, 3167, 2765, 3173, 3182, 3191,
     3208, 2739, 3188, 3201, 3209, 2727, 3181, 3186, 3210, 3212,
     3215, 3198, 3218, 3222, 3225, 3235, 3234, 3248, 3244, 2681,
     3249, 3254, 2679, 3241, 3257, 3264, 3252, 3263, 3267, 3268,

     3271, 2671, 3279, 3270, 2666, 3265, 3282, 3283, 3281, 3284,
     3294, 3287, 3291, 3295, 3301, 2639, 3318, 2636, 3306, 3299,
     3320, 3326, 3308, 3327, 2627, 3328, 3329, 3333, 3335, 2569,
     2561, 3330, 3339, 3344, 3345, 3364, 3350, 2491, 3351, 3360,
     3362, 3361, 3381, 3370, 3375, 3376, 3391, 3399, 3383, 3394,
     3396, 2420, 3401, 3389, 3409, 3390, 3410, 3400, 3418, 3408,
     3419, 3422, 3434, 3423, 3435, 3429, 2386, 3430, 3428, 3431,
     3448, 3458, 3440, 3455, 2378, 3456, 3466, 3452, 2299, 3461,
     2246, 3465, 2212, 3485, 3490, 3482, 2202, 3484, 3485, 3498,
     3500, 3491, 3496, 2143, 3504, 2135, 3481, 3499, 3505, 3495,

     3508, 3516, 3514, 3493, 3539, 2132, 3530, 3540, 3546, 3548,
     3542, 3551, 3541, 3553, 3556, 3557, 3555, 3552, 3562, 3545,
     3566, 3567, 3571, 3569, 3559, 3568, 1995, 3591, 3575, 3576,
     1992, 3587, 1969, 3580, 3602, 3597, 3607, 3611, 3592, 3596,
     3603, 1851, 3614, 3615, 3619, 3618, 3636, 3623, 3625, 3632,
     3655, 3657, 1848, 3630, 3640, 3652, 3656, 3659, 3654, 3667,
     3664, 3670, 3646, 3680, 3678, 3673, 1748, 3687, 3696, 3694,
     3689, 3705, 3712, 3695, 3691, 3714, 3717, 3699, 3719, 1744,
     3720, 1742, 1704, 1693, 3721, 1689, 3722, 1658, 1650, 3726,
     3732, 3728, 1649, 3738, 3740, 3742, 3751, 3739, 3741, 3744,

     1635, 3767, 3768, 3772, 3759, 3769, 3771, 3781, 1633, 3777,
     3784, 3783, 3780, 3788, 3794, 3785, 3798, 1595, 3790, 3786,
     1539, 1505, 3810, 3812, 3802, 3813, 3809, 3825, 3827, 3829,
     3828, 3833, 3837, 1483, 3838, 3839, 3836, 3841, 3846, 1363,
     3857, 3842, 3849, 3852, 3865, 3861, 3859, 1322, 1321, 3860,
     3878, 1305, 3891, 3876, 3879, 3888, 3894, 3892, 3885, 3887,
     3886, 3899, 3908, 3917, 3920, 3918, 1279, 3931, 1244, 3921,
     3907, 1242, 1237, 3937, 1234, 3925, 3938, 3941, 3942, 3924,
     3935, 3948, 1226, 1178, 3940, 1133, 3934, 3945, 3947, 3958,
     1095, 3968, 3960, 3957, 3974, 3977, 3967, 3975, 3970, 3994,

     3995, 1043, 3993, 1002, 3997, 3988, 4000, 4002,  994, 3990,
     3985, 4009, 4018, 4020,  949, 4005,  946,  937, 4001, 4032,
      923, 4028,  914,  848,  822, 4038, 4021, 4040, 4043, 4024,
     4034,  817,  806, 4041, 4035, 4051, 4039, 4037, 4059, 4064,
     4060, 4079, 4061,  777,  702, 4078, 4081, 4080, 4069, 4067,
     4083, 4084, 4091, 4086, 4100,  664, 4094,  603, 4106,  522,
     4105, 4107, 4101,  508, 4109, 4102, 4119, 4113, 4132,  487,
     4133, 4139, 4140, 4142,  483, 4149,  472, 4150, 4152, 4147,
     4148, 4159, 4136, 4153,  435, 4158,  421, 4160, 4179, 4169,
     4163, 4176, 4174,  404, 4180, 4175, 4172, 4181,  365,  362,

      358, 4190, 4202, 4185, 4201,  354,  353, 4186, 4205, 4215,
     4229, 4216,  350, 4204, 4213, 4240, 4234, 4227, 4236, 4232,
     4246, 4247,  344,  342, 4225, 4231, 4248, 4254, 4245, 4256,
     4265, 4270, 4259,  288,  277, 4271, 4275,  273, 4278, 4273,
      248,  207,  200, 4286, 4268, 4294, 4281, 4277,  196, 4272,
     4283, 4300, 4288, 4318, 4317, 4320, 4302, 4321, 4305, 4327,
      160, 4326, 4311,  153, 4314, 4334, 4337, 4336,  151, 4345,
     4340, 4338,  119, 4436, 4399, 4403, 4407,  156, 4411, 4415,
      139, 4417, 4419,  109,  102,   87
    } ;

static const flex_int16_t yy_def[1587] =
    {   0,
     1574,    1, 1575, 1575, 1576, 1576, 1577, 1577, 1574, 1578,
     1574, 1574, 1574, 1579, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1580, 1574, 1574, 1574, 1580,
     1581, 1574, 1574, 1574, 1581, 1582, 1574, 1574, 1582, 1578,
     1578, 1574, 1583, 1579, 1583, 1579, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1580, 1580, 1581,
     1581, 1574, 1582, 1582, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1584, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1585, 1584, 1584, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1585, 1585,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1586, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1586, 1586, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,

     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578,    0, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574
    } ;

static const flex_int16_t yy_nxt[4503] =
    {   0,
       10,   11,   12,   12,   13,   14,   10,   10,   10,   10,
       10,   10,   10,   15,   16,   17,   18,   19,   10,   10,
       20,   21,   10,   22,   23,   24,   25,   26,   27,   10,
       28,   29,   30,   31,   32,   10,   33,   10,   34,   35,
       15,   16,   17,   18,   19,   10,   10,   20,   21,   10,
       22,   23,   24,   25,   26,   27,   10,   28,   29,   30,
       31,   32,   10,   33,   10,   34,   37,   38,   39,   37,
       38,   39,   42,   43,   43,   44,   42,   43,   43,   44,
       47,   47,   48,   47,   47,   48,   52, 1183,   74,   55,
       53,   55,   55,  132,   61,   75,   57,   80,   58,  108,

      108,   51,  749,   40,   81,   59,   40,  104,   60,  633,
       45,   51,   51,   51,   45,   74,   51,   49,   76,   51,
       49,   61,   75,   57,   80,   58,   51,   56,   77,   51,
       78,   81,   59,   52,  104,   60,   62,   53,   79,  110,
       82,   51,  107,   63,   83,   76,   89,   64,   84,  102,
       65,   66,   51,   67,   51,   77,   50,   78,   51,  105,
       85,  106,   51,   62,  103,   79,   51,   82,  214,  107,
       63,   83,   51,   89,   64,   84,  102,   65,   66,   86,
       67,   68,   51,  113,  113,   69,  105,   85,  106,   70,
       51,  103,   51,   87,   71,   72,   51,   88,   73,   51,

       50,   90,   50,   50,   94,   51,   86,   51,   68,   91,
      193,  117,   69,  119,   95,   92,   70,   96,   93,   51,
       87,   71,   72,  100,   88,   73,   51,   51,   90,  108,
      108,   94,  101,   97,   51,   51,   91,   98,  117,   51,
      119,   95,   92,   51,   96,   93,   51,   51,   99,  110,
      100,  110,  110,  115,   50,   51,   50,   50,  116,  101,
       97,  118,  122,   55,   98,   55,   55,  121,   51,  120,
      126,   51,  123,   51,   51,   99,   51,  128,  124,  125,
      115,  127,   51,  133,   51,  116,  129,   51,  118,  122,
       51,   51,  131,  130,  121,   51,  120,  126,  134,  123,

       51,   56,  143,   51,  128,  124,  125,  135,  127,  136,
      133,   51,   51,  129,   51,  137,   51,  145,  139,  131,
      130,  140,  141,   51,   51,  134,  144,   51,   51,  143,
       51,   51,  138,  147,  135,  146,  136,   51,   51,   51,
       51,  148,  137,  149,  145,  151,  142,  150,  152,  153,
      154,   51,   51,  144,   51,  155,   51,   51,   51,  138,
      147,   51,  146,  164,  170,   51,   51,  157,  148,   51,
      149,  156,  151,  142,  150,  152,  153,  154,   51,   51,
       51,   51,  155,   51,  173,  165,  113,  113,  174,   51,
      164,  170,   51,   51,  157,   51,   51,   51,  156,  158,

       51,   51,  159,  166,   51,  171,  176,  177,  160,  161,
      175,  173,  165,  162,  167,  174,   51,  163,  168,  172,
      169,   51,  110,   51,  110,  110,  158,   51,   51,  159,
      166,   51,  171,  176,  177,  160,  161,  175,  178,  179,
      162,  167,  180,   51,  163,  168,  172,  169,   51,   51,
      181,  182,  183,  184,  189,   51,   51,  187,  185,  186,
       51,  188,   51,   51,  194,  178,  179,   51,  195,  180,
      209,  192,   51,   51,   51,  190,   51,  181,  182,  183,
      184,  189,   51,   51,  187,  185,  186,   51,  188,  191,
       51,  194,  197,  196,   51,  195,   51,  198,  192,   51,

      199,  200,  190,   51,   51,  201,  210,  202,  203,  205,
      204,   51,   51,   51,  211,  212,  191,  217,   51,  197,
      196,   51,   51,  238,  198,   51,   51,  199,  200,   51,
       51,   51,  201,  206,  202,  203,  205,  204,  207,   51,
      213,  215,  218,  219,   51,  223,  222,   51,  221,   51,
       51,   51,  208,  216,  224,   51,   51,  226,  220,   51,
      206,   51,  225,   51,   51,  207,  227,  213,   51,  218,
      231,  228,  223,  222,   51,  221,   51,   51,   51,  208,
      216,  224,   51,  233,  226,  220,  229,   51,  230,  225,
      232,   51,   51,  227,  234,   51,   51,  231,  228,  235,

      236,  237,  239,  246,  241,   51,   51,  240,   51,   51,
      233,   51,  242,  229,   51,  230,  243,  232,  244,  247,
      248,  234,  253,  245,  255,   51,  235,  236,  237,  239,
       51,  241,   51,   51,  240,  254,   51,  257,   51,  242,
      250,   51,   51,  243,  249,  244,   51,  251,  258,  259,
      245,  255,   51,   51,  256,   51,  262,  252,   51,  260,
      263,  261,  254,   51,  257,   51,   51,  250,   51,  265,
       51,  249,  264,   51,  251,  258,   51,  266,   51,  267,
      270,  256,   51,  262,  252,  268,  260,  263,  261,  269,
       51,  272,   51,  274,  271,   51,  265,  273,  275,  264,

       51,  276,  277,   51,  266,   51,  267,  270,   51,   51,
      279,  285,  268,   51,   51,   51,  269,   51,  272,   51,
      280,  271,  278,  281,  273,  275,   51,  282,   51,  277,
      283,  286,   51,  284,   51,  287,   51,  279,  290,  291,
      293,   51,   51,   51,   51,   51,  288,  280,   51,  278,
      281,  289,  292,  294,  282,  295,   51,  283,   51,  296,
      284,  297,   51,  298,   51,  290,  291,  293,   51,   51,
       51,  299,  303,  288,  301,  300,  302,   51,  289,  292,
      294,  305,  295,   51,   51,  307,  296,   51,  304,   51,
      298,  306,  310,   51,   51,  308,   51,  309,  311,   51,

       51,  301,  300,  302,   51,  312,   51,  317,  305,   51,
      318,  319,  307,  321,   51,  304,   51,  313,  306,  310,
       51,   51,  308,  320,  309,  311,  314,  315,   51,   51,
      322,  316,  312,   51,  317,   51,  335,  323,  319,  334,
      336,   51,  338,   51,  313,   51,   51,   51,   51,   51,
      320,  337,   51,  314,  315,  351,   51,  322,  316,   51,
       51,   51,  456,  335,  323,  324,  334,  336,  330,  338,
      331,  358,   51,  350,  325,  326,  352,  468,  337,  327,
      328,  343,  329,  332,   51,   51,  333,   51,   51,   51,
       51,   51,  324,  344,   51,  330,  345,  331,  358,  353,

      350,  325,  326,  352,  339,   51,  327,  328,  340,  329,
      332,  341,  346,  333,   51,  354,  355,  356,  342,  347,
      344,  359,   51,  345,   51,  348,  353,   51,   51,   51,
      357,  339,  349,   51,  360,  340,  362,   51,  341,  361,
       51,  363,  354,  355,  356,  342,  347,  364,  359,  367,
      368,  365,  348,   51,  366,  370,   51,  357,   51,  349,
       51,  360,   51,  362,  369,   51,  361,   51,  363,   51,
       51,  371,  373,  374,  375,  377,   51,   51,  365,   51,
       51,  366,  370,  376,  372,   51,  378,  381,   51,   51,
       51,  369,  379,  382,  380,   51,   51,   51,  371,  373,

      374,  375,  377,  383,  385,   51,   51,   51,  384,   51,
      376,  372,   51,  378,  381,   51,   51,   51,  386,  379,
      382,  380,  387,  389,  388,  390,  391,  393,   51,  392,
      383,  385,  394,   51,   51,  384,   51,   51,  398,  395,
      399,   51,  401,  397,  406,  386,   51,   51,   51,  387,
      389,  388,  390,  391,  396,   51,  392,   51,   51,  394,
       51,   51,  400,   51,   51,  398,  395,   51,  402,  401,
      397,  403,  404,   51,  405,  407,  409,   51,  408,  410,
       51,  396,   51,  412,  413,   51,   51,  414,  411,  400,
       51,   51,  415,   51,   51,  402,   51,  416,  403,  404,

      417,  405,  407,  409,   51,  408,  410,   51,   51,   51,
      412,  413,   51,  418,  414,  411,  419,   51,  420,  415,
      422,  421,  423,  424,  416,  425,   51,  417,   51,   51,
      427,   51,  426,  428,   51,  429,   51,   51,  430,  434,
      432,   51,   51,  419,   51,  420,   51,  422,  421,  423,
      424,   51,  425,  431,   51,   51,  433,  427,   51,  426,
      428,   51,  429,  435,   51,  430,  434,  432,  438,  436,
      439,  437,   51,  442,   51,  444,  446,   51,  452,  443,
      431,   51,  448,  433,   51,  440,  445,  441,   51,   51,
      435,   51,  447,   51,   51,  438,  436,  439,  437,   51,

      442,  454,  444,  446,   51,  449,  443,  455,  453,  448,
      457,   51,  440,  445,  441,  458,  460,   51,  450,  447,
       51,  451,  462,  459,   51,  461,  464,   51,  454,  465,
      469,   51,  449,  463,  455,  453,  470,   51,   51,  471,
       51,   51,  458,   51,   51,  450,   51,   51,  451,   51,
      459,  472,  461,  464,  466,   51,  465,  473,   51,  467,
      463,  474,  477,  470,  475,   51,  476,   51,   51,  479,
      480,   51,  478,   51,   51,  481,   51,  482,  472,   51,
      483,   51,   51,   51,  473,   51,   51,   51,  474,  477,
       51,  475,   51,  476,   51,  484,  479,  480,  485,  478,

       51,   51,  481,   51,  482,  486,  488,  483,  500,  487,
      489,  491,  498,  493,  495,  492,   51,  499,   51,   51,
       51,   51,  484,   51,  490,  485,   51,  494,   51,   51,
      506,   51,  486,  488,   51,  500,  487,  489,  491,  501,
      493,  495,  492,  496,   51,   51,  497,  502,  504,  503,
      505,  490,   51,  507,  494,  508,  510,   51,  509,   51,
       51,   51,  512,   51,  517,   51,  501,   51,   51,   51,
      496,   51,   51,  497,  502,  504,  503,  505,  511,  514,
       51,  515,  516,  510,  513,  509,   51,   51,   51,  512,
      518,   51,   51,  519,  522,  523,   51,  524,  520,   51,

       51,  525,   51,  529,   51,  511,  514,  527,  515,  516,
      526,  513,  528,   51,  530,   51,   51,  518,  521,   51,
       51,   51,  523,  533,  524,   51,   51,  534,  525,  531,
      529,   51,   51,  532,  527,  535,   51,  526,  536,  528,
       51,  530,  539,   51,   51,  521,   51,  537,  538,  543,
      533,  545,  540,  549,  534,  542,  531,  541,   51,  546,
      532,   51,  535,  544,   51,  536,   51,  548,   51,  539,
       51,   51,   51,  547,  537,  538,  543,   51,  545,  551,
      549,  550,  542,  552,   51,   51,  546,  553,  554,   51,
      544,  555,  556,  558,  548,   51,   51,  559,   51,  557,

      547,  560,   51,   51,  567,   51,   51,   51,  550,  561,
      552,   51,  562,  568,  553,  554,  563,   51,  555,  556,
      558,  564,   51,   51,  559,   51,  557,  565,  560,  570,
      569,  572,  571,  573,   51,  566,  561,   51,   51,  562,
      584,  574,   51,  581,   51,   51,   51,   51,  632,   51,
       51,   51,  582,   51,  565,  583,  570,  569,  572,  571,
      573,  587,  566,   51,   51,  588,   51,  584,  574,  575,
      581,  600,  585,  576,   51,   51,  577,  586,   51,  582,
       51,  589,  583,  578,  579,   51,  580,   51,  587,  590,
      595,   51,  588,  591,  593,   51,  575,   51,  600,  592,

      576,   51,  594,  577,   51,   51,   51,   51,  589,  598,
      578,  579,  597,  580,   51,   51,  590,  595,  596,   51,
      591,  593,  599,  602,  601,  603,  592,  606,  604,  594,
      611,   51,  605,   51,   51,  607,  598,   51,  608,  597,
      609,   51,  612,   51,  610,  596,  613,   51,  614,   51,
       51,  601,  603,  615,  616,  604,   51,   51,   51,  605,
       51,   51,  607,  617,   51,  608,  619,  609,  618,  620,
       51,  610,   51,  621,   51,  614,  622,  623,   51,   51,
       51,  616,  624,  625,  635,   51,   51,   51,   51,   51,
      617,  626,   51,  628,  627,  618,  620,   51,   51,   51,

      621,   51,   51,  640,   51,   51,   51,  636,  713,  624,
      625,  635,  639,  642,   51,  629,  629,  629,  626,   51,
      628,  627,  630,  637,  638,   51,   51,  641,   51,  644,
      631,   51,   51,  643,  636,   51,   51,   51,  645,  639,
      642,   51,  647,   51,  649,   51,   51,   51,   51,  630,
      637,  638,  646,  651,  641,   51,  644,  631,  653,   51,
      643,  648,   51,  650,  654,  645,   51,  656,   51,  647,
       51,  649,  652,   51,  655,  657,  658,  659,  661,  646,
      651,   51,   51,   51,  662,   51,   51,   51,  648,   51,
      650,  654,   51,  667,  656,   51,  660,  669,   51,  652,

       51,  655,  657,  658,  659,  661,   51,   51,  663,  664,
      665,  662,  666,  670,   51,   51,  671,   51,   51,   51,
      667,  668,  672,  660,  669,   51,   51,   51,   51,  675,
      673,  676,  683,  674,  677,  663,  664,  665,  687,  666,
      670,   51,   51,  671,   51, 1093,  688,  684,  668,  672,
      685,   51,  686,   51,   51,   51,  675,  673,  676,  683,
      674,  677,  678,   51,  679,  689,   51,  690,  680,   51,
      681,  693,   51,  688,  684,  682,  691,  685,  697,  686,
       51,  696,  694,   51,  698,  701,   51,   51,  692,  678,
       51,  679,  695,   51,  690,  680,   51,  681,  693,   51,

       51,  699,  682,  691,   51,  697,  702,  703,  696,  694,
       51,  698,  700,   51,   51,  692,  704,   51,  705,  695,
       51,  706,  707,  708,   51,  712,  714,  709,  699,   51,
      710,  711,   51,  702,  703,   51,   51,  720,   51,  700,
      715,  721,  716,  704,   51,  705,   51,   51,  706,  717,
       51,   51,  712,  718,  709,  726,   51,  710,  711,   51,
      719,  725,   51,   51,  720,  723,  727,  715,  721,  716,
      722,   51,   51,  724,   51,  728,  717,   51,   51,   51,
      718,   51,  726,  729,  730,  731,  740,  719,  725,  732,
      734,  733,  723,   51,  736,   51,  737,  722,   51,   51,

      724,   51,  728,   51,  738,  739,  735,  741,   51,   51,
      729,  730,  731,   51,   51,  743,  732,  734,  733,   51,
       51,  736,  742,  744,  745,  745,  745,  745,  746,   51,
      748,   51,  739,  735,   51,   51,   51,   51,  747,  752,
      751,  753,  743,  633,   51,  633,  633,  754,  755,  742,
       51,  756,   51,   51,   51,  746,   51,  748,   51,  757,
      758,  761,   51,   51,  759,  747,  752,  751,  753,  760,
       51,  762,   51,  763,  754,  755,  764,  765,  756,  766,
      767,   51,  770,   51,  769,  768,  757,  758,  771,  774,
       51,   51,  772,  773,   51,  776,   51,   51,   51,   51,

      763,   51,   51,  764,  775,   51,  766,  777,  781,  770,
       51,  769,  778,   51,  783,  771,   51,  780,  782,  772,
      773,  784,   51,  785,  786,  787,   51,  790,   51,  788,
       51,  775,  779,   51,  791,   51,   51,   51,   51,  789,
       51,   51,   51,   51,  780,  782,  792,   51,  784,   51,
      785,  786,  787,  794,  790,   51,  788,   51,  793,  779,
       51,  791,  795,  796,  797,   51,  789,  799,  802,  800,
      798,   51,  801,  792,   51,  807,   51,   51,  804,   51,
      794,  803,   51,  805,   51,  793,   51,  808,  810,  795,
      796,  797,   51,   51,  799,  802,  800,  798,   51,  801,

       51,  806,   51,   51,  809,  804,  815,   51,  803,   51,
      805,  811,   51,  812,  808,  810,  816,   51,  813,   51,
      814,  817,   51,   51,   51,   51,  818,   51,  806,  820,
      821,  809,  822,  815,   51,  819,  829,  823,  811,  824,
      812,   51,   51,  816,  825,  813,  826,  814,   51,   51,
      828, 1184,   51,  818,  827,   51,  820,  830,   51,   51,
      834,  831,  819,   51,  823,   51,  832,   51,  835,   51,
       51,  825,   51,  826,   51,  836,   51,  828,  837,  838,
      833,  827,   51,  839,  830,   51,   51,  834,  831,  840,
      843,  841,   51,  832,  844,  835,   51,   51,  845,  850,

       51,   51,  842,  849,   51,  837,  838,  833,   51,   51,
      839,   51,  846,  847,   51,  848,  840,  843,  841,  851,
      852,  844,  853,  854,   51,  845,   51,   51,   51,  842,
      849,   51,  856,   51,  857,  858,  855,   51,   51,  846,
      847,   51,  848,  860,   51,   51,  851,  852,  864,  853,
      854,   51,  862,  749,   51,  749,  749,  866,   51,  856,
       51,  857,  858,  855,  744,  745,  745,  745,  745,  859,
      860,  861,  863,  865,  868,   51,   51,  867,   51,  862,
       51,   51,  871,  869,   51,  874,   51,  872,  873,  879,
       51,  870,  878,  880,   51,  887,  859,   51,  861,  863,

      865,  868,   51,  875,  867,   51,  876,   51,  881,  871,
      869,   51,  882,   51,  872,  873,  883,   51,  870,  878,
      877,  893,   51,  884,  889,   51,   51,   51,   51,   51,
      875,  885,  890,  876,  886,  881,  888,   51,   51,  882,
      894,  891,   51,  883,  892,   51,   51,  877,  893,   51,
      884,  895,   51,   51,   51,  896,  901,  898,  885,   51,
      897,  886,   51,  888,   51,   51,  903,  894,  891,   51,
      904,  892,   51,  909,  899,   51,  902,   51,  895,  900,
       51,  905,  896,   51,  898,   51,  906,  897,  911,   51,
      907,  908,   51,  903,  912,   51,  910,  904,  914,   51,

      909,  913,  915,  902,  917,   51,  916,   51,  905,  918,
      924,   51,  919,  906,   51,  922,   51,  907,  908,   51,
       51,  912,   51,  910,  920,   51,  921,   51,  913,  915,
       51,   51,  925,  916,  923,  927,  926,   51,   51,  919,
      928,   51,  922,   51,   51,   51,   51,  929,   51,  931,
      930,  920,   51,  921,  933,   51,   51,   51,  932,  925,
      935,  923,  927,  926,  934,  936,   51,  928,  937,  938,
      939,   51,   51,   51,  929,   51,  931,  930,   51,  940,
      942,  933,  941,  943,  945,  932,   51,  935,   51,   51,
      944,  934,  936,   51,  947,  937,  938,  951,   51,  946,

       51,  950,  949,   51,  948,   51,  940,  942,   51,  941,
      943,  945,   51,   51,   51,  952,   51,  944,   51,  958,
      953,  947,   51,  954,  955,   51,  946,   51,  950,  949,
      956,  948,   51,   51,  957,  959,   51,   51,  962,   51,
      960,  961,  952,   51,  964,   51,  958,  953,  965,   51,
      954,  955,   51,   51,  966,  968,  963,  956,  967,  970,
      969,  957,  959,  971,  972,  962,   51,  960,  961,   51,
       51,  976,  973,  974,  975,   51,   51,   51,   51,   51,
      978,   51,   51,  963,   51,  977,   51,  969,   51,  980,
      971,  972,   51,   51,   51,  979,   51,   51,  976,  973,

      974,  975,   51,  981,  982,   51,  983,  978,  985,  984,
       51,   51,  977,   51,   51,  986,  980,  987, 1184,  988,
       51,  989,  979,   51,  991,  993,  992,   51,   51,   51,
      981,  982,   51,  983,  994,  985,  984,   51,   51,   51,
      995,  990,  986,   51,  987,   51,  988,   51,  989,  996,
      997,  991,  993,  992,  998, 1000, 1006,  999,   51, 1001,
     1002,   51,   51, 1004, 1003, 1011,   51,  995,  990, 1007,
       51,   51,   51, 1005, 1009, 1008,   51,  997,   51,   51,
       51,  998,   51,   51,  999, 1014, 1001, 1002,   51,   51,
     1004, 1003,   51,   51, 1012,   51, 1007,   51, 1015, 1013,

     1005, 1009, 1008, 1010,   51,   51,   51, 1016, 1017,   51,
     1019,   51, 1014, 1021, 1020, 1024,   51, 1025, 1023, 1028,
       51, 1012,   51, 1022, 1018,   51, 1013,   51,   51,   51,
     1010,   51,   51, 1032, 1016, 1017,   51, 1019, 1026,   51,
     1021, 1020, 1027,   51, 1025, 1023, 1029,   51, 1030, 1031,
     1022, 1018, 1033, 1034,   51, 1035,   51, 1037, 1039, 1047,
       51,   51, 1036,   51,   51, 1026,   51, 1038, 1040, 1027,
       51,   51,   51, 1029,   51, 1030, 1031,   51,   51, 1033,
     1034,   51, 1035, 1042, 1037, 1041,   51,   51, 1043, 1036,
     1046,   51,   51, 1049, 1038, 1040,   51,   51, 1044, 1045,

       51,   51, 1051, 1048, 1050, 1052,   51, 1053, 1058, 1060,
     1042,   51, 1041,   51,   51, 1043, 1054, 1046, 1055, 1056,
     1049,   51,   51, 1062, 1057, 1044, 1045,   51, 1059, 1051,
     1048, 1050,   51,   51,   51,   51, 1063,   51,   51,   51,
       51,   51,   51, 1054,   51, 1055, 1056, 1061, 1064, 1065,
     1062, 1057, 1066, 1067,   51, 1059, 1068, 1069,   51, 1070,
     1071,   51, 1072, 1063,   51,   51,   51, 1073, 1075, 1074,
     1081, 1082,   51,   51, 1061, 1064, 1065, 1076, 1083, 1066,
     1078,   51,   51, 1068, 1069, 1080, 1070, 1079, 1088, 1085,
       51,   51,   51,   51, 1073, 1075, 1074, 1077, 1082,   51,

       51, 1084, 1086,   51,   51,   51,   51, 1078, 1087,   51,
       51,   51, 1080, 1089, 1079, 1088, 1085,   51, 1090,   51,
     1091,   51, 1094, 1092, 1077, 1095, 1096, 1101, 1084, 1086,
       51,   51, 1098, 1097, 1100, 1087,   51, 1106, 1102,   51,
     1089, 1099,   51,   51,   51,   51,   51, 1091,   51, 1094,
     1092, 1103, 1095, 1096, 1101, 1105,   51, 1104,   51,   51,
     1097, 1100, 1107, 1108, 1106,   51,   51, 1111, 1099,   51,
       51, 1114,   51, 1109,   51, 1112, 1115, 1116, 1103, 1117,
       51,   51, 1113,   51, 1104, 1119, 1110, 1118,   51, 1107,
     1108,   51, 1125,   51, 1111, 1120,   51,   51, 1114, 1123,

     1109, 1124, 1112, 1115, 1130,   51, 1117,   51,   51, 1113,
     1121,   51, 1119, 1110,   51,   51, 1122,   51, 1126,   51,
       51, 1127, 1120, 1128, 1129,   51, 1123, 1131, 1124, 1132,
     1134, 1136,   51,   51, 1133,   51, 1140, 1121,   51, 1143,
     1135,   51, 1138, 1122,   51, 1126, 1139,   51, 1127, 1142,
     1128, 1129,   51, 1141, 1145,   51, 1132, 1134, 1137,   51,
       51, 1133, 1144, 1146,   51,   51, 1143, 1135,   51,   51,
       51,   51, 1147, 1139,   51,   51, 1142, 1151, 1150,   51,
     1141, 1145, 1153, 1149,   51, 1137, 1148, 1152, 1159, 1144,
     1146,   51, 1167,   51,   51, 1154, 1155, 1156,   51, 1147,

       51, 1157,   51,   51, 1151, 1158,   51, 1160,   51, 1153,
     1149,   51,   51, 1148, 1164,   51,   51, 1165, 1168, 1173,
       51,   51, 1154, 1155, 1156,   51, 1166,   51, 1157, 1170,
       51, 1161, 1158, 1175, 1160, 1162, 1163,   51, 1169, 1171,
       51, 1164, 1176, 1172, 1165, 1168, 1173,   51,   51,   51,
     1174,   51, 1177, 1166,   51, 1178, 1170,   51, 1161, 1179,
     1181,   51, 1162, 1163,   51, 1169, 1171, 1182, 1180, 1176,
     1172, 1185, 1186,   51,   51, 1187, 1196, 1174, 1188, 1177,
       51, 1189, 1178,   51, 1190, 1193, 1191,   51,   51, 1195,
     1194,   51, 1192,   51, 1182, 1180,   51, 1199, 1185, 1186,

     1201, 1200,   51,   51,   51, 1188,   51,   51, 1189,   51,
       51, 1190, 1203, 1191, 1197, 1198, 1195, 1202,   51, 1192,
       51,   51,   51,   51, 1199, 1204,   51, 1205, 1200, 1206,
       51, 1208,   51,   51,   51, 1211, 1207, 1209,   51, 1203,
       51, 1197, 1198, 1210, 1202,   51, 1214,   51, 1212, 1213,
     1215,   51, 1204, 1216, 1205, 1217, 1222,   51, 1208,   51,
     1218, 1219, 1211, 1207, 1209,   51,   51,   51,   51,   51,
     1210, 1220,   51, 1214,   51, 1212, 1213, 1215,   51, 1221,
     1216, 1223, 1217,   51,   51, 1224, 1225, 1218, 1219,   51,
       51, 1226, 1227,   51, 1228,   51, 1229, 1230, 1220,   51,

       51,   51, 1231,   51, 1234, 1232, 1221, 1235, 1223,   51,
     1233, 1242, 1224, 1225,   51,   51, 1240, 1236, 1226, 1238,
       51, 1228,   51, 1229, 1230, 1237, 1239, 1241,   51,   51,
       51, 1234, 1244,   51, 1235,   51, 1245, 1246,   51,   51,
       51, 1249, 1253, 1240, 1236, 1243, 1238,   51,   51,   51,
     1251, 1247, 1237, 1239, 1241, 1248, 1250,   51,   51, 1244,
       51,   51,   51, 1245, 1246, 1252, 1256,   51,   51,   51,
       51, 1255, 1243,   51,   51, 1254, 1257, 1251, 1247,   51,
     1258, 1259, 1248, 1250, 1260, 1261, 1183,   51, 1183, 1183,
     1262,   51, 1252, 1256,   51,   51, 1263,   51, 1255, 1264,

       51, 1265, 1254, 1257,   51,   51, 1266, 1258, 1259, 1267,
     1271, 1260, 1261, 1268, 1270, 1269,   51, 1262, 1272, 1273,
       51,   51, 1274,   51,   51, 1275, 1264, 1279, 1265,   51,
       51, 1278,   51, 1266,   51,   51, 1276,   51,   51,   51,
     1268, 1270, 1269,   51,   51, 1272, 1273,   51, 1277, 1274,
     1280, 1282, 1275,   51, 1279,   51, 1281, 1283, 1278, 1284,
       51, 1285, 1286, 1276, 1288, 1299, 1287, 1289,   51,   51,
     1290,   51, 1291, 1293, 1300, 1277, 1294, 1292,   51,   51,
       51,   51, 1296, 1281,   51,   51, 1295,   51, 1285, 1297,
       51,   51,   51, 1287,   51,   51,   51, 1290,   51, 1291,

     1298,   51, 1301, 1294, 1292,   51,   51,   51,   51, 1296,
       51, 1302, 1303, 1295,   51,   51, 1297, 1304, 1305,   51,
     1306, 1307, 1309,   51, 1308, 1310,   51, 1298, 1311,   51,
       51,   51, 1314, 1312, 1318,   51,   51,   51, 1302, 1303,
     1313,   51,   51, 1323, 1304, 1305,   51, 1306, 1307, 1316,
       51, 1308, 1310,   51,   51, 1311, 1315,   51,   51, 1314,
     1312, 1317,   51, 1319,   51, 1320, 1321, 1313, 1322,   51,
     1323,   51, 1324, 1325, 1332,   51, 1316, 1328, 1330,   51,
     1327, 1326,   51, 1315, 1329,   51,   51, 1331, 1317, 1334,
     1319,   51, 1320,   51,   51,   51,   51, 1335,   51, 1324,

     1325, 1332, 1336,   51, 1328, 1330,   51, 1327, 1326,   51,
     1333, 1329,   51, 1337, 1331, 1338, 1340,   51, 1341,   51,
     1339, 1342, 1343, 1345, 1335, 1346,   51, 1344,   51, 1336,
       51, 1348, 1349,   51,   51,   51, 1347, 1333,   51, 1350,
     1337, 1351, 1338, 1352,   51, 1353,   51, 1339, 1342, 1343,
       51,   51, 1346,   51, 1344, 1354,   51, 1355,   51,   51,
       51,   51, 1356, 1347, 1357,   51, 1350,   51, 1351, 1359,
     1358,   51, 1353, 1361, 1362, 1360, 1364,   51,   51,   51,
       51,   51, 1354,   51, 1355, 1363,   51, 1365, 1366, 1356,
       51, 1357, 1367,   51, 1368, 1369, 1359, 1358,   51, 1372,

       51, 1370, 1360, 1364, 1371, 1373,   51,   51,   51, 1375,
       51,   51, 1363, 1374, 1365, 1366,   51, 1376, 1377,   51,
       51, 1368,   51,   51,   51,   51, 1378,   51, 1370,   51,
     1381, 1371, 1379,   51, 1380, 1382, 1383,   51, 1384, 1386,
     1374,   51, 1385, 1388, 1376, 1377, 1387, 1391,   51,   51,
      750,   51,   51, 1378,   51, 1389, 1390, 1381,   51, 1379,
       51, 1380, 1382, 1393,   51, 1392,   51,   51,   51, 1385,
     1397, 1402,   51, 1387, 1396,   51,   51,   51,   51, 1399,
       51,   51, 1389, 1390, 1398,   51, 1394, 1395,   51, 1401,
     1393,   51, 1392, 1400, 1406, 1403,   51, 1397,   51,   51,

       51, 1396, 1404, 1409,   51, 1407, 1399, 1405, 1411, 1408,
     1412, 1398, 1410, 1394, 1395,   51, 1401,   51,   51,   51,
     1400, 1406, 1403, 1413,   51,   51,   51,   51, 1415, 1417,
       51,   51, 1407,   51, 1405, 1411, 1408, 1412,   51, 1410,
     1414, 1416, 1418,   51, 1420, 1419,   51,   51, 1421, 1423,
     1413, 1422, 1424, 1425,   51, 1429,   51,   51, 1432,   51,
       51, 1426, 1427,   51,   51, 1428, 1430, 1414, 1416, 1433,
       51, 1420, 1419,   51,   51, 1435,   51,   51, 1422,   51,
       51,   51, 1429, 1431,   51, 1434,   51,   51, 1426, 1427,
     1436, 1437, 1428, 1430, 1439, 1440,   51,   51, 1438,   51,

     1442, 1443, 1435, 1441, 1444,   51,   51,   51, 1445,   51,
     1431, 1446, 1434,   51,   51, 1447,   51, 1436, 1437, 1448,
     1449, 1439, 1440, 1450,   51, 1438, 1451,   51, 1455,   51,
     1441, 1454,   51,   51,   51, 1452,   51, 1453, 1446,   51,
       51,   51, 1447, 1456,   51, 1457, 1448, 1449,   51, 1458,
     1450, 1460, 1464, 1451, 1459, 1455, 1462,   51, 1454,   51,
       51, 1463, 1452,   51, 1453, 1465, 1461,   51, 1466, 1468,
     1467,   51, 1457,   51,   51, 1470,   51,   51,   51,   51,
       51, 1459,   51, 1462, 1479, 1469, 1471, 1474, 1463, 1475,
       51, 1477, 1465, 1461, 1472, 1466, 1468, 1467,   51,   51,

       51, 1478, 1473,   51, 1476, 1485,   51, 1483,   51, 1480,
     1481, 1479, 1469, 1471, 1474, 1482, 1487,   51,   51,   51,
       51, 1472,   51,   51, 1488,   51, 1490, 1489, 1478, 1473,
       51, 1476, 1491,   51, 1483, 1484, 1480, 1481, 1486,   51,
       51,   51, 1482, 1494,   51,   51,   51, 1492,   51, 1495,
     1493, 1488,   51, 1490, 1489, 1498, 1496, 1497,   51, 1491,
     1499, 1500, 1484, 1501, 1506, 1486, 1502, 1503, 1505, 1507,
       51,   51,   51,   51, 1492,   51, 1495, 1493,   51,   51,
     1504,   51, 1498, 1496, 1497, 1513,   51,   51,   51,   51,
     1508,   51,   51, 1502, 1503, 1505, 1509,   51,   51,   51,

     1511, 1510,   51, 1512, 1514, 1515, 1517, 1504,   51, 1516,
     1520,   51, 1522,   51,   51,   51, 1523, 1508,   51,   51,
       51, 1527, 1518, 1509,   51,   51, 1524, 1511, 1510,   51,
     1512, 1514, 1515, 1517, 1519, 1525, 1516, 1520, 1521, 1522,
       51,   51, 1526,   51,   51, 1528, 1529, 1531, 1527, 1518,
     1536, 1530,   51, 1533,   51,   51, 1532, 1534, 1535, 1538,
     1539, 1519, 1537, 1540,   51, 1521,   51, 1541,   51, 1526,
       51,   51, 1528,   51, 1531,   51, 1542, 1536, 1530,   51,
     1533, 1543,  634, 1532,   51,   51,   51,   51, 1545, 1537,
     1540, 1544, 1546,   51, 1548,   51, 1547, 1549,   51, 1550,

     1551, 1553, 1552, 1554,   51, 1557,  750,   51, 1555,   51,
       51,   51,   51, 1561,   51, 1545,   51,   51, 1544, 1546,
       51, 1548,   51, 1547, 1556,   51, 1550,   51, 1553, 1552,
     1554, 1558, 1557,   51, 1559, 1555, 1563, 1560, 1564,   51,
     1562,   51, 1566, 1565,   51, 1567,   51, 1568, 1569, 1573,
       51, 1556,   51,   51,   51, 1570,   51,   51, 1558,   51,
       51, 1559, 1571, 1563, 1560,   51,   51, 1562,   51, 1566,
     1565, 1572, 1567,   51, 1568,   51,   51,   51,   51,   51,
       51,   51, 1570,  634,   51,   51,   51,   51,   51, 1571,
       51,   51,   51,   51,   51,   51,   51,   51, 1572,   36,

       36,   36,   36,   41,   41,   41,   41,   46,   46,   46,
       46,   54,   54,   51,   54,  108,  108,  113,  113,   55,
       55,   51,   55,   51,  114,  112,  111,  109,   51,  114,
      112,  111,  109,   51, 1574,    9, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,

     1574, 1574
    } ;

static const flex_int16_t yy_chk[4503] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    3,    3,    3,    4,
        4,    4,    5,    5,    5,    5,    6,    6,    6,    6,
        7,    7,    7,    8,    8,    8,   11, 1586,   19,   14,
       11,   14,   14,   72,   16,   20,   15,   22,   15,   40,

       40,   19, 1585,    3,   23,   15,    4,   32,   15, 1584,
        5,   15,   16,   20,    6,   19,   23,    7,   21,   22,
        8,   16,   20,   15,   22,   15,   72,   14,   21,   32,
       21,   23,   15,   52,   32,   15,   17,   52,   21, 1581,
       24,   21,   34,   17,   24,   21,   26,   17,   24,   31,
       17,   17,   26,   17,   34,   21, 1578,   21, 1573,   33,
       24,   33,   17,   17,   31,   21,   24,   24,  144,   34,
       17,   24,   31,   26,   17,   24,   31,   17,   17,   25,
       17,   18,   33,   49,   49,   18,   33,   24,   33,   18,
     1569,   31, 1564,   25,   18,   18,  144,   25,   18, 1561,

       35,   27,   35,   35,   28,   25,   25,   18,   18,   27,
      126,   58,   18,   60,   28,   27,   18,   28,   27,   58,
       25,   18,   18,   30,   25,   18,   28,   27,   27,  109,
      109,   28,   30,   29,   60, 1549,   27,   29,   58, 1543,
       60,   28,   27,  126,   28,   27, 1542,   30,   29,   45,
       30,   45,   45,   57,   51,   29,   51,   51,   57,   30,
       29,   59,   63,   54,   29,   54,   54,   62,   59,   61,
       66,   63,   64,   57,   62,   29,   66,   68,   65,   65,
       57,   67,   61,   73,   68,   57,   69, 1541,   59,   63,
       64,   65,   71,   70,   62,   73,   61,   66,   74,   64,

       71,   54,   79,   67,   68,   65,   65,   75,   67,   76,
       73,   69, 1538,   69,   70,   77, 1535,   81,   78,   71,
       70,   78,   78,   79,   74,   74,   80, 1534,   80,   79,
       75,   76,   77,   83,   75,   82,   76,   81,   82,   77,
       83,   84,   77,   85,   81,   87,   78,   86,   88,   89,
       90,   78,   87,   80,   84,   91,   89,   90,   85,   77,
       83,   86,   82,   95,   98,   98,   88,   93,   84,   95,
       85,   92,   87,   78,   86,   88,   89,   90,   91,   93,
       92, 1524,   91, 1523,  100,   96,  114,  114,  101, 1513,
       95,   98, 1507, 1506,   93,  100,  101, 1501,   92,   94,

       96, 1500,   94,   97, 1499,   99,  103,  104,   94,   94,
      102,  100,   96,   94,   97,  101,  104,   94,   97,   99,
       97,  102,  111,   94,  111,  111,   94,   97,  103,   94,
       97,   99,   99,  103,  104,   94,   94,  102,  105,  106,
       94,   97,  107, 1494,   94,   97,   99,   97,  106,  105,
      115,  116,  117,  118,  123,  107,  117,  121,  119,  120,
     1487,  122,  115,  116,  127,  105,  106,  119,  128,  107,
      140,  125,  118,  122, 1485,  124,  123,  115,  116,  117,
      118,  123,  120,  121,  121,  119,  120,  125,  122,  124,
      127,  127,  130,  129,  128,  128,  124,  131,  125,  129,

      132,  133,  124,  140,  131,  134,  141,  135,  136,  138,
      137, 1477,  133,  130,  142,  142,  124,  146,  132,  130,
      129,  136, 1475,  165,  131,  137, 1470,  132,  133,  135,
      134,  138,  134,  139,  135,  136,  138,  137,  139,  141,
      143,  145,  147,  148,  142,  151,  150, 1464,  149,  143,
      146,  147,  139,  145,  152,  149,  165,  154,  148,  139,
      139, 1460,  153,  151,  154,  139,  155,  143,  150,  147,
      158,  156,  151,  150,  145,  149,  148,  152,  156,  139,
      145,  152,  153,  160,  154,  148,  157,  155,  157,  153,
      159,  157,  158,  155,  161,  160,  159,  158,  156,  162,

      163,  164,  166,  173,  168,  162,  161,  167,  163,  168,
      160,  166,  169,  157,  164,  157,  170,  159,  171,  174,
      176,  161,  178,  172,  180,  171,  162,  163,  164,  166,
      167,  168,  172,  169,  167,  179,  173,  182,  170,  169,
      177,  182, 1458,  170,  176,  171,  180,  177,  183,  184,
      172,  180,  174,  176,  181,  178,  188,  177,  179,  186,
      189,  187,  179,  181,  182,  177,  186,  177,  188,  191,
      183,  176,  190,  189,  177,  183,  187,  192,  191,  193,
      196,  181,  184,  188,  177,  194,  186,  189,  187,  195,
      190,  198,  194,  200,  197,  192,  191,  199,  201,  190,

      196,  202,  203, 1456,  192,  193,  193,  196,  199,  203,
      205,  211,  194,  201,  195,  197,  195,  198,  198,  205,
      206,  197,  204,  207,  199,  201,  200,  208,  204,  203,
      209,  212,  207,  210,  202,  213,  208,  205,  216,  217,
      219, 1445,  209,  206,  211,  210,  215,  206,  217,  204,
      207,  215,  218,  219,  208,  220,  216,  209,  215,  221,
      210,  222,  219,  223,  212,  216,  217,  219,  213,  220,
      218,  224,  228,  215,  226,  225,  227,  221,  215,  218,
      219,  230,  220,  230,  223,  232,  221,  225,  229,  222,
      223,  231,  235,  232,  227,  233,  226,  234,  236,  224,

      228,  226,  225,  227,  234,  237,  229,  239,  230,  231,
      240,  241,  232,  243,  235,  229, 1444,  238,  231,  235,
      236,  233,  233,  242,  234,  236,  238,  238,  237,  239,
      244,  238,  237,  241,  239,  238,  249,  245,  241,  248,
      250,  242,  252,  240,  238, 1433,  243,  248,  244,  249,
      242,  251,  250,  238,  238,  257, 1432,  244,  238,  245,
      252, 1425,  356,  249,  245,  246,  248,  250,  247,  252,
      247,  264,  251,  256,  246,  246,  258,  367,  251,  246,
      246,  254,  246,  247,  264,  258,  247, 1424,  257,  246,
      356,  256,  246,  254,  247,  247,  254,  247,  264,  259,

      256,  246,  246,  258,  253,  367,  246,  246,  253,  246,
      247,  253,  255,  247,  254,  260,  261,  262,  253,  255,
      254,  265,  259,  254,  262,  255,  259,  260,  261,  253,
      263,  253,  255,  265,  266,  253,  268,  263,  253,  267,
      255,  269,  260,  261,  262,  253,  255,  270,  265,  273,
      273,  271,  255, 1423,  272,  275,  266,  263,  268,  255,
      267,  266, 1421,  268,  274,  272,  267,  269,  269,  271,
      274,  276,  277,  278,  279,  281, 1418,  275,  271,  273,
      270,  272,  275,  280,  276, 1417,  282,  285, 1415,  276,
      277,  274,  283,  286,  284,  279,  278,  281,  276,  277,

      278,  279,  281,  287,  288,  283,  280,  284,  287,  285,
      280,  276,  282,  282,  285,  286,  287,  288,  289,  283,
      286,  284,  290,  292,  291,  293,  294,  296,  293,  295,
      287,  288,  298, 1409,  298,  287,  289,  290,  304,  300,
      305, 1404,  307,  302,  312,  289,  291,  292,  294,  290,
      292,  291,  293,  294,  301,  295,  295,  300,  302,  298,
      296,  304,  306,  301,  307,  304,  300,  306,  308,  307,
      302,  309,  310,  305,  311,  313,  315,  312,  314,  315,
      310,  301, 1402,  317,  318,  311,  313,  319,  316,  306,
      317,  308,  320,  309,  315,  308,  319,  321,  309,  310,

      322,  311,  313,  315,  314,  314,  315,  316,  322,  318,
      317,  318,  321,  323,  319,  316,  324,  320,  325,  320,
      327,  326,  328,  329,  321,  330,  327,  322,  324,  326,
      332,  330,  331,  333, 1391,  334,  325,  334,  335,  338,
      337,  329,  332,  324,  328,  325,  323,  327,  326,  328,
      329,  338,  330,  336,  331,  333,  337,  332,  337,  331,
      333,  336,  334,  339,  335,  335,  338,  337,  342,  340,
      343,  341, 1386,  344,  339,  347,  349,  342,  352,  345,
      336,  340,  350,  337,  341,  343,  348,  343,  345,  350,
      339,  344,  349,  347,  343,  342,  340,  343,  341,  349,

      344,  354,  347,  349,  348,  351,  345,  355,  353,  350,
      357,  352,  343,  348,  343,  358,  360, 1384,  351,  349,
      353,  351,  362,  359,  354,  361,  364,  355,  354,  365,
      368,  351,  351,  363,  355,  353,  369,  358,  359,  370,
      364,  363,  358,  357,  365,  351,  361,  369,  351,  360,
      359,  371,  361,  364,  366,  362,  365,  372,  368,  366,
      363,  373,  376,  369,  374, 1383,  375,  370,  373,  378,
      379,  376,  377, 1375,  371,  380, 1373,  381,  371,  372,
      382, 1372,  378, 1369,  372,  379,  374,  366,  373,  376,
      380,  374,  375,  375,  377,  383,  378,  379,  384,  377,

      381,  383,  380,  382,  381,  385,  387,  382,  395,  386,
      388,  389,  394,  391,  392,  390,  384,  394, 1367,  389,
      385,  395,  383,  386,  388,  384,  390,  391,  387,  392,
      401,  388,  385,  387,  391,  395,  386,  388,  389,  396,
      391,  392,  390,  393, 1352,  394,  393,  397,  399,  398,
      400,  388,  396,  402,  391,  403,  405,  393,  404,  399,
     1349, 1348,  407,  401,  412,  404,  396,  407,  405,  397,
      393,  398,  400,  393,  397,  399,  398,  400,  406,  409,
      409,  410,  411,  405,  408,  404,  402,  406,  403,  407,
      413,  408,  412,  414,  415,  416,  413,  417,  414,  410,

      411,  418, 1340,  422,  417,  406,  409,  420,  410,  411,
      419,  408,  421,  416,  423,  420,  419,  413,  414,  418,
      421,  415,  416,  426,  417,  422,  414,  427,  418,  424,
      422,  423,  426,  425,  420,  428,  427,  419,  429,  421,
      425,  423,  432,  424,  428,  414,  429,  430,  431,  435,
      426,  437,  433,  441,  427,  434,  424,  433,  437,  438,
      425,  430,  428,  436,  432,  429,  431,  440,  434,  432,
      435,  438,  436,  439,  430,  431,  435,  441,  437,  443,
      441,  442,  434,  444,  439,  433,  438,  445,  446,  440,
      436,  447,  448,  450,  440,  445,  442,  451,  444,  449,

      439,  452,  449,  451,  458,  450,  446,  443,  442,  453,
      444,  448,  454,  459,  445,  446,  455,  447,  447,  448,
      450,  455, 1334,  453,  451,  452,  449,  457,  452,  461,
      460,  463,  462,  464,  454,  457,  453,  458,  460,  454,
      474,  465,  474,  470, 1322,  464,  459,  461,  521,  455,
      462,  457,  472,  463,  457,  473,  461,  460,  463,  462,
      464,  476,  457,  465,  473,  477,  470,  474,  465,  466,
      470,  489,  475,  466,  472,  521,  466,  475, 1321,  472,
      489,  478,  473,  466,  466,  476,  466,  477,  476,  479,
      484,  466,  477,  480,  482,  480,  466,  479,  489,  481,

      466,  481,  483,  466,  484,  475,  478,  482,  478,  487,
      466,  466,  486,  466,  486,  483,  479,  484,  485,  485,
      480,  482,  488,  491,  490,  492,  481,  495,  493,  483,
      501,  487,  494,  490, 1318,  496,  487,  493,  497,  486,
      498,  494,  502,  492,  500,  485,  503,  497,  504,  498,
      488,  490,  492,  505,  506,  493,  491,  504,  501,  494,
      495,  496,  496,  507,  500,  497,  509,  498,  508,  510,
      502,  500, 1309,  511, 1301,  504,  512,  512,  510,  503,
      506,  506,  513,  514,  523,  511,  505,  507, 1293, 1289,
      507,  515,  508,  518,  516,  508,  510, 1288,  523,  509,

      511,  516,  515,  528,  513,  514,  512,  524,  597,  513,
      514,  523,  527,  530,  518,  519,  519,  519,  515,  527,
      518,  516,  519,  525,  526,  524,  525,  529, 1286,  532,
      519,  528, 1284,  531,  524,  530,  529,  526,  533,  527,
      530,  597,  535, 1283,  537,  533,  519,  535,  532,  519,
      525,  526,  534,  539,  529,  531,  532,  519,  542,  534,
      531,  536,  539,  538,  543,  533,  537,  545,  536,  535,
      538,  537,  540,  540,  544,  546,  547,  548,  550,  534,
      539, 1282,  547, 1280,  552,  543,  542, 1267,  536,  545,
      538,  543,  548,  557,  545,  546,  549,  559,  544,  540,

      550,  544,  546,  547,  548,  550,  552,  549,  553,  554,
      555,  552,  556,  560,  557,  553,  561,  555,  554,  559,
      557,  558,  562,  549,  559,  560,  556,  562,  558,  565,
      563,  566,  569,  563,  567,  553,  554,  555,  572,  556,
      560,  567,  561,  561,  563,  997,  573,  569,  558,  562,
      570,  565,  571,  566,  569,  571,  565,  563,  566,  569,
      563,  567,  568,  570,  568,  574,  572,  575,  568,  573,
      568,  577,  997,  573,  569,  568,  576,  570,  580,  571,
      575,  579,  578,  577,  581,  584,  568, 1253,  576,  568,
     1242,  568,  578,  574,  575,  568,  579,  568,  577,  576,

      580,  582,  568,  576,  578,  580,  585,  587,  579,  578,
      581,  581,  583,  584,  582,  576,  588,  585,  589,  578,
      583,  590,  591,  592,  588,  596,  598,  593,  582,  587,
      594,  595,  590,  585,  587,  593,  589,  603,  594,  583,
      600,  604,  601,  588,  601,  589,  603,  596,  590,  602,
      591,  592,  596,  602,  593,  609,  595,  594,  595,  598,
      602,  608,  600,  604,  603,  606,  610,  600,  604,  601,
      605,  602,  605,  607,  606,  613,  602,  609,  613,  608,
      602,  607,  609,  614,  615,  616,  625,  602,  608,  617,
      619,  618,  606,  619,  621,  614,  622,  605,  616,  610,

      607,  617,  613,  618,  623,  624,  620,  626, 1233,  615,
      614,  615,  616,  620,  625,  628,  617,  619,  618,  621,
      624,  621,  627,  629,  629,  629,  629,  629,  630,  622,
      631, 1231,  624,  620, 1227,  626,  628,  623,  630,  636,
      635,  637,  628,  634,  627,  634,  634,  638,  639,  627,
      630,  641,  631,  641,  638,  630,  629,  631,  635,  642,
      643,  645,  637,  636,  644,  630,  636,  635,  637,  644,
      639,  646,  643,  647,  638,  639,  648,  649,  641,  650,
      651,  650,  654,  642,  652,  651,  642,  643,  655,  658,
      654,  647,  656,  657,  645,  660,  652,  644,  648,  646,

      647,  656,  657,  648,  659,  649,  650,  661,  664,  654,
      655,  652,  662,  651,  666,  655,  659,  663,  665,  656,
      657,  667,  658,  668,  669,  670,  665,  673,  660,  671,
      667,  659,  662,  669,  674,  661,  664,  670,  663,  672,
      662,  668,  666,  674,  663,  665,  675,  671,  667,  673,
      668,  669,  670,  677,  673,  675,  671,  672,  676,  662,
      676,  674,  678,  679,  680,  677,  672,  682,  685,  683,
      681, 1206,  684,  675, 1196,  692,  679,  680,  688,  682,
      677,  686, 1194,  690,  678,  676,  685,  693,  695,  678,
      679,  680,  681,  683,  682,  685,  683,  681,  684,  684,

      688,  691,  686,  692,  694,  688,  700,  693,  686,  690,
      690,  696,  695,  697,  693,  695,  702,  694,  698,  696,
      699,  703,  697,  691,  700,  698,  704,  699,  691,  706,
      709,  694,  710,  700,  704,  705,  716,  711,  696,  712,
      697, 1187,  702,  702,  713,  698,  714,  699,  705,  703,
      715, 1183,  713,  704,  714,  706,  706,  717,  715,  711,
      720,  718,  705,  709,  711,  710,  719,  712,  721,  716,
      717,  713,  714,  714,  718,  722,  721,  715,  723,  724,
      719,  714,  720,  725,  717, 1181,  724,  720,  718,  726,
      728,  727,  719,  719,  729,  721,  726,  725,  730,  735,

      723,  729,  727,  734,  730,  723,  724,  719,  722,  727,
      725,  728,  731,  732,  731,  733,  726,  728,  727,  736,
      737,  729,  738,  739,  734,  730,  732,  735,  733,  727,
      734,  737,  743,  738,  744,  746,  742,  736, 1179,  731,
      732,  739,  733,  748,  746,  748,  736,  737,  754,  738,
      739,  742,  752,  750,  743,  750,  750,  756,  744,  743,
      752,  744,  746,  742,  745,  745,  745,  745,  745,  747,
      748,  751,  753,  755,  758,  747,  754,  757,  751,  752,
      758,  753,  761,  759,  757,  766,  755,  763,  764,  770,
      756,  759,  769,  771,  759,  779,  747,  745,  751,  753,

      755,  758,  764,  767,  757,  769,  767,  761,  772,  761,
      759,  763,  773,  766,  763,  764,  774, 1175,  759,  769,
      767,  787,  770,  775,  782, 1167,  771,  767,  779,  772,
      767,  776,  784,  767,  776,  772,  780,  787,  773,  773,
      788,  785,  774,  774,  786,  776,  786,  767,  787,  775,
      775,  789,  782,  788,  780,  790,  794,  792,  776, 1152,
      791,  776,  785,  780,  792,  784,  796,  788,  785,  790,
      797,  786,  791,  802,  793,  789,  795,  797,  789,  793,
      802,  798,  790,  798,  792,  795,  799,  791,  804,  794,
      800,  801,  796,  796,  805,  799,  803,  797,  808,  800,

      802,  806,  809,  795,  811,  803,  810,  793,  798,  811,
      818,  801,  812,  799,  806,  815,  804,  800,  801,  805,
      812,  805,  810,  803,  813,  809,  814,  815,  806,  809,
     1138,  808,  819,  810,  816,  821,  820,  811,  818,  812,
      822,  816,  815,  821,  814,  820,  813,  823,  822,  826,
      825,  813,  825,  814,  828,  819,  823,  826,  827,  819,
      830,  816,  821,  820,  829,  831,  827,  822,  832,  833,
      834,  829,  831,  828,  823,  832,  826,  825,  833,  835,
      837,  828,  836,  838,  840,  827,  830,  830,  837,  836,
      839,  829,  831,  840,  842,  832,  833,  846,  835,  841,

     1131,  845,  844,  834,  843,  838,  835,  837, 1130,  836,
      838,  840,  841,  843,  844,  847,  839,  839,  842,  854,
      848,  842,  845,  849,  851,  846,  841,  848,  845,  844,
      852,  843,  849,  854,  853,  855,  847,  851,  858,  852,
      856,  857,  847,  853,  860,  858,  854,  848,  861,  856,
      849,  851,  857,  855,  862,  865,  859,  852,  863,  867,
      866,  853,  855,  868,  869,  858, 1125,  856,  857,  859,
      868,  873,  870,  871,  872, 1118,  869,  860, 1116,  871,
      876,  861,  862,  859,  866,  875,  863,  866,  865,  878,
      868,  869,  867,  870,  873,  877,  872,  875,  873,  870,

      871,  872,  876,  879,  880, 1105,  881,  876,  883,  882,
     1102,  878,  875,  877,  879,  884,  878,  885, 1093,  886,
     1090,  887,  877,  882,  888,  891,  890,  891,  880,  883,
      879,  880,  881,  881,  892,  883,  882,  886,  884,  888,
      893,  887,  884,  885,  885,  887,  886,  890,  887,  894,
      895,  888,  891,  890,  896,  898,  905,  897,  893,  899,
      901,  901,  892,  903,  902,  910, 1076,  893,  887,  906,
      899,  902,  895,  904,  908,  907,  906,  895, 1072,  896,
      897,  896,  894,  898,  897,  914,  899,  901,  903,  905,
      903,  902,  908,  910,  912,  904,  906,  907,  915,  913,

      904,  908,  907,  909, 1067,  909,  913,  916,  917,  912,
      919,  914,  914,  921,  920,  925, 1053,  926,  923,  929,
      921,  912,  920,  922,  917,  923,  913, 1052,  919,  916,
      909,  915,  917,  933,  916,  917,  922,  919,  927,  926,
      921,  920,  928,  925,  926,  923,  930,  929,  931,  932,
      922,  917,  934,  935,  930,  936,  927,  938,  940,  948,
      928,  932,  937, 1047,  938,  927,  933,  939,  941,  928,
      934, 1028,  931,  930,  939,  931,  932,  936,  935,  934,
      935,  937,  936,  943,  938,  942,  941,  948,  944,  937,
      947,  940,  943,  950,  939,  941,  942,  944,  945,  946,

      945,  947,  953,  949,  952,  954,  946,  955,  960,  962,
      943,  953,  942, 1024,  950,  944,  956,  947,  957,  958,
      950, 1011,  952,  964,  959,  945,  946,  949,  961,  953,
      949,  952,  959,  954,  961,  955,  965,  958,  956,  965,
      957,  960,  962,  956,  964,  957,  958,  963,  968,  969,
      964,  959,  970,  971,  963,  961,  972,  973,  968,  974,
      975,  969,  976,  965,  970,  972,  973,  977,  979,  978,
      984,  985,  974,  977,  963,  968,  969,  980,  986,  970,
      981,  971,  979,  972,  973,  983,  974,  982,  991,  988,
      976,  978,  985,  975,  977,  979,  978,  980,  985,  982,

      988,  987,  989,  984,  987,  980,  981,  981,  990,  983,
      991,  986,  983,  992,  982,  991,  988,  990,  993, 1000,
      995,  989,  998,  996,  980,  999, 1001, 1006,  987,  989,
     1001,  999, 1003, 1002, 1005,  990,  996, 1012, 1007,  992,
      992, 1004,  995, 1005,  998, 1002,  993,  995, 1006,  998,
      996, 1008,  999, 1001, 1006, 1010, 1004, 1009, 1008, 1012,
     1002, 1005, 1013, 1014, 1012, 1003, 1007, 1016, 1004, 1014,
     1009, 1018,  994, 1015, 1016, 1017, 1019, 1020, 1008, 1021,
     1013, 1021, 1017, 1010, 1009, 1023, 1015, 1022, 1019, 1013,
     1014, 1015, 1031, 1018, 1016, 1025,  967, 1017, 1018, 1029,

     1015, 1030, 1017, 1019, 1036, 1020, 1021, 1023, 1025, 1017,
     1026, 1026, 1023, 1015, 1029, 1022, 1027, 1027, 1032, 1030,
     1031, 1033, 1025, 1034, 1035, 1032, 1029, 1037, 1030, 1038,
     1040, 1042, 1036, 1035, 1039, 1033, 1046, 1026, 1034, 1050,
     1041, 1039, 1044, 1027, 1040, 1032, 1045, 1038, 1033, 1049,
     1034, 1035, 1041, 1048, 1054, 1037, 1038, 1040, 1043, 1050,
     1043, 1039, 1051, 1055, 1042, 1048, 1050, 1041, 1045, 1046,
     1044, 1049, 1056, 1045, 1051, 1054, 1049, 1060, 1059, 1056,
     1048, 1054, 1062, 1058, 1055, 1043, 1057, 1061, 1069, 1051,
     1055, 1058, 1077, 1057,  966, 1063, 1064, 1065, 1060, 1056,

     1062, 1066, 1064, 1065, 1060, 1068, 1066, 1070,  951, 1062,
     1058, 1059, 1068, 1057, 1073, 1061, 1063, 1074, 1078, 1082,
     1077, 1069, 1063, 1064, 1065, 1078, 1075, 1073, 1066, 1080,
     1070, 1071, 1068, 1084, 1070, 1071, 1071, 1082, 1079, 1081,
     1074, 1073, 1085, 1081, 1074, 1078, 1082, 1071, 1075, 1079,
     1083, 1080, 1086, 1075, 1081, 1087, 1080, 1083, 1071, 1088,
     1091, 1084, 1071, 1071, 1085, 1079, 1081, 1092, 1089, 1085,
     1081, 1094, 1095, 1087, 1086, 1096, 1106, 1083, 1097, 1086,
     1094, 1098, 1087, 1089, 1099, 1103, 1100, 1088, 1091, 1104,
     1103, 1097, 1101, 1092, 1092, 1089, 1095, 1109, 1094, 1095,

     1111, 1110, 1098, 1096, 1106, 1097, 1099, 1100, 1098, 1104,
     1101, 1099, 1113, 1100, 1107, 1108, 1104, 1112, 1103, 1101,
     1109, 1107, 1108, 1110, 1109, 1114, 1112, 1115, 1110, 1117,
     1113, 1120,  924, 1111, 1114, 1123, 1119, 1121, 1120, 1113,
     1115, 1107, 1108, 1122, 1112, 1119, 1127, 1123, 1124, 1126,
     1128,  918, 1114, 1129, 1115, 1132, 1137, 1117, 1120, 1121,
     1133, 1134, 1123, 1119, 1121, 1122, 1124, 1126, 1127, 1132,
     1122, 1135, 1128, 1127, 1129, 1124, 1126, 1128, 1133, 1136,
     1129, 1139, 1132, 1134, 1135, 1140, 1141, 1133, 1134, 1137,
     1139, 1142, 1143,  911, 1144,  900, 1145, 1146, 1135, 1140,

     1142, 1141, 1147, 1136, 1149, 1148, 1136, 1150, 1139, 1144,
     1148, 1158, 1140, 1141, 1145, 1146, 1156, 1151, 1142, 1154,
     1143, 1144, 1149, 1145, 1146, 1153, 1155, 1157, 1154, 1156,
     1147, 1149, 1160, 1150, 1150, 1151, 1161, 1162, 1148, 1158,
     1153, 1165, 1170, 1156, 1151, 1159, 1154, 1160, 1155, 1157,
     1168, 1163, 1153, 1155, 1157, 1164, 1166, 1159, 1161, 1160,
      889, 1162, 1164, 1161, 1162, 1169, 1173, 1169, 1166, 1168,
     1170, 1172, 1159, 1163, 1165, 1171, 1174, 1168, 1163, 1173,
     1176, 1177, 1164, 1166, 1178, 1180, 1184, 1171, 1184, 1184,
     1182, 1178, 1169, 1173, 1174, 1176, 1185, 1172, 1172, 1186,

     1180, 1188, 1171, 1174, 1182, 1177, 1189, 1176, 1177, 1190,
     1195, 1178, 1180, 1191, 1193, 1192,  874, 1182, 1197, 1198,
     1197, 1186, 1199, 1188, 1189, 1200, 1186, 1204, 1188, 1185,
     1192, 1203, 1204, 1189, 1200, 1193, 1201, 1190, 1198, 1191,
     1191, 1193, 1192, 1195, 1199, 1197, 1198, 1201, 1202, 1199,
     1205, 1208, 1200, 1203, 1204, 1202, 1207, 1209, 1203, 1210,
      864, 1211, 1212, 1201, 1214, 1225, 1213, 1215,  850, 1207,
     1216,  824, 1217, 1219, 1226, 1202, 1220, 1218, 1205, 1208,
     1213, 1211, 1222, 1207, 1220, 1209, 1221, 1210, 1211, 1223,
     1212, 1218, 1214, 1213, 1217, 1215, 1216, 1216, 1225, 1217,

     1224, 1219, 1228, 1220, 1218, 1221, 1222, 1226, 1224, 1222,
     1223, 1229, 1230, 1221, 1229, 1230, 1223, 1232, 1234, 1234,
     1235, 1236, 1238,  817, 1237, 1239, 1232, 1224, 1240,  807,
     1228, 1239, 1244, 1241, 1248, 1240, 1236,  783, 1229, 1230,
     1243, 1235, 1241, 1254, 1232, 1234, 1237, 1235, 1236, 1246,
     1238, 1237, 1239, 1243, 1244, 1240, 1245, 1246, 1245, 1244,
     1241, 1247, 1248, 1249, 1249, 1250, 1251, 1243, 1252, 1254,
     1254, 1250, 1255, 1256, 1263, 1247, 1246, 1259, 1261, 1255,
     1258, 1257,  781, 1245, 1260, 1263,  778, 1262, 1247, 1265,
     1249, 1256, 1250, 1259, 1251, 1257, 1252, 1266, 1258, 1255,

     1256, 1263, 1268, 1261, 1259, 1261, 1260, 1258, 1257, 1262,
     1264, 1260, 1266, 1269, 1262, 1270, 1272, 1265, 1273, 1264,
     1271, 1274, 1275, 1277, 1266, 1278, 1268, 1276, 1271, 1268,
     1275, 1281, 1285, 1270, 1274, 1269, 1279, 1264, 1278, 1287,
     1269, 1290, 1270, 1291, 1272, 1292,  777, 1271, 1274, 1275,
      768, 1273, 1278, 1276, 1276, 1294, 1277, 1295, 1279, 1281,
     1285, 1287, 1296, 1279, 1297, 1290, 1287, 1292, 1290, 1299,
     1298, 1291, 1292, 1302, 1303, 1300, 1305, 1294, 1298, 1295,
     1299, 1296, 1294, 1300, 1295, 1304,  765, 1306, 1307, 1296,
     1297, 1297, 1308,  762, 1310, 1311, 1299, 1298, 1305, 1314,

      760, 1312, 1300, 1305, 1313, 1315, 1302, 1303, 1306, 1317,
     1307, 1304, 1304, 1316, 1306, 1307, 1310, 1319, 1320, 1313,
     1308, 1310, 1312, 1311, 1316, 1320, 1323, 1314, 1312, 1319,
     1326, 1313, 1324, 1315, 1325, 1327, 1328, 1317, 1329, 1331,
     1316, 1325, 1330, 1333, 1319, 1320, 1332, 1337, 1327, 1323,
      749, 1324, 1326, 1323,  741, 1335, 1336, 1326,  740, 1324,
      708, 1325, 1327, 1339, 1328, 1338, 1329, 1331, 1330, 1330,
     1343, 1350, 1332, 1332, 1342, 1337, 1333, 1335, 1336, 1345,
     1338, 1342, 1335, 1336, 1344, 1339, 1341, 1341, 1343, 1347,
     1339, 1344, 1338, 1346, 1355, 1351, 1341, 1343, 1347, 1350,

     1346, 1342, 1353, 1358, 1345, 1356, 1345, 1354, 1360, 1357,
     1361, 1344, 1359, 1341, 1341, 1354, 1347, 1351, 1355,  707,
     1346, 1355, 1351, 1362, 1359, 1361, 1360, 1356, 1364, 1366,
     1353, 1358, 1356, 1357, 1354, 1360, 1357, 1361, 1362, 1359,
     1363, 1365, 1368,  701, 1371, 1370, 1371, 1363, 1374, 1377,
     1362, 1376, 1378, 1379,  689, 1385, 1364, 1366, 1389, 1365,
     1370, 1380, 1381, 1380, 1376, 1382, 1387, 1363, 1365, 1390,
     1368, 1371, 1370, 1387, 1381, 1393, 1374, 1377, 1376, 1385,
     1378, 1379, 1385, 1388, 1388, 1392, 1389, 1382, 1380, 1381,
     1394, 1395, 1382, 1387, 1397, 1398, 1394, 1390, 1396, 1393,

     1400, 1401, 1393, 1399, 1403,  687, 1397, 1392, 1405, 1399,
     1388, 1406, 1392, 1395, 1398, 1407, 1396, 1394, 1395, 1408,
     1410, 1397, 1398, 1411, 1411, 1396, 1412, 1406, 1419, 1410,
     1399, 1416, 1403, 1400, 1401, 1413, 1405, 1414, 1406, 1407,
     1419, 1408, 1407, 1420, 1416, 1422, 1408, 1410, 1412, 1426,
     1411, 1428, 1434, 1412, 1427, 1419, 1430, 1413, 1416, 1414,
     1427, 1431, 1413, 1430, 1414, 1435, 1429, 1422, 1436, 1438,
     1437, 1420, 1422, 1431, 1435, 1440, 1438, 1426, 1437, 1428,
     1434, 1427, 1429, 1430, 1450, 1439, 1441, 1443, 1431, 1446,
     1436, 1448, 1435, 1429, 1442, 1436, 1438, 1437, 1439, 1441,

     1443, 1449, 1442, 1440, 1447, 1457, 1450, 1454, 1449, 1451,
     1452, 1450, 1439, 1441, 1443, 1453, 1461, 1446, 1442, 1448,
     1447, 1442, 1451, 1452, 1462, 1454, 1465, 1463, 1449, 1442,
     1453, 1447, 1466, 1457, 1454, 1455, 1451, 1452, 1459, 1455,
     1463, 1466, 1453, 1469, 1461, 1459, 1462, 1467, 1465, 1471,
     1468, 1462, 1468, 1465, 1463, 1474, 1472, 1473, 1467, 1466,
     1476, 1478, 1455, 1479, 1484, 1459, 1480, 1481, 1483, 1486,
      653, 1469, 1471,  640, 1467, 1483, 1471, 1468, 1472, 1473,
     1482, 1474, 1474, 1472, 1473, 1493, 1480, 1481, 1476, 1478,
     1488, 1479, 1484, 1480, 1481, 1483, 1489, 1486, 1482, 1488,

     1491, 1490, 1491, 1492, 1495, 1496, 1498, 1482, 1490, 1497,
     1504, 1497, 1508, 1493, 1496, 1492, 1509, 1488, 1489, 1495,
     1498, 1514, 1502, 1489, 1504, 1508, 1510, 1491, 1490, 1502,
     1492, 1495, 1496, 1498, 1503, 1511, 1497, 1504, 1505, 1508,
     1505, 1503, 1512, 1514, 1509, 1515, 1516, 1518, 1514, 1502,
     1525, 1517, 1515, 1520, 1510, 1512, 1519, 1521, 1522, 1527,
     1528, 1503, 1526, 1529, 1525, 1505, 1518, 1530, 1511, 1512,
     1526, 1520, 1515, 1517, 1518, 1519, 1531, 1525, 1517, 1516,
     1520, 1532,  633, 1519, 1529, 1521, 1522, 1527, 1536, 1526,
     1529, 1533, 1537, 1528, 1540, 1530, 1539, 1544, 1533, 1545,

     1546, 1548, 1547, 1550, 1531, 1553,  632, 1545, 1551, 1532,
     1536, 1550, 1540, 1557, 1537, 1536, 1548, 1539, 1533, 1537,
     1547, 1540, 1551, 1539, 1552, 1544, 1545, 1553, 1548, 1547,
     1550, 1554, 1553, 1546, 1555, 1551, 1559, 1556, 1560, 1552,
     1558, 1557, 1563, 1562, 1559, 1565,  612, 1566, 1567, 1572,
     1563, 1552,  611, 1565,  599, 1568, 1555, 1554, 1554, 1556,
     1558, 1555, 1570, 1559, 1556, 1562, 1560, 1558,  586, 1563,
     1562, 1571, 1565, 1566, 1566, 1568, 1567, 1572,  564, 1571,
      551,  541, 1568,  522, 1570,  520,  517,  499,  471, 1570,
      469,  468,  467,  456,  346,  303,  299,  297, 1571, 1575,

     1575, 1575, 1575, 1576, 1576, 1576, 1576, 1577, 1577, 1577,
     1577, 1579, 1579,  214, 1579, 1580, 1580, 1582, 1582, 1583,
     1583,  185, 1583,  175,  113,  112,  110,  108,   50,   46,
       42,   41,   36,   10,    9, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574, 1574,

     1574, 1574
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

extern int yy_flex_debug;
int yy_flex_debug = 0;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
static int yy_more_flag = 0;
static int yy_more_len = 0;
#define yymore() ((yy_more_flag) = 1)
#define YY_MORE_ADJ (yy_more_len)
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#line 1 "configlexer.lex"
#line 2 "configlexer.lex"
/*
 * configlexer.lex - lexical analyzer for NSD config file
 *
 * Copyright (c) 2001-2006, NLnet Labs. All rights reserved
 *
 * See LICENSE for the license.
 *
 */
/* because flex keeps having sign-unsigned compare problems that are unfixed*/
#if defined(__clang__)||(defined(__GNUC__)&&((__GNUC__ >4)||(defined(__GNUC_MINOR__)&&(__GNUC__ ==4)&&(__GNUC_MINOR__ >=2))))
#pragma GCC diagnostic ignored "-Wsign-compare"
#endif
#include <ctype.h>
#include <errno.h>
#include <string.h>
#include <strings.h>
#ifdef HAVE_GLOB_H
# include <glob.h>
#endif

#include "options.h"
#include "configparser.h"

#if 0
#define LEXOUT(s)  printf s /* used ONLY when debugging */
#else
#define LEXOUT(s)
#endif

struct inc_state {
	char* filename;
	int line;
	YY_BUFFER_STATE buffer;
	struct inc_state* next;
};
static struct inc_state* config_include_stack = NULL;
static int inc_depth = 0;

static void config_start_include(const char* filename)
{
	FILE *input;
	struct inc_state* s;
	char* nm;
	if(inc_depth++ > 10000000) {
		c_error("too many include files");
		return;
	}
	if(strlen(filename) == 0) {
		c_error("empty include file name");
		return;
	}
	s = (struct inc_state*)malloc(sizeof(*s));
	if(!s) {
		c_error("include %s: malloc failure", filename);
		return;
	}
	nm = strdup(filename);
	if(!nm) {
		c_error("include %s: strdup failure", filename);
		free(s);
		return;
	}
	input = fopen(filename, "r");
	if(!input) {
		c_error("cannot open include file '%s': %s",
			filename, strerror(errno));
		free(s);
		free(nm);
		return;
	}
	LEXOUT(("switch_to_include_file(%s) ", filename));
	s->filename = cfg_parser->filename;
	s->line = cfg_parser->line;
	s->buffer = YY_CURRENT_BUFFER;
	s->next = config_include_stack;
	config_include_stack = s;

	cfg_parser->filename = nm;
	cfg_parser->line = 1;
	yy_switch_to_buffer(yy_create_buffer(input, YY_BUF_SIZE));
}

static void config_start_include_glob(const char* filename)
{
	/* check for wildcards */
#ifdef HAVE_GLOB
	glob_t g;
	int i, r, flags;
#endif /* HAVE_GLOB */
	if (cfg_parser->chroot) {
		int l = strlen(cfg_parser->chroot); /* chroot has trailing slash */
		if (strncmp(cfg_parser->chroot, filename, l) != 0) {
			c_error("include file '%s' is not relative to chroot '%s'",
				filename, cfg_parser->chroot);
			return;
		}
		filename += l - 1; /* strip chroot without trailing slash */
	}
#ifdef HAVE_GLOB
	if(!(!strchr(filename, '*') && !strchr(filename, '?') &&
		 !strchr(filename, '[') && !strchr(filename, '{') &&
		 !strchr(filename, '~'))) {
		 flags = 0
#ifdef GLOB_ERR
		 	 | GLOB_ERR
#endif
			 /* do not set GLOB_NOSORT so the results are sorted
			    and in a predictable order. */
#ifdef GLOB_BRACE
			 | GLOB_BRACE
#endif
#ifdef GLOB_TILDE
			 | GLOB_TILDE
#endif
		;
		memset(&g, 0, sizeof(g));
		r = glob(filename, flags, NULL, &g);
		if(r) {
			/* some error */
			globfree(&g);
			if(r == GLOB_NOMATCH)
				return; /* no matches for pattern */
			config_start_include(filename); /* let original deal with it */
			return;
		}
		/* process files found, if any */
		for(i=(int)g.gl_pathc-1; i>=0; i--) {
			config_start_include(g.gl_pathv[i]);
		}
		globfree(&g);
		return;
	}
#endif /* HAVE_GLOB */
	config_start_include(filename);
}

static void config_end_include(void)
{
	struct inc_state* s = config_include_stack;
	--inc_depth;
	if(!s) return;
	free(cfg_parser->filename);
	cfg_parser->filename = s->filename;
	cfg_parser->line = s->line;
	yy_delete_buffer(YY_CURRENT_BUFFER);
	yy_switch_to_buffer(s->buffer);
	config_include_stack = s->next;
	free(s);
}

#ifndef yy_set_bol /* compat definition, for flex 2.4.6 */
#define yy_set_bol(at_bol) \
        { \
	        if ( ! yy_current_buffer ) \
	                yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE ); \
	        yy_current_buffer->yy_ch_buf[0] = ((at_bol)?'\n':' '); \
        }
#endif

#line 2376 "<stdout>"
#define YY_NO_INPUT 1
#line 165 "configlexer.lex"
#ifndef YY_NO_UNPUT
#define YY_NO_UNPUT 1
#endif
#ifndef YY_NO_INPUT
#define YY_NO_INPUT 1
#endif
#line 2385 "<stdout>"

#line 2387 "<stdout>"

#define INITIAL 0
#define quotedstring 1
#define include 2
#define include_quoted 3

#ifndef YY_NO_UNISTD_H
/* Special case for "unistd.h", since it is non-ANSI. We include it way
 * down here because we want the user's section 1 to have been scanned first.
 * The user has a chance to override it with an option.
 */
#include <unistd.h>
#endif

#ifndef YY_EXTRA_TYPE
#define YY_EXTRA_TYPE void *
#endif

static int yy_init_globals ( void );

/* Accessor methods to globals.
   These are made visible to non-reentrant scanners for convenience. */

int yylex_destroy ( void );

int yyget_debug ( void );

void yyset_debug ( int debug_flag  );

YY_EXTRA_TYPE yyget_extra ( void );

void yyset_extra ( YY_EXTRA_TYPE user_defined  );

FILE *yyget_in ( void );

void yyset_in  ( FILE * _in_str  );

FILE *yyget_out ( void );

void yyset_out  ( FILE * _out_str  );

			int yyget_leng ( void );

char *yyget_text ( void );

int yyget_lineno ( void );

void yyset_lineno ( int _line_number  );

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap ( void );
#else
extern int yywrap ( void );
#endif
#endif

#ifndef YY_NO_UNPUT
    
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy ( char *, const char *, int );
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen ( const char * );
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int yyinput ( void );
#else
static int input ( void );
#endif

#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k */
#define YY_READ_BUF_SIZE 16384
#else
#define YY_READ_BUF_SIZE 8192
#endif /* __ia64__ */
#endif

/* Copy whatever the last rule matched to the standard output. */
#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO do { if (fwrite( yytext, (size_t) yyleng, 1, yyout )) {} } while (0)
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( YY_CURRENT_BUFFER_LVALUE->yy_is_interactive ) \
		{ \
		int c = '*'; \
		int n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else \
		{ \
		errno=0; \
		while ( (result = (int) fread(buf, 1, (yy_size_t) max_size, yyin)) == 0 && ferror(yyin)) \
			{ \
			if( errno != EINTR) \
				{ \
				YY_FATAL_ERROR( "input in flex scanner failed" ); \
				break; \
				} \
			errno=0; \
			clearerr(yyin); \
			} \
		}\
\

#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif

/* end tables serialization structures and prototypes */

/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL_IS_OURS 1

extern int yylex (void);

#define YY_DECL int yylex (void)
#endif /* !YY_DECL */

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK /*LINTED*/break;
#endif

#define YY_RULE_SETUP \
	YY_USER_ACTION

/** The main scanner function which does all the work.
 */
YY_DECL
{
	yy_state_type yy_current_state;
	char *yy_cp, *yy_bp;
	int yy_act;
    
	if ( !(yy_init) )
		{
		(yy_init) = 1;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! (yy_start) )
			(yy_start) = 1;	/* first start state */

		if ( ! yyin )
			yyin = stdin;

		if ( ! yyout )
			yyout = stdout;

		if ( ! YY_CURRENT_BUFFER ) {
			yyensure_buffer_stack ();
			YY_CURRENT_BUFFER_LVALUE =
				yy_create_buffer( yyin, YY_BUF_SIZE );
		}

		yy_load_buffer_state(  );
		}

	{
#line 183 "configlexer.lex"

#line 2607 "<stdout>"

	while ( /*CONSTCOND*/1 )		/* loops until end-of-file is reached */
		{
		(yy_more_len) = 0;
		if ( (yy_more_flag) )
			{
			(yy_more_len) = (int) ((yy_c_buf_p) - (yytext_ptr));
			(yy_more_flag) = 0;
			}
		yy_cp = (yy_c_buf_p);

		/* Support of yytext. */
		*yy_cp = (yy_hold_char);

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = (yy_start);
yy_match:
		do
			{
			YY_CHAR yy_c = yy_ec[YY_SC_TO_UI(*yy_cp)] ;
			if ( yy_accept[yy_current_state] )
				{
				(yy_last_accepting_state) = yy_current_state;
				(yy_last_accepting_cpos) = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 1575 )
					yy_c = yy_meta[yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 4436 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;

do_action:	/* This label is used only to access EOF actions. */

		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = (yy_hold_char);
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			goto yy_find_action;

case 1:
YY_RULE_SETUP
#line 184 "configlexer.lex"
{ LEXOUT(("SP ")); /* ignore */ }
	YY_BREAK
case 2:
YY_RULE_SETUP
#line 185 "configlexer.lex"
{ LEXOUT(("comment(%s) ", yytext)); /* ignore */ }
	YY_BREAK
case 3:
YY_RULE_SETUP
#line 186 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SERVER;}
	YY_BREAK
case 4:
YY_RULE_SETUP
#line 187 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_NAME;}
	YY_BREAK
case 5:
YY_RULE_SETUP
#line 188 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IP_ADDRESS;}
	YY_BREAK
case 6:
YY_RULE_SETUP
#line 189 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IP_ADDRESS;}
	YY_BREAK
case 7:
YY_RULE_SETUP
#line 190 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IP_TRANSPARENT;}
	YY_BREAK
case 8:
YY_RULE_SETUP
#line 191 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IP_FREEBIND;}
	YY_BREAK
case 9:
YY_RULE_SETUP
#line 192 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SEND_BUFFER_SIZE;}
	YY_BREAK
case 10:
YY_RULE_SETUP
#line 193 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RECEIVE_BUFFER_SIZE;}
	YY_BREAK
case 11:
YY_RULE_SETUP
#line 194 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DEBUG_MODE;}
	YY_BREAK
case 12:
YY_RULE_SETUP
#line 195 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_USE_SYSTEMD;}
	YY_BREAK
case 13:
YY_RULE_SETUP
#line 196 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_HIDE_VERSION;}
	YY_BREAK
case 14:
YY_RULE_SETUP
#line 197 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_HIDE_IDENTITY;}
	YY_BREAK
case 15:
YY_RULE_SETUP
#line 198 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DROP_UPDATES; }
	YY_BREAK
case 16:
YY_RULE_SETUP
#line 199 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IP4_ONLY;}
	YY_BREAK
case 17:
YY_RULE_SETUP
#line 200 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IP6_ONLY;}
	YY_BREAK
case 18:
YY_RULE_SETUP
#line 201 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DO_IP4;}
	YY_BREAK
case 19:
YY_RULE_SETUP
#line 202 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DO_IP6;}
	YY_BREAK
case 20:
YY_RULE_SETUP
#line 203 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DATABASE;}
	YY_BREAK
case 21:
YY_RULE_SETUP
#line 204 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IDENTITY;}
	YY_BREAK
case 22:
YY_RULE_SETUP
#line 205 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERSION;}
	YY_BREAK
case 23:
YY_RULE_SETUP
#line 206 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_NSID;}
	YY_BREAK
case 24:
YY_RULE_SETUP
#line 207 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_LOGFILE;}
	YY_BREAK
case 25:
YY_RULE_SETUP
#line 208 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_LOG_ONLY_SYSLOG;}
	YY_BREAK
case 26:
YY_RULE_SETUP
#line 209 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SERVER_COUNT;}
	YY_BREAK
case 27:
YY_RULE_SETUP
#line 210 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TCP_COUNT;}
	YY_BREAK
case 28:
YY_RULE_SETUP
#line 211 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TCP_REJECT_OVERFLOW;}
	YY_BREAK
case 29:
YY_RULE_SETUP
#line 212 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TCP_QUERY_COUNT;}
	YY_BREAK
case 30:
YY_RULE_SETUP
#line 213 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TCP_TIMEOUT;}
	YY_BREAK
case 31:
YY_RULE_SETUP
#line 214 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TCP_MSS;}
	YY_BREAK
case 32:
YY_RULE_SETUP
#line 215 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_OUTGOING_TCP_MSS;}
	YY_BREAK
case 33:
YY_RULE_SETUP
#line 216 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TCP_LISTEN_QUEUE;}
	YY_BREAK
case 34:
YY_RULE_SETUP
#line 217 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IPV4_EDNS_SIZE;}
	YY_BREAK
case 35:
YY_RULE_SETUP
#line 218 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IPV6_EDNS_SIZE;}
	YY_BREAK
case 36:
YY_RULE_SETUP
#line 219 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_PIDFILE;}
	YY_BREAK
case 37:
YY_RULE_SETUP
#line 220 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_PORT;}
	YY_BREAK
case 38:
YY_RULE_SETUP
#line 221 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_REUSEPORT;}
	YY_BREAK
case 39:
YY_RULE_SETUP
#line 222 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_STATISTICS;}
	YY_BREAK
case 40:
YY_RULE_SETUP
#line 223 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CHROOT;}
	YY_BREAK
case 41:
YY_RULE_SETUP
#line 224 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_USERNAME;}
	YY_BREAK
case 42:
YY_RULE_SETUP
#line 225 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONESDIR;}
	YY_BREAK
case 43:
YY_RULE_SETUP
#line 226 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONELISTFILE;}
	YY_BREAK
case 44:
YY_RULE_SETUP
#line 227 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DIFFFILE;}
	YY_BREAK
case 45:
YY_RULE_SETUP
#line 228 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XFRDFILE;}
	YY_BREAK
case 46:
YY_RULE_SETUP
#line 229 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XFRDIR;}
	YY_BREAK
case 47:
YY_RULE_SETUP
#line 230 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XFRD_RELOAD_TIMEOUT;}
	YY_BREAK
case 48:
YY_RULE_SETUP
#line 231 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERBOSITY;}
	YY_BREAK
case 49:
YY_RULE_SETUP
#line 232 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONE;}
	YY_BREAK
case 50:
YY_RULE_SETUP
#line 233 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONEFILE;}
	YY_BREAK
case 51:
YY_RULE_SETUP
#line 234 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONESTATS;}
	YY_BREAK
case 52:
YY_RULE_SETUP
#line 235 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ALLOW_NOTIFY;}
	YY_BREAK
case 53:
YY_RULE_SETUP
#line 236 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SIZE_LIMIT_XFR;}
	YY_BREAK
case 54:
YY_RULE_SETUP
#line 237 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_REQUEST_XFR;}
	YY_BREAK
case 55:
YY_RULE_SETUP
#line 238 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_NOTIFY;}
	YY_BREAK
case 56:
YY_RULE_SETUP
#line 239 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_NOTIFY_RETRY;}
	YY_BREAK
case 57:
YY_RULE_SETUP
#line 240 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_PROVIDE_XFR;}
	YY_BREAK
case 58:
YY_RULE_SETUP
#line 241 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ALLOW_QUERY;}
	YY_BREAK
case 59:
YY_RULE_SETUP
#line 242 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_OUTGOING_INTERFACE;}
	YY_BREAK
case 60:
YY_RULE_SETUP
#line 243 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ALLOW_AXFR_FALLBACK;}
	YY_BREAK
case 61:
YY_RULE_SETUP
#line 244 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH;}
	YY_BREAK
case 62:
YY_RULE_SETUP
#line 245 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH_DOMAIN_NAME;}
	YY_BREAK
case 63:
YY_RULE_SETUP
#line 246 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH_CLIENT_CERT;}
	YY_BREAK
case 64:
YY_RULE_SETUP
#line 247 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH_CLIENT_KEY;}
	YY_BREAK
case 65:
YY_RULE_SETUP
#line 248 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH_CLIENT_KEY_PW;}
	YY_BREAK
case 66:
YY_RULE_SETUP
#line 249 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_KEY;}
	YY_BREAK
case 67:
YY_RULE_SETUP
#line 250 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ALGORITHM;}
	YY_BREAK
case 68:
YY_RULE_SETUP
#line 251 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SECRET;}
	YY_BREAK
case 69:
YY_RULE_SETUP
#line 252 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_PATTERN;}
	YY_BREAK
case 70:
YY_RULE_SETUP
#line 253 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_INCLUDE_PATTERN;}
	YY_BREAK
case 71:
YY_RULE_SETUP
#line 254 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_REMOTE_CONTROL;}
	YY_BREAK
case 72:
YY_RULE_SETUP
#line 255 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CONTROL_ENABLE;}
	YY_BREAK
case 73:
YY_RULE_SETUP
#line 256 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CONTROL_INTERFACE;}
	YY_BREAK
case 74:
YY_RULE_SETUP
#line 257 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CONTROL_PORT;}
	YY_BREAK
case 75:
YY_RULE_SETUP
#line 258 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SERVER_KEY_FILE;}
	YY_BREAK
case 76:
YY_RULE_SETUP
#line 259 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_SERVER_CERT_FILE;}
	YY_BREAK
case 77:
YY_RULE_SETUP
#line 260 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CONTROL_KEY_FILE;}
	YY_BREAK
case 78:
YY_RULE_SETUP
#line 261 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CONTROL_CERT_FILE;}
	YY_BREAK
case 79:
YY_RULE_SETUP
#line 262 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_METRICS_ENABLE;}
	YY_BREAK
case 80:
YY_RULE_SETUP
#line 263 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_METRICS_INTERFACE;}
	YY_BREAK
case 81:
YY_RULE_SETUP
#line 264 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_METRICS_PORT;}
	YY_BREAK
case 82:
YY_RULE_SETUP
#line 265 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_METRICS_PATH;}
	YY_BREAK
case 83:
YY_RULE_SETUP
#line 266 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_AXFR;}
	YY_BREAK
case 84:
YY_RULE_SETUP
#line 267 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_UDP;}
	YY_BREAK
case 85:
YY_RULE_SETUP
#line 268 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_SIZE;}
	YY_BREAK
case 86:
YY_RULE_SETUP
#line 269 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_RATELIMIT;}
	YY_BREAK
case 87:
YY_RULE_SETUP
#line 270 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_SLIP;}
	YY_BREAK
case 88:
YY_RULE_SETUP
#line 271 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_IPV4_PREFIX_LENGTH;}
	YY_BREAK
case 89:
YY_RULE_SETUP
#line 272 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_IPV6_PREFIX_LENGTH;}
	YY_BREAK
case 90:
YY_RULE_SETUP
#line 273 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_WHITELIST_RATELIMIT;}
	YY_BREAK
case 91:
YY_RULE_SETUP
#line 274 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RRL_WHITELIST;}
	YY_BREAK
case 92:
YY_RULE_SETUP
#line 275 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_RELOAD_CONFIG; }
	YY_BREAK
case 93:
YY_RULE_SETUP
#line 276 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONEFILES_CHECK;}
	YY_BREAK
case 94:
YY_RULE_SETUP
#line 277 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ZONEFILES_WRITE;}
	YY_BREAK
case 95:
YY_RULE_SETUP
#line 278 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP;}
	YY_BREAK
case 96:
YY_RULE_SETUP
#line 279 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_ENABLE;}
	YY_BREAK
case 97:
YY_RULE_SETUP
#line 280 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_SOCKET_PATH; }
	YY_BREAK
case 98:
YY_RULE_SETUP
#line 281 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_IP; }
	YY_BREAK
case 99:
YY_RULE_SETUP
#line 282 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_TLS; }
	YY_BREAK
case 100:
YY_RULE_SETUP
#line 283 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_TLS_SERVER_NAME; }
	YY_BREAK
case 101:
YY_RULE_SETUP
#line 284 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_TLS_CERT_BUNDLE; }
	YY_BREAK
case 102:
YY_RULE_SETUP
#line 285 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_TLS_CLIENT_KEY_FILE; }
	YY_BREAK
case 103:
YY_RULE_SETUP
#line 286 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_TLS_CLIENT_CERT_FILE; }
	YY_BREAK
case 104:
YY_RULE_SETUP
#line 287 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_SEND_IDENTITY; }
	YY_BREAK
case 105:
YY_RULE_SETUP
#line 288 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_SEND_VERSION; }
	YY_BREAK
case 106:
YY_RULE_SETUP
#line 289 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_IDENTITY; }
	YY_BREAK
case 107:
YY_RULE_SETUP
#line 290 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_VERSION; }
	YY_BREAK
case 108:
YY_RULE_SETUP
#line 291 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_LOG_AUTH_QUERY_MESSAGES; }
	YY_BREAK
case 109:
YY_RULE_SETUP
#line 292 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_DNSTAP_LOG_AUTH_RESPONSE_MESSAGES; }
	YY_BREAK
case 110:
YY_RULE_SETUP
#line 293 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_LOG_TIME_ASCII;}
	YY_BREAK
case 111:
YY_RULE_SETUP
#line 294 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_LOG_TIME_ISO;}
	YY_BREAK
case 112:
YY_RULE_SETUP
#line 295 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ROUND_ROBIN;}
	YY_BREAK
case 113:
YY_RULE_SETUP
#line 296 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MINIMAL_RESPONSES;}
	YY_BREAK
case 114:
YY_RULE_SETUP
#line 297 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CONFINE_TO_ZONE;}
	YY_BREAK
case 115:
YY_RULE_SETUP
#line 298 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_REFUSE_ANY;}
	YY_BREAK
case 116:
YY_RULE_SETUP
#line 299 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MAX_REFRESH_TIME;}
	YY_BREAK
case 117:
YY_RULE_SETUP
#line 300 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MIN_REFRESH_TIME;}
	YY_BREAK
case 118:
YY_RULE_SETUP
#line 301 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MAX_RETRY_TIME;}
	YY_BREAK
case 119:
YY_RULE_SETUP
#line 302 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MIN_RETRY_TIME;}
	YY_BREAK
case 120:
YY_RULE_SETUP
#line 303 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MIN_EXPIRE_TIME;}
	YY_BREAK
case 121:
YY_RULE_SETUP
#line 304 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_STORE_IXFR;}
	YY_BREAK
case 122:
YY_RULE_SETUP
#line 305 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IXFR_SIZE;}
	YY_BREAK
case 123:
YY_RULE_SETUP
#line 306 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_IXFR_NUMBER;}
	YY_BREAK
case 124:
YY_RULE_SETUP
#line 307 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CREATE_IXFR;}
	YY_BREAK
case 125:
YY_RULE_SETUP
#line 308 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MULTI_PRIMARY_CHECK;}
	YY_BREAK
case 126:
YY_RULE_SETUP
#line 309 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_MULTI_PRIMARY_CHECK;}
	YY_BREAK
case 127:
YY_RULE_SETUP
#line 310 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_SERVICE_KEY;}
	YY_BREAK
case 128:
YY_RULE_SETUP
#line 311 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_SERVICE_OCSP;}
	YY_BREAK
case 129:
YY_RULE_SETUP
#line 312 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_SERVICE_PEM;}
	YY_BREAK
case 130:
YY_RULE_SETUP
#line 313 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_PORT;}
	YY_BREAK
case 131:
YY_RULE_SETUP
#line 314 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH_PORT;}
	YY_BREAK
case 132:
YY_RULE_SETUP
#line 315 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_AUTH_XFR_ONLY;}
	YY_BREAK
case 133:
YY_RULE_SETUP
#line 316 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_TLS_CERT_BUNDLE; }
	YY_BREAK
case 134:
YY_RULE_SETUP
#line 317 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_PROXY_PROTOCOL_PORT; }
	YY_BREAK
case 135:
YY_RULE_SETUP
#line 318 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ANSWER_COOKIE;}
	YY_BREAK
case 136:
YY_RULE_SETUP
#line 319 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_COOKIE_SECRET;}
	YY_BREAK
case 137:
YY_RULE_SETUP
#line 320 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_COOKIE_SECRET_FILE;}
	YY_BREAK
case 138:
YY_RULE_SETUP
#line 321 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_COOKIE_STAGING_SECRET;}
	YY_BREAK
case 139:
YY_RULE_SETUP
#line 322 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XFRD_TCP_MAX;}
	YY_BREAK
case 140:
YY_RULE_SETUP
#line 323 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XFRD_TCP_PIPELINE;}
	YY_BREAK
case 141:
YY_RULE_SETUP
#line 324 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFY; }
	YY_BREAK
case 142:
YY_RULE_SETUP
#line 325 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_ENABLE; }
	YY_BREAK
case 143:
YY_RULE_SETUP
#line 326 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFY_ZONE; }
	YY_BREAK
case 144:
YY_RULE_SETUP
#line 327 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFY_ZONES; }
	YY_BREAK
case 145:
YY_RULE_SETUP
#line 328 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFIER; }
	YY_BREAK
case 146:
YY_RULE_SETUP
#line 329 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFIER_COUNT; }
	YY_BREAK
case 147:
YY_RULE_SETUP
#line 330 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFIER_FEED_ZONE; }
	YY_BREAK
case 148:
YY_RULE_SETUP
#line 331 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_VERIFIER_TIMEOUT; }
	YY_BREAK
case 149:
YY_RULE_SETUP
#line 332 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CATALOG; }
	YY_BREAK
case 150:
YY_RULE_SETUP
#line 333 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CATALOG_MEMBER_PATTERN; }
	YY_BREAK
case 151:
YY_RULE_SETUP
#line 334 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CATALOG_PRODUCER_ZONE; }
	YY_BREAK
case 152:
YY_RULE_SETUP
#line 335 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XDP_INTERFACE; }
	YY_BREAK
case 153:
YY_RULE_SETUP
#line 336 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XDP_PROGRAM_PATH; }
	YY_BREAK
case 154:
YY_RULE_SETUP
#line 337 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XDP_PROGRAM_LOAD; }
	YY_BREAK
case 155:
YY_RULE_SETUP
#line 338 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XDP_BPFFS_PATH; }
	YY_BREAK
case 156:
YY_RULE_SETUP
#line 339 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XDP_FORCE_COPY; }
	YY_BREAK
case 157:
/* rule 157 can match eol */
YY_RULE_SETUP
#line 340 "configlexer.lex"
{ LEXOUT(("NL\n")); cfg_parser->line++;}
	YY_BREAK
case 158:
YY_RULE_SETUP
#line 342 "configlexer.lex"
{
	yyless(yyleng - (yyleng - 8));
	LEXOUT(("v(%s) ", yytext));
	return VAR_SERVERS;
}
	YY_BREAK
case 159:
YY_RULE_SETUP
#line 347 "configlexer.lex"
{
	yyless(yyleng - (yyleng - 13));
	LEXOUT(("v(%s) ", yytext));
	return VAR_BINDTODEVICE;
}
	YY_BREAK
case 160:
YY_RULE_SETUP
#line 352 "configlexer.lex"
{
	yyless(yyleng - (yyleng - 7));
	LEXOUT(("v(%s) ", yytext));
	return VAR_SETFIB;
}
	YY_BREAK
case 161:
YY_RULE_SETUP
#line 358 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_CPU_AFFINITY; }
	YY_BREAK
case 162:
YY_RULE_SETUP
#line 359 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); return VAR_XFRD_CPU_AFFINITY; }
	YY_BREAK
case 163:
YY_RULE_SETUP
#line 360 "configlexer.lex"
{
		char *str = yytext;
		LEXOUT(("v(%s) ", yytext));
		/* Skip server- */
		while (*str != '\0' && (*str < '0' || *str > '9')) {
			str++;
		}
		c_lval.llng = strtoll(str, NULL, 10);
		return VAR_SERVER_CPU_AFFINITY;
	}
	YY_BREAK
/* Quoted strings. Strip leading and ending quotes */
case 164:
YY_RULE_SETUP
#line 372 "configlexer.lex"
{ BEGIN(quotedstring); LEXOUT(("QS ")); }
	YY_BREAK
case YY_STATE_EOF(quotedstring):
#line 373 "configlexer.lex"
{
        c_error("EOF inside quoted string");
        BEGIN(INITIAL);
}
	YY_BREAK
case 165:
YY_RULE_SETUP
#line 377 "configlexer.lex"
{ LEXOUT(("STR(%s) ", yytext)); yymore(); }
	YY_BREAK
case 166:
/* rule 166 can match eol */
YY_RULE_SETUP
#line 378 "configlexer.lex"
{ cfg_parser->line++; yymore(); }
	YY_BREAK
case 167:
YY_RULE_SETUP
#line 379 "configlexer.lex"
{
        LEXOUT(("QE "));
        BEGIN(INITIAL);
        yytext[yyleng - 1] = '\0';
	c_lval.str = region_strdup(cfg_parser->opt->region, yytext);
        return STRING;
}
	YY_BREAK
/* include: directive */
case 168:
YY_RULE_SETUP
#line 388 "configlexer.lex"
{ LEXOUT(("v(%s) ", yytext)); BEGIN(include); }
	YY_BREAK
case YY_STATE_EOF(include):
#line 389 "configlexer.lex"
{
        c_error("EOF inside include directive");
        BEGIN(INITIAL);
}
	YY_BREAK
case 169:
YY_RULE_SETUP
#line 393 "configlexer.lex"
{ LEXOUT(("ISP ")); /* ignore */ }
	YY_BREAK
case 170:
/* rule 170 can match eol */
YY_RULE_SETUP
#line 394 "configlexer.lex"
{ LEXOUT(("NL\n")); cfg_parser->line++;}
	YY_BREAK
case 171:
YY_RULE_SETUP
#line 395 "configlexer.lex"
{ LEXOUT(("IQS ")); BEGIN(include_quoted); }
	YY_BREAK
case 172:
YY_RULE_SETUP
#line 396 "configlexer.lex"
{
	LEXOUT(("Iunquotedstr(%s) ", yytext));
	config_start_include_glob(yytext);
	BEGIN(INITIAL);
}
	YY_BREAK
case YY_STATE_EOF(include_quoted):
#line 401 "configlexer.lex"
{
        c_error("EOF inside quoted string");
        BEGIN(INITIAL);
}
	YY_BREAK
case 173:
YY_RULE_SETUP
#line 405 "configlexer.lex"
{ LEXOUT(("ISTR(%s) ", yytext)); yymore(); }
	YY_BREAK
case 174:
/* rule 174 can match eol */
YY_RULE_SETUP
#line 406 "configlexer.lex"
{ cfg_parser->line++; yymore(); }
	YY_BREAK
case 175:
YY_RULE_SETUP
#line 407 "configlexer.lex"
{
	LEXOUT(("IQE "));
	yytext[yyleng - 1] = '\0';
	config_start_include_glob(yytext);
	BEGIN(INITIAL);
}
	YY_BREAK
case YY_STATE_EOF(INITIAL):
#line 413 "configlexer.lex"
{
	yy_set_bol(1); /* Set beginning of line, so "^" rules match.  */
	if (!config_include_stack) {
		yyterminate();
	} else {
		fclose(yyin);
		config_end_include();
	}
}
	YY_BREAK
case 176:
YY_RULE_SETUP
#line 423 "configlexer.lex"
{ LEXOUT(("unquotedstr(%s) ", yytext)); 
			c_lval.str = region_strdup(cfg_parser->opt->region, yytext); return STRING; }
	YY_BREAK
case 177:
YY_RULE_SETUP
#line 426 "configlexer.lex"
ECHO;
	YY_BREAK
#line 3631 "<stdout>"

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - (yytext_ptr)) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = (yy_hold_char);
		YY_RESTORE_YY_MORE_OFFSET

		if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between YY_CURRENT_BUFFER and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
			YY_CURRENT_BUFFER_LVALUE->yy_input_file = yyin;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( (yy_c_buf_p) <= &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			(yy_c_buf_p) = (yytext_ptr) + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state(  );

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state );

			yy_bp = (yytext_ptr) + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++(yy_c_buf_p);
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = (yy_c_buf_p);
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer(  ) )
			{
			case EOB_ACT_END_OF_FILE:
				{
				(yy_did_buffer_switch_on_eof) = 0;

				if ( yywrap(  ) )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					(yy_c_buf_p) = (yytext_ptr) + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				(yy_c_buf_p) =
					(yytext_ptr) + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				(yy_c_buf_p) =
				&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)];

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of user's declarations */
} /* end of yylex */

/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */
static int yy_get_next_buffer (void)
{
    	char *dest = YY_CURRENT_BUFFER_LVALUE->yy_ch_buf;
	char *source = (yytext_ptr);
	int number_to_move, i;
	int ret_val;

	if ( (yy_c_buf_p) > &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( YY_CURRENT_BUFFER_LVALUE->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( (yy_c_buf_p) - (yytext_ptr) - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (int) ((yy_c_buf_p) - (yytext_ptr) - 1);

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars) = 0;

	else
		{
			int num_to_read =
			YY_CURRENT_BUFFER_LVALUE->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = YY_CURRENT_BUFFER_LVALUE;

			int yy_c_buf_p_offset =
				(int) ((yy_c_buf_p) - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				int new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yyrealloc( (void *) b->yy_ch_buf,
							 (yy_size_t) (b->yy_buf_size + 2)  );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = NULL;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			(yy_c_buf_p) = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = YY_CURRENT_BUFFER_LVALUE->yy_buf_size -
						number_to_move - 1;

			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[number_to_move]),
			(yy_n_chars), num_to_read );

		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	if ( (yy_n_chars) == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( yyin  );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	if (((yy_n_chars) + number_to_move) > YY_CURRENT_BUFFER_LVALUE->yy_buf_size) {
		/* Extend the array by 50%, plus the number we really need. */
		int new_size = (yy_n_chars) + number_to_move + ((yy_n_chars) >> 1);
		YY_CURRENT_BUFFER_LVALUE->yy_ch_buf = (char *) yyrealloc(
			(void *) YY_CURRENT_BUFFER_LVALUE->yy_ch_buf, (yy_size_t) new_size  );
		if ( ! YY_CURRENT_BUFFER_LVALUE->yy_ch_buf )
			YY_FATAL_ERROR( "out of dynamic memory in yy_get_next_buffer()" );
		/* "- 2" to take care of EOB's */
		YY_CURRENT_BUFFER_LVALUE->yy_buf_size = (int) (new_size - 2);
	}

	(yy_n_chars) += number_to_move;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] = YY_END_OF_BUFFER_CHAR;

	(yytext_ptr) = &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[0];

	return ret_val;
}

/* yy_get_previous_state - get the state just before the EOB char was reached */

    static yy_state_type yy_get_previous_state (void)
{
	yy_state_type yy_current_state;
	char *yy_cp;
    
	yy_current_state = (yy_start);

	for ( yy_cp = (yytext_ptr) + YY_MORE_ADJ; yy_cp < (yy_c_buf_p); ++yy_cp )
		{
		YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 1);
		if ( yy_accept[yy_current_state] )
			{
			(yy_last_accepting_state) = yy_current_state;
			(yy_last_accepting_cpos) = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 1575 )
				yy_c = yy_meta[yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
		}

	return yy_current_state;
}

/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */
    static yy_state_type yy_try_NUL_trans  (yy_state_type yy_current_state )
{
	int yy_is_jam;
    	char *yy_cp = (yy_c_buf_p);

	YY_CHAR yy_c = 1;
	if ( yy_accept[yy_current_state] )
		{
		(yy_last_accepting_state) = yy_current_state;
		(yy_last_accepting_cpos) = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 1575 )
			yy_c = yy_meta[yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
	yy_is_jam = (yy_current_state == 1574);

		return yy_is_jam ? 0 : yy_current_state;
}

#ifndef YY_NO_UNPUT

#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
    static int yyinput (void)
#else
    static int input  (void)
#endif

{
	int c;
    
	*(yy_c_buf_p) = (yy_hold_char);

	if ( *(yy_c_buf_p) == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( (yy_c_buf_p) < &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			/* This was really a NUL. */
			*(yy_c_buf_p) = '\0';

		else
			{ /* need more input */
			int offset = (int) ((yy_c_buf_p) - (yytext_ptr));
			++(yy_c_buf_p);

			switch ( yy_get_next_buffer(  ) )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( yyin );

					/*FALLTHROUGH*/

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap(  ) )
						return 0;

					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput();
#else
					return input();
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					(yy_c_buf_p) = (yytext_ptr) + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) (yy_c_buf_p);	/* cast for 8-bit char's */
	*(yy_c_buf_p) = '\0';	/* preserve yytext */
	(yy_hold_char) = *++(yy_c_buf_p);

	return c;
}
#endif	/* ifndef YY_NO_INPUT */

/** Immediately switch to a different input stream.
 * @param input_file A readable stream.
 * 
 * @note This function does not reset the start condition to @c INITIAL .
 */
    void yyrestart  (FILE * input_file )
{
    
	if ( ! YY_CURRENT_BUFFER ){
        yyensure_buffer_stack ();
		YY_CURRENT_BUFFER_LVALUE =
            yy_create_buffer( yyin, YY_BUF_SIZE );
	}

	yy_init_buffer( YY_CURRENT_BUFFER, input_file );
	yy_load_buffer_state(  );
}

/** Switch to a different input buffer.
 * @param new_buffer The new input buffer.
 * 
 */
    void yy_switch_to_buffer  (YY_BUFFER_STATE  new_buffer )
{
    
	/* TODO. We should be able to replace this entire function body
	 * with
	 *		yypop_buffer_state();
	 *		yypush_buffer_state(new_buffer);
     */
	yyensure_buffer_stack ();
	if ( YY_CURRENT_BUFFER == new_buffer )
		return;

	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	YY_CURRENT_BUFFER_LVALUE = new_buffer;
	yy_load_buffer_state(  );

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	(yy_did_buffer_switch_on_eof) = 1;
}

static void yy_load_buffer_state  (void)
{
    	(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
	(yytext_ptr) = (yy_c_buf_p) = YY_CURRENT_BUFFER_LVALUE->yy_buf_pos;
	yyin = YY_CURRENT_BUFFER_LVALUE->yy_input_file;
	(yy_hold_char) = *(yy_c_buf_p);
}

/** Allocate and initialize an input buffer state.
 * @param file A readable stream.
 * @param size The character buffer size in bytes. When in doubt, use @c YY_BUF_SIZE.
 * 
 * @return the allocated buffer state.
 */
    YY_BUFFER_STATE yy_create_buffer  (FILE * file, int  size )
{
	YY_BUFFER_STATE b;
    
	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yyalloc( (yy_size_t) (b->yy_buf_size + 2)  );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file );

	return b;
}

/** Destroy the buffer.
 * @param b a buffer created with yy_create_buffer()
 * 
 */
    void yy_delete_buffer (YY_BUFFER_STATE  b )
{
    
	if ( ! b )
		return;

	if ( b == YY_CURRENT_BUFFER ) /* Not sure if we should pop here. */
		YY_CURRENT_BUFFER_LVALUE = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yyfree( (void *) b->yy_ch_buf  );

	yyfree( (void *) b  );
}

/* Initializes or reinitializes a buffer.
 * This function is sometimes called more than once on the same buffer,
 * such as during a yyrestart() or at EOF.
 */
    static void yy_init_buffer  (YY_BUFFER_STATE  b, FILE * file )

{
	int oerrno = errno;
    
	yy_flush_buffer( b );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

    /* If b is the current buffer, then yy_init_buffer was _probably_
     * called from yyrestart() or through yy_get_next_buffer.
     * In that case, we don't want to reset the lineno or column.
     */
    if (b != YY_CURRENT_BUFFER){
        b->yy_bs_lineno = 1;
        b->yy_bs_column = 0;
    }

        b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
    
	errno = oerrno;
}

/** Discard all buffered characters. On the next scan, YY_INPUT will be called.
 * @param b the buffer state to be flushed, usually @c YY_CURRENT_BUFFER.
 * 
 */
    void yy_flush_buffer (YY_BUFFER_STATE  b )
{
    	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == YY_CURRENT_BUFFER )
		yy_load_buffer_state(  );
}

/** Pushes the new state onto the stack. The new state becomes
 *  the current state. This function will allocate the stack
 *  if necessary.
 *  @param new_buffer The new state.
 *  
 */
void yypush_buffer_state (YY_BUFFER_STATE new_buffer )
{
    	if (new_buffer == NULL)
		return;

	yyensure_buffer_stack();

	/* This block is copied from yy_switch_to_buffer. */
	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	/* Only push if top exists. Otherwise, replace top. */
	if (YY_CURRENT_BUFFER)
		(yy_buffer_stack_top)++;
	YY_CURRENT_BUFFER_LVALUE = new_buffer;

	/* copied from yy_switch_to_buffer. */
	yy_load_buffer_state(  );
	(yy_did_buffer_switch_on_eof) = 1;
}

/** Removes and deletes the top of the stack, if present.
 *  The next element becomes the new top.
 *  
 */
void yypop_buffer_state (void)
{
    	if (!YY_CURRENT_BUFFER)
		return;

	yy_delete_buffer(YY_CURRENT_BUFFER );
	YY_CURRENT_BUFFER_LVALUE = NULL;
	if ((yy_buffer_stack_top) > 0)
		--(yy_buffer_stack_top);

	if (YY_CURRENT_BUFFER) {
		yy_load_buffer_state(  );
		(yy_did_buffer_switch_on_eof) = 1;
	}
}

/* Allocates the stack if it does not exist.
 *  Guarantees space for at least one push.
 */
static void yyensure_buffer_stack (void)
{
	yy_size_t num_to_alloc;
    
	if (!(yy_buffer_stack)) {

		/* First allocation is just for 2 elements, since we don't know if this
		 * scanner will even need a stack. We use 2 instead of 1 to avoid an
		 * immediate realloc on the next call.
         */
      num_to_alloc = 1; /* After all that talk, this was set to 1 anyways... */
		(yy_buffer_stack) = (struct yy_buffer_state**)yyalloc
								(num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		memset((yy_buffer_stack), 0, num_to_alloc * sizeof(struct yy_buffer_state*));

		(yy_buffer_stack_max) = num_to_alloc;
		(yy_buffer_stack_top) = 0;
		return;
	}

	if ((yy_buffer_stack_top) >= ((yy_buffer_stack_max)) - 1){

		/* Increase the buffer to prepare for a possible push. */
		yy_size_t grow_size = 8 /* arbitrary grow size */;

		num_to_alloc = (yy_buffer_stack_max) + grow_size;
		(yy_buffer_stack) = (struct yy_buffer_state**)yyrealloc
								((yy_buffer_stack),
								num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		/* zero only the new slots.*/
		memset((yy_buffer_stack) + (yy_buffer_stack_max), 0, grow_size * sizeof(struct yy_buffer_state*));
		(yy_buffer_stack_max) = num_to_alloc;
	}
}

/** Setup the input buffer state to scan directly from a user-specified character buffer.
 * @param base the character buffer
 * @param size the size in bytes of the character buffer
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_buffer  (char * base, yy_size_t  size )
{
	YY_BUFFER_STATE b;
    
	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return NULL;

	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = (int) (size - 2);	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = NULL;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_is_interactive = 0;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b  );

	return b;
}

/** Setup the input buffer state to scan a string. The next call to yylex() will
 * scan from a @e copy of @a str.
 * @param yystr a NUL-terminated string to scan
 * 
 * @return the newly allocated buffer state object.
 * @note If you want to scan bytes that may contain NUL values, then use
 *       yy_scan_bytes() instead.
 */
YY_BUFFER_STATE yy_scan_string (const char * yystr )
{
    
	return yy_scan_bytes( yystr, (int) strlen(yystr) );
}

/** Setup the input buffer state to scan the given bytes. The next call to yylex() will
 * scan from a @e copy of @a bytes.
 * @param yybytes the byte buffer to scan
 * @param _yybytes_len the number of bytes in the buffer pointed to by @a bytes.
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_bytes  (const char * yybytes, int  _yybytes_len )
{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	int i;
    
	/* Get memory for full buffer, including space for trailing EOB's. */
	n = (yy_size_t) (_yybytes_len + 2);
	buf = (char *) yyalloc( n  );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < _yybytes_len; ++i )
		buf[i] = yybytes[i];

	buf[_yybytes_len] = buf[_yybytes_len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n );
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
}

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

static void yynoreturn yy_fatal_error (const char* msg )
{
			fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
}

/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		yytext[yyleng] = (yy_hold_char); \
		(yy_c_buf_p) = yytext + yyless_macro_arg; \
		(yy_hold_char) = *(yy_c_buf_p); \
		*(yy_c_buf_p) = '\0'; \
		yyleng = yyless_macro_arg; \
		} \
	while ( 0 )

/* Accessor  methods (get/set functions) to struct members. */

/** Get the current line number.
 * 
 */
int yyget_lineno  (void)
{
    
    return yylineno;
}

/** Get the input stream.
 * 
 */
FILE *yyget_in  (void)
{
        return yyin;
}

/** Get the output stream.
 * 
 */
FILE *yyget_out  (void)
{
        return yyout;
}

/** Get the length of the current token.
 * 
 */
int yyget_leng  (void)
{
        return yyleng;
}

/** Get the current token.
 * 
 */

char *yyget_text  (void)
{
        return yytext;
}

/** Set the current line number.
 * @param _line_number line number
 * 
 */
void yyset_lineno (int  _line_number )
{
    
    yylineno = _line_number;
}

/** Set the input stream. This does not discard the current
 * input buffer.
 * @param _in_str A readable stream.
 * 
 * @see yy_switch_to_buffer
 */
void yyset_in (FILE *  _in_str )
{
        yyin = _in_str ;
}

void yyset_out (FILE *  _out_str )
{
        yyout = _out_str ;
}

int yyget_debug  (void)
{
        return yy_flex_debug;
}

void yyset_debug (int  _bdebug )
{
        yy_flex_debug = _bdebug ;
}

static int yy_init_globals (void)
{
        /* Initialization is the same as for the non-reentrant scanner.
     * This function is called from yylex_destroy(), so don't allocate here.
     */

    (yy_buffer_stack) = NULL;
    (yy_buffer_stack_top) = 0;
    (yy_buffer_stack_max) = 0;
    (yy_c_buf_p) = NULL;
    (yy_init) = 0;
    (yy_start) = 0;

/* Defined in main.c */
#ifdef YY_STDINIT
    yyin = stdin;
    yyout = stdout;
#else
    yyin = NULL;
    yyout = NULL;
#endif

    /* For future reference: Set errno on error, since we are called by
     * yylex_init()
     */
    return 0;
}

/* yylex_destroy is for both reentrant and non-reentrant scanners. */
int yylex_destroy  (void)
{
    
    /* Pop the buffer stack, destroying each element. */
	while(YY_CURRENT_BUFFER){
		yy_delete_buffer( YY_CURRENT_BUFFER  );
		YY_CURRENT_BUFFER_LVALUE = NULL;
		yypop_buffer_state();
	}

	/* Destroy the stack itself. */
	yyfree((yy_buffer_stack) );
	(yy_buffer_stack) = NULL;

    /* Reset the globals. This is important in a non-reentrant scanner so the next time
     * yylex() is called, initialization will occur. */
    yy_init_globals( );

    return 0;
}

/*
 * Internal utility routines.
 */

#ifndef yytext_ptr
static void yy_flex_strncpy (char* s1, const char * s2, int n )
{
		
	int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
}
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen (const char * s )
{
	int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
}
#endif

void *yyalloc (yy_size_t  size )
{
			return malloc(size);
}

void *yyrealloc  (void * ptr, yy_size_t  size )
{
		
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return realloc(ptr, size);
}

void yyfree (void * ptr )
{
			free( (char *) ptr );	/* see yyrealloc() for (char *) cast */
}

#define YYTABLES_NAME "yytables"

#line 426 "configlexer.lex"


