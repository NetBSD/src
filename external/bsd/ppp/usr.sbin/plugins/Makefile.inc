#	$NetBSD: Makefile.inc,v 1.1 2023/11/15 22:11:38 christos Exp $
PPPD=${NETBSDSRCDIR}/external/bsd/ppp/dist/pppd
