#       $NetBSD: Makefile.inc,v 1.1.2.2 2012/10/30 18:55:46 yamt Exp $

.include <bsd.own.mk>

BINDIR=		/usr/bin

.include "${.PARSEDIR}/../Makefile.inc"
