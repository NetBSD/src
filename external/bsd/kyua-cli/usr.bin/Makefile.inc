# $NetBSD: Makefile.inc,v 1.1.12.2 2014/05/22 15:45:34 yamt Exp $

.include "../Makefile.inc"
