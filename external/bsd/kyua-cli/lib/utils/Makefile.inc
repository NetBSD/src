# $NetBSD: Makefile.inc,v 1.1.4.2 2013/02/25 00:26:20 tls Exp $

.include "../Makefile.inc"
