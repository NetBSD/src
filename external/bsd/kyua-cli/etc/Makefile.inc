# $NetBSD: Makefile.inc,v 1.1.12.2 2014/05/22 15:45:30 yamt Exp $

.include "../Makefile.inc"
