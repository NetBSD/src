#	$NetBSD: Makefile.inc,v 1.1 2008/07/16 00:41:50 christos Exp $
BINDIR?=/usr/bin
WARNS?=0
