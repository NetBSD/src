#	$NetBSD: Makefile.inc,v 1.1.4.2 2019/06/10 21:50:49 christos Exp $

.include "${.PARSEDIR}/../Makefile.inc"
