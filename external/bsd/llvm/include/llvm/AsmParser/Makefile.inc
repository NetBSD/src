#	$NetBSD: Makefile.inc,v 1.1 2018/12/31 19:33:03 maya Exp $

.include "${.PARSEDIR}/../Makefile.inc"
