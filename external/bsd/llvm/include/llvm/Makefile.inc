#	$NetBSD: Makefile.inc,v 1.1 2018/12/31 19:33:02 maya Exp $

.include "${.PARSEDIR}/../Makefile.inc"
