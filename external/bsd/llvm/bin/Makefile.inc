#	$NetBSD: Makefile.inc,v 1.1.2.2 2011/03/06 15:07:39 bouyer Exp $

BINDIR=	/usr/bin

.include "${.PARSEDIR}/../Makefile.inc"
