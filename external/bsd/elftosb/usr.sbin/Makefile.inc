# $NetBSD: Makefile.inc,v 1.1.2.2 2012/11/15 19:49:17 jkunz Exp $

.include "../Makefile.inc"

