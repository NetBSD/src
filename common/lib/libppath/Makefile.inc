#	$NetBSD: Makefile.inc,v 1.1.44.2 2020/04/21 19:37:51 martin Exp $

.PATH:	${.PARSEDIR}

SRCS+=	ppath.c ppath_extant.c
