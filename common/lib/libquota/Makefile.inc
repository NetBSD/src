#	$NetBSD: Makefile.inc,v 1.1 2011/03/24 17:05:39 bouyer Exp $

.PATH.c: ${.PARSEDIR}
SRCS+=	quotaprop.c quotasubr.c
