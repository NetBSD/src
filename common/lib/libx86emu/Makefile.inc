# $NetBSD: Makefile.inc,v 1.2.72.2 2020/04/21 19:37:51 martin Exp $

.PATH:	${.PARSEDIR}

SRCS+=	x86emu.c x86emu_util.c x86emu_i8254.c
