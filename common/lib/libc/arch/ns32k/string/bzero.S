/*	$NetBSD: bzero.S,v 1.1 2005/12/20 19:28:50 christos Exp $	*/

#define BZERO
#include "memset.S"
