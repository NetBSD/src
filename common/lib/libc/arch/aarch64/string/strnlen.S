/* $NetBSD: strnlen.S,v 1.1.26.2 2020/04/21 19:37:41 martin Exp $ */

#define STRNLEN

#include "strlen.S"
