/*	$NetBSD: memmove.S,v 1.1.4.2 2020/04/21 19:37:41 martin Exp $	*/

#define MEMMOVE
#include "bcopy.S"
