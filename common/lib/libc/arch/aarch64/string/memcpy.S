/*	$NetBSD: memcpy.S,v 1.2.4.2 2020/04/21 19:37:41 martin Exp $	*/

#define MEMCOPY
#include "bcopy.S"
