/*	$NetBSD: memmove.S,v 1.2.94.2 2020/04/21 19:37:46 martin Exp $	*/

#define MEMMOVE
#include "memcpy.S"
