/*	$NetBSD: bcopy.S,v 1.2 2006/04/22 23:53:47 uwe Exp $	*/

#define BCOPY
#include "memcpy.S"
