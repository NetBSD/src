/*	$NetBSD: membar_ops.S,v 1.1 2026/11/21 14:53:02 thorpej Exp $	*/

/*-
 * Copyright (c) 2007, 2026 The NetBSD Foundation, Inc.
 * All rights reserved.
 *
 * This code is derived from software contributed to The NetBSD Foundation
 * by Jason R. Thorpe, and by Andrew Doran.
 *
 * Redistribution and use in source and binary forms, with or without
 * modification, are permitted provided that the following conditions
 * are met:
 * 1. Redistributions of source code must retain the above copyright
 *    notice, this list of conditions and the following disclaimer.
 * 2. Redistributions in binary form must reproduce the above copyright
 *    notice, this list of conditions and the following disclaimer in the
 *    documentation and/or other materials provided with the distribution.
 *
 * THIS SOFTWARE IS PROVIDED BY THE NETBSD FOUNDATION, INC. AND CONTRIBUTORS
 * ``AS IS'' AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED
 * TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR
 * PURPOSE ARE DISCLAIMED.  IN NO EVENT SHALL THE FOUNDATION OR CONTRIBUTORS
 * BE LIABLE FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR
 * CONSEQUENTIAL DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF
 * SUBSTITUTE GOODS OR SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS
 * INTERRUPTION) HOWEVER CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN
 * CONTRACT, STRICT LIABILITY, OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE)
 * ARISING IN ANY WAY OUT OF THE USE OF THIS SOFTWARE, EVEN IF ADVISED OF THE
 * POSSIBILITY OF SUCH DAMAGE.
 */

#include "atomic_op_asm.h"

	.text

/*
 * The 68010, 68020, and 68030 have strictly ordered memory operations.
 *
 * The 68040 and 68060 do not, however.  The situation is described in
 * detail in the 68040 User's Manual, section 7.7:
 *
 * <quote>
 * [paragraph 1]
 * The M68040 integer unit generates access requests to the instruction
 * and data memory units to support integer and floating-point operations.
 * Both the <ea> fetch and write-back stages of the integer unit pipeline
 * perform accesses to the data memory unit, with effective address fetches
 * assigned a higher priority. This priority allows data read and write
 * accesses to occur out of order, with a memory write access potentially
 * delayed for many clocks while allowing read accesses generated by later
 * instructions to complete.
 * .
 * .
 * .
 * [paragraph 4]
 * Since write cycles can be deferred indefinitely, many subsequent
 * instructions can be executed, resulting in seemingly nonsequential
 * instruction execution. When this action is not desired and the system
 * depends on sequential execution following bus activity, the NOP
 * instruction can be used. The NOP instruction forces instruction and bus
 * synchronization because it freezes instruction execution until all
 * pending bus cycles have completed.
 * </quote>
 *
 * This is to say: Loads happen in order with respect to other loads,
 * and stores happen in order with respect to other stores, but stores
 * may be observed /after/ subsequent loads.
 */

ENTRY(_membar_acquire)
	/*
	 * load-acquire guarantees that the load-acquire is observed
	 * before any subsequent loads/stores.
	 *
	 * All m68k loads satisfy this requirement.
	 */
	rts

ENTRY(_membar_release)
	/*
	 * store-release guarantees that the store-release is observed
	 * after all prior load/stores.
	 *
	 * All m68k stores satisfy this requirement.
	 */
	rts

ENTRY(_membar_sync)
	/*
	 * Per [paragraph 4] cited above, a NOP is required to serialize
	 * store-before-load.
	 */
	nop
	rts

ATOMIC_OP_ALIAS(membar_acquire,_membar_acquire)
ATOMIC_OP_ALIAS(membar_release,_membar_release)
ATOMIC_OP_ALIAS(membar_sync,_membar_sync)

ATOMIC_OP_ALIAS(membar_consumer,_membar_acquire)
ATOMIC_OP_ALIAS(membar_producer,_membar_release)
ATOMIC_OP_ALIAS(membar_enter,_membar_sync)
ATOMIC_OP_ALIAS(membar_exit,_membar_release)
ATOMIC_OP_ALIAS(membar_sync,_membar_sync)

STRONG_ALIAS(_membar_consumer,_membar_acquire)
STRONG_ALIAS(_membar_producer,_membar_release)
STRONG_ALIAS(_membar_enter,_membar_sync)
STRONG_ALIAS(_membar_exit,_membar_release)

CRT_ALIAS(__sync_synchronize,_membar_sync)
