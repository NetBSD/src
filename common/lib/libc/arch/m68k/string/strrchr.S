/*	$NetBSD: strrchr.S,v 1.1 2005/12/20 19:28:49 christos Exp $	*/

#define STRRCHR
#include "rindex.S"
