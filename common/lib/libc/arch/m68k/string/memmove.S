/*	$NetBSD: memmove.S,v 1.1.94.2 2020/04/21 19:37:44 martin Exp $	*/

#define MEMMOVE
#include "bcopy.S"
