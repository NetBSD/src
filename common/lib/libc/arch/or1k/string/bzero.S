/* $NetBSD: bzero.S,v 1.1.16.2 2020/04/21 19:37:45 martin Exp $ */

#define _BZERO
#include "memset.S"
