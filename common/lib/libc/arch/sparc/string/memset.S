/*	$NetBSD: memset.S,v 1.1.94.2 2020/04/21 19:37:47 martin Exp $	*/

#define MEMSET
#include "bzero.S"
