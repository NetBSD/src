/*	$NetBSD: ffs.S,v 1.3 2006/07/07 07:15:04 ross Exp $ */

#include "../../powerpc/string/ffs.S"
