/*	$NetBSD: strlen.S,v 1.3 2006/07/07 07:15:04 ross Exp $ */

/* XXX could be optimized for ppc64 */

#include "../../powerpc/string/strlen.S"
