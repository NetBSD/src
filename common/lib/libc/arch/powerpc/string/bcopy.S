/* $NetBSD: bcopy.S,v 1.1.4.2 2008/03/24 07:14:29 keiichi Exp $ */

#define _BCOPY
#include "memmove.S"
