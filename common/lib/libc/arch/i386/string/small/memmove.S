/*	$NetBSD: memmove.S,v 1.1.44.2 2020/04/21 19:37:43 martin Exp $	*/

#define MEMMOVE
#include "memcpy.S"
