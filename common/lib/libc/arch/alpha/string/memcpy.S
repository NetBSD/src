/*	$NetBSD: memcpy.S,v 1.1.94.2 2020/04/21 19:37:42 martin Exp $	*/

#define MEMCOPY
#include "bcopy.S"
