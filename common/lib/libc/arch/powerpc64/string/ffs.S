/*	$NetBSD: ffs.S,v 1.1.94.2 2020/04/21 19:37:45 martin Exp $ */

#include "../../powerpc/string/ffs.S"
