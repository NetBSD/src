/*	$NetBSD: strlen.S,v 1.1.94.2 2020/04/21 19:37:45 martin Exp $ */

/* XXX could be optimized for ppc64 */

#include "../../powerpc/string/strlen.S"
