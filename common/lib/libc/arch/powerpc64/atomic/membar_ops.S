/*	$NetBSD: membar_ops.S,v 1.1.4.2 2008/01/09 01:21:06 matt Exp $	*/

#include "../../powerpc/atomic/membar_ops.S"
