#	$NetBSD: Makefile.inc,v 1.7.26.2 2020/04/21 19:37:45 martin Exp $

.PATH:	${NETBSDSRCDIR}/common/lib/libc/arch/powerpc/atomic

.include "${NETBSDSRCDIR}/common/lib/libc/arch/powerpc/atomic/Makefile.inc"
