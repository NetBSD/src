/* $NetBSD: index.S,v 1.1 2005/12/20 19:28:51 christos Exp $ */

#define INDEX
#include "strchr.S"
