/* $NetBSD: rindex.S,v 1.1 2005/12/20 19:28:51 christos Exp $ */

#define RINDEX
#include "strrchr.S"
