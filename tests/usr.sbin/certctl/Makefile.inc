#	$NetBSD: Makefile.inc,v 1.1.2.2 2023/09/04 17:33:27 martin Exp $
#

TESTSDIR=	${TESTSBASE}/usr.sbin/certctl

.include <bsd.own.mk>
