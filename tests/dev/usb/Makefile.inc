# $NetBSD: Makefile.inc,v 1.1.4.2 2020/04/08 14:09:06 martin Exp $
.include "../Makefile.inc"
