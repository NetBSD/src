# $NetBSD: Makefile.inc,v 1.1.8.2 2014/08/20 00:04:46 tls Exp $

.include "../Makefile.inc"
