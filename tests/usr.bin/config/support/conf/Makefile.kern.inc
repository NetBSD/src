#	$NetBSD: Makefile.kern.inc,v 1.1.2.2 2015/03/15 23:01:46 snj Exp $

build_kernel: .USE
	XXX
