# modify to taste
BINDIR?= /usr/local/bin
