#	$NetBSD: Makefile.inc,v 1.2 2004/06/30 03:37:50 jmc Exp $

SETNAME=etc
PREFIX=/
