#	$NetBSD: Makefile.inc,v 1.2 2004/06/30 03:37:43 jmc Exp $

SETNAME=games
PREFIX=/
