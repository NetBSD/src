#	$NetBSD: Makefile.inc,v 1.1.1.1 1995/04/17 19:08:49 leo Exp $

# Revision is 1.0
REV=	10
