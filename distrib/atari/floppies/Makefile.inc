#	$NetBSD: Makefile.inc,v 1.1.1.1 2002/04/12 21:11:46 leo Exp $

.include "${.CURDIR}/../../../Makefile.inc"
