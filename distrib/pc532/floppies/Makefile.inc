#	$NetBSD: Makefile.inc,v 1.10 2002/04/26 15:30:30 lukem Exp $

.include "../../Makefile.inc"
