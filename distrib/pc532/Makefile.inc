#	$Id: Makefile.inc,v 1.1.1.1 1995/08/27 06:36:34 phil Exp $

# Revision is 1.0A
REV=	10A
