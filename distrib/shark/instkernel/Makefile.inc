#	$NetBSD: Makefile.inc,v 1.1 2002/02/11 17:49:40 thorpej Exp $

REV!=sh ${.CURDIR}/../../../../sys/conf/osrelease.sh -s
VER!=sh ${.CURDIR}/../../../../sys/conf/osrelease.sh
