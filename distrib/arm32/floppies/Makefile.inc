# $NetBSD: Makefile.inc,v 1.6 2002/03/06 23:50:56 lukem Exp $
