#	$NetBSD: Makefile.inc,v 1.6.10.1 2002/03/25 17:32:51 he Exp $

REV!=sh ${BSDSRCDIR}/sys/conf/osrelease.sh -s
VERDEP= ${BSDSRCDIR}/sys/conf/osrelease.sh
