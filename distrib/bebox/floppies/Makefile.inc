#	$NetBSD: Makefile.inc,v 1.4 2002/04/26 15:25:33 lukem Exp $

.include "../../Makefile.inc"
