#	$NetBSD: Makefile.inc,v 1.3 1997/05/10 15:42:53 lukem Exp $

REV!=sh ${BSDSRCDIR}/sys/conf/osrelease.sh -s
