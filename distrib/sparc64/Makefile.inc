#	$NetBSD: Makefile.inc,v 1.1 2001/07/23 14:54:25 eeh Exp $

.include "../../Makefile.inc"
.include <bsd.own.mk>
