# $NetBSD: Makefile.inc,v 1.2 2002/03/06 12:39:10 lukem Exp $
.include <bsd.own.mk>
