# $NetBSD: Makefile.inc,v 1.1 2002/01/25 15:28:43 reinoud Exp $

REV!=sh ${.CURDIR}/../../../sys/conf/osrelease.sh -s
