#	$NetBSD: Makefile.inc,v 1.3 2002/04/26 15:27:02 lukem Exp $

.include "../../Makefile.inc"
