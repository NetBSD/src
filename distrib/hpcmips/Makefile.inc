#	$NetBSD: Makefile.inc,v 1.1.1.1 1999/09/16 12:18:26 takemura Exp $

REV!=sh ${.CURDIR}/../../../sys/conf/osrelease.sh -s
VER!=sh ${.CURDIR}/../../../sys/conf/osrelease.sh
