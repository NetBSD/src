#	$NetBSD: Makefile.inc,v 1.9.36.1 2012/04/17 00:02:31 yamt Exp $

.include "../Makefile.inc"

iso_image: .PHONY
live_image: .PHONY
install_image: .PHONY
