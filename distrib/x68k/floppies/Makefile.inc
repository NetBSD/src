#	$NetBSD: Makefile.inc,v 1.9 2002/03/06 12:27:09 lukem Exp $

.include "../../../Makefile.inc"
