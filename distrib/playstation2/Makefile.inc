#	$NetBSD: Makefile.inc,v 1.1 2001/10/15 16:22:50 uch Exp $

REV!=sh ${.CURDIR}/../../../sys/conf/osrelease.sh -s
VER!=sh ${.CURDIR}/../../../sys/conf/osrelease.sh
