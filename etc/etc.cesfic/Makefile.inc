#	$NetBSD: Makefile.inc,v 1.1 2011/01/02 08:17:24 tsutsui Exp $
#
#	etc.cesfic/Makefile.inc -- cesfic-specific etc Makefile targets
#

# If you change the list of distributed kernels, don't forget
# to update the release documentation in distrib/notes/common/contents

KERNEL_SETS=		GENERIC
