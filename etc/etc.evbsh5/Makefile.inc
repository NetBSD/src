#	$NetBSD: Makefile.inc,v 1.1 2004/03/17 20:29:43 scw Exp $
#
#	etc.evbsh5/Makefile.inc -- evbsh5-specific etc Makefile targets
#

KERNEL_SETS=		CAYMAN CAYMAN64

