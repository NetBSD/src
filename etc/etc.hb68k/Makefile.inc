#	$NetBSD: Makefile.inc,v 1.1 2026/07/19 01:48:20 thorpej Exp $
#
#	etc.hb68k/Makefile.inc -- hb68k-specific etc Makefile targets
#

# If you change the list of distributed kernels, don't forget
# to update the release documentation in distrib/notes/common/contents

KERNEL_SETS=		PHAETHON1

#EXTRA_KERNELS=		INSTALL

#BUILD_KERNELS=		RAMDISK

#INSTALLATION_DIRS+=	installation/miniroot	\
#			installation/netboot	\
#			installation/tapeimage
