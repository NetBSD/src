#	$NetBSD: Makefile.inc,v 1.3.4.1 2007/11/06 23:10:27 matt Exp $
#
#	etc.mvmeppc/Makefile.inc -- mvmeppc-specific etc Makefile targets
#

# If you change the list of distributed kernels, don't forget
# to update the release documentation in distrib/notes/common/contents

KERNEL_SETS=		GENERIC
