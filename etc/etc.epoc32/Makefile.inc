#	$NetBSD: Makefile.inc,v 1.1.10.2 2014/05/22 11:27:19 yamt Exp $
#
#	etc.epoc32/Makefile.inc -- epoc32-specific etc Makefile targets
#

KERNEL_SETS=		GENERIC
