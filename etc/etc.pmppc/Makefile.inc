#	$NetBSD: Makefile.inc,v 1.4.6.2 2007/07/24 10:49:28 pavel Exp $
#
#	etc.pmppc/Makefile.inc -- pmppc-specific etc Makefile targets
#

# If you change the list of distributed kernels, don't forget
# to update the release documentation in distrib/notes/common/contents

KERNEL_SETS=		PMPPC INSTALL
