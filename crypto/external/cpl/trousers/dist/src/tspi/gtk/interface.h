
/*
 * Licensed Materials - Property of IBM
 *
 * trousers - An open source TCG Software Stack
 *
 * (C) Copyright International Business Machines Corp. 2004
 *
 */

/*
 * DO NOT EDIT THIS FILE - it is generated by Glade.
 */

#ifndef _INTERFACE_H_
#define _INTERFACE_H_

struct userdata {
	char *string;
	unsigned string_len;
	GtkWidget *window;
	GtkWidget *entry;
	GtkWidget *entryPass;
	GtkWidget *entryConf;
};

GtkWidget* create_password_dialog (struct userdata *, char *);
GtkWidget* create_new_password_dialog (struct userdata *, char *);

#endif
