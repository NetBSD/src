# $NetBSD: Makefile.inc,v 1.1 2012/01/28 02:15:26 christos Exp $
.include "../Makefile.inc"
