# $NetBSD: Makefile.inc,v 1.1 2012/01/28 02:15:25 christos Exp $

.include <bsd.own.mk>

DIST=${NETBSDSRCDIR}/crypto/external/cpl/trousers/dist

CPPFLAGS+= -I${DIST}/src/include

CPPFLAGS+= -DPACKAGE_NAME=\"trousers\" -DPACKAGE_TARNAME=\"trousers\"
CPPFLAGS+= -DPACKAGE_VERSION=\"0.3.8\" -DPACKAGE_STRING=\"trousers\ 0.3.8\"
CPPFLAGS+= -DPACKAGE_BUGREPORT=\"trousers-tech@lists.sf.net\" 
CPPFLAGS+= -DPACKAGE_URL=\"\" -DPACKAGE=\"trousers\" -DVERSION=\"0.3.8\"
CPPFLAGS+= -DSTDC_HEADERS=1 -DHAVE_SYS_TYPES_H=1 -DHAVE_SYS_STAT_H=1
CPPFLAGS+= -DHAVE_STDLIB_H=1 -DHAVE_STRING_H=1 -DHAVE_MEMORY_H=1
CPPFLAGS+= -DHAVE_STRINGS_H=1 -DHAVE_INTTYPES_H=1 -DHAVE_STDINT_H=1
CPPFLAGS+= -DHAVE_UNISTD_H=1 -DHAVE_OPENSSL_BN_H=1 -DHAVE_OPENSSL_ENGINE_H=1
CPPFLAGS+= -DHAVE_PTHREAD_H=1 -DHAVE_DLFCN_H=1 -DHTOLE_DEFINED=1 -DHAVE_DAEMON=1

CPPFLAGS+=-DBI_OPENSSL -DTCSD_DEFAULT_PORT=30003
CPPFLAGS+=-DTSS_VER_MAJOR=0 -DTSS_VER_MINOR=3 -DTSS_SPEC_MAJOR=1
CPPFLAGS+=-DTSS_SPEC_MINOR=2
