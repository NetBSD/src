# $NetBSD: Makefile.inc,v 1.1.4.2 2012/04/17 00:02:23 yamt Exp $
.include "../Makefile.inc"
