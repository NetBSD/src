# $NetBSD: Makefile.inc,v 1.1 2012/01/28 16:04:12 christos Exp $
.include "../Makefile.inc"
