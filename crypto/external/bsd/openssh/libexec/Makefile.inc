#	$NetBSD: Makefile.inc,v 1.2 2025/02/18 17:53:25 christos Exp $

.include "${.PARSEDIR}/../bin/Makefile.inc"
.include "${.PARSEDIR}/../Makefile.inc"
