#	$NetBSD: Makefile.inc,v 1.1.12.1 2025/08/02 05:18:51 perseant Exp $

.include "${.PARSEDIR}/../bin/Makefile.inc"
.include "${.PARSEDIR}/../Makefile.inc"
