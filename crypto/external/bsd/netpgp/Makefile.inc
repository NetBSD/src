#	$NetBSD: Makefile.inc,v 1.1.4.2 2012/10/30 18:46:19 yamt Exp $

WARNS?=4
