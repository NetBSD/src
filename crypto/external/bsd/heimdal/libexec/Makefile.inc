# $NetBSD: Makefile.inc,v 1.6.14.1 2023/08/11 13:40:07 martin Exp $

BINDIR=/usr/libexec

PROGDPLIBS += ${DPLIBKRB5} ${DPLIBHX509} ${DPLIBASN1} ${DPLIBCOM_ERR}
PROGDPLIBS += ${DPLIBWIND} ${DPLIBHEIMBASE} ${DPLIBROKEN} ${DPLIBVERS}
