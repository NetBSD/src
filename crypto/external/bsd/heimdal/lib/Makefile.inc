
CFLAGS+= -g
