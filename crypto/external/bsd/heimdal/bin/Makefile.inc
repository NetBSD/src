# $NetBSD: Makefile.inc,v 1.4.14.1 2023/08/11 13:39:44 martin Exp $

BINDIR=/usr/bin

PROGDPLIBS += ${DPLIBKRB5} ${DPLIBHX509} ${DPLIBASN1} ${DPLIBCOM_ERR}
PROGDPLIBS += ${DPLIBWIND} ${DPLIBHEIMBASE} ${DPLIBROKEN} ${DPLIBVERS}
