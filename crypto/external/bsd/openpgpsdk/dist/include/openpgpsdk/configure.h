/*
 * generated by configure from include/openpgpsdk/configure.h.template. Don't
 * edit.
 */

#undef HAVE_ALLOCA_H

#define PRItime		"ll"

#ifdef WIN32
#define PRIsize		"I"
#else
#define PRIsize		"z"
#endif

/* for silencing unused parameter warnings */
#define OPS_USED(x)	/*LINTED*/(void)&(x)
