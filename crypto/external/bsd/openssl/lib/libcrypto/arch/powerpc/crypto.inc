CPUID_SRCS = ppccap.c
CPUID = yes
.include "../../crypto.inc"
