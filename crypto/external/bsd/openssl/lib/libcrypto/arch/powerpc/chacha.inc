.PATH.S: ${.PARSEDIR}

CHACHA_SRCS = chacha-ppc.S chacha_ppc.c

.include "../../chacha.inc"
