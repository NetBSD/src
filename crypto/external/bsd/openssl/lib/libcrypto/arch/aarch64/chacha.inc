.PATH.S: ${.PARSEDIR}

CHACHA_SRCS = chacha-armv8.S

.include "../../chacha.inc"
