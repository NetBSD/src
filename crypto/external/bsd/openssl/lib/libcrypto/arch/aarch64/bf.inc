#	$NetBSD: bf.inc,v 1.1.2.2 2016/11/04 14:42:36 pgoyette Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
