# $NetBSD: whrlpool.inc,v 1.1 2023/05/11 01:31:54 christos Exp $

WHRLPOOL_SRCS += wp_block.c
.include "../../whrlpool.inc"

