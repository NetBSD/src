.PATH.S: ${.PARSEDIR}
MODES_SRCS += ghashv8-armx.S
.include "../../modes.inc"
