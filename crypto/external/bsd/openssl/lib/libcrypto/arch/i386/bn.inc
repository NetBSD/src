.PATH.S: ${.PARSEDIR}
BN_SRCS = bn-586.S co-586.S
.include "../../bn.inc"
BNCPPFLAGS+= -DOPENSSL_BN_ASM_PART_WORDS
