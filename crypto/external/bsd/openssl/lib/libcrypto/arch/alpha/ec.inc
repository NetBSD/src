# $NetBSD: ec.inc,v 1.1 2023/05/13 18:59:36 christos Exp $
ECNI=yes
ECNONISTZ=yes

.include "../../ec.inc"
