# $NetBSD: ec.inc,v 1.1.2.2 2023/08/11 13:41:57 martin Exp $
ECNI=yes
ECNONISTZ=yes

.include "../../ec.inc"
