# $NetBSD: chacha.inc,v 1.1 2023/05/11 01:45:38 christos Exp $

CHACHA_SRCS += chacha_enc.c
.include "../../chacha.inc"

