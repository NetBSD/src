.PATH.S: ${.PARSEDIR}
CAMELLIA_SRCS = cmllt4-sparcv9.S
.include "../../camellia.inc"
