CPUID_SRCS = sparcv9cap.c
CPUID = yes
.include "../../crypto.inc"
