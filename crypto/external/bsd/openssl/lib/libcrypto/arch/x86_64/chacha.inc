.PATH.S: ${.PARSEDIR}

CHACHA_SRCS = chacha-x86_64.S

.include "../../chacha.inc"
