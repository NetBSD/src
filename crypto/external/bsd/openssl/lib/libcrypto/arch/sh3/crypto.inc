
CRYPTO_SRCS += libc-memequal.c
.include "../../crypto.inc"
