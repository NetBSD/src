.PATH.S: ${.PARSEDIR}

CHACHA_SRCS = chacha-x86.S

.include "../../chacha.inc"
