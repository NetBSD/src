#	$NetBSD: bf.inc,v 1.1.1.1 2018/02/03 22:43:38 christos Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
