.PATH.S: ${.PARSEDIR}
.include "../../rc4.inc"
