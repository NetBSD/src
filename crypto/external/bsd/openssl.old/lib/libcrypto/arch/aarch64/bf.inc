#	$NetBSD: bf.inc,v 1.1.1.2 2023/04/18 14:19:04 christos Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
