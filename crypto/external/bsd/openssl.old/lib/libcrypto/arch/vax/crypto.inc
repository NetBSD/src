.PATH.S: ${.PARSEDIR}

#CRYPTO_SRCS += libc-memequal.c
#CPPFLAGS += -DOPENSSL_CPUID_OBJ

.include "../../crypto.inc"
