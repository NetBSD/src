ECCPPFLAGS+= -DOPENSSL_NO_EC_NISTP_64_GCC_128
.include "../../ec.inc"
