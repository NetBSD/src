SM3CPPFLAGS = -DOPENSSL_SM3_ASM
.include "../../sm3.inc"
