ECCPPFLAGS+= -DOPENSSL_NO_EC_NISTP_64_GCC_128
#ECCPPFLAGS+=-DECP_NISTZ256_ASM

.include "../../ec.inc"
