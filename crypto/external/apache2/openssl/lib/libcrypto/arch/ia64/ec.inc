# $NetBSD: ec.inc,v 1.1 2025/07/17 14:25:31 christos Exp $
ECNI=yes
ECNONISTZ=yes

.include "../../ec.inc"
