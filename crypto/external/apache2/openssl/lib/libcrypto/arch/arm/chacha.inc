.PATH.S: ${.PARSEDIR}

CHACHA_SRCS = chacha-armv4.S

.include "../../chacha.inc"
