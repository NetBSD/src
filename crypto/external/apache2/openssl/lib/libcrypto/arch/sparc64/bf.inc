#	$NetBSD: bf.inc,v 1.1 2025/07/17 14:25:36 christos Exp $

CPPFLAGS+=	-DBF_PTR

.include "${.CURDIR}/bf.inc"
