.PATH.S: ${.PARSEDIR}

CHACHA_SRCS = chacha-riscv64-v-zbb.S

.include "../../chacha.inc"
