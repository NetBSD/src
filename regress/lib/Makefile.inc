#	$NetBSD: Makefile.inc,v 1.1 2002/08/18 14:59:32 itojun Exp $
#
# do not install regression test programs
proginstall::
