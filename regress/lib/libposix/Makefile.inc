#	$NetBSD: Makefile.inc,v 1.1 1999/02/21 00:20:11 mjl Exp $
#
# do not install regression test programs
proginstall::
