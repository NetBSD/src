#	$NetBSD: Makefile.inc,v 1.1.2.2 2001/12/09 17:26:53 he Exp $
#
# do not install regression test programs
proginstall::
