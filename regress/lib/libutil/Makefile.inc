#	$NetBSD: Makefile.inc,v 1.1 2002/09/20 21:13:29 christos Exp $
#
# do not install regression test programs
proginstall::
