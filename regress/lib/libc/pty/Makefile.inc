#	$NetBSD: Makefile.inc,v 1.1 2004/05/27 03:14:26 christos Exp $
#
# do not install regression test programs
proginstall::
