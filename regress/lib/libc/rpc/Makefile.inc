#	$NetBSD: Makefile.inc,v 1.1 2001/02/18 21:57:16 bjh21 Exp $
#
# do not install regression test programs
proginstall::
