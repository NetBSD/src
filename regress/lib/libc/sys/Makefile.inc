#	$NetBSD: Makefile.inc,v 1.1 2001/09/20 16:56:52 atatat Exp $
#
# do not install regression test programs
proginstall::
