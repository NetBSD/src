#	$NetBSD: Makefile.inc,v 1.3 2004/06/30 03:26:27 jmc Exp $

COPTS+=	-mieee-with-inexact -mfp-rounding-mode=d
