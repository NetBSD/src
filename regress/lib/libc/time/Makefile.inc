#	$NetBSD: Makefile.inc,v 1.1 1998/01/22 19:29:37 thorpej Exp $

.include "../Makefile.inc"
