#	$NetBSD: Makefile.inc,v 1.1.4.2 2008/03/23 00:42:58 matt Exp $
#
# do not install regression test programs
proginstall::
