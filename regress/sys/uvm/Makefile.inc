#	$NetBSD: Makefile.inc,v 1.1 2000/03/19 02:47:19 simonb Exp $
#
# do not install regression test programs
proginstall::
