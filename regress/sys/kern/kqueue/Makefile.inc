# $NetBSD: Makefile.inc,v 1.1.1.1 2002/10/03 07:46:02 jdolecek Exp $

WARNS=2
NOMAN=
PROG=${.CURDIR:T}

# LDFLAGS=-static
