# $NetBSD: Makefile.inc,v 1.1.1.1 2002/10/03 07:46:03 jdolecek Exp $

.include "../Makefile.inc"
