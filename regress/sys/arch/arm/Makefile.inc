#	$NetBSD: Makefile.inc,v 1.1 2001/08/06 22:29:58 bjh21 Exp $
#
# do not install regression test programs
proginstall::
