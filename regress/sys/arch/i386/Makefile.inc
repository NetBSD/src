#	$NetBSD: Makefile.inc,v 1.2 1998/01/09 08:03:51 perry Exp $
#
# do not install regression test programs
proginstall::
