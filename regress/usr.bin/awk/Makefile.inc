#	$NetBSD: Makefile.inc,v 1.1 2005/01/13 12:26:12 yamt Exp $

AWK?=		awk
