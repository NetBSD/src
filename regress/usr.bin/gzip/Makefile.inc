#	$NetBSD: Makefile.inc,v 1.3 2006/05/29 16:47:07 simonb Exp $

GZIPPROG?=	gzip
