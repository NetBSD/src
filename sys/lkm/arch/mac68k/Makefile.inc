#	$NetBSD: Makefile.inc,v 1.1 1999/03/26 22:27:59 scottr Exp $

S!=	cd ${.CURDIR}/../../../..;pwd

.include "../../Makefile.inc"
