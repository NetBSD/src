# $NetBSD: Makefile.inc,v 1.1.18.2 2006/06/21 15:10:23 yamt Exp $

S!=	cd ${.CURDIR}/../../../..;pwd

.include "../../Makefile.inc"
