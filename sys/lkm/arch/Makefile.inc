#	$NetBSD: Makefile.inc,v 1.1 1999/03/26 22:31:19 scottr Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
