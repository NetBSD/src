#	$NetBSD: Makefile.inc,v 1.3 1998/03/28 23:58:45 thorpej Exp $

S!=	cd ${.CURDIR}/../../../..;pwd

.include "../../Makefile.inc"
