#	$NetBSD: Makefile.inc,v 1.2 1996/08/27 23:42:03 explorer Exp $

S!=	cd ${.CURDIR}/../../..;pwd
