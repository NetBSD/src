#	$NetBSD: Makefile.inc,v 1.1 1996/08/23 05:39:04 mrg Exp $

S!=	cd ../../../..;pwd
