#	$NetBSD: Makefile.inc,v 1.2.28.1 2002/01/10 20:01:14 thorpej Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
