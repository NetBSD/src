# $NetBSD: Makefile.inc,v 1.1 2007/01/17 11:28:09 elad Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
