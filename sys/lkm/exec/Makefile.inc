#	$NetBSD: Makefile.inc,v 1.1.6.1 2002/01/10 20:00:55 thorpej Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
