#	$NetBSD: Makefile.inc,v 1.3 2001/12/12 12:06:47 lukem Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
