#	$NetBSD: Makefile.inc,v 1.1.2.2 2001/01/08 14:57:32 bouyer Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
