#	$NetBSD: Makefile.inc,v 1.3 2005/12/11 12:24:49 christos Exp $

S!=	cd ${.CURDIR}/../../..;pwd

.include "../Makefile.inc"
