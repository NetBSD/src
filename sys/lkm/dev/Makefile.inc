#	$NetBSD: Makefile.inc,v 1.1.38.1 2006/09/09 02:57:53 rpaulo Exp $

.include "../Makefile.inc"
