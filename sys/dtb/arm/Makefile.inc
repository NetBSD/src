#	$NetBSD: Makefile.inc,v 1.2 2026/01/19 05:25:20 skrll Exp $

DTSARCH=	arm
DTSGNUARCH=	arm arm64 riscv

ARCHDTSDIR=	$S/external/gpl2/dts/dist/arch/arm/boot/dts
