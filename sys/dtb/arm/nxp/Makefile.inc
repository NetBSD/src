#	$NetBSD: Makefile.inc,v 1.2 2026/01/19 05:25:21 skrll Exp $

.include "../Makefile.inc"
