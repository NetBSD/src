#	$NetBSD: Makefile.inc,v 1.1 2026/01/18 11:34:11 skrll Exp $

.include "../Makefile.inc"
#	$NetBSD: Makefile.inc,v 1.1 2026/01/18 11:34:11 skrll Exp $

.include "../Makefile.inc"
