#	$NetBSD: Makefile.inc,v 1.2 2024/08/12 10:55:51 skrll Exp $

DTSARCH=	riscv
DTSGNUARCH=	riscv arm64

ARCHDTSDIR=	$S/external/gpl2/dts/dist/arch/riscv/boot/dts
