#	$NetBSD: Makefile.inc,v 1.1 2020/05/18 21:19:35 jmcneill Exp $

DTSARCH=	arm aarch64
DTSGNUARCH=	arm arm64

ARCHDTSDIR=	$S/external/gpl2/dts/dist/arch/arm64/boot/dts
