#	$NetBSD: Makefile.inc,v 1.3.16.2 2017/12/03 11:38:54 jdolecek Exp $

.PATH:	${NETBSDSRCDIR}/sys/dev/hdaudio
SRCS+=	hdaudio.c
