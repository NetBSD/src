#define NNPF    1