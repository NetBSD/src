#define NPCI 1
