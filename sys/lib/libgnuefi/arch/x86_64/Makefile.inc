#	$NetBSD: Makefile.inc,v 1.1.4.2 2017/03/20 06:57:48 pgoyette Exp $

SRCS+=	callwrap.c efi_stub.S
