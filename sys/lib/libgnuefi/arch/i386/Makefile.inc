#	$NetBSD: Makefile.inc,v 1.1.18.2 2017/12/03 11:38:46 jdolecek Exp $

SRCS+=	efi_stub.S
