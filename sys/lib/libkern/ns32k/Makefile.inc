#	Makefile.inc,v 1.1 1993/09/03 19:04:23 jtc Exp

SRCS+=	__main.c imax.c imin.c lmax.c lmin.c max.c min.c ulmax.c ulmin.c \
	bcmp.c ffs.c strcat.c strcmp.c strcpy.c strlen.c strncmp.c strncpy.c \
	scanc.c skpc.c locc.c \
	htonl.S htons.S ntohl.S ntohs.S setjmp.S
