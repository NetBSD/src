#	$Id: Makefile.inc,v 1.3 1993/10/15 08:41:16 cgd Exp $

SRCS+=	__main.c imax.c imin.c lmax.c lmin.c max.c min.c ulmax.c ulmin.c \
	bcmp.s bzero.s ffs.s strcat.s strcmp.s strcpy.s strlen.s strncmp.c \
	strncpy.c scanc.c skpc.c locc.c htonl.s htons.s ntohl.s ntohs.s \
	setjmp.s
