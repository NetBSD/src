#	$Id: Makefile.inc,v 1.3 1993/10/15 08:41:12 cgd Exp $

SRCS+=	__main.c imax.c imin.c lmax.c lmin.c max.c min.c ulmax.c ulmin.c \
	bcmp.s bzero.s ffs.c strcat.c strcmp.s strcpy.s strlen.s strncmp.s \
	strncpy.s htonl.s htons.s ntohl.s ntohs.s

ARCH=	m68k
