#	$Id: Makefile.inc,v 1.2 1994/06/15 15:27:42 glass Exp $
#	There are likely more that we will notice when we go native
#

SRCS+=	random.c scanc.c skpc.c strcat.c strcpy.c strncmp.c strncpy.c 

