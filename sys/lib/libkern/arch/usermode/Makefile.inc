#	$NetBSD: Makefile.inc,v 1.3.64.1 2019/06/10 22:09:04 christos Exp $
#
#	There are likely more that we will notice when we go native

NO_SRCS+= imax.c imin.c lmax.c lmin.c uimax.c uimin.c ulmax.c ulmin.c
NO_SRCS+= __main.c strlen.c strcmp.c
