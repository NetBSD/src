/*	$NetBSD: memmove.S,v 1.1.6.1 2002/01/10 20:00:30 thorpej Exp $	*/

/*
 * placeholder to keep the make system happy, memove is actually in memcpy.S
 */
