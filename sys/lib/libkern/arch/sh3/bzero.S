/*	$NetBSD: bzero.S,v 1.1.2.2 2002/12/11 06:46:25 thorpej Exp $	*/

#define BZERO
#include "memset.S"

