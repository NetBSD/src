/* On sh3, memcpy, memmove and bcopy share a single routine. */
