/*	$NetBSD: memcpy.S,v 1.1 2000/04/20 13:52:36 msaitoh Exp $	*/

#define MEMCOPY
#include "bcopy.S"
