/*	$NetBSD: memmove.S,v 1.2 2003/04/15 22:49:50 dsl Exp $	*/

#define MEMMOVE
#include "memcpy.S"
