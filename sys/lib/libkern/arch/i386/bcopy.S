/*	$NetBSD: bcopy.S,v 1.4 2003/04/15 22:49:50 dsl Exp $	*/

#define BCOPY
#define NO_OVERLAP
#include "memcpy.S"
