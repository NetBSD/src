/*	$NetBSD: memcpy.S,v 1.2 1998/02/22 08:14:58 mycroft Exp $	*/

#define MEMCOPY
#include "bcopy.S"
