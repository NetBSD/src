/*	$NetBSD: strrchr.S,v 1.1.14.1 2000/11/20 18:09:29 bouyer Exp $	*/

#define STRRCHR
#include "rindex.S"
