/*	$NetBSD: memmove.S,v 1.1.12.1 2000/11/20 18:09:26 bouyer Exp $	*/

#define MEMMOVE
#include "bcopy.S"
