/*	$NetBSD: strchr.S,v 1.1.14.1 2000/11/20 18:09:27 bouyer Exp $	*/

#define STRCHR
#include "index.S"
