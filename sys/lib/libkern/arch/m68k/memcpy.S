/*	$NetBSD: memcpy.S,v 1.1.14.1 2000/11/20 18:09:26 bouyer Exp $	*/

#define MEMCOPY
#include "bcopy.S"
