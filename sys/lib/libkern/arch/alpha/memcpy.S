/*	$NetBSD: memcpy.S,v 1.1 1998/02/22 06:49:58 mycroft Exp $	*/

#define MEMCOPY
#include "bcopy.S"
