/*	$NetBSD: memmove.S,v 1.1 1998/08/04 03:16:19 perry Exp $	*/

#define MEMMOVE
#include "bcopy.S"
