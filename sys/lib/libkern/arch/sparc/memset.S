/*	$NetBSD: memset.S,v 1.1.4.2 2001/08/24 00:11:52 nathanw Exp $	*/

#define MEMSET
#include "bzero.S"
