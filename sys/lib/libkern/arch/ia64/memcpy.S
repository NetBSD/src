/*	$NetBSD: memcpy.S,v 1.1.20.2 2006/09/09 02:57:52 rpaulo Exp $	*/
	
#include <machine/asm.h>

