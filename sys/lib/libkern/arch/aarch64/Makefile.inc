# $NetBSD: Makefile.inc,v 1.1.28.1 2018/03/22 01:44:51 pgoyette Exp $

SRCS+=	byte_swap_2.S byte_swap_4.S byte_swap_8.S
SRCS+=	memcmp.S
SRCS+=	memcpy.S
SRCS+=	memmove.S
SRCS+=	memset.S
#SRCS+=	strcmp.S
#SRCS+=	strncmp.S
