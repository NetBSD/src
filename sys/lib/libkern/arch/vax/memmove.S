#	$NetBSD: memmove.S,v 1.2 1999/02/15 04:54:36 hubertf Exp $
#
#	Dummy file to keep make happy.
#
