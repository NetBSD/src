/*	$NetBSD: bcopy.S,v 1.3 1998/04/03 22:59:29 matthias Exp $	*/

#define BCOPY
#include "memcpy.S"
