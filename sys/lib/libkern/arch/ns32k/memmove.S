/*	$NetBSD: memmove.S,v 1.1 1998/08/04 03:35:59 perry Exp $	*/

#define MEMMOVE
#include "memcpy.S"
