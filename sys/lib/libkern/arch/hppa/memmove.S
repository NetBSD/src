/*	$NetBSD: memmove.S,v 1.1.4.2 2002/06/23 17:49:46 jdolecek Exp $	*/

#define MEMMOVE
#include "bcopy.S"
