/*	$NetBSD: spcopy.S,v 1.1.4.2 2002/06/23 17:49:47 jdolecek Exp $	*/

#define SPCOPY
#include "bcopy.S"
