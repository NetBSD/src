#	$Id: Makefile.inc,v 1.1 1993/09/03 19:04:47 jtc Exp $

SRCS+=	imax.c imin.c lmax.c lmin.c max.c min.c ulmax.c ulmin.c \
	bcmp.s bzero.s ffs.c strcat.c strcmp.s strcpy.s strlen.s strncpy.s \
	htonl.s htons.s ntohl.s ntohs.s

ARCH=	m68k
