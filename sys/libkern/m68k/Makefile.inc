#	$Id: Makefile.inc,v 1.1 1993/09/03 19:03:23 jtc Exp $

SRCS+=	scanc.s skpc.s locc.s

