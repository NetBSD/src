#	$Id: Makefile.inc,v 1.1 1993/09/03 19:04:23 jtc Exp $

SRCS+=	imax.c imin.c lmax.c lmin.c max.c min.c ulmax.c ulmin.c \
	bcmp.s bzero.s ffs.s strcat.s strcmp.s strcpy.s strlen.s strncpy.c \
	scanc.c skpc.c locc.c \
	htonl.s htons.s ntohl.s ntohs.s \
	setjmp.s
