/*	$NetBSD: usbdevs_data.h,v 1.815.2.1 2026/11/15 14:18:50 martin Exp $	*/

/*
 * THIS FILE IS AUTOMATICALLY GENERATED.  DO NOT EDIT.
 *
 * generated from:
 *	NetBSD: usbdevs,v 1.823.2.1 2026/11/15 14:18:14 martin Exp
 */

/*-
 * Copyright (c) 1998-2004 The NetBSD Foundation, Inc.
 * All rights reserved.
 *
 * This code is derived from software contributed to The NetBSD Foundation
 * by Lennart Augustsson (lennart@augustsson.net) at
 * Carlstedt Research & Technology.
 *
 * Redistribution and use in source and binary forms, with or without
 * modification, are permitted provided that the following conditions
 * are met:
 * 1. Redistributions of source code must retain the above copyright
 *    notice, this list of conditions and the following disclaimer.
 * 2. Redistributions in binary form must reproduce the above copyright
 *    notice, this list of conditions and the following disclaimer in the
 *    documentation and/or other materials provided with the distribution.
 *
 * THIS SOFTWARE IS PROVIDED BY THE NETBSD FOUNDATION, INC. AND CONTRIBUTORS
 * ``AS IS'' AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED
 * TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR
 * PURPOSE ARE DISCLAIMED.  IN NO EVENT SHALL THE FOUNDATION OR CONTRIBUTORS
 * BE LIABLE FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR
 * CONSEQUENTIAL DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF
 * SUBSTITUTE GOODS OR SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS
 * INTERRUPTION) HOWEVER CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN
 * CONTRACT, STRICT LIABILITY, OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE)
 * ARISING IN ANY WAY OUT OF THE USE OF THIS SOFTWARE, EVEN IF ADVISED OF THE
 * POSSIBILITY OF SUCH DAMAGE.
 */

static const uint32_t usb_vendors[] = {
	    USB_VENDOR_UNKNOWN1, 1, 9, 0,
	    USB_VENDOR_UNKNOWN2, 1, 9, 0,
	    USB_VENDOR_EGALAX2, 16, 24, 0,
	    USB_VENDOR_QUAN, 29, 0,
	    USB_VENDOR_CHIPSBANK, 34, 44, 61, 0,
	    USB_VENDOR_HUMAX, 65, 0,
	    USB_VENDOR_AOX, 71, 0,
	    USB_VENDOR_ATMEL, 75, 0,
	    USB_VENDOR_MITSUMI, 81, 0,
	    USB_VENDOR_HP, 89, 97, 0,
	    USB_VENDOR_ADAPTEC, 105, 0,
	    USB_VENDOR_NATIONAL, 113, 122, 0,
	    USB_VENDOR_ACERLABS, 136, 141, 0,
	    USB_VENDOR_FTDI, 146, 153, 164, 0,
	    USB_VENDOR_NEC, 172, 0,
	    USB_VENDOR_KODAK, 176, 184, 0,
	    USB_VENDOR_WELTREND, 190, 122, 0,
	    USB_VENDOR_VIA, 199, 0,
	    USB_VENDOR_MELCO, 203, 0,
	    USB_VENDOR_CREATIVE, 209, 141, 0,
	    USB_VENDOR_NOKIA, 218, 0,
	    USB_VENDOR_ADI, 224, 228, 0,
	    USB_VENDOR_CATC, 236, 245, 153, 0,
	    USB_VENDOR_SMSC, 252, 0,
	    USB_VENDOR_GRAVIS, 257, 266, 236, 0,
	    USB_VENDOR_FUJITSUCOMP, 273, 281, 0,
	    USB_VENDOR_TAUGA, 291, 305, 0,
	    USB_VENDOR_AMD, 257, 308, 164, 0,
	    USB_VENDOR_LEXMARK, 314, 322, 0,
	    USB_VENDOR_NANAO, 336, 0,
	    USB_VENDOR_ALPS, 342, 347, 0,
	    USB_VENDOR_THRUST, 356, 0,
	    USB_VENDOR_TI, 369, 375, 0,
	    USB_VENDOR_ANALOGDEVICES, 387, 164, 0,
	    USB_VENDOR_SIS, 394, 402, 228, 413, 0,
	    USB_VENDOR_KYE, 419, 228, 0,
	    USB_VENDOR_DIAMOND2, 423, 431, 0,
	    USB_VENDOR_RENESAS, 439, 0,
	    USB_VENDOR_MICROSOFT, 447, 0,
	    USB_VENDOR_PRIMAX, 457, 464, 0,
	    USB_VENDOR_MGE, 476, 480, 228, 0,
	    USB_VENDOR_AMP, 484, 0,
	    USB_VENDOR_CHERRY, 488, 495, 0,
	    USB_VENDOR_MEGATRENDS, 509, 518, 0,
	    USB_VENDOR_LOGITECH, 529, 0,
	    USB_VENDOR_BTC, 538, 547, 236, 0,
	    USB_VENDOR_PHILIPS, 553, 0,
	    USB_VENDOR_SUN2, 561, 565, 578, 0,
	    USB_VENDOR_SANYO, 589, 347, 0,
	    USB_VENDOR_SEAGATE, 595, 0,
	    USB_VENDOR_CONNECTIX, 603, 0,
	    USB_VENDOR_KENSINGTON, 613, 0,
	    USB_VENDOR_LUCENT, 624, 0,
	    USB_VENDOR_PLANTRONICS, 631, 0,
	    USB_VENDOR_KYOCERA, 643, 651, 413, 0,
	    USB_VENDOR_STMICRO, 660, 0,
	    USB_VENDOR_FOXCONN, 679, 687, 689, 693, 0,
	    USB_VENDOR_MEIZU, 697, 464, 0,
	    USB_VENDOR_YAMAHA, 703, 0,
	    USB_VENDOR_COMPAQ, 710, 0,
	    USB_VENDOR_HITACHI, 717, 0,
	    USB_VENDOR_ACERP, 136, 725, 0,
	    USB_VENDOR_DAVIDCOM, 737, 0,
	    USB_VENDOR_VISIONEER, 745, 0,
	    USB_VENDOR_CANON, 755, 0,
	    USB_VENDOR_NIKON, 761, 0,
	    USB_VENDOR_IBM, 767, 0,
	    USB_VENDOR_CYPRESS, 771, 122, 0,
	    USB_VENDOR_EPSON, 779, 785, 0,
	    USB_VENDOR_RAINBOW, 791, 799, 0,
	    USB_VENDOR_IODATA, 812, 816, 0,
	    USB_VENDOR_TDK, 821, 0,
	    USB_VENDOR_3COMUSR, 825, 830, 0,
	    USB_VENDOR_METHODE, 839, 464, 847, 851, 0,
	    USB_VENDOR_MAXISWITCH, 856, 861, 0,
	    USB_VENDOR_LOCKHEEDMER, 868, 877, 884, 891, 0,
	    USB_VENDOR_FUJITSU, 273, 0,
	    USB_VENDOR_TOSHIBAAM, 900, 908, 0,
	    USB_VENDOR_MICROMACRO, 308, 916, 799, 0,
	    USB_VENDOR_KONICA, 922, 0,
	    USB_VENDOR_LITEON, 929, 153, 0,
	    USB_VENDOR_FUJIPHOTO, 937, 942, 948, 0,
	    USB_VENDOR_PHILIPSSEMI, 553, 953, 0,
	    USB_VENDOR_TATUNG, 968, 61, 975, 908, 0,
	    USB_VENDOR_SCANLOGIC, 978, 0,
	    USB_VENDOR_MYSON, 988, 153, 0,
	    USB_VENDOR_DIGI2, 994, 0,
	    USB_VENDOR_ITTCANON, 999, 755, 0,
	    USB_VENDOR_ALTEC, 1003, 1009, 0,
	    USB_VENDOR_MICROCHIP, 1017, 153, 0,
	    USB_VENDOR_HOLTEK, 1027, 122, 0,
	    USB_VENDOR_PANASONIC, 1034, 1044, 0,
	    USB_VENDOR_HUANHSIN, 1057, 1062, 0,
	    USB_VENDOR_SHARP, 1067, 0,
	    USB_VENDOR_IIYAMA, 1073, 0,
	    USB_VENDOR_EXAR, 1080, 0,
	    USB_VENDOR_SHUTTLE, 1085, 153, 0,
	    USB_VENDOR_SAMSUNG, 1093, 464, 0,
	    USB_VENDOR_ANNABOOKS, 1101, 0,
	    USB_VENDOR_JVC, 1111, 0,
	    USB_VENDOR_CHICONY, 1115, 464, 0,
	    USB_VENDOR_ELAN, 1123, 44, 0,
	    USB_VENDOR_BROTHER, 1128, 1136, 0,
	    USB_VENDOR_DALLAS, 1147, 122, 0,
	    USB_VENDOR_AIPTEK2, 1154, 322, 0,
	    USB_VENDOR_ACER, 136, 0,
	    USB_VENDOR_3COM, 1161, 0,
	    USB_VENDOR_HOSIDEN, 1166, 1174, 0,
	    USB_VENDOR_AZTECH, 1186, 228, 0,
	    USB_VENDOR_BELKIN, 1193, 1200, 0,
	    USB_VENDOR_KAWATSU, 1211, 122, 0,
	    USB_VENDOR_COMPOSITE, 1219, 0,
	    USB_VENDOR_APC, 509, 1229, 1235, 0,
	    USB_VENDOR_CONNECTEK, 257, 1246, 1256, 0,
	    USB_VENDOR_NETCHIP, 1260, 153, 0,
	    USB_VENDOR_ALTRA, 1268, 0,
	    USB_VENDOR_ATI, 1274, 799, 0,
	    USB_VENDOR_AKS, 1278, 1286, 228, 0,
	    USB_VENDOR_UNIACCESS, 1296, 245, 0,
	    USB_VENDOR_VIEWSONIC, 1306, 0,
	    USB_VENDOR_XIRLINK, 1316, 0,
	    USB_VENDOR_ANCHOR, 1324, 1331, 0,
	    USB_VENDOR_SONY, 1337, 0,
	    USB_VENDOR_VISION, 1342, 1347, 0,
	    USB_VENDOR_ASAHIKASEI, 1354, 1360, 565, 0,
	    USB_VENDOR_ATEN, 1366, 322, 0,
	    USB_VENDOR_MUSTEK, 1371, 228, 0,
	    USB_VENDOR_TELEX, 1378, 1384, 0,
	    USB_VENDOR_PERACOM, 1399, 1407, 0,
	    USB_VENDOR_ALCOR2, 1416, 308, 0,
	    USB_VENDOR_XYRATEX, 1422, 0,
	    USB_VENDOR_WACOM, 1430, 0,
	    USB_VENDOR_ETEK, 1436, 141, 0,
	    USB_VENDOR_EIZO, 1442, 0,
	    USB_VENDOR_ELECOM, 1447, 0,
	    USB_VENDOR_CONEXANT, 1454, 0,
	    USB_VENDOR_HAUPPAUGE, 1463, 236, 1473, 0,
	    USB_VENDOR_BAFO, 1479, 236, 1492, 0,
	    USB_VENDOR_YEDATA, 1504, 816, 0,
	    USB_VENDOR_AVM, 1508, 0,
	    USB_VENDOR_NINTENDO, 1512, 0,
	    USB_VENDOR_QUICKSHOT, 1521, 0,
	    USB_VENDOR_ROLAND, 1531, 0,
	    USB_VENDOR_ROCKFIRE, 1538, 0,
	    USB_VENDOR_RATOC, 1547, 228, 0,
	    USB_VENDOR_ZYXEL, 1553, 1559, 0,
	    USB_VENDOR_ALCOR, 1416, 308, 0,
	    USB_VENDOR_IOMEGA, 1573, 0,
	    USB_VENDOR_ATREND, 1580, 153, 0,
	    USB_VENDOR_AID, 257, 1588, 164, 0,
	    USB_VENDOR_LACIE, 1594, 0,
	    USB_VENDOR_CISCOLINKSYS3, 1600, 0,
	    USB_VENDOR_OMNIVISION, 1614, 0,
	    USB_VENDOR_INSYSTEM, 1625, 1635, 0,
	    USB_VENDOR_APPLE, 1642, 236, 0,
	    USB_VENDOR_DIGI, 994, 322, 0,
	    USB_VENDOR_QUALCOMM2, 1648, 0,
	    USB_VENDOR_QTRONIX, 1657, 0,
	    USB_VENDOR_ELSA, 1665, 0,
	    USB_VENDOR_BRAINBOXES, 1670, 1681, 0,
	    USB_VENDOR_ULTIMA, 1689, 0,
	    USB_VENDOR_AXIOHM, 1696, 1703, 1715, 0,
	    USB_VENDOR_MICROTEK, 1725, 0,
	    USB_VENDOR_SUNTAC, 1734, 1174, 0,
	    USB_VENDOR_LEXAR, 1738, 1744, 0,
	    USB_VENDOR_ADDTRON, 1750, 0,
	    USB_VENDOR_SYMBOL, 1758, 799, 0,
	    USB_VENDOR_GENESYS, 1765, 1773, 0,
	    USB_VENDOR_FUJI, 937, 347, 0,
	    USB_VENDOR_KEITHLEY, 1779, 375, 0,
	    USB_VENDOR_EIZONANAO, 1442, 1788, 0,
	    USB_VENDOR_KLSI, 1794, 1803, 0,
	    USB_VENDOR_FFC, 1807, 0,
	    USB_VENDOR_ANKO, 1811, 1816, 0,
	    USB_VENDOR_PIENGINEERING, 1827, 1832, 0,
	    USB_VENDOR_AOC, 1844, 322, 0,
	    USB_VENDOR_CHIC, 1848, 153, 0,
	    USB_VENDOR_BARCO, 1853, 1859, 228, 0,
	    USB_VENDOR_BRIDGE, 1867, 1874, 0,
	    USB_VENDOR_SMK, 1886, 0,
	    USB_VENDOR_SOLIDYEAR, 1890, 1896, 0,
	    USB_VENDOR_BIORAD, 1901, 1909, 0,
	    USB_VENDOR_MACALLY, 1922, 0,
	    USB_VENDOR_ACTLABS, 1930, 141, 0,
	    USB_VENDOR_ALARIS, 1934, 0,
	    USB_VENDOR_APEX, 1941, 0,
	    USB_VENDOR_CREATIVE3, 209, 141, 0,
	    USB_VENDOR_VIVITAR, 1946, 0,
	    USB_VENDOR_AVISION, 1954, 0,
	    USB_VENDOR_TEAC, 1962, 0,
	    USB_VENDOR_SGI, 394, 1967, 0,
	    USB_VENDOR_SANWASUPPLY, 1976, 1982, 0,
	    USB_VENDOR_WAYTECH, 1989, 1997, 24, 0,
	    USB_VENDOR_LINKSYS, 2010, 0,
	    USB_VENDOR_ACERSA, 136, 122, 908, 0,
	    USB_VENDOR_SIGMATEL, 2018, 0,
	    USB_VENDOR_DRAYTEK, 2027, 0,
	    USB_VENDOR_AIWA, 2035, 0,
	    USB_VENDOR_ACARD, 2040, 153, 0,
	    USB_VENDOR_PROLIFIC, 2046, 153, 0,
	    USB_VENDOR_SIEMENS, 2055, 0,
	    USB_VENDOR_AVANCELOGIC, 2063, 1773, 0,
	    USB_VENDOR_SIEMENS2, 2055, 0,
	    USB_VENDOR_MINOLTA, 2070, 0,
	    USB_VENDOR_CHPRODUCTS, 2078, 2081, 0,
	    USB_VENDOR_HAGIWARA, 2090, 2099, 0,
	    USB_VENDOR_CTX, 2107, 0,
	    USB_VENDOR_ASKEY, 2115, 236, 0,
	    USB_VENDOR_SAITEK, 2121, 0,
	    USB_VENDOR_ALCATELT, 2128, 2136, 0,
	    USB_VENDOR_AGFA, 2144, 0,
	    USB_VENDOR_ASIAMD, 2157, 2162, 2178, 0,
	    USB_VENDOR_BIZLINK, 2190, 322, 0,
	    USB_VENDOR_KEYSPAN, 2198, 0,
	    USB_VENDOR_AASHIMA, 2206, 153, 0,
	    USB_VENDOR_MULTITECH, 2214, 0,
	    USB_VENDOR_ADS, 2224, 799, 0,
	    USB_VENDOR_ALCATELM, 2128, 44, 0,
	    USB_VENDOR_SIRIUS, 2228, 799, 0,
	    USB_VENDOR_GUILLEMOT, 2235, 0,
	    USB_VENDOR_BOSTON, 2245, 2252, 0,
	    USB_VENDOR_SMC, 2262, 565, 0,
	    USB_VENDOR_PUTERCOM, 2271, 0,
	    USB_VENDOR_MCT, 2280, 0,
	    USB_VENDOR_IMATION, 2284, 0,
	    USB_VENDOR_SUSTEEN, 2292, 0,
	    USB_VENDOR_EICON, 2300, 1407, 0,
	    USB_VENDOR_MADCATZ, 2306, 2310, 24, 0,
	    USB_VENDOR_DIGITALSTREAM, 2316, 2324, 0,
	    USB_VENDOR_AUREAL, 2331, 122, 0,
	    USB_VENDOR_MIDIMAN, 2338, 0,
	    USB_VENDOR_CYBERPOWER, 2346, 2357, 24, 0,
	    USB_VENDOR_XRITE, 2366, 0,
	    USB_VENDOR_SURECOM, 2373, 153, 0,
	    USB_VENDOR_LINKSYS2, 2010, 0,
	    USB_VENDOR_GRIFFIN, 2381, 153, 0,
	    USB_VENDOR_SANDISK, 2389, 0,
	    USB_VENDOR_JENOPTIK, 2397, 0,
	    USB_VENDOR_LOGITEC, 2406, 0,
	    USB_VENDOR_BRIMAX, 2414, 0,
	    USB_VENDOR_AXIS, 2421, 1384, 0,
	    USB_VENDOR_ABL, 2426, 464, 0,
	    USB_VENDOR_SAGEM, 2430, 0,
	    USB_VENDOR_SUNCOMM, 561, 2436, 24, 0,
	    USB_VENDOR_ALFADATA, 2452, 236, 0,
	    USB_VENDOR_NATIONALTECH, 113, 2461, 228, 0,
	    USB_VENDOR_ONNTO, 2471, 0,
	    USB_VENDOR_BE, 2477, 0,
	    USB_VENDOR_ADMTEK, 2480, 0,
	    USB_VENDOR_COREGA, 2487, 0,
	    USB_VENDOR_FREECOM, 2494, 0,
	    USB_VENDOR_MICROTECH, 2502, 0,
	    USB_VENDOR_GENERALINSTMNTS, 2512, 375, 2520, 0,
	    USB_VENDOR_OLYMPUS, 2531, 0,
	    USB_VENDOR_ABOCOM, 2539, 228, 0,
	    USB_VENDOR_KINGSUN, 2546, 0,
	    USB_VENDOR_KEISOKUGIKEN, 2554, 0,
	    USB_VENDOR_ONSPEC, 2567, 0,
	    USB_VENDOR_APG, 2574, 2578, 2583, 0,
	    USB_VENDOR_BUG, 2590, 0,
	    USB_VENDOR_ALLIEDTELESYN, 2597, 2604, 322, 0,
	    USB_VENDOR_AVERMEDIA, 2612, 799, 0,
	    USB_VENDOR_SIIG, 2622, 0,
	    USB_VENDOR_CASIO, 2627, 0,
	    USB_VENDOR_DLINK2, 2633, 0,
	    USB_VENDOR_APTIO, 2640, 2081, 0,
	    USB_VENDOR_ARASAN, 2646, 2653, 228, 0,
	    USB_VENDOR_ALLIEDCABLE, 2597, 2658, 0,
	    USB_VENDOR_STSN, 2664, 0,
	    USB_VENDOR_BEWAN, 2669, 0,
	    USB_VENDOR_CENTURY, 2675, 1174, 0,
	    USB_VENDOR_ZOOM, 2683, 2688, 0,
	    USB_VENDOR_ZORAN, 2700, 44, 0,
	    USB_VENDOR_SYNET, 2706, 464, 0,
	    USB_VENDOR_BROADLOGIC, 2712, 0,
	    USB_VENDOR_HANDSPRING, 2723, 0,
	    USB_VENDOR_PALM, 2734, 2739, 0,
	    USB_VENDOR_SOURCENEXT, 2749, 0,
	    USB_VENDOR_ACTIONSTAR, 2760, 2767, 2772, 0,
	    USB_VENDOR_ACCTON, 2783, 153, 0,
	    USB_VENDOR_DIAMOND, 423, 0,
	    USB_VENDOR_NETGEAR, 2790, 0,
	    USB_VENDOR_ACTIVEWIRE, 2801, 0,
	    USB_VENDOR_BBELECTRONICS, 2812, 464, 0,
	    USB_VENDOR_PORTGEAR, 2816, 0,
	    USB_VENDOR_NETGEAR2, 2825, 0,
	    USB_VENDOR_SYSTEMTALKS, 2833, 2840, 0,
	    USB_VENDOR_METRICOM, 2846, 0,
	    USB_VENDOR_ADESSOKBTEK, 2855, 908, 0,
	    USB_VENDOR_JATON, 2868, 0,
	    USB_VENDOR_APT, 2874, 799, 0,
	    USB_VENDOR_BOCARESEARCH, 2878, 891, 0,
	    USB_VENDOR_ANDREA, 2883, 464, 0,
	    USB_VENDOR_BURRBROWN, 2890, 2901, 0,
	    USB_VENDOR_2WIRE, 2907, 0,
	    USB_VENDOR_AIPTEK, 1154, 322, 0,
	    USB_VENDOR_SMARTBRIDGES, 2913, 0,
	    USB_VENDOR_BILLIONTON, 2926, 228, 0,
	    USB_VENDOR_EXTENDED, 2937, 228, 0,
	    USB_VENDOR_MSYSTEMS, 2946, 0,
	    USB_VENDOR_AUTHENTEC, 2956, 0,
	    USB_VENDOR_AUDIOTECHNICA, 2966, 0,
	    USB_VENDOR_TRUMPION, 2981, 44, 0,
	    USB_VENDOR_ALATION, 2990, 228, 0,
	    USB_VENDOR_GLOBESPAN, 2998, 0,
	    USB_VENDOR_CONCORDCAMERA, 3008, 3016, 0,
	    USB_VENDOR_GARMIN, 3023, 322, 0,
	    USB_VENDOR_GOHUBS, 3030, 0,
	    USB_VENDOR_BIOMETRIC, 509, 3037, 3047, 0,
	    USB_VENDOR_TOSHIBA, 900, 0,
	    USB_VENDOR_PIXART, 3055, 0,
	    USB_VENDOR_PLEXTOR, 3062, 0,
	    USB_VENDOR_INTREPIDCS, 3070, 0,
	    USB_VENDOR_YANO, 3079, 0,
	    USB_VENDOR_KINGSTON, 3084, 153, 0,
	    USB_VENDOR_BLUEWATER, 3093, 228, 0,
	    USB_VENDOR_AGILENT, 3103, 799, 0,
	    USB_VENDOR_GUDE, 3111, 2224, 0,
	    USB_VENDOR_PORTSMITH, 3116, 0,
	    USB_VENDOR_ACERW, 136, 0,
	    USB_VENDOR_GRETAGMACBETH, 3126, 0,
	    USB_VENDOR_ADIRONDACK, 3140, 3151, 3156, 2658, 0,
	    USB_VENDOR_BECKHOFF, 3158, 0,
	    USB_VENDOR_MINDSATWORK, 3167, 3173, 3176, 0,
	    USB_VENDOR_ZIPPY, 3181, 153, 1174, 0,
	    USB_VENDOR_POINTCHIPS, 3187, 0,
	    USB_VENDOR_INTERSIL, 3198, 0,
	    USB_VENDOR_TRIPPLITE2, 3207, 3213, 0,
	    USB_VENDOR_ALTIUS, 3218, 1715, 0,
	    USB_VENDOR_ARRIS, 3225, 3231, 0,
	    USB_VENDOR_ACTIVCARD, 3243, 0,
	    USB_VENDOR_ACTISYS, 3253, 0,
	    USB_VENDOR_NOVATEL, 3261, 651, 0,
	    USB_VENDOR_AFOURTECH, 3269, 3276, 0,
	    USB_VENDOR_AIMEX, 3281, 0,
	    USB_VENDOR_ADDONICS, 3287, 799, 0,
	    USB_VENDOR_AKAI, 3296, 3301, 3314, 0,
	    USB_VENDOR_ARESCOM, 3319, 0,
	    USB_VENDOR_BAY, 3327, 3331, 0,
	    USB_VENDOR_ALTERA, 3342, 0,
	    USB_VENDOR_CSR, 3349, 394, 3359, 0,
	    USB_VENDOR_TREK, 3365, 153, 0,
	    USB_VENDOR_ASAHIOPTICAL, 1354, 3370, 0,
	    USB_VENDOR_BOCASYSTEMS, 2878, 228, 0,
	    USB_VENDOR_SHANTOU, 3378, 0,
	    USB_VENDOR_MEDIAGEAR, 3386, 0,
	    USB_VENDOR_BROADCOM, 3396, 0,
	    USB_VENDOR_GREENHOUSE, 3405, 0,
	    USB_VENDOR_GEOCAST, 3416, 3424, 228, 0,
	    USB_VENDOR_ZYDAS, 3432, 153, 1174, 0,
	    USB_VENDOR_NEODIO, 3438, 0,
	    USB_VENDOR_OPTIONNV, 3445, 3452, 0,
	    USB_VENDOR_ASUSTEK, 3457, 236, 0,
	    USB_VENDOR_TODOS, 3465, 816, 2833, 0,
	    USB_VENDOR_SIIG2, 2622, 0,
	    USB_VENDOR_TEKRAM, 3471, 153, 0,
	    USB_VENDOR_HAL, 3478, 1174, 0,
	    USB_VENDOR_EMS, 3482, 3486, 0,
	    USB_VENDOR_NEC2, 172, 0,
	    USB_VENDOR_ATI2, 1274, 799, 0,
	    USB_VENDOR_ZEEVO, 3497, 24, 0,
	    USB_VENDOR_KURUSUGAWA, 3504, 3515, 24, 0,
	    USB_VENDOR_ASIX, 3528, 464, 0,
	    USB_VENDOR_PROLIFIC2, 2046, 153, 3533, 0,
	    USB_VENDOR_O2MICRO, 3537, 308, 0,
	    USB_VENDOR_USR, 825, 830, 0,
	    USB_VENDOR_AMBIT, 3540, 565, 0,
	    USB_VENDOR_HTC, 3546, 0,
	    USB_VENDOR_REALTEK, 3550, 0,
	    USB_VENDOR_ADDONICS2, 3287, 153, 0,
	    USB_VENDOR_FSC, 273, 2055, 3558, 0,
	    USB_VENDOR_AGATE, 3568, 799, 0,
	    USB_VENDOR_DMI, 3574, 0,
	    USB_VENDOR_MICRODIA, 3578, 687, 3587, 153, 3593, 3598, 0,
	    USB_VENDOR_SEALEVEL, 3603, 2833, 0,
	    USB_VENDOR_LUWEN, 3612, 0,
	    USB_VENDOR_QUALCOMM_K, 1648, 643, 0,
	    USB_VENDOR_ZCOM, 3621, 0,
	    USB_VENDOR_ATHEROS2, 3627, 1384, 0,
	    USB_VENDOR_TANGTOP, 3635, 0,
	    USB_VENDOR_SMC3, 2262, 565, 0,
	    USB_VENDOR_PEN, 3643, 3647, 0,
	    USB_VENDOR_ACDC, 509, 236, 3156, 2316, 1200, 0,
	    USB_VENDOR_CMEDIA, 3653, 464, 24, 0,
	    USB_VENDOR_CONCEPTRONIC2, 3661, 0,
	    USB_VENDOR_MSI, 308, 2767, 0,
	    USB_VENDOR_ELCON, 3674, 3680, 0,
	    USB_VENDOR_NETWORKFAB, 3694, 1174, 0,
	    USB_VENDOR_SITECOMEU, 3705, 3713, 0,
	    USB_VENDOR_AMIGO, 3720, 153, 0,
	    USB_VENDOR_HAWKING, 3726, 0,
	    USB_VENDOR_GMATE, 3734, 3533, 0,
	    USB_VENDOR_MTK, 3742, 0,
	    USB_VENDOR_OTI, 3746, 153, 0,
	    USB_VENDOR_PILOTECH, 3751, 0,
	    USB_VENDOR_NOVATECH, 3760, 3765, 0,
	    USB_VENDOR_EGALAX, 3770, 0,
	    USB_VENDOR_TOD, 3777, 0,
	    USB_VENDOR_AIRPRIME, 3781, 3791, 0,
	    USB_VENDOR_VTECH, 3804, 0,
	    USB_VENDOR_FALCOM, 3810, 651, 1384, 3817, 0,
	    USB_VENDOR_RIM, 891, 3822, 3825, 0,
	    USB_VENDOR_DYNASTREAM, 3832, 3843, 0,
	    USB_VENDOR_SUNRISING, 3855, 0,
	    USB_VENDOR_DVICO, 3865, 0,
	    USB_VENDOR_LG, 3871, 464, 0,
	    USB_VENDOR_MOTOROLA4, 3874, 0,
	    USB_VENDOR_HP3, 89, 97, 0,
	    USB_VENDOR_GIGABYTE, 3883, 0,
	    USB_VENDOR_YUBICO, 3892, 0,
	    USB_VENDOR_WESTERN, 3902, 2316, 0,
	    USB_VENDOR_MOTOROLA, 3874, 0,
	    USB_VENDOR_CCYU, 3910, 153, 0,
	    USB_VENDOR_HYUNDAI, 3915, 3923, 0,
	    USB_VENDOR_SILABS2, 3931, 0,
	    USB_VENDOR_USI, 3939, 0,
	    USB_VENDOR_PLX, 3943, 0,
	    USB_VENDOR_ASANTE, 3947, 0,
	    USB_VENDOR_SILABS, 394, 141, 0,
	    USB_VENDOR_TENX, 3954, 3958, 3960, 24, 0,
	    USB_VENDOR_JRC, 2901, 3359, 3047, 0,
	    USB_VENDOR_SPHAIRON, 3972, 245, 228, 3817, 0,
	    USB_VENDOR_DELORME, 3981, 0,
	    USB_VENDOR_SERVERWORKS, 3989, 0,
	    USB_VENDOR_ACERCM, 136, 1384, 3156, 4001, 0,
	    USB_VENDOR_SIERRA, 4012, 651, 0,
	    USB_VENDOR_TOPFIELD, 4019, 3593, 4028, 0,
	    USB_VENDOR_NETINDEX, 4032, 0,
	    USB_VENDOR_INTERBIO, 4041, 0,
	    USB_VENDOR_FUJITSU2, 273, 3598, 0,
	    USB_VENDOR_UNKNOWN3, 1, 9, 0,
	    USB_VENDOR_TSUNAMI, 4057, 0,
	    USB_VENDOR_PHEENET, 4065, 0,
	    USB_VENDOR_TARGUS, 4073, 0,
	    USB_VENDOR_TWINMOS, 4080, 0,
	    USB_VENDOR_CREATIVE2, 209, 141, 0,
	    USB_VENDOR_BELKIN2, 1193, 1200, 0,
	    USB_VENDOR_CYBERTAN, 4088, 153, 0,
	    USB_VENDOR_HUAWEI, 4097, 799, 0,
	    USB_VENDOR_ARANEUS, 4104, 1874, 228, 4112, 0,
	    USB_VENDOR_AINCOMM, 4115, 0,
	    USB_VENDOR_MOBILITY, 4123, 0,
	    USB_VENDOR_DICKSMITH, 4132, 4137, 464, 0,
	    USB_VENDOR_NETGEAR3, 2825, 0,
	    USB_VENDOR_VALIDITY, 4143, 4152, 24, 0,
	    USB_VENDOR_BALTECH, 4161, 0,
	    USB_VENDOR_CISCOLINKSYS, 1600, 0,
	    USB_VENDOR_SHARK, 4169, 0,
	    USB_VENDOR_AZUREWAVE, 4175, 0,
	    USB_VENDOR_PHISON, 4185, 464, 413, 0,
	    USB_VENDOR_NOVATEL2, 3261, 0,
	    USB_VENDOR_OMNIVISION2, 1614, 4192, 24, 0,
	    USB_VENDOR_MERLIN, 4206, 0,
	    USB_VENDOR_WISTRONNEWEB, 4213, 4221, 0,
	    USB_VENDOR_HUAWEI3COM, 4227, 0,
	    USB_VENDOR_ABOCOM2, 2539, 228, 0,
	    USB_VENDOR_SILICOM, 4239, 0,
	    USB_VENDOR_RALINK, 4247, 153, 0,
	    USB_VENDOR_CONCEPTRONIC, 3661, 0,
	    USB_VENDOR_SUPERTOP, 4254, 0,
	    USB_VENDOR_PLANEX3, 4263, 1384, 0,
	    USB_VENDOR_SILICONPORTALS, 394, 4270, 0,
	    USB_VENDOR_TOPPING, 4278, 464, 3156, 153, 4286, 0,
	    USB_VENDOR_JMICRON, 4290, 0,
	    USB_VENDOR_OQO, 4298, 0,
	    USB_VENDOR_UMEDIA, 4302, 1384, 0,
	    USB_VENDOR_FIBERLINE, 4310, 0,
	    USB_VENDOR_SPARKLAN, 4320, 0,
	    USB_VENDOR_AMIT2, 4329, 0,
	    USB_VENDOR_SOHOWARE, 4334, 0,
	    USB_VENDOR_UMAX, 4343, 816, 228, 0,
	    USB_VENDOR_INSIDEOUT, 4348, 4355, 1407, 0,
	    USB_VENDOR_GOODWAY, 4359, 4364, 153, 0,
	    USB_VENDOR_ENTREGA, 4368, 0,
	    USB_VENDOR_ACTIONTEC, 4376, 464, 0,
	    USB_VENDOR_CISCOLINKSYS2, 1600, 0,
	    USB_VENDOR_ATHEROS, 3627, 1384, 0,
	    USB_VENDOR_GIGASET, 4386, 0,
	    USB_VENDOR_ANYDATA, 4394, 24, 0,
	    USB_VENDOR_JABLOTRON, 4402, 0,
	    USB_VENDOR_LINKSYS4, 2010, 0,
	    USB_VENDOR_SENAO, 4412, 0,
	    USB_VENDOR_ASMEDIA, 4418, 0,
	    USB_VENDOR_ASUSTEK2, 3457, 236, 0,
	    USB_VENDOR_SWEEX2, 4426, 0,
	    USB_VENDOR_MISC, 4432, 4437, 0,
	    USB_VENDOR_DISPLAYLINK, 4445, 0,
	    USB_VENDOR_LENOVO, 4457, 0,
	    USB_VENDOR_E3C, 4464, 799, 0,
	    USB_VENDOR_AMIT, 4329, 0,
	    USB_VENDOR_QCOM, 4468, 0,
	    USB_VENDOR_LINKSYS3, 2010, 0,
	    USB_VENDOR_MEINBERG, 4473, 4482, 0,
	    USB_VENDOR_BECEEM, 4492, 1384, 0,
	    USB_VENDOR_ZTE, 4499, 0,
	    USB_VENDOR_QUANTA, 4503, 0,
	    USB_VENDOR_TERMINUS, 4510, 153, 0,
	    USB_VENDOR_QINHENG, 4519, 464, 0,
	    USB_VENDOR_OVISLINK, 4527, 0,
	    USB_VENDOR_LONGCHEER, 4536, 153, 0,
	    USB_VENDOR_MPMAN, 4546, 0,
	    USB_VENDOR_PEGATRON, 4552, 0,
	    USB_VENDOR_FUTUREBITS, 146, 4561, 0,
	    USB_VENDOR_LINUXFOUNDATION, 4566, 4572, 0,
	    USB_VENDOR_CINTERION, 4583, 0,
	    USB_VENDOR_AIRTIES, 4593, 0,
	    USB_VENDOR_DLINK, 2633, 0,
	    USB_VENDOR_PLANEX2, 4263, 1384, 0,
	    USB_VENDOR_ENCORE, 4601, 0,
	    USB_VENDOR_HAUPPAUGE2, 1463, 236, 1473, 0,
	    USB_VENDOR_PARA, 4608, 4613, 0,
	    USB_VENDOR_TRENDNET, 4624, 0,
	    USB_VENDOR_RTSYS, 4633, 228, 0,
	    USB_VENDOR_DLINK3, 2633, 0,
	    USB_VENDOR_VIALABS, 199, 141, 0,
	    USB_VENDOR_ERICSSON, 4636, 0,
	    USB_VENDOR_MOTOROLA2, 3874, 0,
	    USB_VENDOR_PINNACLE, 4645, 228, 0,
	    USB_VENDOR_ARDUINO, 4654, 4662, 0,
	    USB_VENDOR_TPLINK, 4665, 0,
	    USB_VENDOR_WMR, 4673, 4678, 3359, 0,
	    USB_VENDOR_TRIPPLITE, 4687, 0,
	    USB_VENDOR_COOLERMASTER, 4698, 4705, 153, 24, 0,
	    USB_VENDOR_HAILUCK, 4712, 3593, 4028, 0,
	    USB_VENDOR_HIROSE, 4720, 347, 0,
	    USB_VENDOR_ONEPLUS, 4727, 0,
	    USB_VENDOR_NHJ, 4735, 0,
	    USB_VENDOR_PLANEX, 4263, 1384, 0,
	    USB_VENDOR_MERCUSYS, 4739, 0,
	    USB_VENDOR_VIDZMEDIA, 4748, 4758, 4028, 0,
	    USB_VENDOR_AEI, 4762, 0,
	    USB_VENDOR_HANK, 4766, 4771, 0,
	    USB_VENDOR_PQI, 4782, 0,
	    USB_VENDOR_DAISY, 4786, 153, 0,
	    USB_VENDOR_NI, 113, 375, 0,
	    USB_VENDOR_MICRONET, 4792, 1384, 0,
	    USB_VENDOR_IODATA2, 812, 816, 0,
	    USB_VENDOR_IRIVER, 4801, 0,
	    USB_VENDOR_DELL, 4808, 0,
	    USB_VENDOR_QINHENG2, 4519, 464, 0,
	    USB_VENDOR_FEIXUN, 4813, 1559, 0,
	    USB_VENDOR_AVERATEC, 4820, 0,
	    USB_VENDOR_SWEEX, 4426, 0,
	    USB_VENDOR_ONSPEC2, 2567, 1816, 24, 0,
	    USB_VENDOR_ZINWELL, 4829, 0,
	    USB_VENDOR_INGENIC, 4837, 122, 3598, 0,
	    USB_VENDOR_SITECOM, 3705, 0,
	    USB_VENDOR_SPRINGERDESIGN, 4845, 4854, 24, 0,
	    USB_VENDOR_ARKMICROCHIPS, 4862, 0,
	    USB_VENDOR_3COM2, 1161, 0,
	    USB_VENDOR_EDIMAX, 4876, 0,
	    USB_VENDOR_INTEL, 4883, 0,
	    USB_VENDOR_INTEL2, 4883, 0,
	    USB_VENDOR_ALLWIN, 4889, 3765, 0,
	    USB_VENDOR_MOSCHIP, 4896, 122, 0,
	    USB_VENDOR_NETGEAR4, 2825, 0,
	    USB_VENDOR_xxFTDI, 4904, 0,
	    USB_VENDOR_CACE, 4909, 799, 0,
	    USB_VENDOR_COMPARE, 4914, 0,
	    USB_VENDOR_DATAAPEX, 4922, 0,
	    USB_VENDOR_EVOLUTION, 4931, 830, 0,
	    USB_VENDOR_EMPIA, 4941, 153, 0,
	    USB_VENDOR_HP2, 89, 97, 0,
	    USB_VENDOR_USRP, 4947, 3359, 4951, 0,
};

static const uint32_t usb_products[] = {
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_HOMECONN, 
	    4956, 4968, 3016, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3CREB96, 
	    4972, 4968, 4982, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3C19250, 
	    4990, 4998, 5007, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3CRSHEW696, 
	    5015, 651, 4982, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3C460, 
	    4956, 5026, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_USR56K, 
	    5032, 5045, 5051, 5057, 5066, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3C460B, 
	    4956, 5070, 0,
	    USB_VENDOR_3COM2, USB_PRODUCT_3COM2_3CRUSB10075, 
	    5077, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_OFFICECONN, 
	    1161, 5089, 387, 5103, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_USRISDN, 
	    1161, 825, 830, 5066, 5109, 5114, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_HOMECONN, 
	    1161, 4956, 5117, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_USR56K, 
	    5032, 5045, 5051, 5057, 5066, 0,
	    USB_VENDOR_ACDC, USB_PRODUCT_ACDC_HUB, 
	    4968, 3643, 3647, 5124, 0,
	    USB_VENDOR_ACDC, USB_PRODUCT_ACDC_SECWRITE, 
	    4968, 3643, 3647, 5128, 5135, 0,
	    USB_VENDOR_ACDC, USB_PRODUCT_ACDC_PEN, 
	    4968, 3643, 3647, 5141, 5128, 5135, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX1, 
	    5146, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX2, 
	    5150, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2770, 
	    5154, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2870, 
	    5161, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT3070, 
	    5168, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT3071, 
	    5175, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT3072, 
	    5182, 0,
	    USB_VENDOR_ABOCOM2, USB_PRODUCT_ABOCOM2_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_URE450, 
	    5189, 4998, 4982, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_UFE1000, 
	    5196, 5204, 4998, 4982, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_DSB650TX_PNA, 
	    5209, 5218, 5007, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX4, 
	    5227, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX5, 
	    5231, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX6, 
	    5235, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX7, 
	    5239, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_LCS8138TX, 
	    5243, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX8, 
	    5254, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX9, 
	    5258, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_UFE2000, 
	    5262, 5270, 5204, 4998, 4982, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_WL54, 
	    5277, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8188EU, 
	    5292, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8188CU_1, 
	    5302, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8188CU_2, 
	    5302, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX10, 
	    5312, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_BWU613, 
	    5317, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_HWU54DM, 
	    5324, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2573_2, 
	    5332, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2573_3, 
	    5332, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2573_4, 
	    5332, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_WUG2700, 
	    5339, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_USB320_EC, 
	    5347, 4998, 4982, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_2664W, 
	    5357, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_111, 
	    5363, 5371, 5375, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SMCWUSBG, 
	    5380, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SMCWUSBTG2, 
	    5390, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SMCWUSBTG2_NF, 
	    5390, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_PRISM_GT, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SS1001, 
	    5414, 4998, 4982, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2770, 
	    5154, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_5, 
	    5161, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_4, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_4, 
	    5161, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_1, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_6, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_AR9280, 
	    5426, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RTL8192SU, 
	    5440, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_5, 
	    5168, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_WN4501H_LF_IR, 
	    5458, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_WUS201, 
	    5472, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_WN7512, 
	    5480, 0,
	    USB_VENDOR_ACERCM, USB_PRODUCT_ACERCM_EP1427X2, 
	    5487, 4998, 0,
	    USB_VENDOR_ACERLABS, USB_PRODUCT_ACERLABS_M5632, 
	    4968, 5410, 816, 5498, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_C310U, 
	    5503, 5512, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_320U, 
	    5503, 5518, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_640U, 
	    5503, 5523, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_620U, 
	    5503, 5528, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ATAPI, 
	    5533, 5007, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_AWL300, 
	    5543, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_AWL400, 
	    5550, 0,
	    USB_VENDOR_ACERW, USB_PRODUCT_ACERW_WARPLINK, 
	    5557, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_PRISM_25, 
	    5566, 5375, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_PRISM_25A, 
	    5566, 5375, 5575, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_AR9287, 
	    5577, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_FREELAN, 
	    5591, 5597, 5605, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_UAT1, 
	    5613, 651, 4998, 5007, 0,
	    USB_VENDOR_ACTISYS, USB_PRODUCT_ACTISYS_IR2000U, 
	    5618, 5630, 0,
	    USB_VENDOR_ACTIVEWIRE, USB_PRODUCT_ACTIVEWIRE_IOBOARD, 
	    5634, 5638, 0,
	    USB_VENDOR_ACTIVEWIRE, USB_PRODUCT_ACTIVEWIRE_IOBOARD_FW1, 
	    5634, 5644, 5651, 5656, 5658, 0,
	    USB_VENDOR_ADAPTEC, USB_PRODUCT_ADAPTEC_AWN8020, 
	    5667, 5375, 0,
	    USB_VENDOR_ADDONICS2, USB_PRODUCT_ADDONICS2_205, 
	    2658, 5676, 0,
	    USB_VENDOR_ADDTRON, USB_PRODUCT_ADDTRON_AWU120, 
	    5680, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII_4, 
	    5688, 4998, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUS, 
	    5695, 4968, 4998, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII, 
	    5701, 4968, 4998, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII_2, 
	    5708, 4998, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII_3, 
	    5715, 4968, 5410, 4998, 0,
	    USB_VENDOR_ADS, USB_PRODUCT_ADS_UBS10BT, 
	    5723, 4998, 0,
	    USB_VENDOR_ADS, USB_PRODUCT_ADS_UBS10BTX, 
	    5723, 4998, 0,
	    USB_VENDOR_ADS, USB_PRODUCT_ADS_RDX155, 
	    5732, 5742, 0,
	    USB_VENDOR_AEI, USB_PRODUCT_AEI_USBTOLAN, 
	    4762, 4968, 5748, 5751, 5007, 0,
	    USB_VENDOR_AGATE, USB_PRODUCT_AGATE_QDRIVE, 
	    5755, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCAN1212U, 
	    5763, 5772, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCAN1236U, 
	    5763, 5778, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANTOUCH, 
	    5763, 5784, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCAN1212U2, 
	    5763, 5772, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE40, 
	    5763, 5790, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE50, 
	    5763, 5794, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE20, 
	    5763, 5798, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE25, 
	    5763, 5802, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE26, 
	    5763, 5806, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE52, 
	    5763, 5810, 0,
	    USB_VENDOR_ARANEUS, USB_PRODUCT_ARANEUS_ALEA, 
	    5814, 5819, 5824, 0,
	    USB_VENDOR_AINCOMM, USB_PRODUCT_AINCOMM_AWU2000B, 
	    5829, 0,
	    USB_VENDOR_AIPTEK2, USB_PRODUCT_AIPTEK2_PENCAM_MEGA_1_3, 
	    5838, 5845, 5850, 0,
	    USB_VENDOR_AIRPRIME, USB_PRODUCT_AIRPRIME_PC5220, 
	    5854, 651, 5859, 5862, 0,
	    USB_VENDOR_AIRTIES, USB_PRODUCT_AIRTIES_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_AIRTIES, USB_PRODUCT_AIRTIES_RT3070, 
	    5168, 0,
	    USB_VENDOR_AKS, USB_PRODUCT_AKS_USBHASP, 
	    5867, 5876, 0,
	    USB_VENDOR_ALCATELT, USB_PRODUCT_ALCATELT_ST120G, 
	    5881, 5892, 0,
	    USB_VENDOR_ALCATELT, USB_PRODUCT_ALCATELT_ST121G, 
	    5881, 5897, 0,
	    USB_VENDOR_ALCOR2, USB_PRODUCT_ALCOR2_KBD_HUB, 
	    5902, 5906, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_AU6366, 
	    5910, 5270, 5917, 5924, 5928, 5937, 5862, 5943, 5950, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_MA_KBD_HUB, 
	    5961, 5902, 5906, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_AU9814, 
	    5969, 5906, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_SM_KBD, 
	    5976, 6002, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_NEC_KBD_HUB, 
	    172, 5902, 5906, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT2070, 
	    6011, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT2770, 
	    5154, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT2870, 
	    5161, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3070, 
	    5168, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3071, 
	    5175, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3072, 
	    5182, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3572, 
	    6018, 0,
	    USB_VENDOR_ALTEC, USB_PRODUCT_ALTEC_ADA70, 
	    6025, 6031, 0,
	    USB_VENDOR_ALTEC, USB_PRODUCT_ALTEC_ASC495, 
	    6040, 6031, 0,
	    USB_VENDOR_APC, USB_PRODUCT_APC_UPS, 
	    6047, 1229, 1982, 0,
	    USB_VENDOR_APC, USB_PRODUCT_APC_UPS3, 
	    6047, 1229, 1982, 0,
	    USB_VENDOR_AMBIT, USB_PRODUCT_AMBIT_NTL_250, 
	    6063, 6067, 6071, 6077, 0,
	    USB_VENDOR_AMD, USB_PRODUCT_AMD_TV_WONDER_600_USB, 
	    6083, 6086, 6093, 4968, 0,
	    USB_VENDOR_AMIGO, USB_PRODUCT_AMIGO_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_AMIGO, USB_PRODUCT_AMIGO_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_AMIT, USB_PRODUCT_AMIT_CGWLUSB2GO, 
	    6097, 0,
	    USB_VENDOR_AMIT, USB_PRODUCT_AMIT_CGWLUSB2GNR, 
	    6109, 0,
	    USB_VENDOR_AMIT, USB_PRODUCT_AMIT_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_AMIT2, USB_PRODUCT_AMIT2_RT2870, 
	    5161, 0,
	    USB_VENDOR_ANCHOR, USB_PRODUCT_ANCHOR_EZUSB, 
	    6122, 0,
	    USB_VENDOR_ANCHOR, USB_PRODUCT_ANCHOR_EZLINK, 
	    6128, 0,
	    USB_VENDOR_ANYDATA, USB_PRODUCT_ANYDATA_A2502, 
	    6135, 6139, 6146, 0,
	    USB_VENDOR_ANYDATA, USB_PRODUCT_ANYDATA_ADU_E100H, 
	    6152, 0,
	    USB_VENDOR_ANYDATA, USB_PRODUCT_ANYDATA_ADU_500A, 
	    6162, 0,
	    USB_VENDOR_AOX, USB_PRODUCT_AOX_USB101, 
	    4968, 5218, 6172, 6183, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_EXT_KBD, 
	    1642, 2937, 4968, 6002, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_FOUNTAIN_ANSI, 
	    1642, 6190, 6199, 6217, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_FOUNTAIN_ISO, 
	    1642, 6190, 6199, 6233, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER_ANSI, 
	    1642, 6190, 6199, 6248, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER_ISO, 
	    1642, 6190, 6199, 6262, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER_JIS, 
	    1642, 6190, 6199, 6275, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER3_ANSI, 
	    1642, 6190, 6199, 6288, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER3_ISO, 
	    1642, 6190, 6199, 6303, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER3_JIS, 
	    1642, 6190, 6199, 6317, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER4_ANSI, 
	    1642, 6190, 6199, 6331, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER4_ISO, 
	    1642, 6190, 6199, 6346, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER4_JIS, 
	    1642, 6190, 6199, 6360, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING_ANSI, 
	    1642, 6190, 6199, 6374, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING_ISO, 
	    1642, 6190, 6199, 6392, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING_JIS, 
	    1642, 6190, 6199, 6409, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING2_ANSI, 
	    1642, 6190, 6199, 6426, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING2_ISO, 
	    1642, 6190, 6199, 6445, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING2_JIS, 
	    1642, 6190, 6199, 6463, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_OPTMOUSE, 
	    3370, 6481, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_MIGHTYMOUSE, 
	    6487, 6494, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_FOUNTAIN_TP, 
	    1642, 6190, 6500, 6509, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER1_TP, 
	    1642, 6190, 6500, 6520, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_MAGICMOUSE, 
	    6529, 6494, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_MAGICTRACKPAD, 
	    6529, 6500, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HIDMODE, 
	    4972, 6535, 6539, 6550, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_EXT_KBD_HUB, 
	    5906, 6556, 1642, 2937, 4968, 6002, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_SPEAKERS, 
	    6031, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_SHUFFLE2, 
	    6559, 6564, 6572, 6577, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE, 
	    6589, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPOD_TOUCH, 
	    6559, 5784, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPOD_TOUCH_4G, 
	    6559, 5784, 6596, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_3G, 
	    6589, 6599, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_3GS, 
	    6589, 6602, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_4, 
	    6589, 6606, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_4_VZW, 
	    6589, 6606, 6608, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_4S, 
	    6589, 6614, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_5, 
	    6589, 6617, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD, 
	    1642, 6619, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD_2, 
	    1642, 6619, 6624, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD_3, 
	    1642, 6619, 6626, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD_MINI, 
	    1642, 6619, 6628, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_ETHERNET, 
	    1642, 4968, 5748, 4998, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH1, 
	    4972, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH2, 
	    4972, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_1, 
	    4972, 4968, 6633, 5950, 6638, 6649, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_2, 
	    4972, 4968, 6633, 5950, 6653, 6658, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_3, 
	    4972, 4968, 6633, 5950, 6638, 6663, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_4, 
	    4972, 4968, 6633, 5950, 6667, 6678, 6682, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_5, 
	    4972, 4968, 6633, 5950, 6667, 6686, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_6, 
	    4972, 4968, 6633, 5950, 6690, 6698, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_7, 
	    4972, 4968, 6633, 5950, 6667, 6702, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_8, 
	    4972, 4968, 6633, 5950, 6638, 6706, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH, 
	    4972, 0,
	    USB_VENDOR_ARKMICROCHIPS, USB_PRODUCT_ARKMICROCHIPS_USBSERIAL, 
	    6710, 5950, 0,
	    USB_VENDOR_ASAHIOPTICAL, USB_PRODUCT_ASAHIOPTICAL_OPTIO230, 
	    6719, 6726, 0,
	    USB_VENDOR_ASAHIOPTICAL, USB_PRODUCT_ASAHIOPTICAL_OPTIO330, 
	    2316, 5117, 0,
	    USB_VENDOR_ASANTE, USB_PRODUCT_ASANTE_EA, 
	    4998, 4982, 0,
	    USB_VENDOR_ASKEY, USB_PRODUCT_ASKEY_WLL013I, 
	    6735, 6742, 0,
	    USB_VENDOR_ASKEY, USB_PRODUCT_ASKEY_WLL013, 
	    6735, 0,
	    USB_VENDOR_ASKEY, USB_PRODUCT_ASKEY_VOYAGER1010, 
	    6753, 6761, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88172, 
	    6766, 4968, 5410, 6774, 5218, 6172, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88178, 
	    6781, 4968, 5410, 6789, 5218, 6172, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88178A, 
	    6797, 4968, 5410, 6789, 5218, 6172, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88179, 
	    6806, 4968, 6814, 6789, 5218, 6172, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772, 
	    6818, 4968, 5410, 6774, 5218, 6172, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772A, 
	    6826, 4968, 5410, 6774, 4998, 5007, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772B, 
	    6835, 4968, 5410, 6774, 4998, 5007, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772B_1, 
	    6844, 4968, 5410, 6774, 4998, 5007, 0,
	    USB_VENDOR_ASMEDIA, USB_PRODUCT_ASMEDIA_ASM1051, 
	    6854, 6872, 1867, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2570, 
	    6877, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL167G, 
	    6884, 5270, 5375, 4982, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL159G, 
	    6892, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_A9T_WIFI, 
	    6900, 6904, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_P5B_WIFI, 
	    6913, 6904, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL167G_2, 
	    6884, 5270, 5375, 4982, 6917, 6926, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL167G_3, 
	    6884, 5270, 5375, 4982, 6917, 6926, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_U3100, 
	    6929, 6932, 6939, 6628, 6945, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_4, 
	    5161, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_5, 
	    5161, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT3070, 
	    5168, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN10, 
	    6951, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT3070_1, 
	    5168, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN53, 
	    6959, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN66, 
	    6967, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN10NANO, 
	    6951, 6975, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RTL8192CU_3, 
	    6980, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBAC53_NANO, 
	    6992, 6975, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN10NANO_B1, 
	    6951, 6975, 7001, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_AURALED, 
	    7004, 7009, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_MYPAL_A730, 
	    7013, 7019, 0,
	    USB_VENDOR_ASUSTEK2, USB_PRODUCT_ASUSTEK2_USBN11, 
	    7024, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC1284, 
	    7032, 7041, 5007, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC10T, 
	    7049, 5218, 5007, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC232A, 
	    7056, 5007, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC210T, 
	    7063, 4998, 5007, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC2324, 
	    7070, 4968, 5748, 7056, 5906, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_DSB650C, 
	    7077, 0,
	    USB_VENDOR_ATHEROS, USB_PRODUCT_ATHEROS_AR5523, 
	    7086, 0,
	    USB_VENDOR_ATHEROS, USB_PRODUCT_ATHEROS_AR5523_NF, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_1, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_1_NF, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_2, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_2_NF, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_3, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_3_NF, 
	    7086, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_TG121N, 
	    7093, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_WN821NV2, 
	    7100, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9271_1, 
	    7109, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_3CRUSBN275, 
	    7116, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_WN612, 
	    7127, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR3011, 
	    7133, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR3012, 
	    7140, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9280, 
	    5426, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9287, 
	    5577, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9170, 
	    7147, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9271_2, 
	    7109, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9271_3, 
	    7109, 0,
	    USB_VENDOR_ATI2, USB_PRODUCT_ATI2_205, 
	    4968, 2658, 5676, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_UHB124, 
	    7154, 7161, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_WN210, 
	    7165, 7174, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_DWL900AP, 
	    7180, 651, 7190, 7197, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_SAM_BA, 
	    7203, 7207, 7214, 7226, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_DWL120, 
	    7231, 651, 5007, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C503I1, 
	    7239, 7248, 7258, 7263, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C503I2, 
	    7239, 7248, 7270, 7263, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C503RFMD, 
	    7239, 7275, 7263, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505RFMD, 
	    7281, 7275, 7263, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505RFMD2958, 
	    7281, 7275, 7290, 7263, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505A, 
	    7295, 7275, 7290, 7263, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505AS, 
	    7305, 7275, 7290, 7263, 0,
	    USB_VENDOR_AUDIOTECHNICA, USB_PRODUCT_AUDIOTECHNICA_ATCHA4USB, 
	    7316, 4968, 7327, 0,
	    USB_VENDOR_AVANCELOGIC, USB_PRODUCT_AVANCELOGIC_USBAUDIO, 
	    4968, 7337, 7343, 0,
	    USB_VENDOR_AVERATEC, USB_PRODUCT_AVERATEC_USBWLAN, 
	    5375, 0,
	    USB_VENDOR_AVISION, USB_PRODUCT_AVISION_1200U, 
	    7351, 7357, 0,
	    USB_VENDOR_AVM, USB_PRODUCT_AVM_FRITZWLAN, 
	    7365, 7376, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070, 
	    5168, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_4, 
	    5168, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_3, 
	    5440, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_4, 
	    5440, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_5, 
	    5168, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_5, 
	    5440, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_1, 
	    7109, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_2, 
	    7109, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_3, 
	    7109, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_4, 
	    7109, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_5, 
	    7109, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_6, 
	    7109, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8188CE_1, 
	    7378, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8188CE_2, 
	    7378, 0,
	    USB_VENDOR_BALTECH, USB_PRODUCT_BALTECH_CARDREADER, 
	    5862, 7388, 0,
	    USB_VENDOR_BBELECTRONICS, USB_PRODUCT_BBELECTRONICS_USOTL4, 
	    7395, 7402, 0,
	    USB_VENDOR_BECEEM, USB_PRODUCT_BECEEM_250U, 
	    7413, 7420, 7426, 0,
	    USB_VENDOR_BELKIN2, USB_PRODUCT_BELKIN2_F5U002, 
	    7429, 7032, 7041, 5007, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D6050, 
	    7436, 5605, 651, 5007, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U103, 
	    7444, 7056, 5007, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U109, 
	    7451, 7056, 5007, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_SCSI, 
	    7458, 7463, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_USB2LAN, 
	    4968, 5748, 7471, 7475, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U208, 
	    7485, 7492, 7501, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U237, 
	    7504, 4968, 5410, 7511, 5906, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U409, 
	    7518, 7056, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_UPS, 
	    480, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192CU_2, 
	    5282, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8188CUS, 
	    7525, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U120, 
	    7536, 5906, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U258, 
	    7546, 6633, 5748, 7560, 5007, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F7D2102, 
	    7565, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192CU_1, 
	    5282, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D5055, 
	    7573, 4998, 5007, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050, 
	    7581, 7589, 4968, 3424, 4982, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7051, 
	    7593, 7589, 4968, 3424, 4982, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050A, 
	    7601, 7589, 4968, 3424, 4982, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050C, 
	    7609, 7589, 4968, 3424, 4982, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050E, 
	    7617, 7589, 4968, 3424, 4982, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D8053V3, 
	    7625, 7633, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D8055, 
	    7636, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D8055V2, 
	    7636, 7644, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D9050V3, 
	    7647, 7655, 6626, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D9050C, 
	    7659, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F6D4050V1, 
	    7668, 7655, 5656, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F6D4050V2, 
	    7668, 7655, 6624, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192SU_3, 
	    5440, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F7D1101V2, 
	    7676, 7644, 0,
	    USB_VENDOR_CENTURY, USB_PRODUCT_CENTURY_CTUSB1HUB, 
	    7684, 0,
	    USB_VENDOR_BEWAN, USB_PRODUCT_BEWAN_BWIFI_USB54AR, 
	    7695, 0,
	    USB_VENDOR_BEWAN, USB_PRODUCT_BEWAN_RT3070, 
	    5168, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USB100, 
	    7709, 6774, 7717, 4982, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USBLP100, 
	    7730, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USBEL100, 
	    7739, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USBE100, 
	    7748, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USB2AR, 
	    7756, 4998, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US101, 
	    7763, 7770, 7781, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US159, 
	    7789, 7770, 7781, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US235, 
	    7796, 7770, 7781, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US257, 
	    7803, 7770, 7810, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_12, 
	    7818, 7770, 7825, 7833, 5656, 7839, 6926, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_34, 
	    7818, 7770, 7825, 7833, 6626, 7839, 7843, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_56, 
	    7818, 7770, 7825, 7833, 6617, 7839, 7846, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_78, 
	    7818, 7770, 7825, 7833, 7849, 7839, 7851, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US313, 
	    7854, 7770, 7861, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US320, 
	    7873, 7770, 7880, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US324, 
	    7892, 7770, 7880, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US346_12, 
	    7899, 7770, 7906, 7833, 5656, 7839, 6926, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US346_34, 
	    7899, 7770, 7906, 7833, 6626, 7839, 7843, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US701_12, 
	    7918, 7770, 7925, 7833, 5656, 7839, 6926, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US701_34, 
	    7918, 7770, 7925, 7833, 6626, 7839, 7843, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_12, 
	    7933, 7770, 7940, 7833, 5656, 7839, 6926, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_34, 
	    7933, 7770, 7940, 7833, 6626, 7839, 7843, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_56, 
	    7933, 7770, 7940, 7833, 6617, 7839, 7846, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_78, 
	    7933, 7770, 7940, 7833, 7849, 7839, 7851, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCMFW, 
	    7952, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM2033, 
	    7958, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM2033NF, 
	    7958, 7966, 7970, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43236, 
	    7980, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43143, 
	    7989, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43242, 
	    7998, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43569, 
	    8007, 0,
	    USB_VENDOR_BROTHER, USB_PRODUCT_BROTHER_HL1050, 
	    8016, 8024, 7041, 0,
	    USB_VENDOR_BTC, USB_PRODUCT_BTC_BTC7932, 
	    6002, 5141, 6481, 7226, 0,
	    USB_VENDOR_CACE, USB_PRODUCT_CACE_AIRPCAPNX, 
	    8030, 8038, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N656U, 
	    8041, 8050, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N1220U, 
	    8041, 8056, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N670U, 
	    8041, 8063, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N1240U, 
	    8041, 8069, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S10, 
	    8076, 8086, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S20, 
	    8076, 8090, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S100_US, 
	    8076, 8094, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S100_EU, 
	    8076, 8094, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_G1, 
	    8076, 8099, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_A20, 
	    8076, 8102, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S200, 
	    8076, 8106, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_EOS300D, 
	    8111, 8115, 687, 2316, 8120, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_SD630, 
	    8076, 8126, 0,
	    USB_VENDOR_CASIO, USB_PRODUCT_CASIO_QV, 
	    8132, 8135, 0,
	    USB_VENDOR_CASIO, USB_PRODUCT_CASIO_BE300, 
	    8149, 8156, 0,
	    USB_VENDOR_CASIO, USB_PRODUCT_CASIO_NAMELAND, 
	    2627, 8160, 8169, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_NETMATE, 
	    8176, 5218, 5007, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_NETMATE2, 
	    8184, 5218, 5007, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_CHIEF, 
	    4968, 8193, 8199, 3156, 8203, 8212, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_ANDROMEDA, 
	    8221, 7161, 0,
	    USB_VENDOR_CCYU, USB_PRODUCT_CCYU_EASYDISK, 
	    3612, 8231, 8240, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_MY3000KBD, 
	    8247, 8254, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_MY3000HUB, 
	    8247, 7161, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_CYBOARD, 
	    8263, 6002, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_MY6000KBD, 
	    8271, 8254, 0,
	    USB_VENDOR_CHIC, USB_PRODUCT_CHIC_MOUSE1, 
	    6481, 0,
	    USB_VENDOR_CHIC, USB_PRODUCT_CHIC_CYPRESS, 
	    771, 4968, 6494, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_KB8933, 
	    8278, 8254, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_OPTMOUSE0939, 
	    4968, 3370, 6494, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_1, 
	    7525, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_2, 
	    7525, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_3, 
	    7525, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_4, 
	    7525, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_5, 
	    7525, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_6, 
	    7525, 0,
	    USB_VENDOR_MICRODIA, USB_PRODUCT_MICRODIA_TWINKLECAM, 
	    8286, 4968, 5117, 0,
	    USB_VENDOR_MICRODIA, USB_PRODUCT_MICRODIA_BWC35HL01, 
	    8297, 8305, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_PROTHROTTLE, 
	    5066, 8317, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_PROPEDALS, 
	    5066, 8326, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_FIGHTERSTICK, 
	    8333, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_FLIGHTYOKE, 
	    8346, 8353, 8357, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GV2, 
	    8362, 7644, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54AG, 
	    8370, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54G, 
	    8362, 8379, 4968, 3424, 4982, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GP, 
	    8390, 8379, 4968, 3424, 4982, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_USB200MV2, 
	    8399, 7644, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_HU200TS, 
	    8407, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GC, 
	    8416, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GR, 
	    8425, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSBF54G, 
	    8434, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB200, 
	    8443, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_AE1000, 
	    8451, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_AM10, 
	    8458, 0,
	    USB_VENDOR_CISCOLINKSYS2, USB_PRODUCT_CISCOLINKSYS2_RT3070, 
	    5168, 0,
	    USB_VENDOR_CISCOLINKSYS3, USB_PRODUCT_CISCOLINKSYS3_RT3070, 
	    5168, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_IPAQPOCKETPC, 
	    8463, 8468, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_A1500, 
	    8477, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_IPAQWLAN, 
	    8463, 5375, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_W100, 
	    8483, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_W200, 
	    5375, 8488, 8498, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_PJB100, 
	    8503, 8512, 8520, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_IPAQLINUX, 
	    8463, 4566, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_HNE200, 
	    8527, 4968, 4998, 5007, 0,
	    USB_VENDOR_COMPARE, USB_PRODUCT_COMPARE_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_COMPOSITE, USB_PRODUCT_COMPOSITE_USBPS2, 
	    4968, 5748, 8535, 7463, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RTL8192SU_3, 
	    5440, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_C54RU, 
	    8539, 5375, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT3070_1, 
	    5168, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_7, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_8, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_C54RU2, 
	    8539, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2573, 
	    8545, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_4, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_5, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_6, 
	    5161, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_CONCEPTRONIC2, USB_PRODUCT_CONCEPTRONIC2_PRISM_GT, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_C11U, 
	    8553, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_WL210, 
	    8558, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_1, 
	    7086, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_1_NF, 
	    7086, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_2, 
	    7086, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_2_NF, 
	    7086, 0,
	    USB_VENDOR_CONCORDCAMERA, USB_PRODUCT_CONCORDCAMERA_EYE_Q_3X, 
	    8565, 8569, 8571, 0,
	    USB_VENDOR_CONNECTIX, USB_PRODUCT_CONNECTIX_QUICKCAM, 
	    8574, 0,
	    USB_VENDOR_COOLERMASTER, USB_PRODUCT_COOLERMASTER_AMD_SR4_LAMPLIGHT, 
	    8583, 8587, 8591, 8601, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_ETHER_USB_T, 
	    8609, 8615, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB_TX, 
	    8621, 8628, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLAN_USB_USB_11, 
	    8635, 8647, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB_TXS, 
	    8621, 8654, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLANUSB, 
	    651, 7471, 4968, 8662, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB2_TX, 
	    8621, 8671, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLUSB_11_KEY, 
	    8679, 8688, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB2GTST, 
	    8692, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGUSBRS232R, 
	    8706, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB2GL, 
	    8719, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB2GPX, 
	    8731, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT3070, 
	    5168, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSBNM, 
	    8744, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB300GNM, 
	    8755, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLUSB_11_STICK, 
	    5375, 4968, 8770, 8776, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB_TXC, 
	    8621, 8779, 0,
	    USB_VENDOR_CREATIVE, USB_PRODUCT_CREATIVE_NOMAD_II, 
	    8787, 7501, 8793, 8797, 0,
	    USB_VENDOR_CREATIVE, USB_PRODUCT_CREATIVE_NOMAD_IIMG, 
	    8787, 7501, 8804, 0,
	    USB_VENDOR_CREATIVE, USB_PRODUCT_CREATIVE_NOMAD, 
	    8787, 0,
	    USB_VENDOR_CREATIVE2, USB_PRODUCT_CREATIVE2_VOIP_BLASTER, 
	    8807, 8812, 0,
	    USB_VENDOR_CREATIVE3, USB_PRODUCT_CREATIVE3_OPTICAL_MOUSE, 
	    8820, 3370, 6494, 0,
	    USB_VENDOR_CSR, USB_PRODUCT_CSR_BLUETOOTH, 
	    4972, 4968, 4982, 0,
	    USB_VENDOR_CSR, USB_PRODUCT_CSR_BLUETOOTH_NF, 
	    4972, 4968, 4982, 0,
	    USB_VENDOR_CMEDIA, USB_PRODUCT_CMEDIA_USBAUDIO, 
	    4968, 8829, 8833, 0,
	    USB_VENDOR_CTX, USB_PRODUCT_CTX_EX1300, 
	    8839, 7161, 0,
	    USB_VENDOR_CYBERPOWER, USB_PRODUCT_CYBERPOWER_UPS0, 
	    6047, 1229, 1982, 0,
	    USB_VENDOR_CYBERPOWER, USB_PRODUCT_CYBERPOWER_UPS, 
	    6047, 1229, 1982, 0,
	    USB_VENDOR_CYBERPOWER, USB_PRODUCT_CYBERPOWER_UPS2, 
	    6047, 1229, 1982, 0,
	    USB_VENDOR_CYBERTAN, USB_PRODUCT_CYBERTAN_TG54USB, 
	    8846, 0,
	    USB_VENDOR_CYBERTAN, USB_PRODUCT_CYBERTAN_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_CYBERTAN, USB_PRODUCT_CYBERTAN_RT2870, 
	    5161, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_MOUSE, 
	    6481, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_THERMO, 
	    8854, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_KBDHUB, 
	    8866, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_FMRADIO, 
	    8879, 3359, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_USBRS232, 
	    8882, 8892, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_HUB2, 
	    8902, 5906, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_LPRDK, 
	    8907, 8914, 8917, 1867, 0,
	    USB_VENDOR_DAISY, USB_PRODUCT_DAISY_DMC, 
	    8921, 8931, 0,
	    USB_VENDOR_DALLAS, USB_PRODUCT_DALLAS_J6502, 
	    8946, 8953, 0,
	    USB_VENDOR_DALLAS, USB_PRODUCT_DALLAS_USB_FOB_IBUTTON, 
	    8962, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_PORT, 
	    8978, 8983, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_SK8125, 
	    8994, 8254, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_X3, 
	    9002, 9007, 8156, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_X30, 
	    9002, 9010, 8156, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_BC02, 
	    9014, 4972, 4968, 4982, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_TM1180, 
	    9019, 9030, 5375, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_PRISM_GT_1, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_TM350, 
	    9019, 9035, 4972, 4968, 4982, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_PRISM_GT_2, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_HSDPA, 
	    9039, 651, 9052, 5103, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_W5500, 
	    4808, 651, 9058, 9052, 5103, 0,
	    USB_VENDOR_DELORME, USB_PRODUCT_DELORME_EARTHMATE, 
	    9064, 9074, 0,
	    USB_VENDOR_DELORME, USB_PRODUCT_DELORME_EARTHMATE_LT20, 
	    9064, 9078, 9074, 0,
	    USB_VENDOR_DIAMOND, USB_PRODUCT_DIAMOND_RIO500USB, 
	    9084, 9088, 4968, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_WL200U, 
	    9092, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_CHUSB611G, 
	    9100, 9106, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_WL240U, 
	    9111, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_XH1153, 
	    9119, 5605, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_RT2573, 
	    5332, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_CWD854F, 
	    9126, 9132, 9140, 9144, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_RTL8187, 
	    9146, 0,
	    USB_VENDOR_DIGI, USB_PRODUCT_DIGI_ACCELEPORT2, 
	    9154, 4968, 6624, 0,
	    USB_VENDOR_DIGI, USB_PRODUCT_DIGI_ACCELEPORT4, 
	    9154, 4968, 6606, 0,
	    USB_VENDOR_DIGI, USB_PRODUCT_DIGI_ACCELEPORT8, 
	    9154, 4968, 9165, 0,
	    USB_VENDOR_DIGITALSTREAM, USB_PRODUCT_DIGITALSTREAM_PS2, 
	    9167, 9172, 4982, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_GUC2020, 
	    9179, 9186, 9190, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LD220, 
	    1093, 9198, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LD190, 
	    1093, 9204, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_U70, 
	    1093, 9210, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_POLARIS2, 
	    9214, 4968, 9223, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_VCUD60, 
	    9228, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_CONV, 
	    9236, 9245, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_DLDVI, 
	    4445, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_USBRGB, 
	    9258, 9266, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCDUSB7X, 
	    9258, 9274, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCDUSB10X, 
	    9258, 9284, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_VGA10, 
	    9298, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_WSDVI, 
	    9311, 3765, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_EC008, 
	    9314, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_FYDVI2, 
	    4445, 9325, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_GXDVIU2, 
	    9333, 9341, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCD4300U, 
	    9351, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCD8000U, 
	    9361, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_HPDOCK, 
	    9371, 4968, 9374, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_NL571, 
	    9371, 4968, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_M01061, 
	    4457, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_NBDOCK, 
	    9382, 9392, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_GXDVIU2B, 
	    9333, 9403, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_SWDVI, 
	    9414, 9186, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LUM70, 
	    9422, 9431, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCD8000UD_DVI, 
	    9437, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LDEWX015U, 
	    2406, 9452, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_KC002N, 
	    9463, 9469, 9476, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_MIMO, 
	    4445, 9487, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_PLUGABLE, 
	    9492, 9501, 9509, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LT1421WIDE, 
	    4457, 9517, 9529, 9536, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_SD_U2VDH, 
	    9541, 9546, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_UM7X0, 
	    9555, 9566, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_FYDVI, 
	    4445, 9571, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUBE100, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUBE100C1, 
	    9578, 9140, 9587, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUB1312, 
	    9590, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX4, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWL120E, 
	    7231, 9140, 9599, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA130C, 
	    9601, 9140, 9609, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_1, 
	    5282, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_2, 
	    5282, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_3, 
	    5282, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_4, 
	    5282, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA131B, 
	    9611, 9140, 9619, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA125D1, 
	    9621, 9140, 9629, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA131E, 
	    9611, 9140, 9599, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA121B1, 
	    9632, 9140, 7001, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWL122, 
	    651, 9640, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG120, 
	    9647, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWL120F, 
	    7231, 9140, 9144, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG122A2, 
	    9656, 9140, 9665, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG132, 
	    9668, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG132_NF, 
	    9668, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG132, 
	    9678, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG132_NF, 
	    9678, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG122, 
	    9687, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG122_NF, 
	    9687, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG122, 
	    9697, 9705, 651, 4968, 4982, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUBE100B1, 
	    9578, 9140, 7001, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RT2870, 
	    5161, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RT3072, 
	    5182, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA140B3, 
	    9707, 9140, 9715, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA160B2, 
	    9718, 9140, 9726, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA127, 
	    9729, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA162, 
	    9737, 651, 4982, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650C, 
	    7049, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX1, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX_PNA, 
	    5209, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX3, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX2, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157E_CD, 
	    9745, 9753, 9760, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157_CD, 
	    9745, 9753, 9760, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157, 
	    9745, 9765, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157E, 
	    9745, 9765, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM222_CD, 
	    9769, 9753, 9760, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM222, 
	    9769, 9765, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWR510_CD, 
	    9777, 9753, 9760, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWR510, 
	    9777, 9765, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA131A1, 
	    9611, 9785, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_WUA2340, 
	    9788, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_WUA2340_NF, 
	    9788, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA160A2, 
	    9718, 9665, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA130D1, 
	    9601, 9140, 9629, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_AR9271, 
	    7109, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWLG122C1, 
	    9656, 9140, 9587, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_WUA1340, 
	    9797, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DUBE100B1, 
	    9578, 9140, 7001, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA111, 
	    9806, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA110, 
	    9814, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3072, 
	    5182, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3072_1, 
	    5182, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_1, 
	    5168, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA160A1, 
	    9718, 9785, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA130, 
	    9601, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_4, 
	    5168, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_5, 
	    5168, 0,
	    USB_VENDOR_DLINK3, USB_PRODUCT_DLINK3_KVM221, 
	    9822, 0,
	    USB_VENDOR_DMI, USB_PRODUCT_DMI_SA2_0, 
	    9830, 4982, 0,
	    USB_VENDOR_DRAYTEK, USB_PRODUCT_DRAYTEK_VIGOR550, 
	    9838, 0,
	    USB_VENDOR_DVICO, USB_PRODUCT_DVICO_RT3070, 
	    5168, 0,
	    USB_VENDOR_DYNASTREAM, USB_PRODUCT_DYNASTREAM_ANTDEVBOARD, 
	    9847, 9851, 9855, 0,
	    USB_VENDOR_E3C, USB_PRODUCT_E3C_EC168, 
	    9861, 6945, 4982, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7318, 
	    9867, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_MT7610U, 
	    9875, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7618, 
	    9883, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192SU_3, 
	    5440, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7717, 
	    9891, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7718, 
	    9899, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7722UTN, 
	    9907, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7811UTC_1, 
	    9918, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7811UTC_2, 
	    9918, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_ELECOM_WDC433SU2M, 
	    9929, 9936, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7811UNV2, 
	    9948, 9958, 0,
	    USB_VENDOR_EGALAX, USB_PRODUCT_EGALAX_TPANEL, 
	    5784, 9961, 0,
	    USB_VENDOR_EGALAX, USB_PRODUCT_EGALAX_TPANEL2, 
	    5784, 9961, 0,
	    USB_VENDOR_EGALAX2, USB_PRODUCT_EGALAX2_TPANEL, 
	    5784, 9961, 0,
	    USB_VENDOR_EICON, USB_PRODUCT_EICON_DIVA852, 
	    9967, 9972, 5109, 5114, 0,
	    USB_VENDOR_EIZO, USB_PRODUCT_EIZO_HUB, 
	    7161, 0,
	    USB_VENDOR_EIZO, USB_PRODUCT_EIZO_MONITOR, 
	    9976, 0,
	    USB_VENDOR_ELAN, USB_PRODUCT_ELAN_ACTIVEJET, 
	    9984, 9994, 4001, 6002, 0,
	    USB_VENDOR_ELAN, USB_PRODUCT_ELAN_TPANEL, 
	    10001, 10006, 6172, 0,
	    USB_VENDOR_ELCON, USB_PRODUCT_ELCON_PLAN, 
	    10018, 10028, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_MOUSE29UO, 
	    6481, 10034, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX0, 
	    10039, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX1, 
	    10039, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBLTX, 
	    10049, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_WDC150SU2M, 
	    10060, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX2, 
	    10039, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_WDC433SU2M2, 
	    10072, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSB20, 
	    10085, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_UCSGT, 
	    10094, 10101, 5007, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_UCSGT0, 
	    10108, 7056, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX3, 
	    10039, 0,
	    USB_VENDOR_ELSA, USB_PRODUCT_ELSA_MODEM1, 
	    1665, 5103, 5638, 0,
	    USB_VENDOR_ELSA, USB_PRODUCT_ELSA_USB2ETHERNET, 
	    10116, 10126, 0,
	    USB_VENDOR_EMPIA, USB_PRODUCT_EMPIA_CAMERA, 
	    3016, 0,
	    USB_VENDOR_EMPIA, USB_PRODUCT_EMPIA_EM2883, 
	    10139, 0,
	    USB_VENDOR_EMS, USB_PRODUCT_EMS_DUAL_SHOOTER, 
	    10146, 10150, 6172, 10154, 0,
	    USB_VENDOR_ENCORE, USB_PRODUCT_ENCORE_RT3070, 
	    5168, 0,
	    USB_VENDOR_ENCORE, USB_PRODUCT_ENCORE_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_ENCORE, USB_PRODUCT_ENCORE_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_1S, 
	    10164, 10101, 10167, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_2S, 
	    10177, 10101, 10167, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_1S25, 
	    10180, 10101, 10167, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_4S, 
	    6614, 10101, 10167, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_E45, 
	    10185, 4998, 5007, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_CENTRONICS, 
	    10189, 10167, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_XX1, 
	    4998, 4982, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_1S9, 
	    10200, 10101, 10167, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_EZUSB, 
	    8169, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_2U4S, 
	    10204, 10101, 10209, 7161, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_XX2, 
	    4998, 4982, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER1, 
	    4968, 10223, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER2, 
	    10231, 4968, 10235, 2658, 10241, 10245, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER3, 
	    10231, 4968, 10235, 2658, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER5, 
	    4968, 10223, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_636, 
	    10249, 10260, 687, 10265, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_610, 
	    10249, 10274, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1200, 
	    10249, 7351, 687, 10278, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1600, 
	    10288, 10299, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1640, 
	    10249, 10304, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1240, 
	    10249, 10311, 687, 10317, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_640U, 
	    10249, 5523, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1250, 
	    10249, 10327, 687, 10333, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1650, 
	    10249, 10343, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_GT9700F, 
	    10348, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_2400, 
	    10249, 10357, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1260, 
	    10249, 10362, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1660, 
	    10249, 10367, 7357, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1670, 
	    10249, 10372, 7357, 0,
	    USB_VENDOR_ETEK, USB_PRODUCT_ETEK_1COM, 
	    7056, 7226, 0,
	    USB_VENDOR_EXAR, USB_PRODUCT_EXAR_XR21V1410, 
	    10377, 5656, 10387, 10395, 0,
	    USB_VENDOR_EXAR, USB_PRODUCT_EXAR_XR21V1412, 
	    10400, 6624, 10387, 10395, 0,
	    USB_VENDOR_EXAR, USB_PRODUCT_EXAR_XR21V1414, 
	    10410, 6606, 10387, 10395, 0,
	    USB_VENDOR_EXTENDED, USB_PRODUCT_EXTENDED_XTNDACCESS, 
	    10420, 10431, 0,
	    USB_VENDOR_FALCOM, USB_PRODUCT_FALCOM_TWIST, 
	    10436, 10442, 6077, 0,
	    USB_VENDOR_FALCOM, USB_PRODUCT_FALCOM_SAMBA, 
	    10451, 10457, 10442, 6077, 0,
	    USB_VENDOR_FEIXUN, USB_PRODUCT_FEIXUN_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_FEIXUN, USB_PRODUCT_FEIXUN_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_FIBERLINE, USB_PRODUCT_FIBERLINE_WL430U, 
	    10463, 0,
	    USB_VENDOR_FOXCONN, USB_PRODUCT_FOXCONN_AR3012, 
	    4972, 7140, 0,
	    USB_VENDOR_FREECOM, USB_PRODUCT_FREECOM_DVD, 
	    10471, 10241, 10481, 10485, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_8U232AM, 
	    10491, 7056, 10154, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_232RL, 
	    10499, 7056, 10154, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_2232C, 
	    10507, 4968, 10513, 10518, 10523, 10530, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_4232H, 
	    10538, 4968, 10544, 10518, 10523, 10530, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_232H, 
	    10549, 4968, 10556, 10395, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_230X, 
	    10569, 7056, 10154, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_PS2KBDMS, 
	    9167, 10576, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_8U100AX, 
	    10591, 7056, 10154, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_OPENRD_JTAGKEY, 
	    10599, 10606, 10614, 9619, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_BEAGLEBONE, 
	    10622, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MAXSTREAM_PKG_U, 
	    10633, 10643, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_KW, 
	    10649, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_YS, 
	    10652, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_Y6, 
	    10655, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_Y8, 
	    10658, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_IC, 
	    10661, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_DB9, 
	    10664, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_RS232, 
	    10668, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_Y9, 
	    10674, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_COASTAL_TNCX, 
	    10677, 10685, 10695, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_CTI_485_MINI, 
	    10701, 10705, 6628, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_CTI_NANO_485, 
	    10701, 6975, 10705, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_MX200_USB, 
	    10709, 10716, 10724, 10736, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_MX4_MX5_USB, 
	    10709, 10716, 10743, 10736, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_LK202_24_USB, 
	    10709, 10716, 10755, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_LK204_24_USB, 
	    10709, 10716, 10770, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_632, 
	    10782, 10795, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_634, 
	    10782, 10803, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_633, 
	    10782, 10811, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_631, 
	    10782, 10819, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_635, 
	    10782, 10827, 10751, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SEMC_DSS20, 
	    10835, 10840, 10847, 0,
	    USB_VENDOR_xxFTDI, USB_PRODUCT_xxFTDI_SHEEVAPLUG_JTAG, 
	    10859, 10606, 0,
	    USB_VENDOR_FUJIPHOTO, USB_PRODUCT_FUJIPHOTO_MASS0100, 
	    10870, 9830, 0,
	    USB_VENDOR_FUJITSU, USB_PRODUCT_FUJITSU_AH_F401U, 
	    10875, 10884, 10888, 10890, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_KEYBOARD6, 
	    10897, 10902, 6002, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_KEYBOARD7, 
	    10897, 7849, 6002, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_MOUSE, 
	    10897, 10902, 6494, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_FX5204PS, 
	    10235, 1229, 10904, 10910, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_FX5251WB, 
	    10920, 10925, 10933, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_VIRTETH, 
	    10943, 10951, 8240, 0,
	    USB_VENDOR_FSC, USB_PRODUCT_FSC_E5400, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_GENERALINSTMNTS, USB_PRODUCT_GENERALINSTMNTS_SB5100, 
	    10955, 10965, 2658, 6077, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GENELINK, 
	    10972, 10981, 1867, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL650, 
	    10991, 5906, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL641USB, 
	    10997, 11006, 5862, 5943, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL641USB2IDE_2, 
	    10997, 11019, 1867, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL641USB2IDE, 
	    10997, 11019, 1867, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GN54G, 
	    11027, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNBR402W, 
	    11034, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWLBM101, 
	    11044, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWBKG, 
	    11055, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWB01GS, 
	    11063, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWI05GS, 
	    11073, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWB31N, 
	    11083, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWB32L, 
	    11092, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_WLAN, 
	    5375, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_SMCWUSBTG, 
	    11101, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_SMCWUSBTG_NF, 
	    11101, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_AR5523, 
	    7086, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_AR5523_NF, 
	    7086, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_RT2573, 
	    5332, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_RT3070_1, 
	    5168, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_GMATE, USB_PRODUCT_GMATE_YP3X00, 
	    11112, 8156, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_GPS_RECEIVER, 
	    9074, 11119, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_MT7610U, 
	    9875, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_MT7630U, 
	    11128, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_MT7650U, 
	    11136, 0,
	    USB_VENDOR_GARMIN, USB_PRODUCT_GARMIN_FORERUNNER305, 
	    11144, 11155, 0,
	    USB_VENDOR_GLOBESPAN, USB_PRODUCT_GLOBESPAN_PRISM_GT_1, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_GLOBESPAN, USB_PRODUCT_GLOBESPAN_PRISM_GT_2, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_GOHUBS, USB_PRODUCT_GOHUBS_GOCOM232, 
	    11159, 7056, 10154, 0,
	    USB_VENDOR_GOODWAY, USB_PRODUCT_GOODWAY_GWUSB2E, 
	    11168, 0,
	    USB_VENDOR_GOODWAY, USB_PRODUCT_GOODWAY_RT2573, 
	    5332, 0,
	    USB_VENDOR_GRAVIS, USB_PRODUCT_GRAVIS_GAMEPADPRO, 
	    11176, 5066, 0,
	    USB_VENDOR_GREENHOUSE, USB_PRODUCT_GREENHOUSE_KANA21, 
	    11184, 5141, 8231, 8793, 11194, 0,
	    USB_VENDOR_GRETAGMACBETH, USB_PRODUCT_GRETAGMACBETH_HUEY, 
	    11201, 0,
	    USB_VENDOR_GRIFFIN, USB_PRODUCT_GRIFFIN_IMATE, 
	    11206, 11213, 5007, 0,
	    USB_VENDOR_GRIFFIN, USB_PRODUCT_GRIFFIN_POWERMATE, 
	    11217, 11227, 5950, 0,
	    USB_VENDOR_GUDE, USB_PRODUCT_GUDE_DCF, 
	    11238, 11244, 4968, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_DALEADER, 
	    11255, 11258, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUSB254, 
	    11265, 5375, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUSB254LB, 
	    11276, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUSB254V2AP, 
	    11290, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWNU300, 
	    11306, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWNUM300, 
	    11315, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUN54, 
	    11325, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWNUP150, 
	    11334, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_HAGIWARA, USB_PRODUCT_HAGIWARA_FGSM, 
	    11344, 11354, 5862, 5943, 0,
	    USB_VENDOR_HAGIWARA, USB_PRODUCT_HAGIWARA_FGCF, 
	    11344, 11006, 5862, 5943, 0,
	    USB_VENDOR_HAGIWARA, USB_PRODUCT_HAGIWARA_FG, 
	    11344, 0,
	    USB_VENDOR_HAILUCK, USB_PRODUCT_HAILUCK_KEYBOARD, 
	    6002, 0,
	    USB_VENDOR_HAL, USB_PRODUCT_HAL_IMR001, 
	    11365, 11378, 11381, 0,
	    USB_VENDOR_HANDSPRING, USB_PRODUCT_HANDSPRING_VISOR, 
	    2723, 11391, 0,
	    USB_VENDOR_HANDSPRING, USB_PRODUCT_HANDSPRING_TREO, 
	    2723, 11397, 0,
	    USB_VENDOR_HANDSPRING, USB_PRODUCT_HANDSPRING_TREO600, 
	    2723, 11397, 6093, 0,
	    USB_VENDOR_HANK, USB_PRODUCT_HANK_HP5187, 
	    9371, 651, 11402, 0,
	    USB_VENDOR_HAUPPAUGE, USB_PRODUCT_HAUPPAUGE_WINTV_USB_FM, 
	    11417, 4968, 8879, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_USB2_FM, 
	    11417, 8902, 8879, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_NOVAT_7700M, 
	    11417, 11423, 6945, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_NOVAT_7700PC, 
	    11417, 11423, 6945, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_NOVAT_7070P, 
	    11417, 11423, 6945, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_HWUN2, 
	    11430, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT3070, 
	    5168, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_4, 
	    5161, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_5, 
	    5161, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192CU_2, 
	    5282, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_UF100, 
	    6774, 4968, 4998, 0,
	    USB_VENDOR_HITACHI, USB_PRODUCT_HITACHI_DZMV100A, 
	    11436, 11444, 11454, 0,
	    USB_VENDOR_HITACHI, USB_PRODUCT_HITACHI_DVDCAM_USB, 
	    11464, 4968, 11471, 8892, 0,
	    USB_VENDOR_HOLTEK, USB_PRODUCT_HOLTEK_MOP35, 
	    11474, 0,
	    USB_VENDOR_HOSIDEN, USB_PRODUCT_HOSIDEN_PPP, 
	    11481, 5950, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_895C, 
	    11498, 11506, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4100C, 
	    11511, 11519, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_S20, 
	    11525, 8090, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_880C, 
	    11498, 11536, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4200C, 
	    11541, 11549, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_CDWRITERPLUS, 
	    11555, 11565, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_KBDHUB, 
	    4001, 6002, 5906, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_HN210W, 
	    11570, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_6200C, 
	    11541, 11577, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_S20b, 
	    11583, 8090, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_815C, 
	    11498, 11594, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_3300C, 
	    11541, 11599, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_CDW8200, 
	    11555, 11565, 11605, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_1220C, 
	    11498, 11611, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_810C, 
	    11498, 11617, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4300C, 
	    11511, 11627, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_CD4E, 
	    11633, 11644, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_G85XI, 
	    11650, 11660, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_1200, 
	    11666, 11675, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_5200C, 
	    11511, 11680, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_830C, 
	    11498, 11686, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_3400CSE, 
	    11541, 11691, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_885C, 
	    11498, 11699, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_6300C, 
	    11511, 11704, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_840C, 
	    11498, 11710, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_2200C, 
	    11541, 11715, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_5300C, 
	    11511, 11721, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4400C, 
	    11511, 11727, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_816C, 
	    11498, 11733, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_2300D, 
	    11738, 11747, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_970CSE, 
	    11753, 11761, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_5400C, 
	    11511, 11768, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_2215, 
	    8463, 11774, 11787, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_959C, 
	    11753, 11791, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_568J, 
	    11796, 11804, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_930C, 
	    11498, 11808, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_P2000U, 
	    11813, 11820, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_RNDIS, 
	    11828, 11836, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_640C, 
	    11498, 11842, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_LP2275W, 
	    11847, 7161, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_LP2475W, 
	    11855, 7161, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4670V, 
	    11541, 11863, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_P1100, 
	    11525, 11869, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_V125W, 
	    11875, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_6127, 
	    11753, 11881, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_UN2430, 
	    4012, 11886, 11893, 11902, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_HN210E, 
	    4998, 11909, 0,
	    USB_VENDOR_HP3, USB_PRODUCT_HP3_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_HP2, USB_PRODUCT_HP2_C500, 
	    11583, 11916, 0,
	    USB_VENDOR_HTC, USB_PRODUCT_HTC_ANDROID, 
	    11921, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_MOBILE, 
	    4097, 7413, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E220, 
	    4097, 11929, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_U8150, 
	    4097, 11934, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_EM770W, 
	    4097, 11940, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E1750, 
	    4097, 11947, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E182, 
	    4097, 11953, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E353, 
	    4097, 11958, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E1750INIT, 
	    4097, 11947, 4968, 11963, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_K3765, 
	    4097, 11966, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E1820, 
	    4097, 11972, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_HWD12_RNDIS, 
	    4097, 11978, 11836, 11984, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E171INIT, 
	    4097, 11989, 4968, 11963, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E392INIT, 
	    4097, 11994, 11999, 12005, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E171, 
	    4097, 11989, 687, 11978, 12015, 11984, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E353_HiLink, 
	    4097, 12019, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_K3765INIT, 
	    4097, 11966, 4968, 11963, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E3272, 
	    4097, 12031, 12037, 687, 12042, 12051, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E353INIT, 
	    4097, 11958, 4968, 11963, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_HWD12_INSTALLER, 
	    4097, 11978, 12005, 0,
	    USB_VENDOR_HUAWEI3COM, USB_PRODUCT_HUAWEI3COM_RT2573, 
	    5332, 0,
	    USB_VENDOR_HYUNDAI, USB_PRODUCT_HYUNDAI_PC5740, 
	    12057, 12064, 0,
	    USB_VENDOR_HYUNDAI, USB_PRODUCT_HYUNDAI_UM175, 
	    12069, 12064, 0,
	    USB_VENDOR_IBM, USB_PRODUCT_IBM_OPTTRAVELMOUSE, 
	    3370, 0,
	    USB_VENDOR_IBM, USB_PRODUCT_IBM_USBCDROMDRIVE, 
	    4968, 9753, 3647, 0,
	    USB_VENDOR_IIYAMA, USB_PRODUCT_IIYAMA_HUB, 
	    5906, 0,
	    USB_VENDOR_IMATION, USB_PRODUCT_IMATION_FLASHGO, 
	    5937, 12075, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4, 
	    12079, 10668, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_HUBPORT7, 
	    12090, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_RAPIDPORT4, 
	    12100, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4T, 
	    12112, 10668, 10241, 12123, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT2, 
	    12130, 10668, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4I, 
	    12112, 12141, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT2I, 
	    12130, 12147, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_HUBPORT4, 
	    12159, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8HAND, 
	    12169, 12180, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_MULTIMODEM, 
	    2214, 12191, 12199, 12202, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORTPPORT, 
	    12207, 7032, 7226, 12222, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT421, 
	    12231, 12244, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT21, 
	    12263, 12275, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8DC, 
	    12290, 12180, 12294, 12297, 12303, 5656, 12306, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8, 
	    12180, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT2DIN, 
	    12130, 10668, 687, 1642, 12311, 10167, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4DIN, 
	    12112, 10668, 687, 1642, 12311, 10167, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT16DC, 
	    12290, 12315, 12294, 12327, 12303, 5656, 12333, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORTCOMP, 
	    12339, 12348, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8I, 
	    12180, 12141, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_MT4X56USB, 
	    12359, 10890, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_F5U002, 
	    7032, 7041, 5007, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ATAPI, 
	    12363, 5007, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_IDEUSB2, 
	    8902, 9830, 4982, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ISD110, 
	    12369, 5007, 12373, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ISD105, 
	    12369, 5007, 12380, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_DRIVEV2, 
	    8231, 4968, 12387, 9958, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_DRIVEV2_5, 
	    8231, 4968, 12387, 9958, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_USBCABLE, 
	    4968, 6071, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ADAPTERV2, 
	    4968, 9830, 4982, 9958, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_EASYPC_CAMERA, 
	    12397, 5859, 3016, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_AP310, 
	    12402, 12408, 7501, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_I2011B, 
	    651, 12417, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_TESTBOARD, 
	    12423, 12429, 9855, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH2, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_GPBT54, 
	    12448, 12453, 4972, 12458, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH3, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH4, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH5, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH6, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH7, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH8, 
	    12434, 12439, 5906, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_N_6235_BT, 
	    12462, 12473, 12478, 4972, 0,
	    USB_VENDOR_INTERSIL, USB_PRODUCT_INTERSIL_PRISM_GT, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_INTERSIL, USB_PRODUCT_INTERSIL_PRISM_2X, 
	    12484, 5375, 0,
	    USB_VENDOR_INTREPIDCS, USB_PRODUCT_INTREPIDCS_VALUECAN, 
	    12493, 0,
	    USB_VENDOR_INTREPIDCS, USB_PRODUCT_INTREPIDCS_NEOVI, 
	    12502, 12508, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_IU_CD2, 
	    10481, 12513, 12524, 12529, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_DVR_UEH8, 
	    10481, 12513, 12524, 12536, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBSSMRW, 
	    12545, 12555, 5007, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBSDRW, 
	    12563, 12555, 5007, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBETT, 
	    4968, 12572, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBETTX, 
	    4968, 12577, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBETTXS, 
	    4968, 12583, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNB11A, 
	    4968, 12591, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNB11, 
	    4968, 12598, 12591, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNG54US, 
	    4968, 12606, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNG54US_NF, 
	    4968, 12606, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_ETXUS2, 
	    12616, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_ETGUS2, 
	    12624, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_FT232R, 
	    12632, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_WNGDNUS2, 
	    12639, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_1, 
	    5182, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_2, 
	    5182, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_3, 
	    5182, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_4, 
	    5182, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_WNG150UM, 
	    12650, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBRSAQ, 
	    4968, 10101, 5007, 12660, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBRSAQ5, 
	    4968, 10101, 5007, 12670, 0,
	    USB_VENDOR_IODATA2, USB_PRODUCT_IODATA2_USB2SC, 
	    12680, 1867, 12692, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_ZIP100, 
	    12700, 12704, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_ZIP250, 
	    12700, 6067, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_ZIP250_2, 
	    12700, 6067, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_CDRW, 
	    12708, 12713, 0,
	    USB_VENDOR_IRIVER, USB_PRODUCT_IRIVER_IFP_1XX, 
	    12718, 0,
	    USB_VENDOR_IRIVER, USB_PRODUCT_IRIVER_IFP_3XX, 
	    12726, 0,
	    USB_VENDOR_IRIVER, USB_PRODUCT_IRIVER_IFP_5XX, 
	    12734, 0,
	    USB_VENDOR_JABLOTRON, USB_PRODUCT_JABLOTRON_PC60B, 
	    12742, 0,
	    USB_VENDOR_JATON, USB_PRODUCT_JATON_EDA, 
	    4998, 8240, 4982, 0,
	    USB_VENDOR_JENOPTIK, USB_PRODUCT_JENOPTIK_JD350, 
	    12749, 9035, 12752, 8797, 0,
	    USB_VENDOR_JMICRON, USB_PRODUCT_JMICRON_JM20329, 
	    4968, 5748, 5533, 1867, 0,
	    USB_VENDOR_JMICRON, USB_PRODUCT_JMICRON_JM20336, 
	    4968, 5748, 6872, 1867, 0,
	    USB_VENDOR_JMICRON, USB_PRODUCT_JMICRON_JM20337, 
	    4968, 5748, 5533, 1867, 0,
	    USB_VENDOR_JRC, USB_PRODUCT_JRC_AH_J3001V_J3002V, 
	    12763, 12774, 0,
	    USB_VENDOR_JVC, USB_PRODUCT_JVC_GR_DX95, 
	    12791, 0,
	    USB_VENDOR_JVC, USB_PRODUCT_JVC_MP_PRX1, 
	    12799, 4998, 0,
	    USB_VENDOR_JVC, USB_PRODUCT_JVC_MP_XP7250_WL, 
	    12807, 12817, 5375, 0,
	    USB_VENDOR_KLSI, USB_PRODUCT_KLSI_DUH3E10BT, 
	    12825, 4998, 12830, 6556, 12839, 12843, 0,
	    USB_VENDOR_KLSI, USB_PRODUCT_KLSI_DUH3E10BTN, 
	    12825, 4998, 12830, 6556, 12839, 12843, 0,
	    USB_VENDOR_KAWATSU, USB_PRODUCT_KAWATSU_MH4000P, 
	    12850, 12858, 0,
	    USB_VENDOR_KAWATSU, USB_PRODUCT_KAWATSU_KC180, 
	    12864, 10431, 0,
	    USB_VENDOR_KEISOKUGIKEN, USB_PRODUCT_KEISOKUGIKEN_USBDAQ, 
	    12871, 12880, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_ORBIT, 
	    12887, 12893, 12901, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_TURBOBALL, 
	    12911, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_ORBIT_MAC, 
	    12887, 4968, 12901, 10241, 10245, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_VIDEOCAM_VGA, 
	    12921, 12930, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28_NF, 
	    12934, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28X_NF, 
	    12941, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19_NF, 
	    12949, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18_NF, 
	    12956, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18X_NF, 
	    12963, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19W_NF, 
	    12971, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19, 
	    12949, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19W, 
	    12971, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA49W_NF, 
	    12979, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA49W, 
	    12979, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QI_NF, 
	    12987, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QI, 
	    12987, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19Q_NF, 
	    12996, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19Q, 
	    12996, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28, 
	    12934, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XXB, 
	    13004, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18, 
	    12956, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18X, 
	    12963, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XB_NF, 
	    13015, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XA_NF, 
	    13015, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XA, 
	    13024, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18XA_NF, 
	    13033, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18XA, 
	    13033, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QW_NF, 
	    13042, 10101, 5007, 7966, 7970, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QW, 
	    13042, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19H, 
	    13051, 10101, 5007, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_UIA10, 
	    13059, 13066, 13073, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_UIA11, 
	    13081, 13066, 13073, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_XX1, 
	    4998, 4982, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_KNU101TX, 
	    13088, 4968, 4998, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT102_G2, 
	    13097, 13100, 13104, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT101_II, 
	    13097, 13107, 7501, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DTMINI10, 
	    13097, 6628, 13111, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT101_G2, 
	    13097, 13107, 13104, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT100_G2, 
	    13097, 12704, 13104, 0,
	    USB_VENDOR_KINGSUN, USB_PRODUCT_KINGSUN_IRDA, 
	    13114, 10431, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC220, 
	    2316, 13131, 13139, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC260, 
	    2316, 13131, 13145, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC265, 
	    2316, 13131, 13151, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC290, 
	    2316, 13131, 13157, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC240, 
	    2316, 13131, 13163, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC280, 
	    2316, 13131, 13169, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DX4900, 
	    13175, 13185, 0,
	    USB_VENDOR_KONICA, USB_PRODUCT_KONICA_CAMERA, 
	    2316, 13192, 3016, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_NICHE, 
	    13198, 6481, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_NETSCROLL, 
	    13204, 13211, 6481, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_G07, 
	    13221, 13229, 13234, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_FLIGHT2000, 
	    8346, 13242, 13247, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_VIVIDPRO, 
	    13256, 13266, 7357, 0,
	    USB_VENDOR_KYOCERA, USB_PRODUCT_KYOCERA_AHK3001V, 
	    13276, 0,
	    USB_VENDOR_LACIE, USB_PRODUCT_LACIE_PKTDRV, 
	    13286, 0,
	    USB_VENDOR_LACIE, USB_PRODUCT_LACIE_HD, 
	    13298, 13303, 0,
	    USB_VENDOR_LACIE, USB_PRODUCT_LACIE_CDRW, 
	    11963, 13308, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_AX88179, 
	    6806, 4968, 6814, 6789, 5218, 6172, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_COMPACTKBDWTP, 
	    13312, 13321, 4968, 8254, 5141, 13329, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_ETHERNET, 
	    4968, 5410, 4998, 0,
	    USB_VENDOR_LEXAR, USB_PRODUCT_LEXAR_JUMPSHOT, 
	    13340, 11006, 5943, 0,
	    USB_VENDOR_LEXAR, USB_PRODUCT_LEXAR_2662WAR, 
	    13349, 0,
	    USB_VENDOR_LEXAR, USB_PRODUCT_LEXAR_MCR, 
	    13358, 5943, 0,
	    USB_VENDOR_LEXMARK, USB_PRODUCT_LEXMARK_S2450, 
	    13369, 13375, 13377, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_CDMA_MSM, 
	    5854, 799, 13382, 13386, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L05A_MODEM, 
	    6135, 13392, 13399, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L05A_STORAGE, 
	    6135, 13392, 13399, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L02C_MODEM, 
	    6135, 13392, 13405, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L02C_STORAGE, 
	    6135, 13392, 13405, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_MSM_HSDPA, 
	    9052, 13382, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_MAUSB2, 
	    13411, 13419, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10TX1, 
	    13427, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_HG20F9, 
	    13435, 4998, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10T, 
	    13442, 4998, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB100TX, 
	    13449, 4998, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB100H1, 
	    13458, 13467, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10TA, 
	    13481, 4998, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_WUSB11, 
	    13489, 651, 4968, 3424, 4982, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_WUSB11_25, 
	    13489, 651, 4968, 3424, 4982, 6917, 13496, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_WUSB12_11, 
	    13501, 5605, 13508, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10TX2, 
	    13427, 0,
	    USB_VENDOR_LINKSYS2, USB_PRODUCT_LINKSYS2_WUSB11, 
	    13489, 0,
	    USB_VENDOR_LINKSYS2, USB_PRODUCT_LINKSYS2_NWU11B, 
	    3424, 13513, 13524, 0,
	    USB_VENDOR_LINKSYS2, USB_PRODUCT_LINKSYS2_USB200M, 
	    4968, 5410, 6774, 5218, 6172, 0,
	    USB_VENDOR_LINKSYS3, USB_PRODUCT_LINKSYS3_WUSB11V28, 
	    13531, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_USB1000, 
	    13542, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB100, 
	    13550, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB600N, 
	    13558, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB54GC_2, 
	    8416, 7644, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB54GC_3, 
	    8416, 7633, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_RT3070, 
	    5168, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB600NV2, 
	    13558, 7644, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_ROOT_HUB_11, 
	    13567, 13571, 7161, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_ROOT_HUB_20, 
	    5410, 13571, 7161, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_ROOT_HUB_30, 
	    6814, 13571, 7161, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_USB3DEBUG, 
	    4968, 6814, 13576, 7226, 0,
	    USB_VENDOR_LITEON, USB_PRODUCT_LITEON_AR9271, 
	    7109, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LDR_H443SU2, 
	    10481, 12513, 12524, 13582, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LDR_H443U2, 
	    10481, 12513, 12524, 13594, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LAN_GTJU2, 
	    13605, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LANTX, 
	    13616, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RTL8187, 
	    9146, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LANW300NU2, 
	    13623, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT3020, 
	    13636, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LANW300NU2S, 
	    13643, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LAN_W450ANU2E, 
	    13657, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LAN_W300ANU2, 
	    13671, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_M2452, 
	    13685, 8254, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_M4848, 
	    13691, 6481, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_PAGESCAN, 
	    13697, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMWEB, 
	    8574, 13706, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO, 
	    8574, 5066, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMEXP, 
	    8574, 13710, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAM, 
	    8574, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMEXP2, 
	    8574, 13710, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO3k, 
	    8574, 5066, 13718, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRONB, 
	    8574, 10241, 8820, 5066, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO4K, 
	    8574, 5066, 13723, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMMESS, 
	    8574, 13728, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_N43, 
	    13738, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_N48, 
	    13742, 6481, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MBA47, 
	    13746, 6481, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMMOUSE, 
	    13753, 13761, 6494, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_BD58, 
	    13768, 6481, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_USBPS2MOUSE, 
	    13773, 3370, 6494, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MUV55A, 
	    13782, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_UN58A, 
	    13790, 6494, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_B100_1, 
	    13796, 3370, 6494, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_B100_2, 
	    13796, 3370, 6494, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMPAD, 
	    13753, 11176, 13801, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMRPAD, 
	    13753, 13809, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMJOY, 
	    13753, 13819, 13247, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMFFGP, 
	    13753, 13825, 13819, 13833, 13836, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_BB13, 
	    13773, 13847, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_BB18, 
	    13857, 13866, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MARBLEMOUSE, 
	    13872, 6494, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_RK53, 
	    13879, 6481, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_RB6, 
	    13879, 8254, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_CDO, 
	    13879, 13888, 3370, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MX700, 
	    13879, 13896, 6481, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_CBT44, 
	    13904, 13911, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO2, 
	    8574, 5066, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_GF310, 
	    13920, 13928, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_DAG, 
	    13933, 2760, 13920, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_WM66, 
	    4536, 13938, 9052, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_D21LCMASS, 
	    13943, 13951, 10870, 13957, 11984, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_D21LC, 
	    13943, 13951, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_XSSTICK_W14, 
	    6596, 228, 13962, 13970, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_XSSTICK_P14, 
	    6596, 228, 13962, 13974, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_510FU, 
	    13978, 13988, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_510FUMASS, 
	    13978, 13988, 10870, 13957, 11984, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_XSSTICK_P14_INSTALLER, 
	    6596, 228, 13962, 13974, 13994, 13996, 14004, 0,
	    USB_VENDOR_LUCENT, USB_PRODUCT_LUCENT_EVALKIT, 
	    14011, 14019, 14030, 0,
	    USB_VENDOR_LUWEN, USB_PRODUCT_LUWEN_EASYDISK, 
	    14034, 0,
	    USB_VENDOR_MACALLY, USB_PRODUCT_MACALLY_MOUSE1, 
	    6481, 0,
	    USB_VENDOR_MADCATZ, USB_PRODUCT_MADCATZ_CYBORG_RAT7, 
	    14043, 14050, 7849, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_HUB0100, 
	    5906, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_DU_H3SP_USB232, 
	    2633, 14057, 4968, 14065, 5906, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_USB232, 
	    14069, 8892, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_SITECOM_USB232, 
	    3705, 14069, 2081, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_ML_4500, 
	    14077, 0,
	    USB_VENDOR_MEDIAGEAR, USB_PRODUCT_MEDIAGEAR_READER9IN1, 
	    5270, 14085, 6556, 5656, 5943, 0,
	    USB_VENDOR_WAYTECH, USB_PRODUCT_WAYTECH_USB2SERIAL, 
	    4968, 5748, 7056, 0,
	    USB_VENDOR_MEINBERG, USB_PRODUCT_MEINBERG_USB5131, 
	    4968, 14087, 14092, 13994, 3359, 14098, 0,
	    USB_VENDOR_MEIZU, USB_PRODUCT_MEIZU_M6_SL, 
	    14104, 14115, 14118, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUATX1, 
	    14123, 4998, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUATX5, 
	    14123, 4998, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUA2TX5, 
	    14130, 4998, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUAKTX, 
	    14138, 4998, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_S11, 
	    14146, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_MCRSM2, 
	    14158, 11354, 5862, 14166, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_DUBPXXG, 
	    11019, 14180, 14188, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KS11G, 
	    14197, 14211, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUAU2KTX, 
	    14220, 4998, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KB11, 
	    14231, 5375, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54YB, 
	    14244, 5375, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54, 
	    14259, 5375, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54AI, 
	    14271, 5375, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUAU2GT, 
	    14286, 4998, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_NINWIFI, 
	    1512, 14296, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_PCOPRS1, 
	    14302, 14316, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_SG54HP, 
	    14326, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_G54HP, 
	    14340, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54L, 
	    14353, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCG300N, 
	    14366, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_SG54HG, 
	    14379, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCAG300N, 
	    14393, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCG, 
	    14407, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGNHP, 
	    14416, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGN, 
	    14428, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCG301N, 
	    14438, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_CEWL_1, 
	    1337, 14451, 5375, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGNM, 
	    14461, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGNM2T, 
	    14472, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WIU2300D, 
	    14485, 0,
	    USB_VENDOR_MERCUSYS, USB_PRODUCT_MERCUSYS_MW150USV2, 
	    14496, 9958, 0,
	    USB_VENDOR_MERLIN, USB_PRODUCT_MERLIN_V620, 
	    4206, 14504, 0,
	    USB_VENDOR_METRICOM, USB_PRODUCT_METRICOM_RICOCHET_GS, 
	    14509, 14518, 0,
	    USB_VENDOR_MGE, USB_PRODUCT_MGE_UPS1, 
	    476, 480, 14521, 14529, 5656, 0,
	    USB_VENDOR_MGE, USB_PRODUCT_MGE_UPS2, 
	    476, 480, 14521, 14529, 6624, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_WLAN, 
	    5375, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_BLUETOOTH, 
	    4972, 4968, 4982, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_8, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_9, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MEGASKY580, 
	    14546, 14550, 6945, 4982, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MEGASKY580_55801, 
	    14546, 14550, 6945, 4982, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MS6861, 
	    14558, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MS6865, 
	    14566, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MS6869, 
	    14574, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573, 
	    5332, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573_2, 
	    5332, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_4, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_5, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_10, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_12, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_13, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_6, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_11, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_14, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_15, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_7, 
	    5168, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573_3, 
	    5332, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573_4, 
	    5332, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_AX88772A, 
	    6826, 4968, 5410, 6774, 4998, 5007, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_BLUETOOTH_2, 
	    4972, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_BLUETOOTH_3, 
	    4972, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_PICKIT1, 
	    14582, 5656, 14593, 14599, 14607, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_PICKIT2, 
	    14611, 6624, 14618, 14634, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_PICKIT3, 
	    14611, 6626, 14618, 14634, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_MCP2221, 
	    4968, 5748, 14645, 8203, 7475, 0,
	    USB_VENDOR_MICRODIA, USB_PRODUCT_MICRODIA_YUREX, 
	    14654, 0,
	    USB_VENDOR_MICRONET, USB_PRODUCT_MICRONET_SP128AR, 
	    14660, 14668, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_SIDEPREC, 
	    14678, 14689, 5066, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INTELLIMOUSE, 
	    14699, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_NATURALKBD, 
	    14712, 6002, 14720, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_DDS80, 
	    2316, 8833, 2833, 14726, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_SIDEWINDER, 
	    14729, 14689, 14740, 13866, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INETPRO, 
	    14747, 6002, 5066, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_TBEXPLORER, 
	    13847, 14756, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INTELLIEYE, 
	    14765, 6481, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INETPRO2, 
	    14747, 6002, 5066, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_MN510, 
	    14776, 651, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_MN110, 
	    6774, 4968, 14782, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_NATURAL_6000, 
	    651, 14786, 6494, 14792, 13911, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_MEMORY_UNIT, 
	    14797, 14802, 14809, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_DVD_PLAYBACK, 
	    14797, 10481, 14814, 14820, 14607, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_CONTROLLER_S10, 
	    14797, 5950, 13375, 14829, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_CONTROLLER_HUB, 
	    14797, 5950, 5906, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_CONTROLLER_S12, 
	    14797, 5950, 13375, 14835, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_360_CONTROLLER, 
	    14797, 14841, 5950, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_360_WIRELESS_RECEIVER, 
	    14797, 14841, 651, 13911, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR10, 
	    14845, 14852, 14864, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR20, 
	    14845, 14852, 14869, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR70, 
	    14845, 14852, 14874, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR80, 
	    14845, 14852, 14879, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR90, 
	    14845, 14852, 14884, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_CM6000, 
	    14889, 6494, 14792, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_SCSIDB25, 
	    14897, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_SCSIHD50, 
	    14911, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_DPCM, 
	    4968, 14925, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_FREECOM, 
	    2494, 11019, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_336CX, 
	    14936, 14944, 13994, 14950, 7357, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_X6U, 
	    14953, 14963, 13994, 14966, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_C6, 
	    14936, 14970, 7357, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_336CX2, 
	    14936, 14944, 13994, 14950, 7357, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_V6USL, 
	    14953, 14973, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_6000, 
	    14953, 14792, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_V6USL2, 
	    14953, 14973, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_V6UL, 
	    14953, 14979, 0,
	    USB_VENDOR_MIDIMAN, USB_PRODUCT_MIDIMAN_MIDISPORT2X2, 
	    14984, 14994, 0,
	    USB_VENDOR_MIDIMAN, USB_PRODUCT_MIDIMAN_MIDISPORT2X4, 
	    14984, 14998, 0,
	    USB_VENDOR_MINDSATWORK, USB_PRODUCT_MINDSATWORK_DW, 
	    2316, 15002, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_2300, 
	    15009, 15016, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_S304, 
	    15009, 15021, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_X, 
	    15009, 3958, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_DIMAGE7I, 
	    15009, 15026, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_5400, 
	    15009, 15029, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_DIMAGEA1, 
	    15009, 9785, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_XT, 
	    15009, 15034, 0,
	    USB_VENDOR_MISC, USB_PRODUCT_MISC_WISPY_24X, 
	    15037, 15046, 15053, 0,
	    USB_VENDOR_MISC, USB_PRODUCT_MISC_TELLSTICK, 
	    15058, 15066, 0,
	    USB_VENDOR_MISC, USB_PRODUCT_MISC_TELLSTICK_DUO, 
	    15058, 15066, 15076, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_CDRRW, 
	    15080, 3647, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_MOUSE, 
	    6494, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_SONY_MOUSE, 
	    15088, 15094, 6494, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_BT_DONGLE, 
	    4972, 4968, 15101, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_FDD, 
	    15108, 0,
	    USB_VENDOR_MOBILITY, USB_PRODUCT_MOBILITY_EA, 
	    4998, 4982, 0,
	    USB_VENDOR_MOBILITY, USB_PRODUCT_MOBILITY_EASIDOCK, 
	    15112, 4998, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7703, 
	    15121, 4968, 7056, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7720, 
	    15129, 4968, 7056, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7730, 
	    15137, 4998, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7780, 
	    15145, 5204, 10431, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7781, 
	    15153, 5204, 10431, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7784, 
	    15161, 15169, 10431, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7810, 
	    15174, 4968, 7056, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7820, 
	    15182, 4968, 7056, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7830, 
	    15190, 4998, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7832, 
	    15198, 4998, 4982, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7840, 
	    15206, 4968, 7056, 4982, 0,
	    USB_VENDOR_MOTOROLA, USB_PRODUCT_MOTOROLA_MC141555, 
	    15214, 7161, 6172, 0,
	    USB_VENDOR_MOTOROLA, USB_PRODUCT_MOTOROLA_SB4100, 
	    15223, 4968, 2658, 5103, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_T720C, 
	    15230, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_A920, 
	    15236, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_USBLAN, 
	    15241, 15248, 15255, 15261, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_USBLAN2, 
	    15241, 15266, 15273, 15280, 15285, 15280, 15289, 15261, 0,
	    USB_VENDOR_MOTOROLA4, USB_PRODUCT_MOTOROLA4_RT2770, 
	    5154, 0,
	    USB_VENDOR_MOTOROLA4, USB_PRODUCT_MOTOROLA4_RT3070, 
	    5168, 0,
	    USB_VENDOR_MSYSTEMS, USB_PRODUCT_MSYSTEMS_DISKONKEY, 
	    15293, 0,
	    USB_VENDOR_MSYSTEMS, USB_PRODUCT_MSYSTEMS_DISKONKEY2, 
	    15293, 0,
	    USB_VENDOR_MSYSTEMS, USB_PRODUCT_MSYSTEMS_DISKONKEY3, 
	    15293, 0,
	    USB_VENDOR_MULTITECH, USB_PRODUCT_MULTITECH_ATLAS, 
	    15303, 6077, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200CU, 
	    11675, 15317, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_600CU, 
	    6093, 15317, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200USB, 
	    11675, 4968, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200UB, 
	    11675, 15320, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200USBPLUS, 
	    11675, 4968, 11565, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200CUPLUS, 
	    11675, 15317, 11565, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_BEARPAW1200F, 
	    15323, 15331, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_BEARPAW1200TA, 
	    15323, 15337, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_600USB, 
	    6093, 4968, 7357, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_MDC800, 
	    15344, 15352, 5117, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_DV2000, 
	    15360, 15352, 5117, 0,
	    USB_VENDOR_NI, USB_PRODUCT_NI_GPIB_USB_A, 
	    15367, 0,
	    USB_VENDOR_NI, USB_PRODUCT_NI_HTOH_7825, 
	    6633, 5748, 6633, 4982, 0,
	    USB_VENDOR_NATIONAL, USB_PRODUCT_NATIONAL_BEARPAW1200, 
	    15323, 11675, 0,
	    USB_VENDOR_NATIONAL, USB_PRODUCT_NATIONAL_BEARPAW2400, 
	    15323, 10357, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_HUB_20, 
	    5410, 7161, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_WL300NUG, 
	    15378, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_HUB, 
	    7161, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_HUB_B, 
	    7161, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY760, 
	    15388, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY900, 
	    15397, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY920, 
	    15406, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY800, 
	    15415, 0,
	    USB_VENDOR_NEC2, USB_PRODUCT_NEC2_HUB2_0, 
	    5270, 5906, 5950, 0,
	    USB_VENDOR_NEODIO, USB_PRODUCT_NEODIO_ND3050, 
	    15424, 5937, 8240, 5950, 0,
	    USB_VENDOR_NEODIO, USB_PRODUCT_NEODIO_ND5010, 
	    15431, 5937, 5950, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_TURBOCONNECT, 
	    15444, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_CLIK40, 
	    15458, 15464, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_ETHERNETGADGET, 
	    4566, 15467, 15482, 12303, 15489, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_NET2270, 
	    11019, 1867, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_EA101, 
	    4998, 5007, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_EA101X, 
	    4998, 5007, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_FA101, 
	    6774, 4998, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_FA120, 
	    4968, 5410, 5204, 4998, 4982, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_MA111NA, 
	    5605, 4982, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_MA111V2, 
	    5605, 9958, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111V2_2, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111V3, 
	    15504, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111U, 
	    15512, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111U_NF, 
	    15512, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111V2, 
	    15519, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_XA601, 
	    4968, 5748, 15527, 4982, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WN111V2, 
	    15530, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNDA3100, 
	    15538, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNDA3200, 
	    15547, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNA1100, 
	    15556, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNA1000, 
	    15564, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNA1000M, 
	    15572, 0,
	    USB_VENDOR_NETGEAR2, USB_PRODUCT_NETGEAR2_MA101, 
	    15581, 0,
	    USB_VENDOR_NETGEAR2, USB_PRODUCT_NETGEAR2_MA101B, 
	    15581, 15587, 9619, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WG111T, 
	    15591, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WG111T_NF, 
	    15591, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WPN111, 
	    15598, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WPN111_NF, 
	    15598, 0,
	    USB_VENDOR_NETGEAR4, USB_PRODUCT_NETGEAR4_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_NETINDEX, USB_PRODUCT_NETINDEX_RTWJ02, 
	    15605, 0,
	    USB_VENDOR_NETINDEX, USB_PRODUCT_NETINDEX_UX312NC, 
	    15613, 0,
	    USB_VENDOR_NETINDEX, USB_PRODUCT_NETINDEX_WS002IN, 
	    15621, 15629, 15637, 0,
	    USB_VENDOR_NHJ, USB_PRODUCT_NHJ_CAM2, 
	    3016, 0,
	    USB_VENDOR_NIKON, USB_PRODUCT_NIKON_E990, 
	    2316, 3016, 15642, 0,
	    USB_VENDOR_NIKON, USB_PRODUCT_NIKON_E880, 
	    2316, 3016, 15647, 0,
	    USB_VENDOR_NIKON, USB_PRODUCT_NIKON_E885, 
	    2316, 3016, 15652, 0,
	    USB_VENDOR_NINTENDO, USB_PRODUCT_NINTENDO_BCM2045A, 
	    3396, 15657, 4972, 3359, 0,
	    USB_VENDOR_NINTENDO, USB_PRODUCT_NINTENDO_RVLCNT01, 
	    15666, 15670, 15677, 15688, 0,
	    USB_VENDOR_NINTENDO, USB_PRODUCT_NINTENDO_RVLCNT01TR, 
	    15666, 15670, 11565, 15697, 15688, 0,
	    USB_VENDOR_NOKIA, USB_PRODUCT_NOKIA_CA42, 
	    7413, 15711, 5007, 0,
	    USB_VENDOR_NOVATECH, USB_PRODUCT_NOVATECH_NV902W, 
	    15717, 0,
	    USB_VENDOR_NOVATECH, USB_PRODUCT_NOVATECH_RT2573, 
	    5332, 0,
	    USB_VENDOR_NOVATECH, USB_PRODUCT_NOVATECH_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_NOVATEL, USB_PRODUCT_NOVATEL_FLEXPACKGPS, 
	    15725, 15733, 9074, 11119, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_EXPRESSCARD, 
	    15742, 6599, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MERLINV620, 
	    3261, 651, 4206, 5854, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_V740, 
	    4206, 15754, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_S720, 
	    15759, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MERLINU740, 
	    3261, 4206, 15764, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U740_2, 
	    4206, 15764, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U870, 
	    4206, 15769, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_XU870, 
	    4206, 15774, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_X950D, 
	    4206, 15780, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_ES620, 
	    15786, 5854, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U720, 
	    15792, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_EU8X0D, 
	    15797, 15806, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U727, 
	    15827, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MC950D, 
	    3261, 651, 15832, 5103, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MC950D_DRIVER, 
	    3261, 651, 15832, 5103, 13996, 15838, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U760_DRIVER, 
	    3261, 651, 15845, 15850, 15838, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U760, 
	    3261, 15862, 0,
	    USB_VENDOR_OLYMPUS, USB_PRODUCT_OLYMPUS_C1, 
	    15869, 2316, 3016, 0,
	    USB_VENDOR_OLYMPUS, USB_PRODUCT_OLYMPUS_C700, 
	    15873, 15879, 2683, 0,
	    USB_VENDOR_OMNIVISION, USB_PRODUCT_OMNIVISION_OV511, 
	    15885, 3016, 0,
	    USB_VENDOR_OMNIVISION, USB_PRODUCT_OMNIVISION_OV511PLUS, 
	    15891, 3016, 0,
	    USB_VENDOR_OMNIVISION2, USB_PRODUCT_OMNIVISION2_PSEYE, 
	    1337, 15898, 8565, 0,
	    USB_VENDOR_ONEPLUS, USB_PRODUCT_ONEPLUS_A5010, 
	    15913, 15921, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_MD2, 
	    15924, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_MDCFEB, 
	    15929, 4968, 15937, 5943, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_SIIGMS, 
	    14802, 15940, 14166, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_DATAFAB3, 
	    15949, 5943, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_DATAFAB4, 
	    15949, 5943, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_PNYCFSM, 
	    15963, 15975, 5943, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_STECHCFSM, 
	    15981, 15988, 15975, 5943, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_LC1, 
	    15937, 16001, 16003, 12478, 16006, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_UCF100, 
	    16012, 16022, 11006, 5943, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_MD1II, 
	    16030, 16038, 16045, 5943, 0,
	    USB_VENDOR_ONSPEC2, USB_PRODUCT_ONSPEC2_8IN2, 
	    16053, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_MC3G, 
	    16058, 7413, 16067, 6599, 16075, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_QUADUMTS2, 
	    16084, 16097, 16104, 3213, 16109, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_QUADUMTS, 
	    16084, 16097, 16104, 3213, 16119, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_QUADPLUSUMTS, 
	    16084, 6599, 16104, 11565, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_HSDPA, 
	    16084, 9052, 5103, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GSICON72, 
	    16122, 16134, 16139, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON225, 
	    16134, 16143, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTMAXHSUPA, 
	    16084, 15832, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GEHSUPA, 
	    16084, 13710, 15832, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTHSUPA, 
	    16084, 15832, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GSHSUPA, 
	    16122, 15832, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X1, 
	    16147, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X2, 
	    16147, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X3, 
	    16147, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON401, 
	    16134, 16153, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTM382, 
	    16157, 16161, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X4, 
	    16147, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTHSUPAM, 
	    16165, 15832, 5103, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICONEDGE, 
	    16134, 16178, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_MODHSXPA, 
	    11902, 16183, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON321, 
	    16134, 16189, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON322, 
	    16134, 16193, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON505, 
	    16134, 16197, 0,
	    USB_VENDOR_OQO, USB_PRODUCT_OQO_WIFI01, 
	    16201, 16207, 16210, 16215, 0,
	    USB_VENDOR_OQO, USB_PRODUCT_OQO_ETHER01PLUS, 
	    16201, 16225, 4998, 0,
	    USB_VENDOR_OQO, USB_PRODUCT_OQO_ETHER01, 
	    16201, 16207, 4998, 16215, 0,
	    USB_VENDOR_OTI, USB_PRODUCT_OTI_SOLID, 
	    1890, 16229, 15924, 0,
	    USB_VENDOR_OTI, USB_PRODUCT_OTI_FLASHDISK, 
	    5937, 13303, 16235, 0,
	    USB_VENDOR_OVISLINK, USB_PRODUCT_OVISLINK_RT3071, 
	    5175, 0,
	    USB_VENDOR_OVISLINK, USB_PRODUCT_OVISLINK_RT3072, 
	    5182, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_SERIAL, 
	    4968, 7056, 7463, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M500, 
	    2734, 16240, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M505, 
	    2734, 16245, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M515, 
	    2734, 16250, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_I705, 
	    2734, 16255, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_TUNGSTEN_Z, 
	    2734, 16260, 16269, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M125, 
	    2734, 16271, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M130, 
	    2734, 16276, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_TUNGSTEN_T, 
	    2734, 16260, 16281, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_ZIRE31, 
	    2734, 16283, 16288, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_ZIRE, 
	    2734, 16283, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_LS120, 
	    16291, 3016, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_KXLRW32AN, 
	    16298, 3647, 16303, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_KXLCB20AN, 
	    16298, 3647, 16314, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_KXLCB35AN, 
	    16325, 3156, 15080, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_SDCAAE, 
	    16333, 4982, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_N5HBZ0000055, 
	    651, 7471, 4968, 4982, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_DMCFS45, 
	    16348, 3016, 16354, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_TYTP50P6S, 
	    16363, 16375, 5784, 9961, 0,
	    USB_VENDOR_PARA, USB_PRODUCT_PARA_RT3070, 
	    5168, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT2870, 
	    5161, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3070, 
	    5168, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3070_2, 
	    5168, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3072, 
	    5182, 0,
	    USB_VENDOR_FUTUREBITS, USB_PRODUCT_FUTUREBITS_4PI, 
	    16380, 16384, 0,
	    USB_VENDOR_FUTUREBITS, USB_PRODUCT_FUTUREBITS_CDL_CAN, 
	    16391, 4968, 16403, 16407, 0,
	    USB_VENDOR_FUTUREBITS, USB_PRODUCT_FUTUREBITS_ONERNG, 
	    16418, 16425, 16432, 16439, 0,
	    USB_VENDOR_INTERBIO, USB_PRODUCT_INTERBIO_CDL_CAN, 
	    16391, 4968, 16403, 16407, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_USBDISKPRO, 
	    4968, 13303, 5066, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_USBREADER, 
	    4968, 10902, 6556, 5656, 5862, 14166, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_MOBILEDRIVE, 
	    4968, 6626, 6556, 5656, 5862, 14166, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_USBDISK, 
	    4968, 13303, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_ATTACHE, 
	    4968, 5410, 5937, 3647, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_SERIAL1, 
	    7056, 7475, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_ENET, 
	    4998, 5007, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_ENET3, 
	    3173, 16449, 4998, 4982, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_ENET2, 
	    4998, 5007, 0,
	    USB_VENDOR_PHEENET, USB_PRODUCT_PHEENET_GWU513, 
	    16454, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DSS350, 
	    16461, 9035, 2316, 7343, 2833, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DSS, 
	    16461, 16465, 2316, 7343, 2833, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_SA235, 
	    16469, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_HUB, 
	    7161, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCA645VC, 
	    16475, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCA646VC, 
	    16484, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC675K, 
	    16493, 16502, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC680K, 
	    16508, 16502, 5066, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC690K, 
	    16517, 16502, 5066, 16526, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC730K, 
	    16531, 16540, 16547, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC740K, 
	    16551, 16540, 5066, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC750K, 
	    16560, 16540, 5066, 16526, 5859, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DSS150, 
	    16461, 16569, 2316, 7343, 2833, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_CPWUA054, 
	    16573, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_SNU5600, 
	    16582, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_SNU5630NS05, 
	    16590, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DIVAUSB, 
	    16603, 4968, 16608, 8797, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_RT2870, 
	    5161, 0,
	    USB_VENDOR_PHILIPSSEMI, USB_PRODUCT_PHILIPSSEMI_HUB1122, 
	    7161, 0,
	    USB_VENDOR_PHILIPSSEMI, USB_PRODUCT_PHILIPSSEMI_PN533, 
	    16612, 16616, 0,
	    USB_VENDOR_PIENGINEERING, USB_PRODUCT_PIENGINEERING_PS2USB, 
	    8535, 5748, 10245, 4968, 4982, 0,
	    USB_VENDOR_PIENGINEERING, USB_PRODUCT_PIENGINEERING_XKEYS58, 
	    16622, 16628, 6002, 16641, 16645, 0,
	    USB_VENDOR_PIENGINEERING, USB_PRODUCT_PIENGINEERING_XKEYS, 
	    16622, 16628, 6002, 0,
	    USB_VENDOR_PILOTECH, USB_PRODUCT_PILOTECH_CRW600, 
	    16651, 15424, 5943, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTV800E, 
	    16659, 16664, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTVDVBTFLASH, 
	    4645, 16659, 6945, 5937, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTV72E, 
	    4645, 16659, 16669, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTV73E, 
	    4645, 16659, 16673, 0,
	    USB_VENDOR_PIXART, USB_PRODUCT_PIXART_RPIMOUSE, 
	    16677, 16687, 6494, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_OPTUSBMOUSE, 
	    4457, 4968, 3370, 6494, 0,
	    USB_VENDOR_PLANEX, USB_PRODUCT_PLANEX_GW_US11H, 
	    16690, 5375, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CUS, 
	    7525, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW_US11S, 
	    16699, 5375, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_3, 
	    5302, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSFANG300, 
	    16708, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54GXS, 
	    16721, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW_US300, 
	    16732, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54HP, 
	    16741, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS300MINIS, 
	    16751, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RT3070, 
	    5168, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSNANO, 
	    16765, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMICRO300, 
	    16775, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_1, 
	    16789, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8192CU, 
	    16800, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_4, 
	    5302, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW900D, 
	    16812, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW450D, 
	    16820, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW450S, 
	    16828, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54MINI2, 
	    16836, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54SG, 
	    16849, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54GZL, 
	    16859, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54GD, 
	    16870, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMM, 
	    16880, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS300MINIX, 
	    16888, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMICRON, 
	    16909, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMICRON2, 
	    16921, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_2, 
	    5302, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSH300N, 
	    16934, 0,
	    USB_VENDOR_PLANEX3, USB_PRODUCT_PLANEX3_GWUS54GZ, 
	    16945, 0,
	    USB_VENDOR_PLANEX3, USB_PRODUCT_PLANEX3_GU1000T, 
	    16955, 0,
	    USB_VENDOR_PLANEX3, USB_PRODUCT_PLANEX3_GWUS54MINI, 
	    16964, 0,
	    USB_VENDOR_PLANTRONICS, USB_PRODUCT_PLANTRONICS_HEADSET, 
	    16976, 16987, 16995, 0,
	    USB_VENDOR_PLEXTOR, USB_PRODUCT_PLEXTOR_40_12_40U, 
	    17003, 17014, 0,
	    USB_VENDOR_PLX, USB_PRODUCT_PLX_TESTBOARD, 
	    12429, 9855, 0,
	    USB_VENDOR_POINTCHIPS, USB_PRODUCT_POINTCHIPS_FLASH, 
	    5937, 0,
	    USB_VENDOR_PORTGEAR, USB_PRODUCT_PORTGEAR_EA8, 
	    4998, 4982, 0,
	    USB_VENDOR_PORTGEAR, USB_PRODUCT_PORTGEAR_EA9, 
	    4998, 4982, 0,
	    USB_VENDOR_PORTSMITH, USB_PRODUCT_PORTSMITH_EEA, 
	    13710, 4998, 4982, 0,
	    USB_VENDOR_PQI, USB_PRODUCT_PQI_TRAVELFLASH, 
	    17024, 5937, 3647, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2X300, 
	    17031, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2E300, 
	    17038, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2300, 
	    17046, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2E3002, 
	    17038, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_9600, 
	    17053, 4968, 17062, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_600U, 
	    17053, 17067, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_6200, 
	    745, 17072, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_19200, 
	    17053, 4968, 17077, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_1200U, 
	    17053, 17083, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G600, 
	    17089, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_636I, 
	    17096, 17106, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2600, 
	    17089, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2E600, 
	    17111, 7357, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_COMFORT, 
	    14889, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_MOUSEINABOX, 
	    17119, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_PCGAUMS1, 
	    1337, 17134, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2301, 
	    17144, 10981, 16215, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2302, 
	    17151, 10981, 16215, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_RSAQ2, 
	    17158, 7056, 5007, 17165, 17173, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303, 
	    17158, 7056, 5007, 17184, 17197, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2305, 
	    7032, 7041, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_ATAPI4, 
	    17205, 1867, 5950, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GC, 
	    17158, 7056, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GB, 
	    17158, 7056, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GT, 
	    17158, 7056, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GL, 
	    17158, 7056, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GE, 
	    17158, 7056, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GS, 
	    17158, 7056, 5007, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2501, 
	    17213, 10981, 16215, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL25A1, 
	    17220, 10981, 16215, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303X, 
	    17158, 7056, 5007, 17227, 17235, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_RSAQ3, 
	    17158, 7056, 5007, 17165, 17240, 0,
	    USB_VENDOR_PROLIFIC2, USB_PRODUCT_PROLIFIC2_PL2303, 
	    17158, 7056, 5007, 17251, 17258, 0,
	    USB_VENDOR_PUTERCOM, USB_PRODUCT_PUTERCOM_UPA100, 
	    17272, 17281, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2573, 
	    5332, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2573_2, 
	    5332, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2573_3, 
	    5332, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2870, 
	    5161, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH341_EPP, 
	    17288, 17294, 1867, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH341_ASP, 
	    17288, 17306, 1867, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH341_UPC, 
	    17288, 17317, 1867, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH340, 
	    17329, 17306, 1867, 0,
	    USB_VENDOR_QINHENG2, USB_PRODUCT_QINHENG2_CH341SER, 
	    17335, 17306, 1867, 0,
	    USB_VENDOR_QTRONIX, USB_PRODUCT_QTRONIX_980N, 
	    17347, 8254, 0,
	    USB_VENDOR_QUALCOMM2, USB_PRODUCT_QUALCOMM2_RWT_FCT, 
	    17361, 17365, 13242, 17374, 6077, 0,
	    USB_VENDOR_QUALCOMM2, USB_PRODUCT_QUALCOMM2_CDMA_MSM, 
	    5854, 799, 13382, 6077, 0,
	    USB_VENDOR_QUALCOMM_K, USB_PRODUCT_QUALCOMM_K_CDMA_MSM_K, 
	    1648, 643, 5854, 799, 13382, 0,
	    USB_VENDOR_QUAN, USB_PRODUCT_QUAN_DM9601, 
	    4968, 5218, 0,
	    USB_VENDOR_QUANTA, USB_PRODUCT_QUANTA_RT3070, 
	    5168, 0,
	    USB_VENDOR_QUICKSHOT, USB_PRODUCT_QUICKSHOT_STRIKEPAD, 
	    4968, 17380, 0,
	    USB_VENDOR_RAINBOW, USB_PRODUCT_RAINBOW_IKEY2000, 
	    17390, 13242, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2570, 
	    6877, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2070, 
	    6011, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2570_2, 
	    6877, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2573, 
	    5332, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT73, 
	    17396, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2671, 
	    17401, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2770, 
	    5154, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2870, 
	    5161, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3070, 
	    5168, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3071, 
	    5175, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3072, 
	    5182, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3370, 
	    17408, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3572, 
	    6018, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3573, 
	    17415, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT5370, 
	    17422, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT5572, 
	    17429, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_MT7610U, 
	    9875, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT8070, 
	    17436, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2570_3, 
	    6877, 0,
	    USB_VENDOR_RATOC, USB_PRODUCT_RATOC_REXUSB60, 
	    4968, 10101, 5007, 17443, 0,
	    USB_VENDOR_RATOC, USB_PRODUCT_RATOC_REXUSB60F, 
	    4968, 10101, 5007, 17453, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188ETV, 
	    17464, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CTV, 
	    17475, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188RU_2, 
	    17486, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8150L, 
	    17496, 17505, 1867, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8151, 
	    17518, 17526, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8152, 
	    17530, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8153, 
	    17538, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8156, 
	    17546, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CE_0, 
	    7378, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8171, 
	    17554, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8172, 
	    17562, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8173, 
	    17570, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8174, 
	    17578, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_0, 
	    5302, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8191CU, 
	    17586, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188EU, 
	    5292, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_1, 
	    5302, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_2, 
	    5302, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192CE, 
	    17596, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188RU, 
	    17486, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CE_1, 
	    7378, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188RU_3, 
	    17486, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187, 
	    9146, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187B_0, 
	    17606, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CUS, 
	    7525, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192EU, 
	    17615, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_3, 
	    5302, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187B_1, 
	    17606, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187B_2, 
	    17606, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8712, 
	    17625, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8713, 
	    17633, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_COMBO, 
	    5302, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192SU, 
	    5440, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188FU, 
	    17641, 0,
	    USB_VENDOR_RIM, USB_PRODUCT_RIM_BLACKBERRY, 
	    17651, 0,
	    USB_VENDOR_RIM, USB_PRODUCT_RIM_BLACKBERRY_PEARL_DUAL, 
	    17651, 17662, 13933, 0,
	    USB_VENDOR_RIM, USB_PRODUCT_RIM_BLACKBERRY_PEARL, 
	    17651, 17662, 0,
	    USB_VENDOR_ROCKFIRE, USB_PRODUCT_ROCKFIRE_GAMEPAD, 
	    13234, 17668, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA100, 
	    17675, 4968, 7337, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM4, 
	    17686, 17691, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SC8850, 
	    17696, 17705, 17713, 17719, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_U8, 
	    17733, 4968, 7337, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM2, 
	    17737, 17691, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SC8820, 
	    17742, 17754, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PC300, 
	    17762, 17691, 6002, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM1, 
	    17769, 17691, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SK500, 
	    17742, 17774, 17691, 6002, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SCD70, 
	    17781, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA3, 
	    17788, 17795, 4968, 17800, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_XV5050, 
	    17806, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM880N, 
	    17788, 17814, 17691, 17682, 17821, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM880G, 
	    17788, 17814, 17691, 17682, 17830, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SD90, 
	    17788, 17840, 17846, 17719, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA1A, 
	    17852, 4968, 7337, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM550, 
	    17858, 17691, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SD20, 
	    17865, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SD80, 
	    17871, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA700, 
	    17877, 4968, 7337, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PCRA, 
	    17788, 17884, 17691, 8254, 17888, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PCR, 
	    17788, 17884, 17691, 8254, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_M1000, 
	    17899, 17800, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA1000, 
	    17788, 17906, 4968, 17800, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA3FXA, 
	    17788, 17914, 4968, 17800, 17682, 17888, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA3FX, 
	    17788, 17914, 4968, 17800, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_FANTOMX, 
	    17921, 17691, 17726, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA25, 
	    17788, 17930, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA101, 
	    17788, 17936, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PC50A, 
	    17788, 17943, 17888, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PC50, 
	    17788, 17943, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA101F, 
	    17788, 17936, 17949, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA1EX, 
	    17788, 17954, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM3, 
	    17788, 17961, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA4FX, 
	    17788, 17966, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SONICCELL, 
	    17973, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA25EXA, 
	    17788, 17983, 17888, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA25EX, 
	    17788, 17983, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UMONE, 
	    17991, 17691, 17682, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_QUADCAPTURE, 
	    17998, 0,
	    USB_VENDOR_RTSYS, USB_PRODUCT_RTSYS_RTS03, 
	    18011, 0,
	    USB_VENDOR_RTSYS, USB_PRODUCT_RTSYS_CT57A, 
	    18018, 3359, 2658, 0,
	    USB_VENDOR_SAGEM, USB_PRODUCT_SAGEM_XG760A, 
	    18024, 0,
	    USB_VENDOR_SAGEM, USB_PRODUCT_SAGEM_XG76NA, 
	    18032, 0,
	    USB_VENDOR_SAITEK, USB_PRODUCT_SAITEK_CYBORG_3D_GOLD, 
	    14043, 16119, 18040, 18045, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_MIGHTYDRIVE, 
	    6487, 3647, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_ML6060, 
	    18054, 8024, 7041, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_ANDROID, 
	    11921, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_GTB3710, 
	    18062, 18071, 16075, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_ANDROID2, 
	    11921, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_GTB3730, 
	    18078, 18071, 16075, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_SWL2100W, 
	    18087, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR05A, 
	    18097, 18107, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR31, 
	    18097, 18116, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR05, 
	    18097, 18124, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR12, 
	    18097, 18132, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR09, 
	    18097, 18140, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR86, 
	    18097, 18148, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR75, 
	    18097, 18156, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_CRUZER, 
	    18164, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SANSA_CLIP, 
	    18171, 18177, 0,
	    USB_VENDOR_SANWASUPPLY, USB_PRODUCT_SANWASUPPLY_JYDV9USB, 
	    18182, 13234, 0,
	    USB_VENDOR_SANYO, USB_PRODUCT_SANYO_SCP4900, 
	    589, 18192, 4968, 15711, 0,
	    USB_VENDOR_SCANLOGIC, USB_PRODUCT_SCANLOGIC_SL11R, 
	    18201, 0,
	    USB_VENDOR_SCANLOGIC, USB_PRODUCT_SCANLOGIC_336CX, 
	    14936, 14944, 13994, 14950, 7357, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_USBSERIAL, 
	    17306, 10154, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P1, 
	    18211, 8978, 5656, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P2, 
	    18211, 8978, 6624, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P3, 
	    18211, 8978, 6626, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P4, 
	    18211, 8978, 6606, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_4, 
	    5161, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_NUB8301, 
	    18221, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RTL8192SU_1, 
	    5440, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RTL8192SU_2, 
	    5440, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3070, 
	    5168, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3071, 
	    5175, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072, 
	    5182, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_2, 
	    5182, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_3, 
	    5182, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_4, 
	    5182, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_5, 
	    5182, 0,
	    USB_VENDOR_SGI, USB_PRODUCT_SGI_SN1_L1_SC, 
	    18230, 18234, 2833, 5950, 0,
	    USB_VENDOR_SHANTOU, USB_PRODUCT_SHANTOU_ST268_USB_NIC, 
	    18237, 4968, 14782, 0,
	    USB_VENDOR_SHANTOU, USB_PRODUCT_SHANTOU_ADM8515, 
	    5715, 4998, 0,
	    USB_VENDOR_SHARK, USB_PRODUCT_SHARK_PA, 
	    18243, 4982, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_CE175TU, 
	    18250, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_SL5500, 
	    18258, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_A300, 
	    18265, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_SL5600, 
	    18270, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_C700, 
	    18277, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_C750, 
	    18282, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_RUITZ1016YCZZ, 
	    18287, 5375, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_WS007SH, 
	    18295, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_WS011SH, 
	    18303, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_NWKBD, 
	    18311, 6002, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSB, 
	    18321, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSCSI, 
	    18327, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SDDR09, 
	    18097, 18334, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSBSMCF, 
	    18341, 11354, 687, 11006, 4982, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_ZIOMMC, 
	    18341, 16333, 4982, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_HIFD, 
	    1337, 18346, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSBATAPI, 
	    18341, 5533, 4982, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_CF, 
	    18341, 11006, 4982, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSCSI_B, 
	    18327, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSCSI_C, 
	    18327, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_CDRW, 
	    18351, 8240, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_ORCA, 
	    18341, 18357, 16104, 5943, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SCM, 
	    18362, 308, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SCL3711, 
	    18362, 308, 18366, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SCL3712, 
	    18362, 308, 18381, 0,
	    USB_VENDOR_SIEMENS, USB_PRODUCT_SIEMENS_SPEEDSTREAM, 
	    5414, 4968, 0,
	    USB_VENDOR_SIEMENS, USB_PRODUCT_SIEMENS_SPEEDSTREAM22, 
	    5414, 4968, 18396, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_WLL013, 
	    6735, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_MC75, 
	    651, 18401, 18409, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_HC28MDMNET, 
	    18414, 18419, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_HC28MS, 
	    18414, 10870, 9830, 8240, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_HC28MDM, 
	    18414, 18426, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_WL54G, 
	    7589, 4968, 3424, 4982, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_EM5625, 
	    18430, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC5720_2, 
	    18437, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AIRCARD595, 
	    4012, 651, 18444, 18452, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC5725, 
	    18456, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC597E, 
	    4012, 651, 18444, 18463, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_C597, 
	    4012, 651, 18468, 18476, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AIRCARD580, 
	    4012, 651, 18444, 18480, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC595U, 
	    4012, 651, 18444, 18484, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC5720, 
	    18437, 651, 5103, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MINI5725, 
	    4012, 651, 18489, 18497, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_250U, 
	    18502, 651, 18509, 6599, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_INSTALLER, 
	    18514, 15838, 12005, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8755_2, 
	    18522, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8765, 
	    18529, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8755, 
	    18522, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC875U, 
	    18536, 9052, 4968, 5103, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8755_3, 
	    18522, 9052, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8775_2, 
	    18543, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AIRCARD875, 
	    18514, 18550, 9052, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8780, 
	    18554, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8781, 
	    18561, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC880, 
	    4012, 651, 18444, 18568, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC881, 
	    4012, 651, 18444, 18572, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC880E, 
	    4012, 651, 18444, 18576, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC881E, 
	    4012, 651, 18444, 18581, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC880U, 
	    4012, 651, 18444, 18586, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC881U, 
	    4012, 651, 18444, 18591, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC885U, 
	    4012, 651, 18444, 18596, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_C01SW, 
	    18601, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_USB305, 
	    4012, 651, 18444, 4968, 11155, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC7304, 
	    18607, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_EM7455, 
	    18614, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_SIR4116, 
	    18621, 18630, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_IRDA, 
	    10431, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_FIR4210, 
	    18634, 5630, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_VFIR4220, 
	    18643, 18652, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_I_BEAD100, 
	    18657, 12704, 8793, 11194, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_I_BEAD150, 
	    18657, 16569, 8793, 11194, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_DNSSF7X, 
	    18664, 1407, 18670, 18677, 18683, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_MUSICSTICK, 
	    18691, 18700, 0,
	    USB_VENDOR_ALLIEDTELESYN, USB_PRODUCT_ALLIEDTELESYN_AT_USB10, 
	    18711, 4968, 4998, 4982, 0,
	    USB_VENDOR_SIIG, USB_PRODUCT_SIIG_DIGIFILMREADER, 
	    18720, 5943, 0,
	    USB_VENDOR_SIIG, USB_PRODUCT_SIIG_UISDMC2S, 
	    18735, 0,
	    USB_VENDOR_SIIG, USB_PRODUCT_SIIG_MULTICARDREADER, 
	    18735, 0,
	    USB_VENDOR_SIIG2, USB_PRODUCT_SIIG2_USBTOETHER, 
	    4968, 18751, 4998, 0,
	    USB_VENDOR_SIIG2, USB_PRODUCT_SIIG2_US2308, 
	    7056, 0,
	    USB_VENDOR_SILICOM, USB_PRODUCT_SILICOM_U2E, 
	    18754, 0,
	    USB_VENDOR_SILICOM, USB_PRODUCT_SILICOM_GPE, 
	    18758, 18040, 8978, 4998, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_POLOLU, 
	    18764, 7056, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_ARGUSISP, 
	    18771, 18781, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CRUMB128, 
	    18785, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_DEGREECONT, 
	    18794, 18801, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_SUNNTO, 
	    18810, 18817, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_DESKTOPMOBILE, 
	    18824, 13888, 18833, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_IPLINK1220, 
	    18840, 18848, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_LIPOWSKY_JTAG, 
	    18853, 18862, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_LIPOWSKY_LIN, 
	    18853, 18872, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_LIPOWSKY_HARP, 
	    18853, 18881, 0,
	    USB_VENDOR_SILABS2, USB_PRODUCT_SILABS2_DCU11CLONE, 
	    18888, 18895, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CP210X_1, 
	    18901, 7056, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CP210X_2, 
	    18901, 7056, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CP210X_3, 
	    18901, 7056, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_EC3, 
	    18908, 4968, 18912, 4982, 0,
	    USB_VENDOR_SILICONPORTALS, USB_PRODUCT_SILICONPORTALS_YAPPH_NF, 
	    18918, 15711, 7966, 7970, 0,
	    USB_VENDOR_SILICONPORTALS, USB_PRODUCT_SILICONPORTALS_YAPPHONE, 
	    18918, 15711, 0,
	    USB_VENDOR_SIS, USB_PRODUCT_SIS_SIS_163U, 
	    18922, 651, 7471, 4982, 0,
	    USB_VENDOR_SIRIUS, USB_PRODUCT_SIRIUS_ROADSTER, 
	    18930, 18938, 7501, 18947, 4968, 0,
	    USB_VENDOR_SITECOM, USB_PRODUCT_SITECOM_LN029, 
	    18950, 0,
	    USB_VENDOR_SITECOM, USB_PRODUCT_SITECOM_CN104, 
	    18956, 10101, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL168V1, 
	    18962, 18969, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_LN030, 
	    18972, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL168V4, 
	    18962, 18979, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT2870_3, 
	    5161, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL302, 
	    18982, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL603, 
	    18989, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL315, 
	    18996, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL321, 
	    19003, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3070_3, 
	    5168, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL324, 
	    19010, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL343, 
	    19017, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL608, 
	    19024, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL344, 
	    19031, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL329, 
	    19038, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL345, 
	    19045, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL353, 
	    19052, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_3, 
	    5182, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_4, 
	    5182, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL349V1, 
	    19059, 18969, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_6, 
	    5182, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL349V4, 
	    19059, 18979, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3070_1, 
	    5168, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_LN031, 
	    19066, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8188CU_2, 
	    5302, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_5, 
	    5182, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WLA4000, 
	    19073, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WLA5000, 
	    19082, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_AX88179, 
	    6806, 4968, 6814, 6789, 5218, 6172, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_LN028, 
	    19091, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8192CUR2, 
	    5282, 9140, 19098, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL113, 
	    19102, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL172, 
	    19109, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL113R2, 
	    19102, 9140, 6624, 0,
	    USB_VENDOR_SMARTBRIDGES, USB_PRODUCT_SMARTBRIDGES_SMARTLINK, 
	    19116, 4968, 5218, 5007, 0,
	    USB_VENDOR_SMARTBRIDGES, USB_PRODUCT_SMARTBRIDGES_SMARTNIC, 
	    19126, 6624, 19135, 4982, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2102USB, 
	    7049, 5218, 5007, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2202USB, 
	    6774, 5218, 5007, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2206USB, 
	    19139, 16067, 4968, 4998, 4982, 0,
	    USB_VENDOR_SMC3, USB_PRODUCT_SMC3_2662WV1, 
	    19139, 16067, 19142, 0,
	    USB_VENDOR_SMC3, USB_PRODUCT_SMC3_2662WV2, 
	    19139, 16067, 19142, 7644, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2862WG, 
	    19139, 16067, 19149, 7644, 4968, 5410, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2862WG_V1, 
	    19139, 16067, 19149, 18969, 4968, 19156, 0,
	    USB_VENDOR_SMK, USB_PRODUCT_SMK_MCE_IR, 
	    19160, 19166, 14852, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2020HUB, 
	    4968, 5906, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2512HUB, 
	    4968, 5410, 19175, 5906, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2513HUB, 
	    4968, 5410, 19182, 5906, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2514HUB, 
	    4968, 5410, 19189, 5906, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2517HUB, 
	    4968, 5410, 7511, 5906, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7500, 
	    19196, 4968, 5410, 6789, 5218, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7505, 
	    19204, 4968, 5410, 6789, 5218, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7800, 
	    19212, 4968, 19220, 6789, 5218, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7801, 
	    19224, 4968, 19220, 6789, 5218, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7850, 
	    19232, 4968, 5410, 6789, 5218, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500, 
	    19240, 4998, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505, 
	    19249, 4998, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512, 
	    19258, 4968, 5906, 3156, 4998, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9514, 
	    19267, 4968, 5906, 3156, 4998, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN9530, 
	    19276, 4998, 8240, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN9730, 
	    19284, 4998, 8240, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500_SAL10, 
	    19240, 4998, 10890, 19292, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505_SAL10, 
	    19249, 4998, 10890, 19292, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A_SAL10, 
	    19300, 4998, 10890, 19292, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505A_SAL10, 
	    19310, 4998, 10890, 19292, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512_14_SAL10, 
	    19320, 5906, 3156, 4998, 8240, 19292, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A_HAL, 
	    19300, 4998, 8240, 19332, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505A_HAL, 
	    19310, 4998, 8240, 19332, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500_ALT, 
	    19240, 4998, 8240, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A_ALT, 
	    19300, 4998, 8240, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512_14_ALT, 
	    19258, 5906, 3156, 4998, 8240, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A, 
	    19300, 4998, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505A, 
	    19310, 4998, 10890, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN89530, 
	    19338, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512_14, 
	    19347, 4968, 5906, 3156, 4998, 10890, 0,
	    USB_VENDOR_SOHOWARE, USB_PRODUCT_SOHOWARE_NUB100, 
	    6774, 4968, 4998, 0,
	    USB_VENDOR_SOHOWARE, USB_PRODUCT_SOHOWARE_NUB110, 
	    19361, 4998, 0,
	    USB_VENDOR_SOLIDYEAR, USB_PRODUCT_SOLIDYEAR_KEYBOARD, 
	    1890, 1896, 4968, 8254, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_DSC, 
	    19368, 19372, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_NWMS7, 
	    19380, 19392, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_DRIVEV2, 
	    12387, 9958, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_MSACUS1, 
	    19380, 19399, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_HANDYCAM, 
	    19408, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_MSC, 
	    19417, 19421, 19428, 19434, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_35, 
	    1337, 19439, 19444, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2KEYBOARD, 
	    19449, 8254, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2KEYBOARDHUB, 
	    19449, 8254, 7161, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2MOUSE, 
	    19449, 6481, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_40, 
	    1337, 19439, 19462, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_MSC_U03, 
	    19417, 19421, 19428, 19434, 19467, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_40_MS, 
	    1337, 19439, 19462, 14802, 8770, 19434, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_S360, 
	    1337, 19439, 19475, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_41_MS, 
	    1337, 19439, 19480, 14802, 8770, 19434, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_41, 
	    1337, 19439, 19480, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_NX60, 
	    1337, 19439, 19485, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2EYETOY4, 
	    19449, 19490, 19497, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2EYETOY5, 
	    19449, 19490, 19502, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_TJ25, 
	    1337, 19439, 19507, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_IFU_WLM2, 
	    19512, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS3CONTROLLER, 
	    1337, 19521, 5950, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_GPS_CS1, 
	    1337, 9074, 19537, 0,
	    USB_VENDOR_SOURCENEXT, USB_PRODUCT_SOURCENEXT_KEIKAI8_CHG, 
	    19545, 9165, 5141, 19557, 0,
	    USB_VENDOR_SOURCENEXT, USB_PRODUCT_SOURCENEXT_KEIKAI8, 
	    19545, 9165, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT2573, 
	    5332, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT3070, 
	    5168, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_SPRINGERDESIGN, USB_PRODUCT_SPRINGERDESIGN_TTSMP3PLAYER, 
	    4845, 1635, 19565, 0,
	    USB_VENDOR_SPHAIRON, USB_PRODUCT_SPHAIRON_UB801R, 
	    19578, 0,
	    USB_VENDOR_SPHAIRON, USB_PRODUCT_SPHAIRON_RTL8187, 
	    9146, 0,
	    USB_VENDOR_STMICRO, USB_PRODUCT_STMICRO_COMMUNICATOR, 
	    4968, 19585, 0,
	    USB_VENDOR_STSN, USB_PRODUCT_STSN_STSN0001, 
	    14747, 245, 8240, 0,
	    USB_VENDOR_SUNCOMM, USB_PRODUCT_SUNCOMM_MB_ADAPTOR, 
	    7413, 7463, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_DS96L, 
	    19598, 19605, 19613, 19618, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_PS64P1, 
	    19598, 19605, 19613, 19621, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_VS10U, 
	    19598, 19624, 19632, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_IS96U, 
	    19598, 19634, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_AS64LX, 
	    19598, 19605, 19613, 19645, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_AS144L4, 
	    19605, 19613, 19648, 0,
	    USB_VENDOR_SUNRISING, USB_PRODUCT_SUNRISING_SR9600, 
	    19651, 4998, 0,
	    USB_VENDOR_SUNRISING, USB_PRODUCT_SUNRISING_QF9700, 
	    19658, 4998, 0,
	    USB_VENDOR_SUPERTOP, USB_PRODUCT_SUPERTOP_IDEBRIDGE, 
	    4254, 12369, 1867, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_SUPRAEXPRESS56K, 
	    19665, 13710, 19671, 6077, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_SUPRA2890, 
	    19675, 19684, 19671, 5103, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_RIO600USB, 
	    9084, 6093, 4968, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_RIO800USB, 
	    9084, 19689, 4968, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_PSAPLAY120, 
	    19693, 19698, 19707, 0,
	    USB_VENDOR_SURECOM, USB_PRODUCT_SURECOM_EP9001G2A, 
	    19711, 9140, 19721, 0,
	    USB_VENDOR_SURECOM, USB_PRODUCT_SURECOM_EP9001G, 
	    19711, 0,
	    USB_VENDOR_SURECOM, USB_PRODUCT_SURECOM_RT2573, 
	    5332, 0,
	    USB_VENDOR_SUSTEEN, USB_PRODUCT_SUSTEEN_DCU10, 
	    4968, 2658, 0,
	    USB_VENDOR_SWEEX, USB_PRODUCT_SWEEX_ZD1211, 
	    19724, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW153, 
	    19731, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW154, 
	    19737, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW303, 
	    19743, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW313, 
	    19749, 0,
	    USB_VENDOR_SYNET, USB_PRODUCT_SYNET_MWP54SS, 
	    19755, 4968, 651, 19764, 19774, 0,
	    USB_VENDOR_SYSTEMTALKS, USB_PRODUCT_SYSTEMTALKS_SGCX2UL, 
	    19781, 0,
	    USB_VENDOR_TANGTOP, USB_PRODUCT_TANGTOP_USBPS2, 
	    19790, 0,
	    USB_VENDOR_TARGUS, USB_PRODUCT_TARGUS_PAUM004, 
	    19797, 6494, 0,
	    USB_VENDOR_TAUGA, USB_PRODUCT_TAUGA_CAMERAMATE, 
	    14925, 19805, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UPA9664, 
	    19816, 4982, 19824, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UCA1464, 
	    19832, 4982, 19844, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UHA6400, 
	    19852, 4982, 19860, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UPA6400, 
	    19852, 4982, 19868, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_BT_DONGLE, 
	    4972, 4968, 15101, 0,
	    USB_VENDOR_TEAC, USB_PRODUCT_TEAC_FD05PUB, 
	    19876, 19885, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_0193, 
	    19892, 19899, 5375, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_ZYAIR_B200, 
	    1553, 19904, 19910, 5375, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_U300C, 
	    19915, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_QUICKWLAN, 
	    19922, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_ZD1211_1, 
	    19724, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_ZD1211_2, 
	    19724, 0,
	    USB_VENDOR_TELEX, USB_PRODUCT_TELEX_MIC1, 
	    19932, 4968, 19941, 0,
	    USB_VENDOR_TENX, USB_PRODUCT_TENX_MISSILE, 
	    19952, 19960, 0,
	    USB_VENDOR_TENX, USB_PRODUCT_TENX_TEMPER, 
	    19969, 19976, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_UTUSB41, 
	    19983, 7161, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_TUSB2046, 
	    19992, 7161, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_TUSB3410, 
	    20001, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_NEXII, 
	    20010, 7501, 2316, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_MSP430_JTAG, 
	    20014, 20028, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_MSP430, 
	    20014, 0,
	    USB_VENDOR_THRUST, USB_PRODUCT_THRUST_FUSION_PAD, 
	    16097, 2316, 13920, 0,
	    USB_VENDOR_TOD, USB_PRODUCT_TOD_DOOGI_SLIM, 
	    20033, 20039, 4968, 6002, 0,
	    USB_VENDOR_TODOS, USB_PRODUCT_TODOS_ARGOS_MINI, 
	    20044, 6628, 20050, 5943, 0,
	    USB_VENDOR_TOPFIELD, USB_PRODUCT_TOPFIELD_TF5000PVR, 
	    20060, 2316, 20070, 20076, 0,
	    USB_VENDOR_TOPPING, USB_PRODUCT_TOPPING_DX3_PRO, 
	    20085, 5066, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_POCKETPC_E740, 
	    8468, 20089, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_RT3070, 
	    5168, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_AX88179, 
	    6806, 4968, 6814, 6789, 5218, 6172, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_HSDPA_MODEM_EU870DT1, 
	    9052, 6599, 5103, 5862, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_WN821NV5, 
	    20094, 20104, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_WN822NV4, 
	    20107, 18979, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_WN823NV2, 
	    20117, 7644, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_RTL8188EU, 
	    5292, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_T4UV2, 
	    20127, 20134, 7655, 6624, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_T4UHV2, 
	    20127, 20138, 7655, 6624, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_T2UNANO, 
	    20127, 20143, 6975, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_UE300, 
	    20147, 20153, 7471, 0,
	    USB_VENDOR_TREK, USB_PRODUCT_TREK_THUMBDRIVE, 
	    20165, 0,
	    USB_VENDOR_TREK, USB_PRODUCT_TREK_THUMBDRIVE_8MB, 
	    20165, 20176, 0,
	    USB_VENDOR_TRENDNET, USB_PRODUCT_TRENDNET_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_TRENDNET, USB_PRODUCT_TRENDNET_RTL8188CU, 
	    5302, 0,
	    USB_VENDOR_TRENDNET, USB_PRODUCT_TRENDNET_TEW648UBM, 
	    20180, 0,
	    USB_VENDOR_TRIPPLITE, USB_PRODUCT_TRIPPLITE_U209, 
	    20191, 7056, 5007, 0,
	    USB_VENDOR_TRIPPLITE2, USB_PRODUCT_TRIPPLITE2_UPS, 
	    3207, 3213, 480, 0,
	    USB_VENDOR_TRIPPLITE2, USB_PRODUCT_TRIPPLITE2_SMARTLCD, 
	    20196, 480, 0,
	    USB_VENDOR_TRIPPLITE2, USB_PRODUCT_TRIPPLITE2_AVR550U, 
	    3207, 3213, 20205, 0,
	    USB_VENDOR_TRUMPION, USB_PRODUCT_TRUMPION_T33521, 
	    20213, 20221, 0,
	    USB_VENDOR_TRUMPION, USB_PRODUCT_TRUMPION_XXX1100, 
	    16465, 20229, 0,
	    USB_VENDOR_TSUNAMI, USB_PRODUCT_TSUNAMI_SM2000, 
	    20234, 0,
	    USB_VENDOR_TWINMOS, USB_PRODUCT_TWINMOS_G240, 
	    20242, 0,
	    USB_VENDOR_ULTIMA, USB_PRODUCT_ULTIMA_1200UBPLUS, 
	    11675, 15320, 11565, 7357, 0,
	    USB_VENDOR_ULTIMA, USB_PRODUCT_ULTIMA_T14BR, 
	    20247, 20253, 6945, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA1236U, 
	    20259, 5778, 20265, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA1220U, 
	    20259, 20273, 20265, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA2000U, 
	    20259, 20279, 20265, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA3400, 
	    20259, 20285, 20265, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA2100U, 
	    20259, 20290, 20265, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA2200U, 
	    20259, 20296, 20265, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW429UB_A, 
	    20302, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW429UB, 
	    20314, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW429UBC1, 
	    20314, 9587, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW645UB, 
	    20324, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_ALL0298V2, 
	    20334, 7644, 0,
	    USB_VENDOR_UNIACCESS, USB_PRODUCT_UNIACCESS_PANACHE, 
	    20342, 20350, 4968, 5109, 4982, 0,
	    USB_VENDOR_UNKNOWN1, USB_PRODUCT_UNKNOWN1_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_UNKNOWN2, USB_PRODUCT_UNKNOWN2_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_UNKNOWN2, USB_PRODUCT_UNKNOWN2_NW3100, 
	    20355, 0,
	    USB_VENDOR_UNKNOWN3, USB_PRODUCT_UNKNOWN3_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_NETWORKFAB, USB_PRODUCT_NETWORKFAB_NF_RIC, 
	    20363, 20366, 0,
	    USB_VENDOR_USR, USB_PRODUCT_USR_USR1120, 
	    20370, 5375, 0,
	    USB_VENDOR_USR, USB_PRODUCT_USR_USR5422, 
	    20378, 5375, 0,
	    USB_VENDOR_USR, USB_PRODUCT_USR_USR5423, 
	    20386, 5375, 0,
	    USB_VENDOR_USI, USB_PRODUCT_USI_MC60, 
	    20394, 7056, 0,
	    USB_VENDOR_USRP, USB_PRODUCT_USRP_USRPv2, 
	    4951, 20399, 6624, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS101, 
	    20408, 20415, 5943, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS301, 
	    20427, 20415, 5943, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS451, 
	    20434, 20415, 5943, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS300, 
	    20441, 20415, 5943, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS5011, 
	    20448, 20415, 5943, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS471, 
	    20456, 20415, 5943, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS491, 
	    20463, 20415, 5943, 0,
	    USB_VENDOR_VIDZMEDIA, USB_PRODUCT_VIDZMEDIA_MONSTERTV, 
	    20470, 20480, 0,
	    USB_VENDOR_VIA, USB_PRODUCT_VIA_AR9271, 
	    7109, 0,
	    USB_VENDOR_VIEWSONIC, USB_PRODUCT_VIEWSONIC_G773HUB, 
	    20484, 20489, 5906, 0,
	    USB_VENDOR_VIEWSONIC, USB_PRODUCT_VIEWSONIC_P815HUB, 
	    20497, 20489, 5906, 0,
	    USB_VENDOR_VIEWSONIC, USB_PRODUCT_VIEWSONIC_G773CTRL, 
	    20484, 20489, 8601, 0,
	    USB_VENDOR_VISION, USB_PRODUCT_VISION_VC6452V002, 
	    20502, 3016, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_7600, 
	    20507, 20516, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_5300, 
	    20507, 20521, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_3000, 
	    20526, 13718, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_6100, 
	    20507, 20535, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_6200, 
	    20507, 17072, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_8100, 
	    20507, 20540, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_8600, 
	    20507, 20545, 0,
	    USB_VENDOR_VIVITAR, USB_PRODUCT_VIVITAR_DSC350, 
	    20550, 3016, 0,
	    USB_VENDOR_VTECH, USB_PRODUCT_VTECH_RT2570, 
	    6877, 0,
	    USB_VENDOR_VTECH, USB_PRODUCT_VTECH_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CT0405U, 
	    20557, 20567, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE, 
	    20574, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE2, 
	    20583, 20593, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE3_4X5, 
	    20604, 20614, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE3_6X8, 
	    20604, 20618, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE4_4X5, 
	    20622, 20614, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_INTUOSA5, 
	    20632, 20639, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GD0912U, 
	    20632, 20642, 1967, 20567, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_XD0912U, 
	    20647, 19648, 20655, 20661, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTL671, 
	    20671, 20567, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTH490K0, 
	    20632, 20679, 20683, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTH690K0, 
	    20632, 20679, 20694, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTL6100WL, 
	    20632, 20705, 0,
	    USB_VENDOR_WELTREND, USB_PRODUCT_WELTREND_HID, 
	    20707, 8240, 0,
	    USB_VENDOR_WMR, USB_PRODUCT_WMR_RIGBLASTER, 
	    20711, 0,
	    USB_VENDOR_WESTERN, USB_PRODUCT_WESTERN_EXTHDD, 
	    20722, 20731, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_WNC0600, 
	    20735, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_UR045G, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_UR055G, 
	    20747, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_O8494, 
	    20754, 20762, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_1, 
	    7086, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_1_NF, 
	    7086, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_2, 
	    7086, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_2_NF, 
	    7086, 0,
	    USB_VENDOR_XIRLINK, USB_PRODUCT_XIRLINK_IMAGING, 
	    20770, 20778, 0,
	    USB_VENDOR_XIRLINK, USB_PRODUCT_XIRLINK_PCCAM, 
	    767, 5859, 3016, 0,
	    USB_VENDOR_XRITE, USB_PRODUCT_XRITE_HUEY_1, 
	    11201, 0,
	    USB_VENDOR_XRITE, USB_PRODUCT_XRITE_HUEY_2, 
	    11201, 0,
	    USB_VENDOR_CONEXANT, USB_PRODUCT_CONEXANT_MODEM_1, 
	    4968, 5103, 0,
	    USB_VENDOR_CONEXANT, USB_PRODUCT_CONEXANT_PRISM_GT_1, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_CONEXANT, USB_PRODUCT_CONEXANT_PRISM_GT_2, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UX256, 
	    20785, 17691, 17682, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MU1000, 
	    20791, 17691, 17726, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MU2000, 
	    20798, 17691, 17726, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MU500, 
	    20805, 17691, 17726, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UW500, 
	    20811, 4968, 7337, 17682, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MOTIF6, 
	    20817, 17691, 17726, 20824, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MOTIF7, 
	    20836, 17691, 17726, 20824, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MOTIF8, 
	    20843, 17691, 17726, 20824, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UX96, 
	    20850, 17691, 17682, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UX16, 
	    20855, 17691, 17682, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_S08, 
	    20860, 17691, 6002, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_CLP150, 
	    20864, 15352, 20872, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_CLP170, 
	    20878, 15352, 20872, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RPU200, 
	    20886, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTA54I, 
	    20894, 20905, 20912, 19774, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTW65B, 
	    20894, 20927, 19764, 651, 19774, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTW65I, 
	    20894, 20934, 20912, 651, 19774, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTA55I, 
	    20894, 20941, 19764, 20948, 19774, 0,
	    USB_VENDOR_YANO, USB_PRODUCT_YANO_U640MO, 
	    20953, 0,
	    USB_VENDOR_YEDATA, USB_PRODUCT_YEDATA_FLASHBUSTERU, 
	    20963, 0,
	    USB_VENDOR_YUBICO, USB_PRODUCT_YUBICO_YUBIKEY4MODE1, 
	    20977, 6606, 20985, 0,
	    USB_VENDOR_YUBICO, USB_PRODUCT_YUBICO_YUBIKEY4MODE2, 
	    20977, 6606, 20990, 0,
	    USB_VENDOR_YUBICO, USB_PRODUCT_YUBICO_YUBIKEY4MODE6, 
	    20977, 6606, 20999, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_M4Y750, 
	    21012, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_725, 
	    21020, 5566, 5375, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_XI735, 
	    21028, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_MD40900, 
	    21035, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_XG703A, 
	    5402, 4968, 5410, 5375, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_ZD1211, 
	    19724, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_AR5523, 
	    7086, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_AR5523_NF, 
	    7086, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_UB81, 
	    21043, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_UB82, 
	    21048, 0,
	    USB_VENDOR_ZEEVO, USB_PRODUCT_ZEEVO_BLUETOOTH, 
	    21053, 4972, 4968, 4982, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_ZWXG261, 
	    21060, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT3072, 
	    5182, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT3072_2, 
	    5182, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT3070, 
	    5168, 0,
	    USB_VENDOR_ZOOM, USB_PRODUCT_ZOOM_2986L, 
	    21069, 21075, 6077, 0,
	    USB_VENDOR_ZOOM, USB_PRODUCT_ZOOM_3095, 
	    21079, 4968, 21075, 6077, 0,
	    USB_VENDOR_ZORAN, USB_PRODUCT_ZORAN_EX20DSC, 
	    2316, 3016, 21084, 19368, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF622, 
	    21090, 6077, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF628, 
	    21096, 6077, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF633, 
	    21102, 21108, 4968, 6077, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF626, 
	    21114, 6077, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_UMASS_INSTALLER2, 
	    4968, 13382, 21120, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF112, 
	    21130, 21136, 21142, 21148, 6077, 687, 12042, 21154, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_UMASS_INSTALLER3, 
	    4968, 13382, 21120, 21159, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF820D_INSTALLER, 
	    21167, 11963, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF820D, 
	    21167, 6077, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_INSTALLER, 
	    21174, 11963, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MC2718, 
	    21179, 6077, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_AC8700, 
	    5854, 21186, 4968, 6077, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1201, 
	    21193, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1211, 
	    19724, 5375, 21200, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1211B, 
	    5450, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1221, 
	    21204, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ALL0298, 
	    20334, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1211B_2, 
	    5450, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_OMNI56K, 
	    21211, 19671, 11565, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_980N, 
	    17347, 8254, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_ZYAIRG220, 
	    19904, 21216, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G200V2, 
	    21222, 7644, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_AG225H, 
	    21228, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_M202, 
	    21236, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G270S, 
	    21242, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G220V2, 
	    21216, 7644, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G202, 
	    21249, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT2573, 
	    5332, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT2870_1, 
	    5161, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD271N, 
	    21255, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD211AN, 
	    21264, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT2870_2, 
	    5161, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD2105, 
	    21274, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RTL8192CU, 
	    5282, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD2705, 
	    21282, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD6605, 
	    21290, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT3070, 
	    5168, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_PRESTIGE, 
	    21297, 0,
};
static const char usb_words[] = { "." 
	    "Unknown\0" /* 3 refs @ 1 */
	    "vendor\0" /* 3 refs @ 9 */
	    "eGalax,\0" /* 1 refs @ 16 */
	    "Inc.\0" /* 15 refs @ 24 */
	    "Quan\0" /* 1 refs @ 29 */
	    "Chipsbank\0" /* 1 refs @ 34 */
	    "Microelectronics\0" /* 5 refs @ 44 */
	    "Co.\0" /* 2 refs @ 61 */
	    "HUMAX\0" /* 1 refs @ 65 */
	    "AOX\0" /* 1 refs @ 71 */
	    "Atmel\0" /* 1 refs @ 75 */
	    "Mitsumi\0" /* 1 refs @ 81 */
	    "Hewlett\0" /* 3 refs @ 89 */
	    "Packard\0" /* 3 refs @ 97 */
	    "Adaptec\0" /* 1 refs @ 105 */
	    "National\0" /* 3 refs @ 113 */
	    "Semiconductor\0" /* 10 refs @ 122 */
	    "Acer\0" /* 6 refs @ 136 */
	    "Labs\0" /* 8 refs @ 141 */
	    "Future\0" /* 2 refs @ 146 */
	    "Technology\0" /* 35 refs @ 153 */
	    "Devices\0" /* 4 refs @ 164 */
	    "NEC\0" /* 3 refs @ 172 */
	    "Eastman\0" /* 1 refs @ 176 */
	    "Kodak\0" /* 1 refs @ 184 */
	    "Weltrend\0" /* 1 refs @ 190 */
	    "VIA\0" /* 2 refs @ 199 */
	    "Melco\0" /* 1 refs @ 203 */
	    "Creative\0" /* 3 refs @ 209 */
	    "Nokia\0" /* 1 refs @ 218 */
	    "ADI\0" /* 1 refs @ 224 */
	    "Systems\0" /* 27 refs @ 228 */
	    "Computer\0" /* 12 refs @ 236 */
	    "Access\0" /* 4 refs @ 245 */
	    "SMSC\0" /* 1 refs @ 252 */
	    "Advanced\0" /* 4 refs @ 257 */
	    "Gravis\0" /* 1 refs @ 266 */
	    "Fujitsu\0" /* 4 refs @ 273 */
	    "Component\0" /* 1 refs @ 281 */
	    "Taugagreining\0" /* 1 refs @ 291 */
	    "HF\0" /* 1 refs @ 305 */
	    "Micro\0" /* 9 refs @ 308 */
	    "Lexmark\0" /* 1 refs @ 314 */
	    "International\0" /* 9 refs @ 322 */
	    "NANAO\0" /* 1 refs @ 336 */
	    "Alps\0" /* 1 refs @ 342 */
	    "Electric\0" /* 4 refs @ 347 */
	    "Thrustmaster\0" /* 1 refs @ 356 */
	    "Texas\0" /* 1 refs @ 369 */
	    "Instruments\0" /* 4 refs @ 375 */
	    "Analog\0" /* 2 refs @ 387 */
	    "Silicon\0" /* 5 refs @ 394 */
	    "Integrated\0" /* 1 refs @ 402 */
	    "Corp.\0" /* 3 refs @ 413 */
	    "KYE\0" /* 1 refs @ 419 */
	    "Diamond\0" /* 2 refs @ 423 */
	    "(Supra)\0" /* 1 refs @ 431 */
	    "Renesas\0" /* 1 refs @ 439 */
	    "Microsoft\0" /* 1 refs @ 447 */
	    "Primax\0" /* 1 refs @ 457 */
	    "Electronics\0" /* 18 refs @ 464 */
	    "MGE\0" /* 3 refs @ 476 */
	    "UPS\0" /* 6 refs @ 480 */
	    "AMP\0" /* 1 refs @ 484 */
	    "Cherry\0" /* 1 refs @ 488 */
	    "Mikroschalter\0" /* 1 refs @ 495 */
	    "American\0" /* 4 refs @ 509 */
	    "Megatrends\0" /* 1 refs @ 518 */
	    "Logitech\0" /* 1 refs @ 529 */
	    "Behavior\0" /* 1 refs @ 538 */
	    "Tech.\0" /* 1 refs @ 547 */
	    "Philips\0" /* 2 refs @ 553 */
	    "Sun\0" /* 2 refs @ 561 */
	    "Microsystems\0" /* 5 refs @ 565 */
	    "(official)\0" /* 1 refs @ 578 */
	    "Sanyo\0" /* 2 refs @ 589 */
	    "Seagate\0" /* 1 refs @ 595 */
	    "Connectix\0" /* 1 refs @ 603 */
	    "Kensington\0" /* 1 refs @ 613 */
	    "Lucent\0" /* 1 refs @ 624 */
	    "Plantronics\0" /* 1 refs @ 631 */
	    "Kyocera\0" /* 3 refs @ 643 */
	    "Wireless\0" /* 49 refs @ 651 */
	    "STMicroelectronics\0" /* 1 refs @ 660 */
	    "Foxconn\0" /* 1 refs @ 679 */
	    "/\0" /* 13 refs @ 687 */
	    "Hon\0" /* 1 refs @ 689 */
	    "Hai\0" /* 1 refs @ 693 */
	    "Meizu\0" /* 1 refs @ 697 */
	    "YAMAHA\0" /* 1 refs @ 703 */
	    "Compaq\0" /* 1 refs @ 710 */
	    "Hitachi\0" /* 1 refs @ 717 */
	    "Peripherals\0" /* 1 refs @ 725 */
	    "Davicom\0" /* 1 refs @ 737 */
	    "Visioneer\0" /* 2 refs @ 745 */
	    "Canon\0" /* 2 refs @ 755 */
	    "Nikon\0" /* 1 refs @ 761 */
	    "IBM\0" /* 2 refs @ 767 */
	    "Cypress\0" /* 2 refs @ 771 */
	    "Seiko\0" /* 1 refs @ 779 */
	    "Epson\0" /* 1 refs @ 785 */
	    "Rainbow\0" /* 1 refs @ 791 */
	    "Technologies\0" /* 18 refs @ 799 */
	    "I-O\0" /* 2 refs @ 812 */
	    "Data\0" /* 6 refs @ 816 */
	    "TDK\0" /* 1 refs @ 821 */
	    "U.S.\0" /* 3 refs @ 825 */
	    "Robotics\0" /* 4 refs @ 830 */
	    "Methode\0" /* 1 refs @ 839 */
	    "Far\0" /* 1 refs @ 847 */
	    "East\0" /* 1 refs @ 851 */
	    "Maxi\0" /* 1 refs @ 856 */
	    "Switch\0" /* 1 refs @ 861 */
	    "Lockheed\0" /* 1 refs @ 868 */
	    "Martin\0" /* 1 refs @ 877 */
	    "Energy\0" /* 1 refs @ 884 */
	    "Research\0" /* 3 refs @ 891 */
	    "Toshiba\0" /* 2 refs @ 900 */
	    "America\0" /* 4 refs @ 908 */
	    "Macro\0" /* 1 refs @ 916 */
	    "Konica\0" /* 1 refs @ 922 */
	    "Lite-On\0" /* 1 refs @ 929 */
	    "Fuji\0" /* 2 refs @ 937 */
	    "Photo\0" /* 1 refs @ 942 */
	    "Film\0" /* 1 refs @ 948 */
	    "Semiconductors\0" /* 1 refs @ 953 */
	    "Tatung\0" /* 1 refs @ 968 */
	    "Of\0" /* 1 refs @ 975 */
	    "ScanLogic\0" /* 1 refs @ 978 */
	    "Myson\0" /* 1 refs @ 988 */
	    "Digi\0" /* 2 refs @ 994 */
	    "ITT\0" /* 1 refs @ 999 */
	    "Altec\0" /* 1 refs @ 1003 */
	    "Lansing\0" /* 1 refs @ 1009 */
	    "Microchip\0" /* 1 refs @ 1017 */
	    "Holtek\0" /* 1 refs @ 1027 */
	    "Panasonic\0" /* 1 refs @ 1034 */
	    "(Matsushita)\0" /* 1 refs @ 1044 */
	    "Huan\0" /* 1 refs @ 1057 */
	    "Hsin\0" /* 1 refs @ 1062 */
	    "Sharp\0" /* 1 refs @ 1067 */
	    "Iiyama\0" /* 1 refs @ 1073 */
	    "Exar\0" /* 1 refs @ 1080 */
	    "Shuttle\0" /* 1 refs @ 1085 */
	    "Samsung\0" /* 4 refs @ 1093 */
	    "Annabooks\0" /* 1 refs @ 1101 */
	    "JVC\0" /* 1 refs @ 1111 */
	    "Chicony\0" /* 1 refs @ 1115 */
	    "ELAN\0" /* 1 refs @ 1123 */
	    "Brother\0" /* 1 refs @ 1128 */
	    "Industries\0" /* 1 refs @ 1136 */
	    "Dallas\0" /* 1 refs @ 1147 */
	    "AIPTEK\0" /* 2 refs @ 1154 */
	    "3Com\0" /* 5 refs @ 1161 */
	    "Hosiden\0" /* 1 refs @ 1166 */
	    "Corporation\0" /* 7 refs @ 1174 */
	    "Aztech\0" /* 1 refs @ 1186 */
	    "Belkin\0" /* 2 refs @ 1193 */
	    "Components\0" /* 3 refs @ 1200 */
	    "Kawatsu\0" /* 1 refs @ 1211 */
	    "Composite\0" /* 1 refs @ 1219 */
	    "Power\0" /* 7 refs @ 1229 */
	    "Conversion\0" /* 1 refs @ 1235 */
	    "Connectek\0" /* 1 refs @ 1246 */
	    "USA\0" /* 1 refs @ 1256 */
	    "NetChip\0" /* 1 refs @ 1260 */
	    "ALTRA\0" /* 1 refs @ 1268 */
	    "ATI\0" /* 2 refs @ 1274 */
	    "Aladdin\0" /* 1 refs @ 1278 */
	    "Knowledge\0" /* 1 refs @ 1286 */
	    "Universal\0" /* 1 refs @ 1296 */
	    "ViewSonic\0" /* 1 refs @ 1306 */
	    "Xirlink\0" /* 1 refs @ 1316 */
	    "Anchor\0" /* 1 refs @ 1324 */
	    "Chips\0" /* 1 refs @ 1331 */
	    "Sony\0" /* 15 refs @ 1337 */
	    "VLSI\0" /* 1 refs @ 1342 */
	    "Vision\0" /* 1 refs @ 1347 */
	    "Asahi\0" /* 2 refs @ 1354 */
	    "Kasei\0" /* 1 refs @ 1360 */
	    "ATEN\0" /* 1 refs @ 1366 */
	    "Mustek\0" /* 1 refs @ 1371 */
	    "Telex\0" /* 1 refs @ 1378 */
	    "Communications\0" /* 12 refs @ 1384 */
	    "Peracom\0" /* 1 refs @ 1399 */
	    "Networks\0" /* 4 refs @ 1407 */
	    "Alcor\0" /* 2 refs @ 1416 */
	    "Xyratex\0" /* 1 refs @ 1422 */
	    "WACOM\0" /* 1 refs @ 1430 */
	    "e-TEK\0" /* 1 refs @ 1436 */
	    "EIZO\0" /* 2 refs @ 1442 */
	    "Elecom\0" /* 1 refs @ 1447 */
	    "Conexant\0" /* 1 refs @ 1454 */
	    "Hauppauge\0" /* 2 refs @ 1463 */
	    "Works\0" /* 2 refs @ 1473 */
	    "BAFO/Quality\0" /* 1 refs @ 1479 */
	    "Accessories\0" /* 1 refs @ 1492 */
	    "Y-E\0" /* 1 refs @ 1504 */
	    "AVM\0" /* 1 refs @ 1508 */
	    "Nintendo\0" /* 2 refs @ 1512 */
	    "Quickshot\0" /* 1 refs @ 1521 */
	    "Roland\0" /* 1 refs @ 1531 */
	    "Rockfire\0" /* 1 refs @ 1538 */
	    "RATOC\0" /* 1 refs @ 1547 */
	    "ZyXEL\0" /* 2 refs @ 1553 */
	    "Communication\0" /* 2 refs @ 1559 */
	    "Iomega\0" /* 1 refs @ 1573 */
	    "A-Trend\0" /* 1 refs @ 1580 */
	    "Input\0" /* 1 refs @ 1588 */
	    "LaCie\0" /* 1 refs @ 1594 */
	    "Cisco-Linksys\0" /* 3 refs @ 1600 */
	    "OmniVision\0" /* 2 refs @ 1614 */
	    "In-System\0" /* 1 refs @ 1625 */
	    "Design\0" /* 2 refs @ 1635 */
	    "Apple\0" /* 29 refs @ 1642 */
	    "Qualcomm\0" /* 3 refs @ 1648 */
	    "Qtronix\0" /* 1 refs @ 1657 */
	    "ELSA\0" /* 2 refs @ 1665 */
	    "Brainboxes\0" /* 1 refs @ 1670 */
	    "Limited\0" /* 1 refs @ 1681 */
	    "Ultima\0" /* 1 refs @ 1689 */
	    "Axiohm\0" /* 1 refs @ 1696 */
	    "Transaction\0" /* 1 refs @ 1703 */
	    "Solutions\0" /* 2 refs @ 1715 */
	    "Microtek\0" /* 1 refs @ 1725 */
	    "SUN\0" /* 1 refs @ 1734 */
	    "Lexar\0" /* 1 refs @ 1738 */
	    "Media\0" /* 1 refs @ 1744 */
	    "Addtron\0" /* 1 refs @ 1750 */
	    "Symbol\0" /* 1 refs @ 1758 */
	    "Genesys\0" /* 1 refs @ 1765 */
	    "Logic\0" /* 2 refs @ 1773 */
	    "Keithley\0" /* 1 refs @ 1779 */
	    "Nanao\0" /* 1 refs @ 1788 */
	    "Kawasaki\0" /* 1 refs @ 1794 */
	    "LSI\0" /* 1 refs @ 1803 */
	    "FFC\0" /* 1 refs @ 1807 */
	    "Anko\0" /* 1 refs @ 1811 */
	    "Electronic\0" /* 2 refs @ 1816 */
	    "P.I.\0" /* 1 refs @ 1827 */
	    "Engineering\0" /* 1 refs @ 1832 */
	    "AOC\0" /* 1 refs @ 1844 */
	    "Chic\0" /* 1 refs @ 1848 */
	    "Barco\0" /* 1 refs @ 1853 */
	    "Display\0" /* 1 refs @ 1859 */
	    "Bridge\0" /* 23 refs @ 1867 */
	    "Information\0" /* 2 refs @ 1874 */
	    "SMK\0" /* 1 refs @ 1886 */
	    "Solid\0" /* 3 refs @ 1890 */
	    "Year\0" /* 2 refs @ 1896 */
	    "Bio-Rad\0" /* 1 refs @ 1901 */
	    "Laboratories\0" /* 1 refs @ 1909 */
	    "Macally\0" /* 1 refs @ 1922 */
	    "Act\0" /* 1 refs @ 1930 */
	    "Alaris\0" /* 1 refs @ 1934 */
	    "Apex\0" /* 1 refs @ 1941 */
	    "Vivitar\0" /* 1 refs @ 1946 */
	    "Avision\0" /* 1 refs @ 1954 */
	    "TEAC\0" /* 1 refs @ 1962 */
	    "Graphics\0" /* 2 refs @ 1967 */
	    "Sanwa\0" /* 1 refs @ 1976 */
	    "Supply\0" /* 6 refs @ 1982 */
	    "WayTech\0" /* 1 refs @ 1989 */
	    "Development,\0" /* 1 refs @ 1997 */
	    "Linksys\0" /* 4 refs @ 2010 */
	    "Sigmatel\0" /* 1 refs @ 2018 */
	    "DrayTek\0" /* 1 refs @ 2027 */
	    "Aiwa\0" /* 1 refs @ 2035 */
	    "ACARD\0" /* 1 refs @ 2040 */
	    "Prolific\0" /* 2 refs @ 2046 */
	    "Siemens\0" /* 3 refs @ 2055 */
	    "Avance\0" /* 1 refs @ 2063 */
	    "Minolta\0" /* 1 refs @ 2070 */
	    "CH\0" /* 1 refs @ 2078 */
	    "Products\0" /* 3 refs @ 2081 */
	    "Hagiwara\0" /* 1 refs @ 2090 */
	    "Sys-Com\0" /* 1 refs @ 2099 */
	    "Chuntex\0" /* 1 refs @ 2107 */
	    "Askey\0" /* 1 refs @ 2115 */
	    "Saitek\0" /* 1 refs @ 2121 */
	    "Alcatel\0" /* 2 refs @ 2128 */
	    "Telecom\0" /* 1 refs @ 2136 */
	    "AGFA-Gevaert\0" /* 1 refs @ 2144 */
	    "Asia\0" /* 1 refs @ 2157 */
	    "Microelectronic\0" /* 1 refs @ 2162 */
	    "Development\0" /* 1 refs @ 2178 */
	    "Bizlink\0" /* 1 refs @ 2190 */
	    "Keyspan\0" /* 1 refs @ 2198 */
	    "Aashima\0" /* 1 refs @ 2206 */
	    "MultiTech\0" /* 2 refs @ 2214 */
	    "ADS\0" /* 2 refs @ 2224 */
	    "Sirius\0" /* 1 refs @ 2228 */
	    "Guillemot\0" /* 1 refs @ 2235 */
	    "Boston\0" /* 1 refs @ 2245 */
	    "Acoustics\0" /* 1 refs @ 2252 */
	    "Standard\0" /* 2 refs @ 2262 */
	    "Putercom\0" /* 1 refs @ 2271 */
	    "MCT\0" /* 1 refs @ 2280 */
	    "Imation\0" /* 1 refs @ 2284 */
	    "Susteen\0" /* 1 refs @ 2292 */
	    "Eicon\0" /* 1 refs @ 2300 */
	    "Mad\0" /* 1 refs @ 2306 */
	    "Catz,\0" /* 1 refs @ 2310 */
	    "Digital\0" /* 25 refs @ 2316 */
	    "Stream\0" /* 1 refs @ 2324 */
	    "Aureal\0" /* 1 refs @ 2331 */
	    "Midiman\0" /* 1 refs @ 2338 */
	    "CyberPower\0" /* 1 refs @ 2346 */
	    "Systems,\0" /* 1 refs @ 2357 */
	    "X-Rite\0" /* 1 refs @ 2366 */
	    "Surecom\0" /* 1 refs @ 2373 */
	    "Griffin\0" /* 1 refs @ 2381 */
	    "SanDisk\0" /* 1 refs @ 2389 */
	    "Jenoptik\0" /* 1 refs @ 2397 */
	    "Logitec\0" /* 2 refs @ 2406 */
	    "Brimax\0" /* 1 refs @ 2414 */
	    "Axis\0" /* 1 refs @ 2421 */
	    "ABL\0" /* 1 refs @ 2426 */
	    "Sagem\0" /* 1 refs @ 2430 */
	    "Communications,\0" /* 1 refs @ 2436 */
	    "Alfadata\0" /* 1 refs @ 2452 */
	    "Technical\0" /* 1 refs @ 2461 */
	    "Onnto\0" /* 1 refs @ 2471 */
	    "Be\0" /* 1 refs @ 2477 */
	    "ADMtek\0" /* 1 refs @ 2480 */
	    "Corega\0" /* 1 refs @ 2487 */
	    "Freecom\0" /* 2 refs @ 2494 */
	    "Microtech\0" /* 1 refs @ 2502 */
	    "General\0" /* 1 refs @ 2512 */
	    "(Motorola)\0" /* 1 refs @ 2520 */
	    "Olympus\0" /* 1 refs @ 2531 */
	    "AboCom\0" /* 2 refs @ 2539 */
	    "KingSun\0" /* 1 refs @ 2546 */
	    "Keisokugiken\0" /* 1 refs @ 2554 */
	    "OnSpec\0" /* 2 refs @ 2567 */
	    "APG\0" /* 1 refs @ 2574 */
	    "Cash\0" /* 1 refs @ 2578 */
	    "Drawer\0" /* 1 refs @ 2583 */
	    "B.U.G.\0" /* 1 refs @ 2590 */
	    "Allied\0" /* 2 refs @ 2597 */
	    "Telesyn\0" /* 1 refs @ 2604 */
	    "AVerMedia\0" /* 1 refs @ 2612 */
	    "SIIG\0" /* 2 refs @ 2622 */
	    "CASIO\0" /* 2 refs @ 2627 */
	    "D-Link\0" /* 4 refs @ 2633 */
	    "Aptio\0" /* 1 refs @ 2640 */
	    "Arasan\0" /* 1 refs @ 2646 */
	    "Chip\0" /* 1 refs @ 2653 */
	    "Cable\0" /* 10 refs @ 2658 */
	    "STSN\0" /* 1 refs @ 2664 */
	    "Bewan\0" /* 1 refs @ 2669 */
	    "CENTURY\0" /* 1 refs @ 2675 */
	    "Zoom\0" /* 2 refs @ 2683 */
	    "Telephonics\0" /* 1 refs @ 2688 */
	    "Zoran\0" /* 1 refs @ 2700 */
	    "Synet\0" /* 1 refs @ 2706 */
	    "BroadLogic\0" /* 1 refs @ 2712 */
	    "Handspring\0" /* 4 refs @ 2723 */
	    "Palm\0" /* 11 refs @ 2734 */
	    "Computing\0" /* 1 refs @ 2739 */
	    "SOURCENEXT\0" /* 1 refs @ 2749 */
	    "Action\0" /* 2 refs @ 2760 */
	    "Star\0" /* 2 refs @ 2767 */
	    "Enterprise\0" /* 1 refs @ 2772 */
	    "Accton\0" /* 1 refs @ 2783 */
	    "BayNETGEAR\0" /* 1 refs @ 2790 */
	    "ActiveWire\0" /* 1 refs @ 2801 */
	    "B&B\0" /* 1 refs @ 2812 */
	    "PortGear\0" /* 1 refs @ 2816 */
	    "Netgear\0" /* 3 refs @ 2825 */
	    "System\0" /* 8 refs @ 2833 */
	    "Talks\0" /* 1 refs @ 2840 */
	    "Metricom\0" /* 1 refs @ 2846 */
	    "ADESSO/Kbtek\0" /* 1 refs @ 2855 */
	    "Jaton\0" /* 1 refs @ 2868 */
	    "APT\0" /* 1 refs @ 2874 */
	    "Boca\0" /* 2 refs @ 2878 */
	    "Andrea\0" /* 1 refs @ 2883 */
	    "Burr-Brown\0" /* 1 refs @ 2890 */
	    "Japan\0" /* 2 refs @ 2901 */
	    "2Wire\0" /* 1 refs @ 2907 */
	    "SmartBridges\0" /* 1 refs @ 2913 */
	    "Billionton\0" /* 1 refs @ 2926 */
	    "Extended\0" /* 3 refs @ 2937 */
	    "M-Systems\0" /* 1 refs @ 2946 */
	    "AuthenTec\0" /* 1 refs @ 2956 */
	    "Audio-Technica\0" /* 1 refs @ 2966 */
	    "Trumpion\0" /* 1 refs @ 2981 */
	    "Alation\0" /* 1 refs @ 2990 */
	    "Globespan\0" /* 1 refs @ 2998 */
	    "Concord\0" /* 1 refs @ 3008 */
	    "Camera\0" /* 26 refs @ 3016 */
	    "Garmin\0" /* 1 refs @ 3023 */
	    "GoHubs\0" /* 1 refs @ 3030 */
	    "Biometric\0" /* 1 refs @ 3037 */
	    "Company\0" /* 2 refs @ 3047 */
	    "PixArt\0" /* 1 refs @ 3055 */
	    "Plextor\0" /* 1 refs @ 3062 */
	    "Intrepid\0" /* 1 refs @ 3070 */
	    "Yano\0" /* 1 refs @ 3079 */
	    "Kingston\0" /* 1 refs @ 3084 */
	    "BlueWater\0" /* 1 refs @ 3093 */
	    "Agilent\0" /* 1 refs @ 3103 */
	    "Gude\0" /* 1 refs @ 3111 */
	    "Portsmith\0" /* 1 refs @ 3116 */
	    "GretagMacbeth\0" /* 1 refs @ 3126 */
	    "Adirondack\0" /* 1 refs @ 3140 */
	    "Wire\0" /* 1 refs @ 3151 */
	    "&\0" /* 11 refs @ 3156 */
	    "Beckhoff\0" /* 1 refs @ 3158 */
	    "Minds\0" /* 1 refs @ 3167 */
	    "At\0" /* 2 refs @ 3173 */
	    "Work\0" /* 1 refs @ 3176 */
	    "Zippy\0" /* 1 refs @ 3181 */
	    "PointChips\0" /* 1 refs @ 3187 */
	    "Intersil\0" /* 1 refs @ 3198 */
	    "Tripp\0" /* 3 refs @ 3207 */
	    "Lite\0" /* 5 refs @ 3213 */
	    "Altius\0" /* 1 refs @ 3218 */
	    "Arris\0" /* 1 refs @ 3225 */
	    "Interactive\0" /* 1 refs @ 3231 */
	    "ACTIVCARD\0" /* 1 refs @ 3243 */
	    "ACTiSYS\0" /* 1 refs @ 3253 */
	    "Novatel\0" /* 8 refs @ 3261 */
	    "A-FOUR\0" /* 1 refs @ 3269 */
	    "TECH\0" /* 1 refs @ 3276 */
	    "AIMEX\0" /* 1 refs @ 3281 */
	    "Addonics\0" /* 2 refs @ 3287 */
	    "AKAI\0" /* 1 refs @ 3296 */
	    "professional\0" /* 1 refs @ 3301 */
	    "M.I.\0" /* 1 refs @ 3314 */
	    "ARESCOM\0" /* 1 refs @ 3319 */
	    "Bay\0" /* 1 refs @ 3327 */
	    "Associates\0" /* 1 refs @ 3331 */
	    "Altera\0" /* 1 refs @ 3342 */
	    "Cambridge\0" /* 1 refs @ 3349 */
	    "Radio\0" /* 8 refs @ 3359 */
	    "Trek\0" /* 1 refs @ 3365 */
	    "Optical\0" /* 10 refs @ 3370 */
	    "ShanTou\0" /* 1 refs @ 3378 */
	    "MediaGear\0" /* 1 refs @ 3386 */
	    "Broadcom\0" /* 2 refs @ 3396 */
	    "GREENHOUSE\0" /* 1 refs @ 3405 */
	    "Geocast\0" /* 1 refs @ 3416 */
	    "Network\0" /* 12 refs @ 3424 */
	    "Zydas\0" /* 1 refs @ 3432 */
	    "Neodio\0" /* 1 refs @ 3438 */
	    "Option\0" /* 1 refs @ 3445 */
	    "N.V.\0" /* 1 refs @ 3452 */
	    "ASUSTeK\0" /* 2 refs @ 3457 */
	    "Todos\0" /* 1 refs @ 3465 */
	    "Tekram\0" /* 1 refs @ 3471 */
	    "HAL\0" /* 1 refs @ 3478 */
	    "EMS\0" /* 1 refs @ 3482 */
	    "Production\0" /* 1 refs @ 3486 */
	    "Zeevo,\0" /* 1 refs @ 3497 */
	    "Kurusugawa\0" /* 1 refs @ 3504 */
	    "Electronics,\0" /* 1 refs @ 3515 */
	    "ASIX\0" /* 1 refs @ 3528 */
	    "Inc\0" /* 2 refs @ 3533 */
	    "O2\0" /* 1 refs @ 3537 */
	    "Ambit\0" /* 1 refs @ 3540 */
	    "HTC\0" /* 1 refs @ 3546 */
	    "Realtek\0" /* 1 refs @ 3550 */
	    "Computers\0" /* 1 refs @ 3558 */
	    "Agate\0" /* 1 refs @ 3568 */
	    "DMI\0" /* 1 refs @ 3574 */
	    "Microdia\0" /* 1 refs @ 3578 */
	    "Sonix\0" /* 1 refs @ 3587 */
	    "Co.,\0" /* 3 refs @ 3593 */
	    "Ltd.\0" /* 3 refs @ 3598 */
	    "Sealevel\0" /* 1 refs @ 3603 */
	    "EasyDisk\0" /* 2 refs @ 3612 */
	    "Z-Com\0" /* 1 refs @ 3621 */
	    "Atheros\0" /* 2 refs @ 3627 */
	    "Tangtop\0" /* 1 refs @ 3635 */
	    "Pen\0" /* 4 refs @ 3643 */
	    "Drive\0" /* 11 refs @ 3647 */
	    "C-Media\0" /* 1 refs @ 3653 */
	    "Conceptronic\0" /* 2 refs @ 3661 */
	    "ELCON\0" /* 1 refs @ 3674 */
	    "Systemtechnik\0" /* 1 refs @ 3680 */
	    "NetworkFab\0" /* 1 refs @ 3694 */
	    "Sitecom\0" /* 3 refs @ 3705 */
	    "Europe\0" /* 1 refs @ 3713 */
	    "Amigo\0" /* 1 refs @ 3720 */
	    "Hawking\0" /* 1 refs @ 3726 */
	    "G.Mate,\0" /* 1 refs @ 3734 */
	    "MTK\0" /* 1 refs @ 3742 */
	    "Ours\0" /* 1 refs @ 3746 */
	    "Pilotech\0" /* 1 refs @ 3751 */
	    "Nova\0" /* 1 refs @ 3760 */
	    "Tech\0" /* 3 refs @ 3765 */
	    "eGalax\0" /* 1 refs @ 3770 */
	    "TOD\0" /* 1 refs @ 3777 */
	    "AirPrime,\0" /* 1 refs @ 3781 */
	    "Incorporated\0" /* 1 refs @ 3791 */
	    "VTech\0" /* 1 refs @ 3804 */
	    "Falcom\0" /* 1 refs @ 3810 */
	    "GmbH\0" /* 2 refs @ 3817 */
	    "In\0" /* 1 refs @ 3822 */
	    "Motion\0" /* 1 refs @ 3825 */
	    "Dynastream\0" /* 1 refs @ 3832 */
	    "Innovations\0" /* 1 refs @ 3843 */
	    "SUNRISING\0" /* 1 refs @ 3855 */
	    "DViCO\0" /* 1 refs @ 3865 */
	    "LG\0" /* 1 refs @ 3871 */
	    "Motorola\0" /* 3 refs @ 3874 */
	    "GIGABYTE\0" /* 1 refs @ 3883 */
	    "Yubico.se\0" /* 1 refs @ 3892 */
	    "Western\0" /* 1 refs @ 3902 */
	    "CCYU\0" /* 1 refs @ 3910 */
	    "Hyundai\0" /* 1 refs @ 3915 */
	    "CuriTel\0" /* 1 refs @ 3923 */
	    "SILABS2\0" /* 1 refs @ 3931 */
	    "USI\0" /* 1 refs @ 3939 */
	    "PLX\0" /* 1 refs @ 3943 */
	    "Asante\0" /* 1 refs @ 3947 */
	    "Ten\0" /* 1 refs @ 3954 */
	    "X\0" /* 2 refs @ 3958 */
	    "Technology,\0" /* 1 refs @ 3960 */
	    "Sphairon\0" /* 1 refs @ 3972 */
	    "DeLorme\0" /* 1 refs @ 3981 */
	    "ServerWorks\0" /* 1 refs @ 3989 */
	    "Multimedia\0" /* 3 refs @ 4001 */
	    "Sierra\0" /* 16 refs @ 4012 */
	    "Topfield\0" /* 1 refs @ 4019 */
	    "Ltd\0" /* 3 refs @ 4028 */
	    "NetIndex\0" /* 1 refs @ 4032 */
	    "InterBiometrics\0" /* 1 refs @ 4041 */
	    "Tsunami\0" /* 1 refs @ 4057 */
	    "Pheenet\0" /* 1 refs @ 4065 */
	    "Targus\0" /* 1 refs @ 4073 */
	    "TwinMOS\0" /* 1 refs @ 4080 */
	    "CyberTAN\0" /* 1 refs @ 4088 */
	    "Huawei\0" /* 20 refs @ 4097 */
	    "Araneus\0" /* 1 refs @ 4104 */
	    "Oy\0" /* 1 refs @ 4112 */
	    "Aincomm\0" /* 1 refs @ 4115 */
	    "Mobility\0" /* 1 refs @ 4123 */
	    "Dick\0" /* 1 refs @ 4132 */
	    "Smith\0" /* 1 refs @ 4137 */
	    "Validity\0" /* 1 refs @ 4143 */
	    "Sensors,\0" /* 1 refs @ 4152 */
	    "Baltech\0" /* 1 refs @ 4161 */
	    "Shark\0" /* 1 refs @ 4169 */
	    "AzureWave\0" /* 1 refs @ 4175 */
	    "Phison\0" /* 1 refs @ 4185 */
	    "Technologies,\0" /* 1 refs @ 4192 */
	    "Merlin\0" /* 9 refs @ 4206 */
	    "Wistron\0" /* 1 refs @ 4213 */
	    "NeWeb\0" /* 1 refs @ 4221 */
	    "Huawei-3Com\0" /* 1 refs @ 4227 */
	    "Silicom\0" /* 1 refs @ 4239 */
	    "Ralink\0" /* 1 refs @ 4247 */
	    "SuperTop\0" /* 2 refs @ 4254 */
	    "Planex\0" /* 3 refs @ 4263 */
	    "Portals\0" /* 1 refs @ 4270 */
	    "TOPPING\0" /* 1 refs @ 4278 */
	    "co.\0" /* 1 refs @ 4286 */
	    "JMicron\0" /* 1 refs @ 4290 */
	    "OQO\0" /* 1 refs @ 4298 */
	    "U-MEDIA\0" /* 1 refs @ 4302 */
	    "Fiberline\0" /* 1 refs @ 4310 */
	    "SparkLAN\0" /* 1 refs @ 4320 */
	    "AMIT\0" /* 2 refs @ 4329 */
	    "SOHOware\0" /* 1 refs @ 4334 */
	    "UMAX\0" /* 1 refs @ 4343 */
	    "Inside\0" /* 1 refs @ 4348 */
	    "Out\0" /* 1 refs @ 4355 */
	    "Good\0" /* 1 refs @ 4359 */
	    "Way\0" /* 1 refs @ 4364 */
	    "Entrega\0" /* 1 refs @ 4368 */
	    "Actiontec\0" /* 1 refs @ 4376 */
	    "Gigaset\0" /* 1 refs @ 4386 */
	    "AnyDATA\0" /* 1 refs @ 4394 */
	    "Jablotron\0" /* 1 refs @ 4402 */
	    "Senao\0" /* 1 refs @ 4412 */
	    "ASMedia\0" /* 1 refs @ 4418 */
	    "Sweex\0" /* 2 refs @ 4426 */
	    "Misc\0" /* 1 refs @ 4432 */
	    "Vendors\0" /* 1 refs @ 4437 */
	    "DisplayLink\0" /* 5 refs @ 4445 */
	    "Lenovo\0" /* 4 refs @ 4457 */
	    "E3C\0" /* 1 refs @ 4464 */
	    "Qcom\0" /* 1 refs @ 4468 */
	    "Meinberg\0" /* 1 refs @ 4473 */
	    "Funkuhren\0" /* 1 refs @ 4482 */
	    "Beceem\0" /* 1 refs @ 4492 */
	    "ZTE\0" /* 1 refs @ 4499 */
	    "Quanta\0" /* 1 refs @ 4503 */
	    "Terminus\0" /* 1 refs @ 4510 */
	    "QinHeng\0" /* 2 refs @ 4519 */
	    "OvisLink\0" /* 1 refs @ 4527 */
	    "Longcheer\0" /* 2 refs @ 4536 */
	    "MPMan\0" /* 1 refs @ 4546 */
	    "Pegatron\0" /* 1 refs @ 4552 */
	    "Bits\0" /* 1 refs @ 4561 */
	    "Linux\0" /* 3 refs @ 4566 */
	    "Foundation\0" /* 1 refs @ 4572 */
	    "Cinterion\0" /* 1 refs @ 4583 */
	    "AirTies\0" /* 1 refs @ 4593 */
	    "Encore\0" /* 1 refs @ 4601 */
	    "PARA\0" /* 1 refs @ 4608 */
	    "Industrial\0" /* 1 refs @ 4613 */
	    "TRENDnet\0" /* 1 refs @ 4624 */
	    "RT\0" /* 1 refs @ 4633 */
	    "Ericsson\0" /* 1 refs @ 4636 */
	    "Pinnacle\0" /* 4 refs @ 4645 */
	    "Arduino\0" /* 1 refs @ 4654 */
	    "SA\0" /* 1 refs @ 4662 */
	    "TP-Link\0" /* 1 refs @ 4665 */
	    "West\0" /* 1 refs @ 4673 */
	    "Mountain\0" /* 1 refs @ 4678 */
	    "Tripp-Lite\0" /* 1 refs @ 4687 */
	    "Cooler\0" /* 1 refs @ 4698 */
	    "Master\0" /* 1 refs @ 4705 */
	    "HAILUCK\0" /* 1 refs @ 4712 */
	    "Hirose\0" /* 1 refs @ 4720 */
	    "ONEPLUS\0" /* 1 refs @ 4727 */
	    "NHJ\0" /* 1 refs @ 4735 */
	    "Mercusys\0" /* 1 refs @ 4739 */
	    "VidzMedia\0" /* 1 refs @ 4748 */
	    "Pte\0" /* 1 refs @ 4758 */
	    "AEI\0" /* 2 refs @ 4762 */
	    "Hank\0" /* 1 refs @ 4766 */
	    "Connection\0" /* 1 refs @ 4771 */
	    "PQI\0" /* 1 refs @ 4782 */
	    "Daisy\0" /* 1 refs @ 4786 */
	    "Micronet\0" /* 1 refs @ 4792 */
	    "iRiver\0" /* 1 refs @ 4801 */
	    "Dell\0" /* 2 refs @ 4808 */
	    "FeiXun\0" /* 1 refs @ 4813 */
	    "Averatec\0" /* 1 refs @ 4820 */
	    "Zinwell\0" /* 1 refs @ 4829 */
	    "Ingenic\0" /* 1 refs @ 4837 */
	    "Springer\0" /* 2 refs @ 4845 */
	    "Design,\0" /* 1 refs @ 4854 */
	    "ArkMicroChips\0" /* 1 refs @ 4862 */
	    "EDIMAX\0" /* 1 refs @ 4876 */
	    "Intel\0" /* 2 refs @ 4883 */
	    "ALLWIN\0" /* 1 refs @ 4889 */
	    "MosChip\0" /* 1 refs @ 4896 */
	    "FTDI\0" /* 1 refs @ 4904 */
	    "CACE\0" /* 1 refs @ 4909 */
	    "Compare\0" /* 1 refs @ 4914 */
	    "DataApex\0" /* 1 refs @ 4922 */
	    "Evolution\0" /* 1 refs @ 4931 */
	    "eMPIA\0" /* 1 refs @ 4941 */
	    "GNU\0" /* 1 refs @ 4947 */
	    "USRP\0" /* 2 refs @ 4951 */
	    "HomeConnect\0" /* 4 refs @ 4956 */
	    "USB\0" /* 215 refs @ 4968 */
	    "Bluetooth\0" /* 27 refs @ 4972 */
	    "Adapter\0" /* 79 refs @ 4982 */
	    "3C19250\0" /* 1 refs @ 4990 */
	    "Ethernet\0" /* 92 refs @ 4998 */
	    "adapter\0" /* 92 refs @ 5007 */
	    "3CRSHEW696\0" /* 1 refs @ 5015 */
	    "3C460\0" /* 1 refs @ 5026 */
	    "U.S.Robotics\0" /* 2 refs @ 5032 */
	    "56000\0" /* 2 refs @ 5045 */
	    "Voice\0" /* 2 refs @ 5051 */
	    "Faxmodem\0" /* 2 refs @ 5057 */
	    "Pro\0" /* 20 refs @ 5066 */
	    "3C460B\0" /* 1 refs @ 5070 */
	    "3CRUSB10075\0" /* 1 refs @ 5077 */
	    "OfficeConnect\0" /* 1 refs @ 5089 */
	    "Modem\0" /* 14 refs @ 5103 */
	    "ISDN\0" /* 3 refs @ 5109 */
	    "TA\0" /* 2 refs @ 5114 */
	    "camera\0" /* 5 refs @ 5117 */
	    "HUB\0" /* 1 refs @ 5124 */
	    "Secure\0" /* 2 refs @ 5128 */
	    "Write\0" /* 2 refs @ 5135 */
	    "with\0" /* 5 refs @ 5141 */
	    "XX1\0" /* 1 refs @ 5146 */
	    "XX2\0" /* 1 refs @ 5150 */
	    "RT2770\0" /* 5 refs @ 5154 */
	    "RT2870\0" /* 69 refs @ 5161 */
	    "RT3070\0" /* 68 refs @ 5168 */
	    "RT3071\0" /* 5 refs @ 5175 */
	    "RT3072\0" /* 23 refs @ 5182 */
	    "URE450\0" /* 1 refs @ 5189 */
	    "UFE1000\0" /* 1 refs @ 5196 */
	    "Fast\0" /* 5 refs @ 5204 */
	    "1/10/100\0" /* 2 refs @ 5209 */
	    "ethernet\0" /* 32 refs @ 5218 */
	    "XX4\0" /* 1 refs @ 5227 */
	    "XX5\0" /* 1 refs @ 5231 */
	    "XX6\0" /* 1 refs @ 5235 */
	    "XX7\0" /* 1 refs @ 5239 */
	    "LCS-8138TX\0" /* 1 refs @ 5243 */
	    "XX8\0" /* 1 refs @ 5254 */
	    "XX9\0" /* 1 refs @ 5258 */
	    "UFE2000\0" /* 1 refs @ 5262 */
	    "USB2.0\0" /* 7 refs @ 5270 */
	    "WL54\0" /* 1 refs @ 5277 */
	    "RTL8192CU\0" /* 24 refs @ 5282 */
	    "RTL8188EU\0" /* 3 refs @ 5292 */
	    "RTL8188CU\0" /* 21 refs @ 5302 */
	    "XX10\0" /* 1 refs @ 5312 */
	    "BWU613\0" /* 1 refs @ 5317 */
	    "HWU54DM\0" /* 1 refs @ 5324 */
	    "RT2573\0" /* 19 refs @ 5332 */
	    "WUG2700\0" /* 1 refs @ 5339 */
	    "USB320-EC\0" /* 1 refs @ 5347 */
	    "2664W\0" /* 1 refs @ 5357 */
	    "T-Sinus\0" /* 1 refs @ 5363 */
	    "111\0" /* 1 refs @ 5371 */
	    "WLAN\0" /* 46 refs @ 5375 */
	    "SMCWUSB-G\0" /* 1 refs @ 5380 */
	    "SMCWUSBT-G2\0" /* 2 refs @ 5390 */
	    "PrismGT\0" /* 13 refs @ 5402 */
	    "2.0\0" /* 38 refs @ 5410 */
	    "SpeedStream\0" /* 3 refs @ 5414 */
	    "AR9280+AR7010\0" /* 2 refs @ 5426 */
	    "RTL8192SU\0" /* 23 refs @ 5440 */
	    "ZD1211B\0" /* 11 refs @ 5450 */
	    "WN4501H-LF-IR\0" /* 1 refs @ 5458 */
	    "WUS-201\0" /* 1 refs @ 5472 */
	    "WN7512\0" /* 1 refs @ 5480 */
	    "EP-1427X-2\0" /* 1 refs @ 5487 */
	    "Link\0" /* 1 refs @ 5498 */
	    "Acerscan\0" /* 4 refs @ 5503 */
	    "C310U\0" /* 1 refs @ 5512 */
	    "320U\0" /* 1 refs @ 5518 */
	    "640U\0" /* 2 refs @ 5523 */
	    "620U\0" /* 1 refs @ 5528 */
	    "ATA/ATAPI\0" /* 4 refs @ 5533 */
	    "AWL300\0" /* 1 refs @ 5543 */
	    "AWL400\0" /* 1 refs @ 5550 */
	    "Warplink\0" /* 1 refs @ 5557 */
	    "Prism2.5\0" /* 3 refs @ 5566 */
	    "A\0" /* 1 refs @ 5575 */
	    "AR9287+AR7010\0" /* 2 refs @ 5577 */
	    "ROPEX\0" /* 1 refs @ 5591 */
	    "FreeLan\0" /* 1 refs @ 5597 */
	    "802.11b\0" /* 6 refs @ 5605 */
	    "UAT1\0" /* 1 refs @ 5613 */
	    "ACT-IR2000U\0" /* 1 refs @ 5618 */
	    "FIR\0" /* 2 refs @ 5630 */
	    "I/O\0" /* 2 refs @ 5634 */
	    "Board\0" /* 2 refs @ 5638 */
	    "Board,\0" /* 1 refs @ 5644 */
	    "rev.\0" /* 1 refs @ 5651 */
	    "1\0" /* 15 refs @ 5656 */
	    "firmware\0" /* 1 refs @ 5658 */
	    "AWN-8020\0" /* 1 refs @ 5667 */
	    "205\0" /* 2 refs @ 5676 */
	    "AWU-120\0" /* 1 refs @ 5680 */
	    "AN986A\0" /* 1 refs @ 5688 */
	    "AN986\0" /* 1 refs @ 5695 */
	    "AN8511\0" /* 1 refs @ 5701 */
	    "AN8513\0" /* 1 refs @ 5708 */
	    "ADM8515\0" /* 2 refs @ 5715 */
	    "UBS-10BT\0" /* 2 refs @ 5723 */
	    "InstantFM\0" /* 1 refs @ 5732 */
	    "Music\0" /* 1 refs @ 5742 */
	    "to\0" /* 14 refs @ 5748 */
	    "Lan\0" /* 1 refs @ 5751 */
	    "Q-Drive\0" /* 1 refs @ 5755 */
	    "SnapScan\0" /* 10 refs @ 5763 */
	    "1212U\0" /* 2 refs @ 5772 */
	    "1236U\0" /* 2 refs @ 5778 */
	    "Touch\0" /* 7 refs @ 5784 */
	    "e40\0" /* 1 refs @ 5790 */
	    "e50\0" /* 1 refs @ 5794 */
	    "e20\0" /* 1 refs @ 5798 */
	    "e25\0" /* 1 refs @ 5802 */
	    "e26\0" /* 1 refs @ 5806 */
	    "e52\0" /* 1 refs @ 5810 */
	    "Alea\0" /* 1 refs @ 5814 */
	    "I/II\0" /* 1 refs @ 5819 */
	    "TRNG\0" /* 1 refs @ 5824 */
	    "AWU2000B\0" /* 1 refs @ 5829 */
	    "PenCam\0" /* 1 refs @ 5838 */
	    "Mega\0" /* 1 refs @ 5845 */
	    "1.3\0" /* 1 refs @ 5850 */
	    "CDMA\0" /* 7 refs @ 5854 */
	    "PC\0" /* 11 refs @ 5859 */
	    "Card\0" /* 10 refs @ 5862 */
	    "USB-HASP\0" /* 1 refs @ 5867 */
	    "0.06\0" /* 1 refs @ 5876 */
	    "SpeedTouch\0" /* 2 refs @ 5881 */
	    "120g\0" /* 1 refs @ 5892 */
	    "121g\0" /* 1 refs @ 5897 */
	    "Kbd\0" /* 3 refs @ 5902 */
	    "Hub\0" /* 36 refs @ 5906 */
	    "AU6366\0" /* 1 refs @ 5910 */
	    "Single\0" /* 1 refs @ 5917 */
	    "LUN\0" /* 1 refs @ 5924 */
	    "Multiple\0" /* 1 refs @ 5928 */
	    "Flash\0" /* 9 refs @ 5937 */
	    "Reader\0" /* 25 refs @ 5943 */
	    "Controller\0" /* 22 refs @ 5950 */
	    "MacAlly\0" /* 1 refs @ 5961 */
	    "AU9814\0" /* 1 refs @ 5969 */
	    "MicroConnectors/StrongMan\0" /* 1 refs @ 5976 */
	    "Keyboard\0" /* 20 refs @ 6002 */
	    "RT2070\0" /* 2 refs @ 6011 */
	    "RT3572\0" /* 2 refs @ 6018 */
	    "ADA70\0" /* 1 refs @ 6025 */
	    "Speakers\0" /* 3 refs @ 6031 */
	    "ASC495\0" /* 1 refs @ 6040 */
	    "Uninterruptible\0" /* 5 refs @ 6047 */
	    "NTL\0" /* 1 refs @ 6063 */
	    "250\0" /* 3 refs @ 6067 */
	    "cable\0" /* 2 refs @ 6071 */
	    "modem\0" /* 18 refs @ 6077 */
	    "TV\0" /* 1 refs @ 6083 */
	    "Wonder\0" /* 1 refs @ 6086 */
	    "600\0" /* 5 refs @ 6093 */
	    "CG-WLUSB2GO\0" /* 1 refs @ 6097 */
	    "CG-WLUSB2GNR\0" /* 1 refs @ 6109 */
	    "EZUSB\0" /* 1 refs @ 6122 */
	    "EZLINK\0" /* 1 refs @ 6128 */
	    "NTT\0" /* 5 refs @ 6135 */
	    "DoCoMo\0" /* 1 refs @ 6139 */
	    "A2502\0" /* 1 refs @ 6146 */
	    "ADU-E100H\0" /* 1 refs @ 6152 */
	    "ADU-E500A\0" /* 1 refs @ 6162 */
	    "controller\0" /* 13 refs @ 6172 */
	    "engine\0" /* 1 refs @ 6183 */
	    "Internal\0" /* 19 refs @ 6190 */
	    "Keyboard/Trackpad\0" /* 17 refs @ 6199 */
	    "(Fountain/ANSI)\0" /* 1 refs @ 6217 */
	    "(Fountain/ISO)\0" /* 1 refs @ 6233 */
	    "(Geyser/ANSI)\0" /* 1 refs @ 6248 */
	    "(Geyser/ISO)\0" /* 1 refs @ 6262 */
	    "(Geyser/JIS)\0" /* 1 refs @ 6275 */
	    "(Geyser3/ANSI)\0" /* 1 refs @ 6288 */
	    "(Geyser3/ISO)\0" /* 1 refs @ 6303 */
	    "(Geyser3/JIS)\0" /* 1 refs @ 6317 */
	    "(Geyser4/ANSI)\0" /* 1 refs @ 6331 */
	    "(Geyser4/ISO)\0" /* 1 refs @ 6346 */
	    "(Geyser4/JIS)\0" /* 1 refs @ 6360 */
	    "(Wellspring/ANSI)\0" /* 1 refs @ 6374 */
	    "(Wellspring/ISO)\0" /* 1 refs @ 6392 */
	    "(Wellspring/JIS)\0" /* 1 refs @ 6409 */
	    "(Wellspring2/ANSI)\0" /* 1 refs @ 6426 */
	    "(Wellspring2/ISO)\0" /* 1 refs @ 6445 */
	    "(Wellspring2/JIS)\0" /* 1 refs @ 6463 */
	    "mouse\0" /* 16 refs @ 6481 */
	    "Mighty\0" /* 2 refs @ 6487 */
	    "Mouse\0" /* 19 refs @ 6494 */
	    "Trackpad\0" /* 3 refs @ 6500 */
	    "(Fountain)\0" /* 1 refs @ 6509 */
	    "(Geyser)\0" /* 1 refs @ 6520 */
	    "Magic\0" /* 2 refs @ 6529 */
	    "HCI\0" /* 1 refs @ 6535 */
	    "(HID-proxy\0" /* 1 refs @ 6539 */
	    "mode)\0" /* 1 refs @ 6550 */
	    "in\0" /* 6 refs @ 6556 */
	    "iPod\0" /* 3 refs @ 6559 */
	    "Shuffle\0" /* 1 refs @ 6564 */
	    "(2nd\0" /* 1 refs @ 6572 */
	    "generation)\0" /* 1 refs @ 6577 */
	    "iPhone\0" /* 7 refs @ 6589 */
	    "4G\0" /* 4 refs @ 6596 */
	    "3G\0" /* 6 refs @ 6599 */
	    "3GS\0" /* 1 refs @ 6602 */
	    "4\0" /* 8 refs @ 6606 */
	    "(VZW)\0" /* 1 refs @ 6608 */
	    "4S\0" /* 2 refs @ 6614 */
	    "5\0" /* 3 refs @ 6617 */
	    "iPad\0" /* 4 refs @ 6619 */
	    "2\0" /* 12 refs @ 6624 */
	    "3\0" /* 9 refs @ 6626 */
	    "Mini\0" /* 5 refs @ 6628 */
	    "Host\0" /* 11 refs @ 6633 */
	    "MacBookPro\0" /* 3 refs @ 6638 */
	    "7,1\0" /* 1 refs @ 6649 */
	    "iMac\0" /* 1 refs @ 6653 */
	    "11,1\0" /* 1 refs @ 6658 */
	    "8,2\0" /* 1 refs @ 6663 */
	    "MacBookAir\0" /* 3 refs @ 6667 */
	    "3,1\0" /* 1 refs @ 6678 */
	    "3,2\0" /* 1 refs @ 6682 */
	    "4,1\0" /* 1 refs @ 6686 */
	    "MacMini\0" /* 1 refs @ 6690 */
	    "5,1\0" /* 1 refs @ 6698 */
	    "6,1\0" /* 1 refs @ 6702 */
	    "9,2\0" /* 1 refs @ 6706 */
	    "USB-UART\0" /* 1 refs @ 6710 */
	    "PENTAX\0" /* 1 refs @ 6719 */
	    "Optio230\0" /* 1 refs @ 6726 */
	    "WLL013\0" /* 3 refs @ 6735 */
	    "(Intersil)\0" /* 1 refs @ 6742 */
	    "Voyager\0" /* 1 refs @ 6753 */
	    "1010\0" /* 1 refs @ 6761 */
	    "AX88172\0" /* 1 refs @ 6766 */
	    "10/100\0" /* 20 refs @ 6774 */
	    "AX88178\0" /* 1 refs @ 6781 */
	    "gigabit\0" /* 11 refs @ 6789 */
	    "AX88178A\0" /* 1 refs @ 6797 */
	    "AX88179\0" /* 4 refs @ 6806 */
	    "3.0\0" /* 6 refs @ 6814 */
	    "AX88772\0" /* 1 refs @ 6818 */
	    "AX88772A\0" /* 2 refs @ 6826 */
	    "AX88772B\0" /* 1 refs @ 6835 */
	    "AX88772B1\0" /* 1 refs @ 6844 */
	    "ASM1051,1053,1153\0" /* 1 refs @ 6854 */
	    "SATA\0" /* 2 refs @ 6872 */
	    "RT2570\0" /* 5 refs @ 6877 */
	    "WL-167g\0" /* 3 refs @ 6884 */
	    "WL-159g\0" /* 1 refs @ 6892 */
	    "A9T\0" /* 1 refs @ 6900 */
	    "wireless\0" /* 2 refs @ 6904 */
	    "P5B\0" /* 1 refs @ 6913 */
	    "(version\0" /* 3 refs @ 6917 */
	    "2)\0" /* 6 refs @ 6926 */
	    "My\0" /* 1 refs @ 6929 */
	    "Cinema\0" /* 1 refs @ 6932 */
	    "U3100\0" /* 1 refs @ 6939 */
	    "DVB-T\0" /* 9 refs @ 6945 */
	    "USB-N10\0" /* 3 refs @ 6951 */
	    "USB-N53\0" /* 1 refs @ 6959 */
	    "USB-N66\0" /* 1 refs @ 6967 */
	    "Nano\0" /* 5 refs @ 6975 */
	    "RTL8192CU_3\0" /* 1 refs @ 6980 */
	    "USB-AC53\0" /* 1 refs @ 6992 */
	    "B1\0" /* 4 refs @ 7001 */
	    "AURA\0" /* 1 refs @ 7004 */
	    "LED\0" /* 1 refs @ 7009 */
	    "MyPal\0" /* 1 refs @ 7013 */
	    "A730\0" /* 1 refs @ 7019 */
	    "USB-N11\0" /* 1 refs @ 7024 */
	    "Parallel\0" /* 5 refs @ 7032 */
	    "printer\0" /* 6 refs @ 7041 */
	    "10Mbps\0" /* 3 refs @ 7049 */
	    "Serial\0" /* 38 refs @ 7056 */
	    "UC210T\0" /* 1 refs @ 7063 */
	    "UC2324\0" /* 1 refs @ 7070 */
	    "DSB-650C\0" /* 1 refs @ 7077 */
	    "AR5523\0" /* 20 refs @ 7086 */
	    "TG121N\0" /* 1 refs @ 7093 */
	    "WN821NV2\0" /* 1 refs @ 7100 */
	    "AR9271\0" /* 12 refs @ 7109 */
	    "3CRUSBN275\0" /* 1 refs @ 7116 */
	    "WN612\0" /* 1 refs @ 7127 */
	    "AR3011\0" /* 1 refs @ 7133 */
	    "AR3012\0" /* 2 refs @ 7140 */
	    "AR9170\0" /* 1 refs @ 7147 */
	    "UHB124\0" /* 1 refs @ 7154 */
	    "hub\0" /* 20 refs @ 7161 */
	    "W-Buddie\0" /* 1 refs @ 7165 */
	    "WN210\0" /* 1 refs @ 7174 */
	    "DWL-900AP\0" /* 1 refs @ 7180 */
	    "access\0" /* 1 refs @ 7190 */
	    "point\0" /* 1 refs @ 7197 */
	    "ARM\0" /* 1 refs @ 7203 */
	    "SAM-BA\0" /* 1 refs @ 7207 */
	    "programming\0" /* 1 refs @ 7214 */
	    "port\0" /* 5 refs @ 7226 */
	    "DWL-120\0" /* 3 refs @ 7231 */
	    "AT76C503\0" /* 3 refs @ 7239 */
	    "(Intersil\0" /* 2 refs @ 7248 */
	    "3861\0" /* 1 refs @ 7258 */
	    "Radio)\0" /* 7 refs @ 7263 */
	    "3863\0" /* 1 refs @ 7270 */
	    "(RFMD\0" /* 5 refs @ 7275 */
	    "AT76C505\0" /* 2 refs @ 7281 */
	    "2958\0" /* 3 refs @ 7290 */
	    "AT76C505A\0" /* 1 refs @ 7295 */
	    "AT76C505AS\0" /* 1 refs @ 7305 */
	    "ATC-HA4USB\0" /* 1 refs @ 7316 */
	    "headphone\0" /* 1 refs @ 7327 */
	    "Audio\0" /* 6 refs @ 7337 */
	    "Speaker\0" /* 4 refs @ 7343 */
	    "1200U\0" /* 2 refs @ 7351 */
	    "scanner\0" /* 42 refs @ 7357 */
	    "FRITZ!WLAN\0" /* 1 refs @ 7365 */
	    "N\0" /* 1 refs @ 7376 */
	    "RTL8188CE\0" /* 4 refs @ 7378 */
	    "reader\0" /* 1 refs @ 7388 */
	    "uLinks\0" /* 1 refs @ 7395 */
	    "RS-422/485\0" /* 1 refs @ 7402 */
	    "Mobile\0" /* 5 refs @ 7413 */
	    "WiMax\0" /* 1 refs @ 7420 */
	    "SS\0" /* 1 refs @ 7426 */
	    "F5U002\0" /* 1 refs @ 7429 */
	    "F5D6050\0" /* 1 refs @ 7436 */
	    "F5U103\0" /* 1 refs @ 7444 */
	    "F5U109\0" /* 1 refs @ 7451 */
	    "SCSI\0" /* 1 refs @ 7458 */
	    "Adaptor\0" /* 4 refs @ 7463 */
	    "LAN\0" /* 5 refs @ 7471 */
	    "Converter\0" /* 3 refs @ 7475 */
	    "F5U208\0" /* 1 refs @ 7485 */
	    "VideoBus\0" /* 1 refs @ 7492 */
	    "II\0" /* 7 refs @ 7501 */
	    "F5U237\0" /* 1 refs @ 7504 */
	    "7-Port\0" /* 2 refs @ 7511 */
	    "F5U409\0" /* 1 refs @ 7518 */
	    "RTL8188CUS\0" /* 9 refs @ 7525 */
	    "F5U120-PC\0" /* 1 refs @ 7536 */
	    "F5U258/F5U279\0" /* 1 refs @ 7546 */
	    "host\0" /* 1 refs @ 7560 */
	    "F7D2102\0" /* 1 refs @ 7565 */
	    "F5D5055\0" /* 1 refs @ 7573 */
	    "F5D7050\0" /* 1 refs @ 7581 */
	    "54g\0" /* 6 refs @ 7589 */
	    "F5D7051\0" /* 1 refs @ 7593 */
	    "F5D705A\0" /* 1 refs @ 7601 */
	    "F5D705C\0" /* 1 refs @ 7609 */
	    "F5D705E\0" /* 1 refs @ 7617 */
	    "F5D8053\0" /* 1 refs @ 7625 */
	    "v3\0" /* 2 refs @ 7633 */
	    "F5D8055\0" /* 2 refs @ 7636 */
	    "v2\0" /* 12 refs @ 7644 */
	    "F5D9050\0" /* 1 refs @ 7647 */
	    "ver\0" /* 5 refs @ 7655 */
	    "F5D9050C\0" /* 1 refs @ 7659 */
	    "F6D4050\0" /* 2 refs @ 7668 */
	    "F7D1101\0" /* 1 refs @ 7676 */
	    "CT-USB1HUB\0" /* 1 refs @ 7684 */
	    "BWIFI-USB54AR\0" /* 1 refs @ 7695 */
	    "USB100N\0" /* 1 refs @ 7709 */
	    "FastEthernet\0" /* 1 refs @ 7717 */
	    "USB100LP\0" /* 1 refs @ 7730 */
	    "USB100EL\0" /* 1 refs @ 7739 */
	    "USBE100\0" /* 1 refs @ 7748 */
	    "USB2AR\0" /* 1 refs @ 7756 */
	    "US-101\0" /* 1 refs @ 7763 */
	    "USB2Serial\0" /* 19 refs @ 7770 */
	    "1xRS232\0" /* 3 refs @ 7781 */
	    "US-159\0" /* 1 refs @ 7789 */
	    "US-235\0" /* 1 refs @ 7796 */
	    "US-257\0" /* 1 refs @ 7803 */
	    "2xRS232\0" /* 1 refs @ 7810 */
	    "US-279\0" /* 4 refs @ 7818 */
	    "8xRS232\0" /* 4 refs @ 7825 */
	    "(Port\0" /* 12 refs @ 7833 */
	    "and\0" /* 12 refs @ 7839 */
	    "4)\0" /* 4 refs @ 7843 */
	    "6)\0" /* 2 refs @ 7846 */
	    "7\0" /* 4 refs @ 7849 */
	    "8)\0" /* 2 refs @ 7851 */
	    "US-313\0" /* 1 refs @ 7854 */
	    "2xRS422/485\0" /* 1 refs @ 7861 */
	    "US-320\0" /* 1 refs @ 7873 */
	    "1xRS422/485\0" /* 2 refs @ 7880 */
	    "US-324\0" /* 1 refs @ 7892 */
	    "US-346\0" /* 2 refs @ 7899 */
	    "4xRS422/485\0" /* 2 refs @ 7906 */
	    "US-701\0" /* 2 refs @ 7918 */
	    "4xRS232\0" /* 2 refs @ 7925 */
	    "US-842\0" /* 4 refs @ 7933 */
	    "8xRS422/485\0" /* 4 refs @ 7940 */
	    "BCMFW\0" /* 1 refs @ 7952 */
	    "BCM2033\0" /* 2 refs @ 7958 */
	    "(no\0" /* 15 refs @ 7966 */
	    "firmware)\0" /* 15 refs @ 7970 */
	    "BCM43236\0" /* 1 refs @ 7980 */
	    "BCM43143\0" /* 1 refs @ 7989 */
	    "BCM43242\0" /* 1 refs @ 7998 */
	    "BCM43569\0" /* 1 refs @ 8007 */
	    "HL-1050\0" /* 1 refs @ 8016 */
	    "laser\0" /* 2 refs @ 8024 */
	    "AirPcap\0" /* 1 refs @ 8030 */
	    "Nx\0" /* 1 refs @ 8038 */
	    "CanoScan\0" /* 4 refs @ 8041 */
	    "N656U\0" /* 1 refs @ 8050 */
	    "N1220U\0" /* 1 refs @ 8056 */
	    "N670U\0" /* 1 refs @ 8063 */
	    "N1240U\0" /* 1 refs @ 8069 */
	    "PowerShot\0" /* 8 refs @ 8076 */
	    "S10\0" /* 1 refs @ 8086 */
	    "S20\0" /* 3 refs @ 8090 */
	    "S100\0" /* 2 refs @ 8094 */
	    "G1\0" /* 1 refs @ 8099 */
	    "A20\0" /* 1 refs @ 8102 */
	    "S200\0" /* 1 refs @ 8106 */
	    "EOS\0" /* 1 refs @ 8111 */
	    "300D\0" /* 1 refs @ 8115 */
	    "Rebel\0" /* 1 refs @ 8120 */
	    "SD630\0" /* 1 refs @ 8126 */
	    "QV\0" /* 1 refs @ 8132 */
	    "DigitalCamera\0" /* 1 refs @ 8135 */
	    "BE-300\0" /* 1 refs @ 8149 */
	    "PDA\0" /* 4 refs @ 8156 */
	    "Nameland\0" /* 1 refs @ 8160 */
	    "EZ-USB\0" /* 2 refs @ 8169 */
	    "Netmate\0" /* 1 refs @ 8176 */
	    "Netmate2\0" /* 1 refs @ 8184 */
	    "Chief\0" /* 1 refs @ 8193 */
	    "Bus\0" /* 1 refs @ 8199 */
	    "Protocol\0" /* 2 refs @ 8203 */
	    "Analyzer\0" /* 1 refs @ 8212 */
	    "Andromeda\0" /* 1 refs @ 8221 */
	    "Portable\0" /* 4 refs @ 8231 */
	    "Device\0" /* 16 refs @ 8240 */
	    "My3000\0" /* 2 refs @ 8247 */
	    "keyboard\0" /* 14 refs @ 8254 */
	    "CyBoard\0" /* 1 refs @ 8263 */
	    "My6000\0" /* 1 refs @ 8271 */
	    "KB-8933\0" /* 1 refs @ 8278 */
	    "TwinkleCam\0" /* 1 refs @ 8286 */
	    "Buffalo\0" /* 1 refs @ 8297 */
	    "WBC-35H/L01\0" /* 1 refs @ 8305 */
	    "Throttle\0" /* 1 refs @ 8317 */
	    "Pedals\0" /* 1 refs @ 8326 */
	    "Fighterstick\0" /* 1 refs @ 8333 */
	    "Flight\0" /* 2 refs @ 8346 */
	    "Sim\0" /* 1 refs @ 8353 */
	    "Yoke\0" /* 1 refs @ 8357 */
	    "WUSB54G\0" /* 2 refs @ 8362 */
	    "WUSB54AG\0" /* 1 refs @ 8370 */
	    "Wireless-G\0" /* 2 refs @ 8379 */
	    "WUSB54GP\0" /* 1 refs @ 8390 */
	    "USB200M\0" /* 1 refs @ 8399 */
	    "HU200-TS\0" /* 1 refs @ 8407 */
	    "WUSB54GC\0" /* 3 refs @ 8416 */
	    "WUSB54GR\0" /* 1 refs @ 8425 */
	    "WUSBF54G\0" /* 1 refs @ 8434 */
	    "WUSB200\0" /* 1 refs @ 8443 */
	    "AE1000\0" /* 1 refs @ 8451 */
	    "AM10\0" /* 1 refs @ 8458 */
	    "iPAQ\0" /* 4 refs @ 8463 */
	    "PocketPC\0" /* 2 refs @ 8468 */
	    "A1500\0" /* 1 refs @ 8477 */
	    "W100\0" /* 1 refs @ 8483 */
	    "MultiPort\0" /* 1 refs @ 8488 */
	    "W200\0" /* 1 refs @ 8498 */
	    "Personal\0" /* 1 refs @ 8503 */
	    "Jukebox\0" /* 1 refs @ 8512 */
	    "PJB100\0" /* 1 refs @ 8520 */
	    "HNE-200\0" /* 1 refs @ 8527 */
	    "PS2\0" /* 2 refs @ 8535 */
	    "C54RU\0" /* 2 refs @ 8539 */
	    "RT2573M\0" /* 1 refs @ 8545 */
	    "C11U\0" /* 1 refs @ 8553 */
	    "WL-210\0" /* 1 refs @ 8558 */
	    "Eye\0" /* 2 refs @ 8565 */
	    "Q\0" /* 1 refs @ 8569 */
	    "3x\0" /* 1 refs @ 8571 */
	    "QuickCam\0" /* 11 refs @ 8574 */
	    "AMD\0" /* 1 refs @ 8583 */
	    "SR4\0" /* 1 refs @ 8587 */
	    "lamplight\0" /* 1 refs @ 8591 */
	    "Control\0" /* 2 refs @ 8601 */
	    "Ether\0" /* 1 refs @ 8609 */
	    "USB-T\0" /* 1 refs @ 8615 */
	    "FEther\0" /* 4 refs @ 8621 */
	    "USB-TX\0" /* 1 refs @ 8628 */
	    "WirelessLAN\0" /* 1 refs @ 8635 */
	    "USB-11\0" /* 1 refs @ 8647 */
	    "USB-TXS\0" /* 1 refs @ 8654 */
	    "Stick-11\0" /* 1 refs @ 8662 */
	    "USB2-TX\0" /* 1 refs @ 8671 */
	    "ULUSB-11\0" /* 1 refs @ 8679 */
	    "Key\0" /* 1 refs @ 8688 */
	    "CG-WLUSB2GTST\0" /* 1 refs @ 8692 */
	    "CG-USBRS232R\0" /* 1 refs @ 8706 */
	    "CG-WLUSB2GL\0" /* 1 refs @ 8719 */
	    "CG-WLUSB2GPX\0" /* 1 refs @ 8731 */
	    "CG-WLUSBNM\0" /* 1 refs @ 8744 */
	    "CG-WLUSB300GNM\0" /* 1 refs @ 8755 */
	    "Stick\0" /* 3 refs @ 8770 */
	    "11\0" /* 1 refs @ 8776 */
	    "USB-TXC\0" /* 1 refs @ 8779 */
	    "Nomad\0" /* 3 refs @ 8787 */
	    "MP3\0" /* 4 refs @ 8793 */
	    "player\0" /* 3 refs @ 8797 */
	    "MG\0" /* 1 refs @ 8804 */
	    "Voip\0" /* 1 refs @ 8807 */
	    "Blaster\0" /* 1 refs @ 8812 */
	    "Notebook\0" /* 2 refs @ 8820 */
	    "Pnp\0" /* 1 refs @ 8829 */
	    "Sound\0" /* 2 refs @ 8833 */
	    "Ex1300\0" /* 1 refs @ 8839 */
	    "TG54USB\0" /* 1 refs @ 8846 */
	    "thermometer\0" /* 1 refs @ 8854 */
	    "Keyboard/Hub\0" /* 1 refs @ 8866 */
	    "FM\0" /* 3 refs @ 8879 */
	    "USB-RS232\0" /* 1 refs @ 8882 */
	    "Interface\0" /* 3 refs @ 8892 */
	    "USB2\0" /* 3 refs @ 8902 */
	    "CY4636\0" /* 1 refs @ 8907 */
	    "LP\0" /* 1 refs @ 8914 */
	    "RDK\0" /* 1 refs @ 8917 */
	    "PhotoClip\0" /* 1 refs @ 8921 */
	    "USBMediaReader\0" /* 1 refs @ 8931 */
	    "J-6502\0" /* 1 refs @ 8946 */
	    "speakers\0" /* 1 refs @ 8953 */
	    "USB-FOB/iBUTTON\0" /* 1 refs @ 8962 */
	    "Port\0" /* 6 refs @ 8978 */
	    "Replicator\0" /* 1 refs @ 8983 */
	    "SK-8125\0" /* 1 refs @ 8994 */
	    "Axim\0" /* 2 refs @ 9002 */
	    "X3\0" /* 1 refs @ 9007 */
	    "X30\0" /* 1 refs @ 9010 */
	    "BC02\0" /* 1 refs @ 9014 */
	    "TrueMobile\0" /* 2 refs @ 9019 */
	    "1180\0" /* 1 refs @ 9030 */
	    "350\0" /* 3 refs @ 9035 */
	    "Dell/Novatel\0" /* 1 refs @ 9039 */
	    "HSDPA\0" /* 9 refs @ 9052 */
	    "W5500\0" /* 1 refs @ 9058 */
	    "Earthmate\0" /* 2 refs @ 9064 */
	    "GPS\0" /* 5 refs @ 9074 */
	    "LT-20\0" /* 1 refs @ 9078 */
	    "Rio\0" /* 3 refs @ 9084 */
	    "500\0" /* 1 refs @ 9088 */
	    "WL-200U\0" /* 1 refs @ 9092 */
	    "CHUSB\0" /* 1 refs @ 9100 */
	    "611G\0" /* 1 refs @ 9106 */
	    "WL-240U\0" /* 1 refs @ 9111 */
	    "XH1153\0" /* 1 refs @ 9119 */
	    "C-Net\0" /* 1 refs @ 9126 */
	    "CWD-854\0" /* 1 refs @ 9132 */
	    "rev\0" /* 19 refs @ 9140 */
	    "F\0" /* 2 refs @ 9144 */
	    "RTL8187\0" /* 4 refs @ 9146 */
	    "AccelePort\0" /* 3 refs @ 9154 */
	    "8\0" /* 3 refs @ 9165 */
	    "PS/2\0" /* 2 refs @ 9167 */
	    "Active\0" /* 1 refs @ 9172 */
	    "IOGEAR\0" /* 1 refs @ 9179 */
	    "DVI\0" /* 8 refs @ 9186 */
	    "GUC2020\0" /* 1 refs @ 9190 */
	    "LD220\0" /* 1 refs @ 9198 */
	    "LD190\0" /* 1 refs @ 9204 */
	    "U70\0" /* 1 refs @ 9210 */
	    "Polaris2\0" /* 1 refs @ 9214 */
	    "dock\0" /* 1 refs @ 9223 */
	    "Rextron\0" /* 1 refs @ 9228 */
	    "StarTech\0" /* 1 refs @ 9236 */
	    "CONV-USB2DVI\0" /* 1 refs @ 9245 */
	    "IO-DATA\0" /* 3 refs @ 9258 */
	    "USB-RGB\0" /* 1 refs @ 9266 */
	    "LCD-USB7X\0" /* 1 refs @ 9274 */
	    "LCD-USB10XB-T\0" /* 1 refs @ 9284 */
	    "CMP-USBVGA10\0" /* 1 refs @ 9298 */
	    "WS\0" /* 1 refs @ 9311 */
	    "EasyCAP008\0" /* 1 refs @ 9314 */
	    "FY-DVI2\0" /* 1 refs @ 9325 */
	    "BUFFALO\0" /* 2 refs @ 9333 */
	    "GX-DVI/U2\0" /* 1 refs @ 9341 */
	    "LCD-4300U\0" /* 1 refs @ 9351 */
	    "LCD-8000U\0" /* 1 refs @ 9361 */
	    "HP\0" /* 3 refs @ 9371 */
	    "Docking\0" /* 1 refs @ 9374 */
	    "VideoHome\0" /* 1 refs @ 9382 */
	    "NBdock1920\0" /* 1 refs @ 9392 */
	    "GX-DVI/U2B\0" /* 1 refs @ 9403 */
	    "SUNWEIT\0" /* 1 refs @ 9414 */
	    "Lilliput\0" /* 1 refs @ 9422 */
	    "UM-70\0" /* 1 refs @ 9431 */
	    "LCD-8000UD-DVI\0" /* 1 refs @ 9437 */
	    "LDE-WX015U\0" /* 1 refs @ 9452 */
	    "SANWA\0" /* 1 refs @ 9463 */
	    "SUPPLY\0" /* 1 refs @ 9469 */
	    "500-KC002N\0" /* 1 refs @ 9476 */
	    "MIMO\0" /* 1 refs @ 9487 */
	    "Plugable\0" /* 1 refs @ 9492 */
	    "docking\0" /* 1 refs @ 9501 */
	    "station\0" /* 1 refs @ 9509 */
	    "ThinkVision\0" /* 1 refs @ 9517 */
	    "LT1421\0" /* 1 refs @ 9529 */
	    "Wide\0" /* 1 refs @ 9536 */
	    "AREA\0" /* 1 refs @ 9541 */
	    "SD-U2VDH\0" /* 1 refs @ 9546 */
	    "nanovision\0" /* 1 refs @ 9555 */
	    "MiMo\0" /* 1 refs @ 9566 */
	    "FY-DVI\0" /* 1 refs @ 9571 */
	    "DUB-E100\0" /* 3 refs @ 9578 */
	    "C1\0" /* 3 refs @ 9587 */
	    "DUB-1312\0" /* 1 refs @ 9590 */
	    "E\0" /* 2 refs @ 9599 */
	    "DWA-130\0" /* 3 refs @ 9601 */
	    "C\0" /* 1 refs @ 9609 */
	    "DWA-131\0" /* 3 refs @ 9611 */
	    "B\0" /* 3 refs @ 9619 */
	    "DWA-125\0" /* 1 refs @ 9621 */
	    "D1\0" /* 2 refs @ 9629 */
	    "DWA-121\0" /* 1 refs @ 9632 */
	    "DWL122\0" /* 1 refs @ 9640 */
	    "DWL-G120\0" /* 1 refs @ 9647 */
	    "DWL-G122\0" /* 2 refs @ 9656 */
	    "A2\0" /* 2 refs @ 9665 */
	    "DWL-AG132\0" /* 2 refs @ 9668 */
	    "DWL-G132\0" /* 2 refs @ 9678 */
	    "DWL-AG122\0" /* 2 refs @ 9687 */
	    "AirPlus\0" /* 1 refs @ 9697 */
	    "G\0" /* 1 refs @ 9705 */
	    "DWA-140\0" /* 1 refs @ 9707 */
	    "B3\0" /* 1 refs @ 9715 */
	    "DWA-160\0" /* 3 refs @ 9718 */
	    "B2\0" /* 1 refs @ 9726 */
	    "DWA-127\0" /* 1 refs @ 9729 */
	    "DWA-162\0" /* 1 refs @ 9737 */
	    "DWM-157\0" /* 4 refs @ 9745 */
	    "CD-ROM\0" /* 5 refs @ 9753 */
	    "Mode\0" /* 4 refs @ 9760 */
	    "LTE\0" /* 4 refs @ 9765 */
	    "DWM-222\0" /* 2 refs @ 9769 */
	    "DWR-510\0" /* 2 refs @ 9777 */
	    "A1\0" /* 3 refs @ 9785 */
	    "WUA-2340\0" /* 2 refs @ 9788 */
	    "WUA-1340\0" /* 1 refs @ 9797 */
	    "DWA-111\0" /* 1 refs @ 9806 */
	    "DWA-110\0" /* 1 refs @ 9814 */
	    "KVM-221\0" /* 1 refs @ 9822 */
	    "Storage\0" /* 5 refs @ 9830 */
	    "Vigor550\0" /* 1 refs @ 9838 */
	    "ANT\0" /* 1 refs @ 9847 */
	    "dev\0" /* 1 refs @ 9851 */
	    "board\0" /* 3 refs @ 9855 */
	    "EC168\0" /* 1 refs @ 9861 */
	    "EW-7318\0" /* 1 refs @ 9867 */
	    "MT7610U\0" /* 3 refs @ 9875 */
	    "EW-7618\0" /* 1 refs @ 9883 */
	    "EW-7717\0" /* 1 refs @ 9891 */
	    "EW-7718\0" /* 1 refs @ 9899 */
	    "EW-7722UTn\0" /* 1 refs @ 9907 */
	    "EW-7811UTC\0" /* 2 refs @ 9918 */
	    "ELECOM\0" /* 1 refs @ 9929 */
	    "WDC-433SU2M\0" /* 1 refs @ 9936 */
	    "EW-7811Un\0" /* 1 refs @ 9948 */
	    "V2\0" /* 7 refs @ 9958 */
	    "Panel\0" /* 4 refs @ 9961 */
	    "Diva\0" /* 1 refs @ 9967 */
	    "852\0" /* 1 refs @ 9972 */
	    "monitor\0" /* 1 refs @ 9976 */
	    "ActiveJet\0" /* 1 refs @ 9984 */
	    "K-2024\0" /* 1 refs @ 9994 */
	    "Elan\0" /* 1 refs @ 10001 */
	    "Touchscreen\0" /* 1 refs @ 10006 */
	    "Goldpfeil\0" /* 1 refs @ 10018 */
	    "P-LAN\0" /* 1 refs @ 10028 */
	    "29UO\0" /* 1 refs @ 10034 */
	    "LD-USB/TX\0" /* 4 refs @ 10039 */
	    "LD-USBL/TX\0" /* 1 refs @ 10049 */
	    "WDC-150SU2M\0" /* 1 refs @ 10060 */
	    "WDC-433SU2M2\0" /* 1 refs @ 10072 */
	    "LD-USB20\0" /* 1 refs @ 10085 */
	    "UC-SGT\0" /* 1 refs @ 10094 */
	    "serial\0" /* 38 refs @ 10101 */
	    "UC-SGT0\0" /* 1 refs @ 10108 */
	    "Microlink\0" /* 1 refs @ 10116 */
	    "USB2Ethernet\0" /* 1 refs @ 10126 */
	    "EM2883\0" /* 1 refs @ 10139 */
	    "PSX\0" /* 1 refs @ 10146 */
	    "gun\0" /* 1 refs @ 10150 */
	    "converter\0" /* 7 refs @ 10154 */
	    "1S\0" /* 1 refs @ 10164 */
	    "connector\0" /* 8 refs @ 10167 */
	    "2S\0" /* 1 refs @ 10177 */
	    "1S25\0" /* 1 refs @ 10180 */
	    "E45\0" /* 1 refs @ 10185 */
	    "Centronics\0" /* 1 refs @ 10189 */
	    "1S9\0" /* 1 refs @ 10200 */
	    "2U4S\0" /* 1 refs @ 10204 */
	    "connector/usb\0" /* 1 refs @ 10209 */
	    "Printer\0" /* 2 refs @ 10223 */
	    "ISD\0" /* 2 refs @ 10231 */
	    "Smart\0" /* 3 refs @ 10235 */
	    "for\0" /* 5 refs @ 10241 */
	    "Mac\0" /* 3 refs @ 10245 */
	    "Perfection\0" /* 12 refs @ 10249 */
	    "636U\0" /* 1 refs @ 10260 */
	    "636Photo\0" /* 1 refs @ 10265 */
	    "610\0" /* 1 refs @ 10274 */
	    "1200Photo\0" /* 1 refs @ 10278 */
	    "Expression\0" /* 1 refs @ 10288 */
	    "1600\0" /* 1 refs @ 10299 */
	    "1640SU\0" /* 1 refs @ 10304 */
	    "1240U\0" /* 1 refs @ 10311 */
	    "1240Photo\0" /* 1 refs @ 10317 */
	    "1250U\0" /* 1 refs @ 10327 */
	    "1250Photo\0" /* 1 refs @ 10333 */
	    "1650\0" /* 1 refs @ 10343 */
	    "GT-9700F\0" /* 1 refs @ 10348 */
	    "2400\0" /* 2 refs @ 10357 */
	    "1260\0" /* 1 refs @ 10362 */
	    "1660\0" /* 1 refs @ 10367 */
	    "1670\0" /* 1 refs @ 10372 */
	    "XR21V1410\0" /* 1 refs @ 10377 */
	    "channel\0" /* 3 refs @ 10387 */
	    "UART\0" /* 4 refs @ 10395 */
	    "XR21V1412\0" /* 1 refs @ 10400 */
	    "XR21V1414\0" /* 1 refs @ 10410 */
	    "XTNDAccess\0" /* 1 refs @ 10420 */
	    "IrDA\0" /* 7 refs @ 10431 */
	    "Twist\0" /* 1 refs @ 10436 */
	    "GSM/GPRS\0" /* 2 refs @ 10442 */
	    "Samba\0" /* 1 refs @ 10451 */
	    "55/56\0" /* 1 refs @ 10457 */
	    "WL-430U\0" /* 1 refs @ 10463 */
	    "Connector\0" /* 1 refs @ 10471 */
	    "DVD\0" /* 6 refs @ 10481 */
	    "drive\0" /* 1 refs @ 10485 */
	    "8U232AM\0" /* 1 refs @ 10491 */
	    "FT232RL\0" /* 1 refs @ 10499 */
	    "2232C\0" /* 1 refs @ 10507 */
	    "dual\0" /* 1 refs @ 10513 */
	    "FAST\0" /* 2 refs @ 10518 */
	    "SERIAL\0" /* 2 refs @ 10523 */
	    "ADAPTER\0" /* 2 refs @ 10530 */
	    "2232H\0" /* 1 refs @ 10538 */
	    "quad\0" /* 1 refs @ 10544 */
	    "C232HM\0" /* 1 refs @ 10549 */
	    "Multipurpose\0" /* 1 refs @ 10556 */
	    "FT230X\0" /* 1 refs @ 10569 */
	    "Keyboard/Mouse\0" /* 1 refs @ 10576 */
	    "8U100AX\0" /* 1 refs @ 10591 */
	    "OpenRD\0" /* 1 refs @ 10599 */
	    "JTAGKey\0" /* 2 refs @ 10606 */
	    "FT2232D\0" /* 1 refs @ 10614 */
	    "BeagleBone\0" /* 1 refs @ 10622 */
	    "MaxStream\0" /* 1 refs @ 10633 */
	    "PKG-U\0" /* 1 refs @ 10643 */
	    "KW\0" /* 1 refs @ 10649 */
	    "YS\0" /* 1 refs @ 10652 */
	    "Y6\0" /* 1 refs @ 10655 */
	    "Y8\0" /* 1 refs @ 10658 */
	    "IC\0" /* 1 refs @ 10661 */
	    "DB9\0" /* 1 refs @ 10664 */
	    "RS232\0" /* 6 refs @ 10668 */
	    "Y9\0" /* 1 refs @ 10674 */
	    "Coastal\0" /* 1 refs @ 10677 */
	    "ChipWorks\0" /* 1 refs @ 10685 */
	    "TNC-X\0" /* 1 refs @ 10695 */
	    "CTI\0" /* 2 refs @ 10701 */
	    "485\0" /* 2 refs @ 10705 */
	    "Matrix\0" /* 4 refs @ 10709 */
	    "Orbital\0" /* 4 refs @ 10716 */
	    "MX2/MX3/MX6\0" /* 1 refs @ 10724 */
	    "Series\0" /* 2 refs @ 10736 */
	    "MX4/MX5\0" /* 1 refs @ 10743 */
	    "LCD\0" /* 8 refs @ 10751 */
	    "LK/VK/PK202-24\0" /* 1 refs @ 10755 */
	    "LK/VK204-24\0" /* 1 refs @ 10770 */
	    "Crystalfontz\0" /* 5 refs @ 10782 */
	    "CFA-632\0" /* 1 refs @ 10795 */
	    "CFA-634\0" /* 1 refs @ 10803 */
	    "CFA-633\0" /* 1 refs @ 10811 */
	    "CFA-631\0" /* 1 refs @ 10819 */
	    "CFA-635\0" /* 1 refs @ 10827 */
	    "SEMC\0" /* 1 refs @ 10835 */
	    "DSS-20\0" /* 1 refs @ 10840 */
	    "SyncStation\0" /* 1 refs @ 10847 */
	    "SheevaPlug\0" /* 1 refs @ 10859 */
	    "Mass\0" /* 4 refs @ 10870 */
	    "AH-F401U\0" /* 1 refs @ 10875 */
	    "Air\0" /* 1 refs @ 10884 */
	    "H\0" /* 1 refs @ 10888 */
	    "device\0" /* 18 refs @ 10890 */
	    "Type\0" /* 3 refs @ 10897 */
	    "6\0" /* 3 refs @ 10902 */
	    "Strip\0" /* 1 refs @ 10904 */
	    "FX-5204PS\0" /* 1 refs @ 10910 */
	    "Base\0" /* 1 refs @ 10920 */
	    "Station\0" /* 1 refs @ 10925 */
	    "FX-5251WB\0" /* 1 refs @ 10933 */
	    "Virtual\0" /* 1 refs @ 10943 */
	    "Eth\0" /* 1 refs @ 10951 */
	    "SURFboard\0" /* 1 refs @ 10955 */
	    "SB5100\0" /* 1 refs @ 10965 */
	    "GeneLink\0" /* 1 refs @ 10972 */
	    "Host-Host\0" /* 5 refs @ 10981 */
	    "GL650\0" /* 1 refs @ 10991 */
	    "GL641USB\0" /* 3 refs @ 10997 */
	    "CompactFlash\0" /* 6 refs @ 11006 */
	    "USB-IDE\0" /* 5 refs @ 11019 */
	    "GN-54G\0" /* 1 refs @ 11027 */
	    "GN-BR402W\0" /* 1 refs @ 11034 */
	    "GN-WLBM101\0" /* 1 refs @ 11044 */
	    "GN-WBKG\0" /* 1 refs @ 11055 */
	    "GN-WB01GS\0" /* 1 refs @ 11063 */
	    "GN-WI05GS\0" /* 1 refs @ 11073 */
	    "GN-WB31N\0" /* 1 refs @ 11083 */
	    "GN-WB32L\0" /* 1 refs @ 11092 */
	    "SMCWUSBT-G\0" /* 2 refs @ 11101 */
	    "YP3X00\0" /* 1 refs @ 11112 */
	    "receiver\0" /* 2 refs @ 11119 */
	    "MT7630U\0" /* 1 refs @ 11128 */
	    "MT7650U\0" /* 1 refs @ 11136 */
	    "Forerunner\0" /* 1 refs @ 11144 */
	    "305\0" /* 2 refs @ 11155 */
	    "GoCOM232\0" /* 1 refs @ 11159 */
	    "GWUSB2E\0" /* 1 refs @ 11168 */
	    "GamePad\0" /* 2 refs @ 11176 */
	    "CF-writer\0" /* 1 refs @ 11184 */
	    "Player\0" /* 3 refs @ 11194 */
	    "Huey\0" /* 3 refs @ 11201 */
	    "iMate,\0" /* 1 refs @ 11206 */
	    "ADB\0" /* 1 refs @ 11213 */
	    "PowerMate\0" /* 1 refs @ 11217 */
	    "Assignable\0" /* 1 refs @ 11227 */
	    "Exper\0" /* 1 refs @ 11238 */
	    "mouseCLOCK\0" /* 1 refs @ 11244 */
	    "DA\0" /* 1 refs @ 11255 */
	    "Leader\0" /* 1 refs @ 11258 */
	    "HWGUSB2-54\0" /* 1 refs @ 11265 */
	    "HWGUSB2-54-LB\0" /* 1 refs @ 11276 */
	    "HWGUSB2-54V2-AP\0" /* 1 refs @ 11290 */
	    "HWNU-300\0" /* 1 refs @ 11306 */
	    "HWNUm-300\0" /* 1 refs @ 11315 */
	    "HWGUn-54\0" /* 1 refs @ 11325 */
	    "HWNUP-150\0" /* 1 refs @ 11334 */
	    "FlashGate\0" /* 3 refs @ 11344 */
	    "SmartMedia\0" /* 3 refs @ 11354 */
	    "Crossam2+USB\0" /* 1 refs @ 11365 */
	    "IR\0" /* 1 refs @ 11378 */
	    "commander\0" /* 1 refs @ 11381 */
	    "Visor\0" /* 1 refs @ 11391 */
	    "Treo\0" /* 2 refs @ 11397 */
	    "Keyboard&Mouse\0" /* 1 refs @ 11402 */
	    "WinTV\0" /* 5 refs @ 11417 */
	    "Nova-T\0" /* 3 refs @ 11423 */
	    "HWUN2\0" /* 1 refs @ 11430 */
	    "DVD-CAM\0" /* 1 refs @ 11436 */
	    "DZ-MV100A\0" /* 1 refs @ 11444 */
	    "Camcorder\0" /* 1 refs @ 11454 */
	    "DVDCAM\0" /* 1 refs @ 11464 */
	    "HS\0" /* 1 refs @ 11471 */
	    "MOP-35\0" /* 1 refs @ 11474 */
	    "ParaParaParadise\0" /* 1 refs @ 11481 */
	    "DeskJet\0" /* 11 refs @ 11498 */
	    "895C\0" /* 1 refs @ 11506 */
	    "Scanjet\0" /* 7 refs @ 11511 */
	    "4100C\0" /* 1 refs @ 11519 */
	    "Photosmart\0" /* 2 refs @ 11525 */
	    "880C\0" /* 1 refs @ 11536 */
	    "ScanJet\0" /* 6 refs @ 11541 */
	    "4200C\0" /* 1 refs @ 11549 */
	    "CD-Writer\0" /* 2 refs @ 11555 */
	    "Plus\0" /* 8 refs @ 11565 */
	    "HN210W\0" /* 1 refs @ 11570 */
	    "6200C\0" /* 1 refs @ 11577 */
	    "PhotoSmart\0" /* 2 refs @ 11583 */
	    "815C\0" /* 1 refs @ 11594 */
	    "3300C\0" /* 1 refs @ 11599 */
	    "8200e\0" /* 1 refs @ 11605 */
	    "1220C\0" /* 1 refs @ 11611 */
	    "810C/812C\0" /* 1 refs @ 11617 */
	    "4300C\0" /* 1 refs @ 11627 */
	    "CD-Writer+\0" /* 1 refs @ 11633 */
	    "CD-4e\0" /* 1 refs @ 11644 */
	    "OfficeJet\0" /* 1 refs @ 11650 */
	    "G85xi\0" /* 1 refs @ 11660 */
	    "LaserJet\0" /* 1 refs @ 11666 */
	    "1200\0" /* 8 refs @ 11675 */
	    "5200C\0" /* 1 refs @ 11680 */
	    "830C\0" /* 1 refs @ 11686 */
	    "3400cse\0" /* 1 refs @ 11691 */
	    "885C\0" /* 1 refs @ 11699 */
	    "6300C\0" /* 1 refs @ 11704 */
	    "840c\0" /* 1 refs @ 11710 */
	    "2200C\0" /* 1 refs @ 11715 */
	    "5300C\0" /* 1 refs @ 11721 */
	    "4400C\0" /* 1 refs @ 11727 */
	    "816C\0" /* 1 refs @ 11733 */
	    "Laserjet\0" /* 1 refs @ 11738 */
	    "2300d\0" /* 1 refs @ 11747 */
	    "Deskjet\0" /* 3 refs @ 11753 */
	    "970Cse\0" /* 1 refs @ 11761 */
	    "5400C\0" /* 1 refs @ 11768 */
	    "22xx/Jornada\0" /* 1 refs @ 11774 */
	    "548\0" /* 1 refs @ 11787 */
	    "959C\0" /* 1 refs @ 11791 */
	    "Jornada\0" /* 1 refs @ 11796 */
	    "568\0" /* 1 refs @ 11804 */
	    "930c\0" /* 1 refs @ 11808 */
	    "Inkjet\0" /* 1 refs @ 11813 */
	    "P-2000U\0" /* 1 refs @ 11820 */
	    "Generic\0" /* 1 refs @ 11828 */
	    "RNDIS\0" /* 2 refs @ 11836 */
	    "640c\0" /* 1 refs @ 11842 */
	    "LP2275w\0" /* 1 refs @ 11847 */
	    "LP2475w\0" /* 1 refs @ 11855 */
	    "4670v\0" /* 1 refs @ 11863 */
	    "P1100\0" /* 1 refs @ 11869 */
	    "v125w\0" /* 1 refs @ 11875 */
	    "6127\0" /* 1 refs @ 11881 */
	    "un2430\0" /* 1 refs @ 11886 */
	    "WWAN/GPS\0" /* 1 refs @ 11893 */
	    "Module\0" /* 2 refs @ 11902 */
	    "HN210E\0" /* 1 refs @ 11909 */
	    "C500\0" /* 1 refs @ 11916 */
	    "Android\0" /* 3 refs @ 11921 */
	    "E220\0" /* 1 refs @ 11929 */
	    "U8150\0" /* 1 refs @ 11934 */
	    "EM770W\0" /* 1 refs @ 11940 */
	    "E1750\0" /* 2 refs @ 11947 */
	    "E182\0" /* 1 refs @ 11953 */
	    "E353\0" /* 2 refs @ 11958 */
	    "CD\0" /* 7 refs @ 11963 */
	    "K3765\0" /* 2 refs @ 11966 */
	    "E1820\0" /* 1 refs @ 11972 */
	    "HWD12\0" /* 3 refs @ 11978 */
	    "mode\0" /* 4 refs @ 11984 */
	    "E171\0" /* 2 refs @ 11989 */
	    "E392\0" /* 1 refs @ 11994 */
	    "EC156\0" /* 1 refs @ 11999 */
	    "Installer\0" /* 3 refs @ 12005 */
	    "RAS\0" /* 1 refs @ 12015 */
	    "E353_HiLink\0" /* 1 refs @ 12019 */
	    "E3272\0" /* 1 refs @ 12031 */
	    "E355\0" /* 1 refs @ 12037 */
	    "Softbank\0" /* 2 refs @ 12042 */
	    "203HW\0" /* 1 refs @ 12051 */
	    "PC5740\0" /* 1 refs @ 12057 */
	    "EVDO\0" /* 2 refs @ 12064 */
	    "UM175\0" /* 1 refs @ 12069 */
	    "Go!\0" /* 1 refs @ 12075 */
	    "EdgePort/4\0" /* 1 refs @ 12079 */
	    "Hubport/7\0" /* 1 refs @ 12090 */
	    "Rapidport/4\0" /* 1 refs @ 12100 */
	    "Edgeport/4\0" /* 3 refs @ 12112 */
	    "Telxon\0" /* 1 refs @ 12123 */
	    "Edgeport/2\0" /* 3 refs @ 12130 */
	    "RS422\0" /* 2 refs @ 12141 */
	    "RS422/RS485\0" /* 1 refs @ 12147 */
	    "Hubport/4\0" /* 1 refs @ 12159 */
	    "Hand-built\0" /* 1 refs @ 12169 */
	    "Edgeport/8\0" /* 4 refs @ 12180 */
	    "version\0" /* 1 refs @ 12191 */
	    "of\0" /* 1 refs @ 12199 */
	    "RP/4\0" /* 1 refs @ 12202 */
	    "Edgeport/(4)21\0" /* 1 refs @ 12207 */
	    "(USS720)\0" /* 1 refs @ 12222 */
	    "Edgeport/421\0" /* 1 refs @ 12231 */
	    "Hub+RS232+Parallel\0" /* 1 refs @ 12244 */
	    "Edgeport/21\0" /* 1 refs @ 12263 */
	    "RS232+Parallel\0" /* 1 refs @ 12275 */
	    "1/2\0" /* 2 refs @ 12290 */
	    "(2\0" /* 2 refs @ 12294 */
	    "EP/4s\0" /* 1 refs @ 12297 */
	    "on\0" /* 3 refs @ 12303 */
	    "PCB)\0" /* 1 refs @ 12306 */
	    "DIN\0" /* 2 refs @ 12311 */
	    "Edgeport/16\0" /* 1 refs @ 12315 */
	    "EP/8s\0" /* 1 refs @ 12327 */
	    "PCB))\0" /* 1 refs @ 12333 */
	    "Edgeport\0" /* 1 refs @ 12339 */
	    "Compatible\0" /* 1 refs @ 12348 */
	    "OEM\0" /* 1 refs @ 12359 */
	    "ATAPI\0" /* 1 refs @ 12363 */
	    "IDE\0" /* 3 refs @ 12369 */
	    "ISD110\0" /* 1 refs @ 12373 */
	    "ISD105\0" /* 1 refs @ 12380 */
	    "Harddrive\0" /* 3 refs @ 12387 */
	    "Easy\0" /* 1 refs @ 12397 */
	    "AP310\0" /* 1 refs @ 12402 */
	    "AnyPoint\0" /* 1 refs @ 12408 */
	    "2011B\0" /* 1 refs @ 12417 */
	    "82930\0" /* 1 refs @ 12423 */
	    "test\0" /* 2 refs @ 12429 */
	    "Rate\0" /* 8 refs @ 12434 */
	    "Matching\0" /* 8 refs @ 12439 */
	    "Gale\0" /* 1 refs @ 12448 */
	    "Peak\0" /* 1 refs @ 12453 */
	    "5.4\0" /* 1 refs @ 12458 */
	    "Advanced-N\0" /* 1 refs @ 12462 */
	    "6235\0" /* 1 refs @ 12473 */
	    "Combo\0" /* 2 refs @ 12478 */
	    "Prism2.x\0" /* 1 refs @ 12484 */
	    "ValueCAN\0" /* 1 refs @ 12493 */
	    "NeoVI\0" /* 1 refs @ 12502 */
	    "Blue\0" /* 1 refs @ 12508 */
	    "Multi-plus\0" /* 4 refs @ 12513 */
	    "unit\0" /* 4 refs @ 12524 */
	    "iU-CD2\0" /* 1 refs @ 12529 */
	    "DVR-UEH8\0" /* 1 refs @ 12536 */
	    "USB-SSMRW\0" /* 1 refs @ 12545 */
	    "SD-card\0" /* 2 refs @ 12555 */
	    "USB-SDRW\0" /* 1 refs @ 12563 */
	    "ET/T\0" /* 1 refs @ 12572 */
	    "ET/TX\0" /* 1 refs @ 12577 */
	    "ET/TX-S\0" /* 1 refs @ 12583 */
	    "WN-B11\0" /* 2 refs @ 12591 */
	    "Airport\0" /* 1 refs @ 12598 */
	    "WN-G54/US\0" /* 2 refs @ 12606 */
	    "ETX-US2\0" /* 1 refs @ 12616 */
	    "ETG-US2\0" /* 1 refs @ 12624 */
	    "FT232R\0" /* 1 refs @ 12632 */
	    "WN-GDN/US2\0" /* 1 refs @ 12639 */
	    "WN-G150UM\0" /* 1 refs @ 12650 */
	    "USB-RSAQ1\0" /* 1 refs @ 12660 */
	    "USB-RSAQ5\0" /* 1 refs @ 12670 */
	    "USB2.0-SCSI\0" /* 1 refs @ 12680 */
	    "USB2-SC\0" /* 1 refs @ 12692 */
	    "Zip\0" /* 3 refs @ 12700 */
	    "100\0" /* 3 refs @ 12704 */
	    "CDRW\0" /* 1 refs @ 12708 */
	    "9602\0" /* 1 refs @ 12713 */
	    "iFP-1xx\0" /* 1 refs @ 12718 */
	    "iFP-3xx\0" /* 1 refs @ 12726 */
	    "iFP-5xx\0" /* 1 refs @ 12734 */
	    "PC-60B\0" /* 1 refs @ 12742 */
	    "JD\0" /* 1 refs @ 12749 */
	    "Camera/mp3\0" /* 1 refs @ 12752 */
	    "AirH\"PHONE\0" /* 1 refs @ 12763 */
	    "AH-J3001V/J3002V\0" /* 1 refs @ 12774 */
	    "GR-DX95\0" /* 1 refs @ 12791 */
	    "MP-PRX1\0" /* 1 refs @ 12799 */
	    "MP-XP7250\0" /* 1 refs @ 12807 */
	    "Builtin\0" /* 1 refs @ 12817 */
	    "10BT\0" /* 2 refs @ 12825 */
	    "adapter,\0" /* 2 refs @ 12830 */
	    "the\0" /* 2 refs @ 12839 */
	    "DU-H3E\0" /* 2 refs @ 12843 */
	    "MiniHub\0" /* 1 refs @ 12850 */
	    "4000P\0" /* 1 refs @ 12858 */
	    "KC-180\0" /* 1 refs @ 12864 */
	    "HKS-0200\0" /* 1 refs @ 12871 */
	    "USBDAQ\0" /* 1 refs @ 12880 */
	    "Orbit\0" /* 2 refs @ 12887 */
	    "USB/PS2\0" /* 1 refs @ 12893 */
	    "trackball\0" /* 2 refs @ 12901 */
	    "TurboBall\0" /* 1 refs @ 12911 */
	    "VideoCAM\0" /* 1 refs @ 12921 */
	    "VGA\0" /* 1 refs @ 12930 */
	    "USA-28\0" /* 2 refs @ 12934 */
	    "USA-28X\0" /* 1 refs @ 12941 */
	    "USA-19\0" /* 2 refs @ 12949 */
	    "USA-18\0" /* 2 refs @ 12956 */
	    "USA-18X\0" /* 2 refs @ 12963 */
	    "USA-19W\0" /* 2 refs @ 12971 */
	    "USA-49W\0" /* 2 refs @ 12979 */
	    "USA-19QI\0" /* 2 refs @ 12987 */
	    "USA-19Q\0" /* 2 refs @ 12996 */
	    "USA-28X/XB\0" /* 1 refs @ 13004 */
	    "USA-28XB\0" /* 2 refs @ 13015 */
	    "USA-28XA\0" /* 1 refs @ 13024 */
	    "USA-18XA\0" /* 2 refs @ 13033 */
	    "USA-19QW\0" /* 2 refs @ 13042 */
	    "USA-19H\0" /* 1 refs @ 13051 */
	    "UIA-10\0" /* 1 refs @ 13059 */
	    "remote\0" /* 2 refs @ 13066 */
	    "control\0" /* 2 refs @ 13073 */
	    "UIA-11\0" /* 1 refs @ 13081 */
	    "KNU101TX\0" /* 1 refs @ 13088 */
	    "DT\0" /* 5 refs @ 13097 */
	    "102\0" /* 1 refs @ 13100 */
	    "G2\0" /* 3 refs @ 13104 */
	    "101\0" /* 2 refs @ 13107 */
	    "10\0" /* 1 refs @ 13111 */
	    "KingSun/DonShine\0" /* 1 refs @ 13114 */
	    "Science\0" /* 6 refs @ 13131 */
	    "DC220\0" /* 1 refs @ 13139 */
	    "DC260\0" /* 1 refs @ 13145 */
	    "DC265\0" /* 1 refs @ 13151 */
	    "DC290\0" /* 1 refs @ 13157 */
	    "DC240\0" /* 1 refs @ 13163 */
	    "DC280\0" /* 1 refs @ 13169 */
	    "EasyShare\0" /* 1 refs @ 13175 */
	    "DX4900\0" /* 1 refs @ 13185 */
	    "Color\0" /* 1 refs @ 13192 */
	    "Niche\0" /* 1 refs @ 13198 */
	    "Genius\0" /* 1 refs @ 13204 */
	    "NetScroll\0" /* 1 refs @ 13211 */
	    "MaxFire\0" /* 1 refs @ 13221 */
	    "G-07\0" /* 1 refs @ 13229 */
	    "gamepad\0" /* 3 refs @ 13234 */
	    "2000\0" /* 3 refs @ 13242 */
	    "joystick\0" /* 2 refs @ 13247 */
	    "ColorPage\0" /* 1 refs @ 13256 */
	    "Vivid-Pro\0" /* 1 refs @ 13266 */
	    "AH-K3001V\0" /* 1 refs @ 13276 */
	    "PocketDrive\0" /* 1 refs @ 13286 */
	    "Hard\0" /* 1 refs @ 13298 */
	    "Disk\0" /* 4 refs @ 13303 */
	    "R/W\0" /* 1 refs @ 13308 */
	    "ThinkPad\0" /* 1 refs @ 13312 */
	    "Compact\0" /* 1 refs @ 13321 */
	    "TrackPoint\0" /* 1 refs @ 13329 */
	    "jumpSHOT\0" /* 1 refs @ 13340 */
	    "2662W-AR\0" /* 1 refs @ 13349 */
	    "Multi-Card\0" /* 1 refs @ 13358 */
	    "Optra\0" /* 1 refs @ 13369 */
	    "S\0" /* 3 refs @ 13375 */
	    "2450\0" /* 1 refs @ 13377 */
	    "MSM\0" /* 6 refs @ 13382 */
	    "phone\0" /* 1 refs @ 13386 */
	    "DOCOMO\0" /* 4 refs @ 13392 */
	    "L-05A\0" /* 2 refs @ 13399 */
	    "L-02C\0" /* 2 refs @ 13405 */
	    "Camedia\0" /* 1 refs @ 13411 */
	    "MAUSB-2\0" /* 1 refs @ 13419 */
	    "USB10TX\0" /* 2 refs @ 13427 */
	    "HG20F9\0" /* 1 refs @ 13435 */
	    "USB10T\0" /* 1 refs @ 13442 */
	    "USB100TX\0" /* 1 refs @ 13449 */
	    "USB100H1\0" /* 1 refs @ 13458 */
	    "Ethernet/HPNA\0" /* 1 refs @ 13467 */
	    "USB10TA\0" /* 1 refs @ 13481 */
	    "WUSB11\0" /* 3 refs @ 13489 */
	    "2.5)\0" /* 1 refs @ 13496 */
	    "WUSB12\0" /* 1 refs @ 13501 */
	    "v1.1\0" /* 1 refs @ 13508 */
	    "Everywhere\0" /* 1 refs @ 13513 */
	    "NWU11B\0" /* 1 refs @ 13524 */
	    "WUSB11-V28\0" /* 1 refs @ 13531 */
	    "USB1000\0" /* 1 refs @ 13542 */
	    "WUSB100\0" /* 1 refs @ 13550 */
	    "WUSB600N\0" /* 2 refs @ 13558 */
	    "1.1\0" /* 1 refs @ 13567 */
	    "root\0" /* 3 refs @ 13571 */
	    "debug\0" /* 1 refs @ 13576 */
	    "LDR-H443SU2\0" /* 1 refs @ 13582 */
	    "LDR-H443U2\0" /* 1 refs @ 13594 */
	    "LAN-GTJ/U2\0" /* 1 refs @ 13605 */
	    "LAN-TX\0" /* 1 refs @ 13616 */
	    "LAN-W300N/U2\0" /* 1 refs @ 13623 */
	    "RT3020\0" /* 1 refs @ 13636 */
	    "LAN-W300N/U2S\0" /* 1 refs @ 13643 */
	    "LAN-W450ANU2E\0" /* 1 refs @ 13657 */
	    "LAN-W300AN/U2\0" /* 1 refs @ 13671 */
	    "M2452\0" /* 1 refs @ 13685 */
	    "M4848\0" /* 1 refs @ 13691 */
	    "PageScan\0" /* 1 refs @ 13697 */
	    "Web\0" /* 1 refs @ 13706 */
	    "Express\0" /* 5 refs @ 13710 */
	    "3000\0" /* 2 refs @ 13718 */
	    "4000\0" /* 1 refs @ 13723 */
	    "Messenger\0" /* 1 refs @ 13728 */
	    "N43\0" /* 1 refs @ 13738 */
	    "N48\0" /* 1 refs @ 13742 */
	    "M-BA47\0" /* 1 refs @ 13746 */
	    "WingMan\0" /* 5 refs @ 13753 */
	    "Gaming\0" /* 1 refs @ 13761 */
	    "BD58\0" /* 1 refs @ 13768 */
	    "USB-PS/2\0" /* 2 refs @ 13773 */
	    "M-UV55a\0" /* 1 refs @ 13782 */
	    "iFeel\0" /* 1 refs @ 13790 */
	    "B100\0" /* 2 refs @ 13796 */
	    "Extreme\0" /* 1 refs @ 13801 */
	    "RumblePad\0" /* 1 refs @ 13809 */
	    "Force\0" /* 2 refs @ 13819 */
	    "Formula\0" /* 1 refs @ 13825 */
	    "GP\0" /* 1 refs @ 13833 */
	    "(GT-Force)\0" /* 1 refs @ 13836 */
	    "Trackball\0" /* 2 refs @ 13847 */
	    "TrackMan\0" /* 1 refs @ 13857 */
	    "Wheel\0" /* 2 refs @ 13866 */
	    "Marble\0" /* 1 refs @ 13872 */
	    "Cordless\0" /* 4 refs @ 13879 */
	    "Desktop\0" /* 2 refs @ 13888 */
	    "optical\0" /* 1 refs @ 13896 */
	    "C-BT44\0" /* 1 refs @ 13904 */
	    "Receiver\0" /* 3 refs @ 13911 */
	    "Gamepad\0" /* 3 refs @ 13920 */
	    "F310\0" /* 1 refs @ 13928 */
	    "Dual\0" /* 2 refs @ 13933 */
	    "WM66\0" /* 1 refs @ 13938 */
	    "Emobile\0" /* 2 refs @ 13943 */
	    "D21LC\0" /* 2 refs @ 13951 */
	    "only\0" /* 2 refs @ 13957 */
	    "XSStick\0" /* 3 refs @ 13962 */
	    "W14\0" /* 1 refs @ 13970 */
	    "P14\0" /* 2 refs @ 13974 */
	    "IIJmobile\0" /* 2 refs @ 13978 */
	    "510FU\0" /* 2 refs @ 13988 */
	    "-\0" /* 6 refs @ 13994 */
	    "Windows\0" /* 2 refs @ 13996 */
	    "driver\0" /* 1 refs @ 14004 */
	    "USS-720\0" /* 1 refs @ 14011 */
	    "evaluation\0" /* 1 refs @ 14019 */
	    "kit\0" /* 1 refs @ 14030 */
	    "EasyDisc\0" /* 1 refs @ 14034 */
	    "Cyborg\0" /* 2 refs @ 14043 */
	    "R.A.T.\0" /* 1 refs @ 14050 */
	    "DU-H3SP\0" /* 1 refs @ 14057 */
	    "BAY\0" /* 1 refs @ 14065 */
	    "USB-232\0" /* 2 refs @ 14069 */
	    "ML-4500\0" /* 1 refs @ 14077 */
	    "9\0" /* 1 refs @ 14085 */
	    "5131\0" /* 1 refs @ 14087 */
	    "DCF77\0" /* 1 refs @ 14092 */
	    "Clock\0" /* 1 refs @ 14098 */
	    "MiniPlayer\0" /* 1 refs @ 14104 */
	    "M6\0" /* 1 refs @ 14115 */
	    "(SL)\0" /* 1 refs @ 14118 */
	    "LUA-TX\0" /* 2 refs @ 14123 */
	    "LUA2-TX\0" /* 1 refs @ 14130 */
	    "LUA-KTX\0" /* 1 refs @ 14138 */
	    "WLI-USB-S11\0" /* 1 refs @ 14146 */
	    "MCR-SM2\0" /* 1 refs @ 14158 */
	    "Reader/Writer\0" /* 4 refs @ 14166 */
	    "Bridge:\0" /* 1 refs @ 14180 */
	    "DUB-PxxG\0" /* 1 refs @ 14188 */
	    "WLI-USB-KS11G\0" /* 1 refs @ 14197 */
	    "USB-wlan\0" /* 1 refs @ 14211 */
	    "LUA-U2-KTX\0" /* 1 refs @ 14220 */
	    "WLI-USB-KB11\0" /* 1 refs @ 14231 */
	    "WLI-U2-KG54-YB\0" /* 1 refs @ 14244 */
	    "WLI-U2-KG54\0" /* 1 refs @ 14259 */
	    "WLI-U2-KG54-AI\0" /* 1 refs @ 14271 */
	    "LUA-U2-GT\0" /* 1 refs @ 14286 */
	    "Wi-Fi\0" /* 1 refs @ 14296 */
	    "RemoteStation\0" /* 1 refs @ 14302 */
	    "PC-OP-RS1\0" /* 1 refs @ 14316 */
	    "WLI-U2-SG54HP\0" /* 1 refs @ 14326 */
	    "WLI-U2-G54HP\0" /* 1 refs @ 14340 */
	    "WLI-U2-KG54L\0" /* 1 refs @ 14353 */
	    "WLI-UC-G300N\0" /* 1 refs @ 14366 */
	    "WLI-U2-SG54HG\0" /* 1 refs @ 14379 */
	    "WLI-UC-AG300N\0" /* 1 refs @ 14393 */
	    "WLI-UC-G\0" /* 1 refs @ 14407 */
	    "WLI-UC-GNHP\0" /* 1 refs @ 14416 */
	    "WLI-UC-GN\0" /* 1 refs @ 14428 */
	    "WLI-UC-G301N\0" /* 1 refs @ 14438 */
	    "UWA-BR100\0" /* 1 refs @ 14451 */
	    "WLI-UC-GNM\0" /* 1 refs @ 14461 */
	    "WLI-UC-GNM2T\0" /* 1 refs @ 14472 */
	    "WI-U2-300D\0" /* 1 refs @ 14485 */
	    "MW150US\0" /* 1 refs @ 14496 */
	    "V620\0" /* 1 refs @ 14504 */
	    "Ricochet\0" /* 1 refs @ 14509 */
	    "GS\0" /* 1 refs @ 14518 */
	    "SYSTEMS\0" /* 2 refs @ 14521 */
	    "PROTECTIONCENTER\0" /* 2 refs @ 14529 */
	    "MSI\0" /* 2 refs @ 14546 */
	    "MegaSky\0" /* 2 refs @ 14550 */
	    "MS-6861\0" /* 1 refs @ 14558 */
	    "MS-6865\0" /* 1 refs @ 14566 */
	    "MS-6869\0" /* 1 refs @ 14574 */
	    "PICkit(TM)\0" /* 1 refs @ 14582 */
	    "FLASH\0" /* 1 refs @ 14593 */
	    "Starter\0" /* 1 refs @ 14599 */
	    "Kit\0" /* 2 refs @ 14607 */
	    "PICkit\0" /* 2 refs @ 14611 */
	    "Microcontroller\0" /* 2 refs @ 14618 */
	    "Programmer\0" /* 2 refs @ 14634 */
	    "I2C/UART\0" /* 1 refs @ 14645 */
	    "YUREX\0" /* 1 refs @ 14654 */
	    "SP128AR\0" /* 1 refs @ 14660 */
	    "EtherFast\0" /* 1 refs @ 14668 */
	    "SideWinder\0" /* 1 refs @ 14678 */
	    "Precision\0" /* 2 refs @ 14689 */
	    "IntelliMouse\0" /* 1 refs @ 14699 */
	    "Natural\0" /* 1 refs @ 14712 */
	    "Elite\0" /* 1 refs @ 14720 */
	    "80\0" /* 1 refs @ 14726 */
	    "Sidewinder\0" /* 1 refs @ 14729 */
	    "Racing\0" /* 1 refs @ 14740 */
	    "Internet\0" /* 3 refs @ 14747 */
	    "Explorer\0" /* 1 refs @ 14756 */
	    "IntelliEye\0" /* 1 refs @ 14765 */
	    "MN510\0" /* 1 refs @ 14776 */
	    "NIC\0" /* 2 refs @ 14782 */
	    "Laser\0" /* 1 refs @ 14786 */
	    "6000\0" /* 3 refs @ 14792 */
	    "Xbox\0" /* 7 refs @ 14797 */
	    "Memory\0" /* 4 refs @ 14802 */
	    "Unit\0" /* 1 refs @ 14809 */
	    "Movie\0" /* 1 refs @ 14814 */
	    "Playback\0" /* 1 refs @ 14820 */
	    "(1.0)\0" /* 1 refs @ 14829 */
	    "(1.2)\0" /* 1 refs @ 14835 */
	    "360\0" /* 2 refs @ 14841 */
	    "2.4GHz\0" /* 5 refs @ 14845 */
	    "Transceiver\0" /* 6 refs @ 14852 */
	    "V1.0\0" /* 1 refs @ 14864 */
	    "V2.0\0" /* 1 refs @ 14869 */
	    "V7.0\0" /* 1 refs @ 14874 */
	    "V8.0\0" /* 1 refs @ 14879 */
	    "V9.0\0" /* 1 refs @ 14884 */
	    "Comfort\0" /* 2 refs @ 14889 */
	    "USB-SCSI-DB25\0" /* 1 refs @ 14897 */
	    "USB-SCSI-HD50\0" /* 1 refs @ 14911 */
	    "CameraMate\0" /* 2 refs @ 14925 */
	    "Phantom\0" /* 4 refs @ 14936 */
	    "336CX\0" /* 3 refs @ 14944 */
	    "C3\0" /* 3 refs @ 14950 */
	    "ScanMaker\0" /* 5 refs @ 14953 */
	    "X6\0" /* 1 refs @ 14963 */
	    "X6U\0" /* 1 refs @ 14966 */
	    "C6\0" /* 1 refs @ 14970 */
	    "V6USL\0" /* 2 refs @ 14973 */
	    "V6UL\0" /* 1 refs @ 14979 */
	    "Midisport\0" /* 2 refs @ 14984 */
	    "2x2\0" /* 1 refs @ 14994 */
	    "2x4\0" /* 1 refs @ 14998 */
	    "Wallet\0" /* 1 refs @ 15002 */
	    "Dimage\0" /* 7 refs @ 15009 */
	    "2300\0" /* 1 refs @ 15016 */
	    "S304\0" /* 1 refs @ 15021 */
	    "7i\0" /* 1 refs @ 15026 */
	    "5400\0" /* 1 refs @ 15029 */
	    "Xt\0" /* 1 refs @ 15034 */
	    "MetaGeek\0" /* 1 refs @ 15037 */
	    "Wi-Spy\0" /* 1 refs @ 15046 */
	    "2.4x\0" /* 1 refs @ 15053 */
	    "Telldus\0" /* 2 refs @ 15058 */
	    "Tellstick\0" /* 2 refs @ 15066 */
	    "Duo\0" /* 1 refs @ 15076 */
	    "CD-R/RW\0" /* 2 refs @ 15080 */
	    "Quick\0" /* 1 refs @ 15088 */
	    "Scroll\0" /* 1 refs @ 15094 */
	    "dongle\0" /* 2 refs @ 15101 */
	    "FDD\0" /* 1 refs @ 15108 */
	    "EasiDock\0" /* 1 refs @ 15112 */
	    "MCS7703\0" /* 1 refs @ 15121 */
	    "MCS7720\0" /* 1 refs @ 15129 */
	    "MCS7730\0" /* 1 refs @ 15137 */
	    "MCS7780\0" /* 1 refs @ 15145 */
	    "MCS7781\0" /* 1 refs @ 15153 */
	    "MCS7784\0" /* 1 refs @ 15161 */
	    "Slow\0" /* 1 refs @ 15169 */
	    "MCS7810\0" /* 1 refs @ 15174 */
	    "MCS7820\0" /* 1 refs @ 15182 */
	    "MCS7830\0" /* 1 refs @ 15190 */
	    "MCS7832\0" /* 1 refs @ 15198 */
	    "MCS7840\0" /* 1 refs @ 15206 */
	    "MC141555\0" /* 1 refs @ 15214 */
	    "SB4100\0" /* 1 refs @ 15223 */
	    "T720c\0" /* 1 refs @ 15230 */
	    "A920\0" /* 1 refs @ 15236 */
	    "USBLAN\0" /* 2 refs @ 15241 */
	    "(A780,\0" /* 1 refs @ 15248 */
	    "E680,\0" /* 1 refs @ 15255 */
	    "...)\0" /* 2 refs @ 15261 */
	    "(A910,\0" /* 1 refs @ 15266 */
	    "A1200,\0" /* 1 refs @ 15273 */
	    "Rokr\0" /* 2 refs @ 15280 */
	    "E2,\0" /* 1 refs @ 15285 */
	    "E6,\0" /* 1 refs @ 15289 */
	    "DiskOnKey\0" /* 3 refs @ 15293 */
	    "MT5634ZBA-USB\0" /* 1 refs @ 15303 */
	    "CU\0" /* 3 refs @ 15317 */
	    "UB\0" /* 2 refs @ 15320 */
	    "BearPaw\0" /* 4 refs @ 15323 */
	    "1200F\0" /* 1 refs @ 15331 */
	    "1200TA\0" /* 1 refs @ 15337 */
	    "MDC-800\0" /* 1 refs @ 15344 */
	    "digital\0" /* 4 refs @ 15352 */
	    "DV2000\0" /* 1 refs @ 15360 */
	    "GPIB-USB-A\0" /* 1 refs @ 15367 */
	    "WL300NU-G\0" /* 1 refs @ 15378 */
	    "Picty760\0" /* 1 refs @ 15388 */
	    "Picty900\0" /* 1 refs @ 15397 */
	    "Picty920\0" /* 1 refs @ 15406 */
	    "Picty800\0" /* 1 refs @ 15415 */
	    "6-in-1\0" /* 2 refs @ 15424 */
	    "Multi-format\0" /* 1 refs @ 15431 */
	    "Turbo-Connect\0" /* 1 refs @ 15444 */
	    "Clik!\0" /* 1 refs @ 15458 */
	    "40\0" /* 1 refs @ 15464 */
	    "Ethernet/RNDIS\0" /* 1 refs @ 15467 */
	    "gadget\0" /* 1 refs @ 15482 */
	    "pxa210/25x/26x\0" /* 1 refs @ 15489 */
	    "WG111v3\0" /* 1 refs @ 15504 */
	    "WG111U\0" /* 2 refs @ 15512 */
	    "WG111v2\0" /* 1 refs @ 15519 */
	    "PL\0" /* 1 refs @ 15527 */
	    "WN111V2\0" /* 1 refs @ 15530 */
	    "WNDA3100\0" /* 1 refs @ 15538 */
	    "WNDA3200\0" /* 1 refs @ 15547 */
	    "WNA1100\0" /* 1 refs @ 15556 */
	    "WNA1000\0" /* 1 refs @ 15564 */
	    "WNA1000M\0" /* 1 refs @ 15572 */
	    "MA101\0" /* 2 refs @ 15581 */
	    "Rev\0" /* 1 refs @ 15587 */
	    "WG111T\0" /* 2 refs @ 15591 */
	    "WPN111\0" /* 2 refs @ 15598 */
	    "RT-WJ02\0" /* 1 refs @ 15605 */
	    "UX312NC\0" /* 1 refs @ 15613 */
	    "Willcom\0" /* 1 refs @ 15621 */
	    "WS002IN\0" /* 1 refs @ 15629 */
	    "(DD)\0" /* 1 refs @ 15637 */
	    "E990\0" /* 1 refs @ 15642 */
	    "E880\0" /* 1 refs @ 15647 */
	    "E885\0" /* 1 refs @ 15652 */
	    "BCM2045A\0" /* 1 refs @ 15657 */
	    "Wii\0" /* 2 refs @ 15666 */
	    "Remote\0" /* 2 refs @ 15670 */
	    "RVL-CNT-01\0" /* 1 refs @ 15677 */
	    "(BT-HID)\0" /* 2 refs @ 15688 */
	    "RVL-CNT-01-TR\0" /* 1 refs @ 15697 */
	    "Phone\0" /* 4 refs @ 15711 */
	    "NV-902W\0" /* 1 refs @ 15717 */
	    "NovAtel\0" /* 1 refs @ 15725 */
	    "FlexPack\0" /* 1 refs @ 15733 */
	    "ExpressCard\0" /* 1 refs @ 15742 */
	    "V740\0" /* 1 refs @ 15754 */
	    "S720\0" /* 1 refs @ 15759 */
	    "U740\0" /* 2 refs @ 15764 */
	    "U870\0" /* 1 refs @ 15769 */
	    "XU870\0" /* 1 refs @ 15774 */
	    "X950D\0" /* 1 refs @ 15780 */
	    "ES620\0" /* 1 refs @ 15786 */
	    "U720\0" /* 1 refs @ 15792 */
	    "Expedite\0" /* 1 refs @ 15797 */
	    "EU850D/EU860D/EU870D\0" /* 1 refs @ 15806 */
	    "U727\0" /* 1 refs @ 15827 */
	    "HSUPA\0" /* 7 refs @ 15832 */
	    "Driver\0" /* 3 refs @ 15838 */
	    "U760\0" /* 1 refs @ 15845 */
	    "Windows/Mac\0" /* 1 refs @ 15850 */
	    "760USB\0" /* 1 refs @ 15862 */
	    "C-1\0" /* 1 refs @ 15869 */
	    "C-700\0" /* 1 refs @ 15873 */
	    "Ultra\0" /* 1 refs @ 15879 */
	    "OV511\0" /* 1 refs @ 15885 */
	    "OV511+\0" /* 1 refs @ 15891 */
	    "PLAYSTATION(R)\0" /* 1 refs @ 15898 */
	    "OnePlus\0" /* 1 refs @ 15913 */
	    "5T\0" /* 1 refs @ 15921 */
	    "disk\0" /* 2 refs @ 15924 */
	    "MDCFE-B\0" /* 1 refs @ 15929 */
	    "CF\0" /* 2 refs @ 15937 */
	    "Stick+CF\0" /* 1 refs @ 15940 */
	    "Datafab-based\0" /* 2 refs @ 15949 */
	    "PNY/Datafab\0" /* 1 refs @ 15963 */
	    "CF+SM\0" /* 2 refs @ 15975 */
	    "Simple\0" /* 1 refs @ 15981 */
	    "Tech/Datafab\0" /* 1 refs @ 15988 */
	    "+\0" /* 1 refs @ 16001 */
	    "SM\0" /* 1 refs @ 16003 */
	    "(LC1)\0" /* 1 refs @ 16006 */
	    "FlashLink\0" /* 1 refs @ 16012 */
	    "UCF-100\0" /* 1 refs @ 16022 */
	    "Datafab\0" /* 1 refs @ 16030 */
	    "MD1-II\0" /* 1 refs @ 16038 */
	    "PC-Card\0" /* 1 refs @ 16045 */
	    "8In2\0" /* 1 refs @ 16053 */
	    "Vodafone\0" /* 1 refs @ 16058 */
	    "Connect\0" /* 6 refs @ 16067 */
	    "datacard\0" /* 3 refs @ 16075 */
	    "GlobeTrotter\0" /* 7 refs @ 16084 */
	    "Fusion\0" /* 3 refs @ 16097 */
	    "Quad\0" /* 4 refs @ 16104 */
	    "UMTS/GPRS\0" /* 1 refs @ 16109 */
	    "3D\0" /* 2 refs @ 16119 */
	    "GlobeSurfer\0" /* 2 refs @ 16122 */
	    "iCON\0" /* 7 refs @ 16134 */
	    "7.2\0" /* 1 refs @ 16139 */
	    "225\0" /* 1 refs @ 16143 */
	    "GE40x\0" /* 4 refs @ 16147 */
	    "401\0" /* 1 refs @ 16153 */
	    "GTM\0" /* 1 refs @ 16157 */
	    "382\0" /* 1 refs @ 16161 */
	    "Globetrotter\0" /* 1 refs @ 16165 */
	    "EDGE\0" /* 1 refs @ 16178 */
	    "HSxPA\0" /* 1 refs @ 16183 */
	    "321\0" /* 1 refs @ 16189 */
	    "322\0" /* 1 refs @ 16193 */
	    "505\0" /* 1 refs @ 16197 */
	    "model\0" /* 3 refs @ 16201 */
	    "01\0" /* 2 refs @ 16207 */
	    "WiFi\0" /* 1 refs @ 16210 */
	    "interface\0" /* 6 refs @ 16215 */
	    "01+\0" /* 1 refs @ 16225 */
	    "state\0" /* 1 refs @ 16229 */
	    "128M\0" /* 1 refs @ 16235 */
	    "m500\0" /* 1 refs @ 16240 */
	    "m505\0" /* 1 refs @ 16245 */
	    "m515\0" /* 1 refs @ 16250 */
	    "i705\0" /* 1 refs @ 16255 */
	    "Tungsten\0" /* 2 refs @ 16260 */
	    "Z\0" /* 1 refs @ 16269 */
	    "m125\0" /* 1 refs @ 16271 */
	    "m130\0" /* 1 refs @ 16276 */
	    "T\0" /* 1 refs @ 16281 */
	    "Zire\0" /* 2 refs @ 16283 */
	    "31\0" /* 1 refs @ 16288 */
	    "LS-120\0" /* 1 refs @ 16291 */
	    "CD-R\0" /* 2 refs @ 16298 */
	    "KXL-RW32AN\0" /* 1 refs @ 16303 */
	    "KXL-CB20AN\0" /* 1 refs @ 16314 */
	    "DVD-ROM\0" /* 1 refs @ 16325 */
	    "MultiMediaCard\0" /* 2 refs @ 16333 */
	    "Lumix\0" /* 1 refs @ 16348 */
	    "DMC-FS45\0" /* 1 refs @ 16354 */
	    "TY-TP50P6-S\0" /* 1 refs @ 16363 */
	    "50in\0" /* 1 refs @ 16375 */
	    "4Pi\0" /* 1 refs @ 16380 */
	    "reprap\0" /* 1 refs @ 16384 */
	    "candleLight\0" /* 2 refs @ 16391 */
	    "CAN\0" /* 2 refs @ 16403 */
	    "interfaces\0" /* 2 refs @ 16407 */
	    "OneRNG\0" /* 1 refs @ 16418 */
	    "Random\0" /* 1 refs @ 16425 */
	    "Number\0" /* 1 refs @ 16432 */
	    "Generator\0" /* 1 refs @ 16439 */
	    "Home\0" /* 1 refs @ 16449 */
	    "GWU513\0" /* 1 refs @ 16454 */
	    "DSS\0" /* 3 refs @ 16461 */
	    "XXX\0" /* 2 refs @ 16465 */
	    "SA235\0" /* 1 refs @ 16469 */
	    "PCA645VC\0" /* 1 refs @ 16475 */
	    "PCA646VC\0" /* 1 refs @ 16484 */
	    "PCVC675K\0" /* 1 refs @ 16493 */
	    "Vesta\0" /* 3 refs @ 16502 */
	    "PCVC680K\0" /* 1 refs @ 16508 */
	    "PCVC690K\0" /* 1 refs @ 16517 */
	    "Scan\0" /* 2 refs @ 16526 */
	    "PCVC730K\0" /* 1 refs @ 16531 */
	    "ToUCam\0" /* 3 refs @ 16540 */
	    "Fun\0" /* 1 refs @ 16547 */
	    "PCVC740K\0" /* 1 refs @ 16551 */
	    "PCVC750K\0" /* 1 refs @ 16560 */
	    "150\0" /* 2 refs @ 16569 */
	    "CPWUA054\0" /* 1 refs @ 16573 */
	    "SNU5600\0" /* 1 refs @ 16582 */
	    "SNU5630NS/05\0" /* 1 refs @ 16590 */
	    "DIVA\0" /* 1 refs @ 16603 */
	    "mp3\0" /* 1 refs @ 16608 */
	    "NFC\0" /* 1 refs @ 16612 */
	    "PN533\0" /* 1 refs @ 16616 */
	    "Xkeys\0" /* 2 refs @ 16622 */
	    "Programmable\0" /* 2 refs @ 16628 */
	    "(58\0" /* 1 refs @ 16641 */
	    "Keys)\0" /* 1 refs @ 16645 */
	    "CRW-600\0" /* 1 refs @ 16651 */
	    "PCTV\0" /* 4 refs @ 16659 */
	    "800e\0" /* 1 refs @ 16664 */
	    "72e\0" /* 1 refs @ 16669 */
	    "73e\0" /* 1 refs @ 16673 */
	    "Raspberry\0" /* 1 refs @ 16677 */
	    "Pi\0" /* 1 refs @ 16687 */
	    "GW-US11H\0" /* 1 refs @ 16690 */
	    "GW-US11S\0" /* 1 refs @ 16699 */
	    "GW-USFang300\0" /* 1 refs @ 16708 */
	    "GW-US54GXS\0" /* 1 refs @ 16721 */
	    "GW-US300\0" /* 1 refs @ 16732 */
	    "GW-US54HP\0" /* 1 refs @ 16741 */
	    "GW-US300MiniS\0" /* 1 refs @ 16751 */
	    "GW-USNano\0" /* 1 refs @ 16765 */
	    "GW-USMicro300\0" /* 1 refs @ 16775 */
	    "GW-USNano2\0" /* 1 refs @ 16789 */
	    "GW-USEco300\0" /* 1 refs @ 16800 */
	    "GW-900D\0" /* 1 refs @ 16812 */
	    "GW-450D\0" /* 1 refs @ 16820 */
	    "GW-450S\0" /* 1 refs @ 16828 */
	    "GW-US54Mini2\0" /* 1 refs @ 16836 */
	    "GW-US54SG\0" /* 1 refs @ 16849 */
	    "GW-US54GZL\0" /* 1 refs @ 16859 */
	    "GW-US54GD\0" /* 1 refs @ 16870 */
	    "GW-USMM\0" /* 1 refs @ 16880 */
	    "GW-US300Mini-X/MiniW\0" /* 1 refs @ 16888 */
	    "GW-USMicroN\0" /* 1 refs @ 16909 */
	    "GW-USMicroN2\0" /* 1 refs @ 16921 */
	    "GW-USH300N\0" /* 1 refs @ 16934 */
	    "GW-US54GZ\0" /* 1 refs @ 16945 */
	    "GU-1000T\0" /* 1 refs @ 16955 */
	    "GW-US54Mini\0" /* 1 refs @ 16964 */
	    "Platronics\0" /* 1 refs @ 16976 */
	    "DSP-400\0" /* 1 refs @ 16987 */
	    "Headset\0" /* 1 refs @ 16995 */
	    "PlexWriter\0" /* 1 refs @ 17003 */
	    "40/12/40U\0" /* 1 refs @ 17014 */
	    "Travel\0" /* 1 refs @ 17024 */
	    "G2-200\0" /* 1 refs @ 17031 */
	    "G2E-300\0" /* 2 refs @ 17038 */
	    "G2-300\0" /* 1 refs @ 17046 */
	    "Colorado\0" /* 4 refs @ 17053 */
	    "9600\0" /* 1 refs @ 17062 */
	    "600u\0" /* 1 refs @ 17067 */
	    "6200\0" /* 2 refs @ 17072 */
	    "19200\0" /* 1 refs @ 17077 */
	    "1200u\0" /* 1 refs @ 17083 */
	    "G2-600\0" /* 2 refs @ 17089 */
	    "ReadyScan\0" /* 1 refs @ 17096 */
	    "636i\0" /* 1 refs @ 17106 */
	    "G2E-600\0" /* 1 refs @ 17111 */
	    "Mouse-in-a-Box\0" /* 1 refs @ 17119 */
	    "PCGA-UMS1\0" /* 1 refs @ 17134 */
	    "PL2301\0" /* 1 refs @ 17144 */
	    "PL2302\0" /* 1 refs @ 17151 */
	    "PL2303\0" /* 11 refs @ 17158 */
	    "(IODATA\0" /* 2 refs @ 17165 */
	    "USB-RSAQ2)\0" /* 1 refs @ 17173 */
	    "(ATEN/IOGEAR\0" /* 1 refs @ 17184 */
	    "UC232A)\0" /* 1 refs @ 17197 */
	    "ATAPI-4\0" /* 1 refs @ 17205 */
	    "PL2501\0" /* 1 refs @ 17213 */
	    "PL25A1\0" /* 1 refs @ 17220 */
	    "(Pharos\0" /* 1 refs @ 17227 */
	    "GPS)\0" /* 1 refs @ 17235 */
	    "USB-RSAQ3)\0" /* 1 refs @ 17240 */
	    "(SMART\0" /* 1 refs @ 17251 */
	    "Technologies)\0" /* 1 refs @ 17258 */
	    "USB-1284\0" /* 1 refs @ 17272 */
	    "BRIDGE\0" /* 1 refs @ 17281 */
	    "CH341\0" /* 3 refs @ 17288 */
	    "USB-EPP/SSP\0" /* 1 refs @ 17294 */
	    "USB-Serial\0" /* 4 refs @ 17306 */
	    "USB-Printer\0" /* 1 refs @ 17317 */
	    "CH340\0" /* 1 refs @ 17329 */
	    "CH341/CH340\0" /* 1 refs @ 17335 */
	    "Scorpion-980N\0" /* 2 refs @ 17347 */
	    "RWT\0" /* 1 refs @ 17361 */
	    "FCT-CDMA\0" /* 1 refs @ 17365 */
	    "1xRTT\0" /* 1 refs @ 17374 */
	    "StrikePad\0" /* 1 refs @ 17380 */
	    "i-Key\0" /* 1 refs @ 17390 */
	    "RT73\0" /* 1 refs @ 17396 */
	    "RT2671\0" /* 1 refs @ 17401 */
	    "RT3370\0" /* 1 refs @ 17408 */
	    "RT3573\0" /* 1 refs @ 17415 */
	    "RT5370\0" /* 1 refs @ 17422 */
	    "RT5572\0" /* 1 refs @ 17429 */
	    "RT8070\0" /* 1 refs @ 17436 */
	    "REX-USB60\0" /* 1 refs @ 17443 */
	    "REX-USB60F\0" /* 1 refs @ 17453 */
	    "RTL8188ETV\0" /* 1 refs @ 17464 */
	    "RTL8188CTV\0" /* 1 refs @ 17475 */
	    "RTL8188RU\0" /* 3 refs @ 17486 */
	    "RTL8150L\0" /* 1 refs @ 17496 */
	    "USB-Ethernet\0" /* 1 refs @ 17505 */
	    "RTL8151\0" /* 1 refs @ 17518 */
	    "PNA\0" /* 1 refs @ 17526 */
	    "RTL8152\0" /* 1 refs @ 17530 */
	    "RTL8153\0" /* 1 refs @ 17538 */
	    "RTL8156\0" /* 1 refs @ 17546 */
	    "RTL8171\0" /* 1 refs @ 17554 */
	    "RTL8172\0" /* 1 refs @ 17562 */
	    "RTL8173\0" /* 1 refs @ 17570 */
	    "RTL8174\0" /* 1 refs @ 17578 */
	    "RTL8191CU\0" /* 1 refs @ 17586 */
	    "RTL8192CE\0" /* 1 refs @ 17596 */
	    "RTL8187B\0" /* 3 refs @ 17606 */
	    "RTL8192EU\0" /* 1 refs @ 17615 */
	    "RTL8712\0" /* 1 refs @ 17625 */
	    "RTL8713\0" /* 1 refs @ 17633 */
	    "RTL8188FU\0" /* 1 refs @ 17641 */
	    "BlackBerry\0" /* 3 refs @ 17651 */
	    "Pearl\0" /* 2 refs @ 17662 */
	    "203USB\0" /* 1 refs @ 17668 */
	    "UA-100\0" /* 1 refs @ 17675 */
	    "I/F\0" /* 20 refs @ 17682 */
	    "UM-4\0" /* 1 refs @ 17686 */
	    "MIDI\0" /* 29 refs @ 17691 */
	    "RolandED\0" /* 1 refs @ 17696 */
	    "SC-8850\0" /* 1 refs @ 17705 */
	    "SOUND\0" /* 1 refs @ 17713 */
	    "Canvas\0" /* 2 refs @ 17719 */
	    "Synth.\0" /* 14 refs @ 17726 */
	    "U-8\0" /* 1 refs @ 17733 */
	    "UM-2\0" /* 1 refs @ 17737 */
	    "SoundCanvas\0" /* 2 refs @ 17742 */
	    "SC-8820\0" /* 1 refs @ 17754 */
	    "PC-300\0" /* 1 refs @ 17762 */
	    "UM-1\0" /* 1 refs @ 17769 */
	    "SK-500\0" /* 1 refs @ 17774 */
	    "SC-D70\0" /* 1 refs @ 17781 */
	    "EDIROL\0" /* 19 refs @ 17788 */
	    "UA-3\0" /* 1 refs @ 17795 */
	    "audio\0" /* 5 refs @ 17800 */
	    "XV-5050\0" /* 1 refs @ 17806 */
	    "UM-880\0" /* 2 refs @ 17814 */
	    "(native)\0" /* 1 refs @ 17821 */
	    "(generic)\0" /* 1 refs @ 17830 */
	    "SD-90\0" /* 1 refs @ 17840 */
	    "STDIO\0" /* 1 refs @ 17846 */
	    "UA-1A\0" /* 1 refs @ 17852 */
	    "UM-550\0" /* 1 refs @ 17858 */
	    "SD-20\0" /* 1 refs @ 17865 */
	    "SD-80\0" /* 1 refs @ 17871 */
	    "UA-700\0" /* 1 refs @ 17877 */
	    "PCR\0" /* 2 refs @ 17884 */
	    "(advanced)\0" /* 4 refs @ 17888 */
	    "M-1000\0" /* 1 refs @ 17899 */
	    "UA-1000\0" /* 1 refs @ 17906 */
	    "UA-3FX\0" /* 2 refs @ 17914 */
	    "Fantom-X\0" /* 1 refs @ 17921 */
	    "UA-25\0" /* 1 refs @ 17930 */
	    "UA-101\0" /* 2 refs @ 17936 */
	    "PC-50\0" /* 2 refs @ 17943 */
	    "USB1\0" /* 1 refs @ 17949 */
	    "UA-1EX\0" /* 1 refs @ 17954 */
	    "UM-3\0" /* 1 refs @ 17961 */
	    "UA-4FX\0" /* 1 refs @ 17966 */
	    "SonicCell\0" /* 1 refs @ 17973 */
	    "UA-25EX\0" /* 2 refs @ 17983 */
	    "UM-ONE\0" /* 1 refs @ 17991 */
	    "QUAD-CAPTURE\0" /* 1 refs @ 17998 */
	    "RTS-03\0" /* 1 refs @ 18011 */
	    "CT57A\0" /* 1 refs @ 18018 */
	    "XG-760A\0" /* 1 refs @ 18024 */
	    "XG-76NA\0" /* 1 refs @ 18032 */
	    "Gold\0" /* 2 refs @ 18040 */
	    "Joystick\0" /* 1 refs @ 18045 */
	    "ML-6060\0" /* 1 refs @ 18054 */
	    "GT-B3710\0" /* 1 refs @ 18062 */
	    "LTE/4G\0" /* 2 refs @ 18071 */
	    "GT-B3730\0" /* 1 refs @ 18078 */
	    "SWL-2100U\0" /* 1 refs @ 18087 */
	    "ImageMate\0" /* 8 refs @ 18097 */
	    "SDDR-05a\0" /* 1 refs @ 18107 */
	    "SDDR-31\0" /* 1 refs @ 18116 */
	    "SDDR-05\0" /* 1 refs @ 18124 */
	    "SDDR-12\0" /* 1 refs @ 18132 */
	    "SDDR-09\0" /* 1 refs @ 18140 */
	    "SDDR-86\0" /* 1 refs @ 18148 */
	    "SDDR-75\0" /* 1 refs @ 18156 */
	    "Cruzer\0" /* 1 refs @ 18164 */
	    "Sansa\0" /* 1 refs @ 18171 */
	    "Clip\0" /* 1 refs @ 18177 */
	    "JY-DV9USB\0" /* 1 refs @ 18182 */
	    "SCP-4900\0" /* 1 refs @ 18192 */
	    "SL11R-IDE\0" /* 1 refs @ 18201 */
	    "SeaPort+4\0" /* 4 refs @ 18211 */
	    "NUB-8301\0" /* 1 refs @ 18221 */
	    "SN1\0" /* 1 refs @ 18230 */
	    "L1\0" /* 1 refs @ 18234 */
	    "ST268\0" /* 1 refs @ 18237 */
	    "Pocket\0" /* 1 refs @ 18243 */
	    "CE175TU\0" /* 1 refs @ 18250 */
	    "SL5500\0" /* 1 refs @ 18258 */
	    "A300\0" /* 1 refs @ 18265 */
	    "SL5600\0" /* 1 refs @ 18270 */
	    "C700\0" /* 1 refs @ 18277 */
	    "C750\0" /* 1 refs @ 18282 */
	    "WS003SH\0" /* 1 refs @ 18287 */
	    "WS007SH\0" /* 1 refs @ 18295 */
	    "WS011SH\0" /* 1 refs @ 18303 */
	    "NetWalker\0" /* 1 refs @ 18311 */
	    "E-USB\0" /* 1 refs @ 18321 */
	    "eUSCSI\0" /* 3 refs @ 18327 */
	    "SDDR09\0" /* 1 refs @ 18334 */
	    "eUSB\0" /* 5 refs @ 18341 */
	    "Hifd\0" /* 1 refs @ 18346 */
	    "CD-RW\0" /* 1 refs @ 18351 */
	    "ORCA\0" /* 1 refs @ 18357 */
	    "SCM\0" /* 3 refs @ 18362 */
	    "SCL3711-NFC&RW\0" /* 1 refs @ 18366 */
	    "SCL3712-NFC&RW\0" /* 1 refs @ 18381 */
	    "1022\0" /* 1 refs @ 18396 */
	    "Modules\0" /* 1 refs @ 18401 */
	    "MC75\0" /* 1 refs @ 18409 */
	    "HC28\0" /* 3 refs @ 18414 */
	    "MdmNet\0" /* 1 refs @ 18419 */
	    "Mdm\0" /* 1 refs @ 18426 */
	    "EM5625\0" /* 1 refs @ 18430 */
	    "MC5720\0" /* 2 refs @ 18437 */
	    "AirCard\0" /* 12 refs @ 18444 */
	    "595\0" /* 1 refs @ 18452 */
	    "MC5725\0" /* 1 refs @ 18456 */
	    "597E\0" /* 1 refs @ 18463 */
	    "Compass\0" /* 1 refs @ 18468 */
	    "597\0" /* 1 refs @ 18476 */
	    "580\0" /* 1 refs @ 18480 */
	    "595U\0" /* 1 refs @ 18484 */
	    "miniPCI\0" /* 1 refs @ 18489 */
	    "5275\0" /* 1 refs @ 18497 */
	    "Sieral\0" /* 1 refs @ 18502 */
	    "250U\0" /* 1 refs @ 18509 */
	    "Aircard\0" /* 2 refs @ 18514 */
	    "MC8755\0" /* 3 refs @ 18522 */
	    "MC8765\0" /* 1 refs @ 18529 */
	    "AC875U\0" /* 1 refs @ 18536 */
	    "MC8775\0" /* 1 refs @ 18543 */
	    "875\0" /* 1 refs @ 18550 */
	    "MC8780\0" /* 1 refs @ 18554 */
	    "MC8781\0" /* 1 refs @ 18561 */
	    "880\0" /* 1 refs @ 18568 */
	    "881\0" /* 1 refs @ 18572 */
	    "880E\0" /* 1 refs @ 18576 */
	    "881E\0" /* 1 refs @ 18581 */
	    "880U\0" /* 1 refs @ 18586 */
	    "881U\0" /* 1 refs @ 18591 */
	    "885U\0" /* 1 refs @ 18596 */
	    "C01SW\0" /* 1 refs @ 18601 */
	    "MC7304\0" /* 1 refs @ 18607 */
	    "EM7455\0" /* 1 refs @ 18614 */
	    "StIR4116\0" /* 1 refs @ 18621 */
	    "SIR\0" /* 1 refs @ 18630 */
	    "StIR4210\0" /* 1 refs @ 18634 */
	    "StIR4220\0" /* 1 refs @ 18643 */
	    "VFIR\0" /* 1 refs @ 18652 */
	    "i-Bead\0" /* 2 refs @ 18657 */
	    "Datum\0" /* 1 refs @ 18664 */
	    "SSF-7X\0" /* 1 refs @ 18670 */
	    "Multi\0" /* 1 refs @ 18677 */
	    "Players\0" /* 1 refs @ 18683 */
	    "TrekStor\0" /* 1 refs @ 18691 */
	    "Musicstick\0" /* 1 refs @ 18700 */
	    "AT-USB10\0" /* 1 refs @ 18711 */
	    "DigiFilm-Combo\0" /* 1 refs @ 18720 */
	    "MULTICARDREADER\0" /* 2 refs @ 18735 */
	    "TO\0" /* 1 refs @ 18751 */
	    "U2E\0" /* 1 refs @ 18754 */
	    "Psion\0" /* 1 refs @ 18758 */
	    "Pololu\0" /* 1 refs @ 18764 */
	    "Argussoft\0" /* 1 refs @ 18771 */
	    "ISP\0" /* 1 refs @ 18781 */
	    "Crumb128\0" /* 1 refs @ 18785 */
	    "Degree\0" /* 1 refs @ 18794 */
	    "Controls\0" /* 1 refs @ 18801 */
	    "Suunto\0" /* 1 refs @ 18810 */
	    "sports\0" /* 1 refs @ 18817 */
	    "Burnside\0" /* 1 refs @ 18824 */
	    "mobile\0" /* 1 refs @ 18833 */
	    "IP-Link\0" /* 1 refs @ 18840 */
	    "1220\0" /* 1 refs @ 18848 */
	    "Lipowsky\0" /* 3 refs @ 18853 */
	    "Baby-JTAG\0" /* 1 refs @ 18862 */
	    "Baby-LIN\0" /* 1 refs @ 18872 */
	    "HARP-1\0" /* 1 refs @ 18881 */
	    "DCU-11\0" /* 1 refs @ 18888 */
	    "clone\0" /* 1 refs @ 18895 */
	    "CP210x\0" /* 3 refs @ 18901 */
	    "EC3\0" /* 1 refs @ 18908 */
	    "Debug\0" /* 1 refs @ 18912 */
	    "YAP\0" /* 2 refs @ 18918 */
	    "802.11g\0" /* 1 refs @ 18922 */
	    "NetComm\0" /* 1 refs @ 18930 */
	    "Roadster\0" /* 1 refs @ 18938 */
	    "56\0" /* 1 refs @ 18947 */
	    "LN029\0" /* 1 refs @ 18950 */
	    "CN104\0" /* 1 refs @ 18956 */
	    "WL-168\0" /* 2 refs @ 18962 */
	    "v1\0" /* 3 refs @ 18969 */
	    "LN-030\0" /* 1 refs @ 18972 */
	    "v4\0" /* 3 refs @ 18979 */
	    "WL-302\0" /* 1 refs @ 18982 */
	    "WL-603\0" /* 1 refs @ 18989 */
	    "WL-315\0" /* 1 refs @ 18996 */
	    "WL-321\0" /* 1 refs @ 19003 */
	    "WL-324\0" /* 1 refs @ 19010 */
	    "WL-343\0" /* 1 refs @ 19017 */
	    "WL-608\0" /* 1 refs @ 19024 */
	    "WL-344\0" /* 1 refs @ 19031 */
	    "WL-329\0" /* 1 refs @ 19038 */
	    "WL-345\0" /* 1 refs @ 19045 */
	    "WL-353\0" /* 1 refs @ 19052 */
	    "WL-349\0" /* 2 refs @ 19059 */
	    "LN-031\0" /* 1 refs @ 19066 */
	    "WLA-4000\0" /* 1 refs @ 19073 */
	    "WLA-5000\0" /* 1 refs @ 19082 */
	    "LN-028\0" /* 1 refs @ 19091 */
	    "2/2\0" /* 1 refs @ 19098 */
	    "WL-113\0" /* 2 refs @ 19102 */
	    "WL-172\0" /* 1 refs @ 19109 */
	    "SmartLink\0" /* 1 refs @ 19116 */
	    "smartNIC\0" /* 1 refs @ 19126 */
	    "PnP\0" /* 1 refs @ 19135 */
	    "EZ\0" /* 5 refs @ 19139 */
	    "11Mbps\0" /* 2 refs @ 19142 */
	    "54Mbps\0" /* 2 refs @ 19149 */
	    "1.0\0" /* 1 refs @ 19156 */
	    "eHome\0" /* 1 refs @ 19160 */
	    "Infrared\0" /* 1 refs @ 19166 */
	    "2-Port\0" /* 1 refs @ 19175 */
	    "3-Port\0" /* 1 refs @ 19182 */
	    "4-Port\0" /* 1 refs @ 19189 */
	    "LAN7500\0" /* 1 refs @ 19196 */
	    "LAN7505\0" /* 1 refs @ 19204 */
	    "LAN7800\0" /* 1 refs @ 19212 */
	    "3.1\0" /* 2 refs @ 19220 */
	    "LAN7801\0" /* 1 refs @ 19224 */
	    "LAN7850\0" /* 1 refs @ 19232 */
	    "SMSC9500\0" /* 3 refs @ 19240 */
	    "SMSC9505\0" /* 2 refs @ 19249 */
	    "SMSC9512\0" /* 2 refs @ 19258 */
	    "SMSC9514\0" /* 1 refs @ 19267 */
	    "LAN9530\0" /* 1 refs @ 19276 */
	    "LAN9730\0" /* 1 refs @ 19284 */
	    "(SAL10)\0" /* 5 refs @ 19292 */
	    "SMSC9500A\0" /* 4 refs @ 19300 */
	    "SMSC9505A\0" /* 3 refs @ 19310 */
	    "SMSC9512/14\0" /* 1 refs @ 19320 */
	    "(HAL)\0" /* 2 refs @ 19332 */
	    "LAN89530\0" /* 1 refs @ 19338 */
	    "SMSC9512/9514\0" /* 1 refs @ 19347 */
	    "NUB110\0" /* 1 refs @ 19361 */
	    "DSC\0" /* 2 refs @ 19368 */
	    "cameras\0" /* 1 refs @ 19372 */
	    "Memorystick\0" /* 2 refs @ 19380 */
	    "NW-MS7\0" /* 1 refs @ 19392 */
	    "MSAC-US1\0" /* 1 refs @ 19399 */
	    "Handycam\0" /* 1 refs @ 19408 */
	    "MSC\0" /* 2 refs @ 19417 */
	    "memory\0" /* 2 refs @ 19421 */
	    "stick\0" /* 2 refs @ 19428 */
	    "slot\0" /* 4 refs @ 19434 */
	    "Clie\0" /* 8 refs @ 19439 */
	    "v3.5\0" /* 1 refs @ 19444 */
	    "PlayStation2\0" /* 5 refs @ 19449 */
	    "v4.0\0" /* 2 refs @ 19462 */
	    "MSC-U03\0" /* 1 refs @ 19467 */
	    "s360\0" /* 1 refs @ 19475 */
	    "v4.1\0" /* 2 refs @ 19480 */
	    "nx60\0" /* 1 refs @ 19485 */
	    "EyeToy\0" /* 2 refs @ 19490 */
	    "v154\0" /* 1 refs @ 19497 */
	    "v155\0" /* 1 refs @ 19502 */
	    "tj25\0" /* 1 refs @ 19507 */
	    "IFU-WLM2\0" /* 1 refs @ 19512 */
	    "PLAYSTATION(R)3\0" /* 1 refs @ 19521 */
	    "GPS-CS1\0" /* 1 refs @ 19537 */
	    "KeikaiDenwa\0" /* 2 refs @ 19545 */
	    "charger\0" /* 1 refs @ 19557 */
	    "TTSMP3Player\0" /* 1 refs @ 19565 */
	    "UB801R\0" /* 1 refs @ 19578 */
	    "Communicator\0" /* 1 refs @ 19585 */
	    "SUNTAC\0" /* 5 refs @ 19598 */
	    "U-Cable\0" /* 4 refs @ 19605 */
	    "type\0" /* 4 refs @ 19613 */
	    "D2\0" /* 1 refs @ 19618 */
	    "P1\0" /* 1 refs @ 19621 */
	    "Slipper\0" /* 1 refs @ 19624 */
	    "U\0" /* 1 refs @ 19632 */
	    "Ir-Trinity\0" /* 1 refs @ 19634 */
	    "A3\0" /* 1 refs @ 19645 */
	    "A4\0" /* 2 refs @ 19648 */
	    "SR9600\0" /* 1 refs @ 19651 */
	    "QF9700\0" /* 1 refs @ 19658 */
	    "Supra\0" /* 1 refs @ 19665 */
	    "56K\0" /* 3 refs @ 19671 */
	    "SupraMax\0" /* 1 refs @ 19675 */
	    "2890\0" /* 1 refs @ 19684 */
	    "800\0" /* 1 refs @ 19689 */
	    "Nike\0" /* 1 refs @ 19693 */
	    "psa[play\0" /* 1 refs @ 19698 */
	    "120\0" /* 1 refs @ 19707 */
	    "EP-9001-g\0" /* 2 refs @ 19711 */
	    "2a\0" /* 1 refs @ 19721 */
	    "ZD1211\0" /* 5 refs @ 19724 */
	    "LW153\0" /* 1 refs @ 19731 */
	    "LW154\0" /* 1 refs @ 19737 */
	    "LW303\0" /* 1 refs @ 19743 */
	    "LW313\0" /* 1 refs @ 19749 */
	    "MW-P54SS\0" /* 1 refs @ 19755 */
	    "Broadband\0" /* 3 refs @ 19764 */
	    "Router\0" /* 5 refs @ 19774 */
	    "SGC-X2UL\0" /* 1 refs @ 19781 */
	    "USBPS2\0" /* 1 refs @ 19790 */
	    "PAUM004\0" /* 1 refs @ 19797 */
	    "(DPCM_USB)\0" /* 1 refs @ 19805 */
	    "USB-PDC\0" /* 1 refs @ 19816 */
	    "UPA9664\0" /* 1 refs @ 19824 */
	    "USB-cdmaOne\0" /* 1 refs @ 19832 */
	    "UCA1464\0" /* 1 refs @ 19844 */
	    "USB-PHS\0" /* 2 refs @ 19852 */
	    "UHA6400\0" /* 1 refs @ 19860 */
	    "UPA6400\0" /* 1 refs @ 19868 */
	    "FD-05PUB\0" /* 1 refs @ 19876 */
	    "floppy\0" /* 1 refs @ 19885 */
	    "ALLNET\0" /* 1 refs @ 19892 */
	    "0193\0" /* 1 refs @ 19899 */
	    "ZyAIR\0" /* 2 refs @ 19904 */
	    "B200\0" /* 1 refs @ 19910 */
	    "U-300C\0" /* 1 refs @ 19915 */
	    "QuickWLAN\0" /* 1 refs @ 19922 */
	    "Enhanced\0" /* 1 refs @ 19932 */
	    "Microphone\0" /* 1 refs @ 19941 */
	    "Missile\0" /* 1 refs @ 19952 */
	    "Launcher\0" /* 1 refs @ 19960 */
	    "TEMPer\0" /* 1 refs @ 19969 */
	    "sensor\0" /* 1 refs @ 19976 */
	    "UT-USB41\0" /* 1 refs @ 19983 */
	    "TUSB2046\0" /* 1 refs @ 19992 */
	    "TUSB3410\0" /* 1 refs @ 20001 */
	    "Nex\0" /* 1 refs @ 20010 */
	    "MSP-FET430UIF\0" /* 2 refs @ 20014 */
	    "JTAG\0" /* 1 refs @ 20028 */
	    "DOOGI\0" /* 1 refs @ 20033 */
	    "SLIM\0" /* 1 refs @ 20039 */
	    "Argos\0" /* 1 refs @ 20044 */
	    "Smartcard\0" /* 1 refs @ 20050 */
	    "TF5000PVR\0" /* 1 refs @ 20060 */
	    "Video\0" /* 1 refs @ 20070 */
	    "Recorder\0" /* 1 refs @ 20076 */
	    "DX3\0" /* 1 refs @ 20085 */
	    "e740\0" /* 1 refs @ 20089 */
	    "TL-WN821N\0" /* 1 refs @ 20094 */
	    "v5\0" /* 1 refs @ 20104 */
	    "TL-WN822N\0" /* 1 refs @ 20107 */
	    "TL-WN823N\0" /* 1 refs @ 20117 */
	    "Archer\0" /* 3 refs @ 20127 */
	    "T4U\0" /* 1 refs @ 20134 */
	    "T4UH\0" /* 1 refs @ 20138 */
	    "T2U\0" /* 1 refs @ 20143 */
	    "UE300\0" /* 1 refs @ 20147 */
	    "10/100/1000\0" /* 1 refs @ 20153 */
	    "ThumbDrive\0" /* 2 refs @ 20165 */
	    "8MB\0" /* 1 refs @ 20176 */
	    "TEW-648UBM\0" /* 1 refs @ 20180 */
	    "U209\0" /* 1 refs @ 20191 */
	    "SmartLCD\0" /* 1 refs @ 20196 */
	    "AVR550U\0" /* 1 refs @ 20205 */
	    "USB/MP3\0" /* 1 refs @ 20213 */
	    "decoder\0" /* 1 refs @ 20221 */
	    "1100\0" /* 1 refs @ 20229 */
	    "SM-2000\0" /* 1 refs @ 20234 */
	    "G240\0" /* 1 refs @ 20242 */
	    "Artec\0" /* 1 refs @ 20247 */
	    "T14BR\0" /* 1 refs @ 20253 */
	    "Astra\0" /* 6 refs @ 20259 */
	    "Scanner\0" /* 6 refs @ 20265 */
	    "1220U\0" /* 1 refs @ 20273 */
	    "2000U\0" /* 1 refs @ 20279 */
	    "3400\0" /* 1 refs @ 20285 */
	    "2100U\0" /* 1 refs @ 20290 */
	    "2200U\0" /* 1 refs @ 20296 */
	    "TEW-429UB_A\0" /* 1 refs @ 20302 */
	    "TEW-429UB\0" /* 2 refs @ 20314 */
	    "TEW-645UB\0" /* 1 refs @ 20324 */
	    "ALL0298\0" /* 2 refs @ 20334 */
	    "Panache\0" /* 1 refs @ 20342 */
	    "Surf\0" /* 1 refs @ 20350 */
	    "NW-3100\0" /* 1 refs @ 20355 */
	    "NF\0" /* 1 refs @ 20363 */
	    "RIC\0" /* 1 refs @ 20366 */
	    "USR1120\0" /* 1 refs @ 20370 */
	    "USR5422\0" /* 1 refs @ 20378 */
	    "USR5423\0" /* 1 refs @ 20386 */
	    "MC60\0" /* 1 refs @ 20394 */
	    "Revision\0" /* 1 refs @ 20399 */
	    "VFS101\0" /* 1 refs @ 20408 */
	    "Fingerprint\0" /* 7 refs @ 20415 */
	    "VFS301\0" /* 1 refs @ 20427 */
	    "VFS451\0" /* 1 refs @ 20434 */
	    "VFS300\0" /* 1 refs @ 20441 */
	    "VFS5011\0" /* 1 refs @ 20448 */
	    "VFS471\0" /* 1 refs @ 20456 */
	    "VFS491\0" /* 1 refs @ 20463 */
	    "MonsterTV\0" /* 1 refs @ 20470 */
	    "P2H\0" /* 1 refs @ 20480 */
	    "G773\0" /* 2 refs @ 20484 */
	    "Monitor\0" /* 3 refs @ 20489 */
	    "P815\0" /* 1 refs @ 20497 */
	    "CPiA\0" /* 1 refs @ 20502 */
	    "OneTouch\0" /* 6 refs @ 20507 */
	    "7600\0" /* 1 refs @ 20516 */
	    "5300\0" /* 1 refs @ 20521 */
	    "Scanport\0" /* 1 refs @ 20526 */
	    "6100\0" /* 1 refs @ 20535 */
	    "8100\0" /* 1 refs @ 20540 */
	    "8600\0" /* 1 refs @ 20545 */
	    "DSC350\0" /* 1 refs @ 20550 */
	    "CT-0405-U\0" /* 1 refs @ 20557 */
	    "Tablet\0" /* 3 refs @ 20567 */
	    "Graphire\0" /* 1 refs @ 20574 */
	    "Graphire2\0" /* 1 refs @ 20583 */
	    "ET-0405A-U\0" /* 1 refs @ 20593 */
	    "Graphire3\0" /* 2 refs @ 20604 */
	    "4x5\0" /* 2 refs @ 20614 */
	    "6x8\0" /* 1 refs @ 20618 */
	    "Graphire4\0" /* 1 refs @ 20622 */
	    "Intuos\0" /* 5 refs @ 20632 */
	    "A5\0" /* 1 refs @ 20639 */
	    "9x12\0" /* 1 refs @ 20642 */
	    "Intuos2\0" /* 1 refs @ 20647 */
	    "i-920\0" /* 1 refs @ 20655 */
	    "XD-0912-U\0" /* 1 refs @ 20661 */
	    "CTL-671\0" /* 1 refs @ 20671 */
	    "Art\0" /* 2 refs @ 20679 */
	    "CTH-490/K0\0" /* 1 refs @ 20683 */
	    "CTH-690/K0\0" /* 1 refs @ 20694 */
	    "M\0" /* 1 refs @ 20705 */
	    "HID\0" /* 1 refs @ 20707 */
	    "RIGblaster\0" /* 1 refs @ 20711 */
	    "External\0" /* 1 refs @ 20722 */
	    "HDD\0" /* 1 refs @ 20731 */
	    "WNC-0600USB\0" /* 1 refs @ 20735 */
	    "UR055G\0" /* 1 refs @ 20747 */
	    "ORiNOCO\0" /* 1 refs @ 20754 */
	    "802.11n\0" /* 1 refs @ 20762 */
	    "IMAGING\0" /* 1 refs @ 20770 */
	    "DEVICE\0" /* 1 refs @ 20778 */
	    "UX256\0" /* 1 refs @ 20785 */
	    "MU1000\0" /* 1 refs @ 20791 */
	    "MU2000\0" /* 1 refs @ 20798 */
	    "MU500\0" /* 1 refs @ 20805 */
	    "UW500\0" /* 1 refs @ 20811 */
	    "MOTIF6\0" /* 1 refs @ 20817 */
	    "Workstation\0" /* 3 refs @ 20824 */
	    "MOTIF7\0" /* 1 refs @ 20836 */
	    "MOTIF8\0" /* 1 refs @ 20843 */
	    "UX96\0" /* 1 refs @ 20850 */
	    "UX16\0" /* 1 refs @ 20855 */
	    "S08\0" /* 1 refs @ 20860 */
	    "CLP-150\0" /* 1 refs @ 20864 */
	    "piano\0" /* 2 refs @ 20872 */
	    "CLP-170\0" /* 1 refs @ 20878 */
	    "RP-U200\0" /* 1 refs @ 20886 */
	    "NetVolante\0" /* 4 refs @ 20894 */
	    "RTA54i\0" /* 1 refs @ 20905 */
	    "Broadband&ISDN\0" /* 2 refs @ 20912 */
	    "RTW65b\0" /* 1 refs @ 20927 */
	    "RTW65i\0" /* 1 refs @ 20934 */
	    "RTA55i\0" /* 1 refs @ 20941 */
	    "VoIP\0" /* 1 refs @ 20948 */
	    "U640MO-03\0" /* 1 refs @ 20953 */
	    "Flashbuster-U\0" /* 1 refs @ 20963 */
	    "YubiKey\0" /* 3 refs @ 20977 */
	    "CCID\0" /* 1 refs @ 20985 */
	    "OTP+CCID\0" /* 1 refs @ 20990 */
	    "OTP+CCID+U2F\0" /* 1 refs @ 20999 */
	    "M4Y-750\0" /* 1 refs @ 21012 */
	    "725/726\0" /* 1 refs @ 21020 */
	    "XI-735\0" /* 1 refs @ 21028 */
	    "MD40900\0" /* 1 refs @ 21035 */
	    "UB81\0" /* 1 refs @ 21043 */
	    "UB82\0" /* 1 refs @ 21048 */
	    "BT-500\0" /* 1 refs @ 21053 */
	    "ZWX-G261\0" /* 1 refs @ 21060 */
	    "2986L\0" /* 1 refs @ 21069 */
	    "Fax\0" /* 2 refs @ 21075 */
	    "3095\0" /* 1 refs @ 21079 */
	    "EX-20\0" /* 1 refs @ 21084 */
	    "MF622\0" /* 1 refs @ 21090 */
	    "MF628\0" /* 1 refs @ 21096 */
	    "MF633\0" /* 1 refs @ 21102 */
	    "USUPA\0" /* 1 refs @ 21108 */
	    "MF626\0" /* 1 refs @ 21114 */
	    "installer\0" /* 2 refs @ 21120 */
	    "MF112\0" /* 1 refs @ 21130 */
	    "MF119\0" /* 1 refs @ 21136 */
	    "MF190\0" /* 1 refs @ 21142 */
	    "MF228\0" /* 1 refs @ 21148 */
	    "004Z\0" /* 1 refs @ 21154 */
	    "(MF288)\0" /* 1 refs @ 21159 */
	    "MF820D\0" /* 2 refs @ 21167 */
	    "UMTS\0" /* 1 refs @ 21174 */
	    "MC2718\0" /* 1 refs @ 21179 */
	    "1xEVDO\0" /* 1 refs @ 21186 */
	    "ZD1201\0" /* 1 refs @ 21193 */
	    "abg\0" /* 1 refs @ 21200 */
	    "ZD1221\0" /* 1 refs @ 21204 */
	    "Omni\0" /* 1 refs @ 21211 */
	    "G-220\0" /* 2 refs @ 21216 */
	    "G-200\0" /* 1 refs @ 21222 */
	    "AG-225H\0" /* 1 refs @ 21228 */
	    "M-202\0" /* 1 refs @ 21236 */
	    "G-270S\0" /* 1 refs @ 21242 */
	    "G-202\0" /* 1 refs @ 21249 */
	    "NWD-271N\0" /* 1 refs @ 21255 */
	    "NWD-211AN\0" /* 1 refs @ 21264 */
	    "NWD2105\0" /* 1 refs @ 21274 */
	    "NWD2705\0" /* 1 refs @ 21282 */
	    "ND6605\0" /* 1 refs @ 21290 */
	    "Prestige\0" /* 1 refs @ 21297 */
};
const int usb_nwords = 2833;

