/*	$NetBSD: usbdevs_data.h,v 1.818 2026/03/18 05:54:57 mrg Exp $	*/

/*
 * THIS FILE IS AUTOMATICALLY GENERATED.  DO NOT EDIT.
 *
 * generated from:
 *	NetBSD: usbdevs,v 1.827 2026/03/18 05:54:44 mrg Exp
 */

/*-
 * Copyright (c) 1998-2004 The NetBSD Foundation, Inc.
 * All rights reserved.
 *
 * This code is derived from software contributed to The NetBSD Foundation
 * by Lennart Augustsson (lennart@augustsson.net) at
 * Carlstedt Research & Technology.
 *
 * Redistribution and use in source and binary forms, with or without
 * modification, are permitted provided that the following conditions
 * are met:
 * 1. Redistributions of source code must retain the above copyright
 *    notice, this list of conditions and the following disclaimer.
 * 2. Redistributions in binary form must reproduce the above copyright
 *    notice, this list of conditions and the following disclaimer in the
 *    documentation and/or other materials provided with the distribution.
 *
 * THIS SOFTWARE IS PROVIDED BY THE NETBSD FOUNDATION, INC. AND CONTRIBUTORS
 * ``AS IS'' AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED
 * TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR
 * PURPOSE ARE DISCLAIMED.  IN NO EVENT SHALL THE FOUNDATION OR CONTRIBUTORS
 * BE LIABLE FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR
 * CONSEQUENTIAL DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF
 * SUBSTITUTE GOODS OR SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS
 * INTERRUPTION) HOWEVER CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN
 * CONTRACT, STRICT LIABILITY, OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE)
 * ARISING IN ANY WAY OUT OF THE USE OF THIS SOFTWARE, EVEN IF ADVISED OF THE
 * POSSIBILITY OF SUCH DAMAGE.
 */

static const uint32_t usb_vendors[] = {
	    USB_VENDOR_UNKNOWN1, 1, 9, 0,
	    USB_VENDOR_UNKNOWN2, 1, 9, 0,
	    USB_VENDOR_EGALAX2, 16, 24, 0,
	    USB_VENDOR_QUAN, 29, 0,
	    USB_VENDOR_CHIPSBANK, 34, 44, 61, 0,
	    USB_VENDOR_HUMAX, 65, 0,
	    USB_VENDOR_AOX, 71, 0,
	    USB_VENDOR_ATMEL, 75, 0,
	    USB_VENDOR_MITSUMI, 81, 0,
	    USB_VENDOR_HP, 89, 97, 0,
	    USB_VENDOR_ADAPTEC, 105, 0,
	    USB_VENDOR_NATIONAL, 113, 122, 0,
	    USB_VENDOR_ACERLABS, 136, 141, 0,
	    USB_VENDOR_FTDI, 146, 153, 164, 0,
	    USB_VENDOR_NEC, 172, 0,
	    USB_VENDOR_KODAK, 176, 184, 0,
	    USB_VENDOR_WELTREND, 190, 122, 0,
	    USB_VENDOR_VIA, 199, 0,
	    USB_VENDOR_MELCO, 203, 0,
	    USB_VENDOR_CREATIVE, 209, 141, 0,
	    USB_VENDOR_NOKIA, 218, 0,
	    USB_VENDOR_ADI, 224, 228, 0,
	    USB_VENDOR_CATC, 236, 245, 153, 0,
	    USB_VENDOR_SMSC, 252, 0,
	    USB_VENDOR_GRAVIS, 257, 266, 236, 0,
	    USB_VENDOR_FUJITSUCOMP, 273, 281, 0,
	    USB_VENDOR_TAUGA, 291, 305, 0,
	    USB_VENDOR_AMD, 257, 308, 164, 0,
	    USB_VENDOR_LEXMARK, 314, 322, 0,
	    USB_VENDOR_NANAO, 336, 0,
	    USB_VENDOR_ALPS, 342, 347, 0,
	    USB_VENDOR_THRUST, 356, 0,
	    USB_VENDOR_TI, 369, 375, 0,
	    USB_VENDOR_ANALOGDEVICES, 387, 164, 0,
	    USB_VENDOR_SIS, 394, 402, 228, 413, 0,
	    USB_VENDOR_KYE, 419, 228, 0,
	    USB_VENDOR_DIAMOND2, 423, 431, 0,
	    USB_VENDOR_RENESAS, 439, 0,
	    USB_VENDOR_MICROSOFT, 447, 0,
	    USB_VENDOR_PRIMAX, 457, 464, 0,
	    USB_VENDOR_MGE, 476, 480, 228, 0,
	    USB_VENDOR_AMP, 484, 0,
	    USB_VENDOR_CHERRY, 488, 495, 0,
	    USB_VENDOR_MEGATRENDS, 509, 518, 0,
	    USB_VENDOR_LOGITECH, 529, 0,
	    USB_VENDOR_BTC, 538, 547, 236, 0,
	    USB_VENDOR_PHILIPS, 553, 0,
	    USB_VENDOR_SUN2, 561, 565, 578, 0,
	    USB_VENDOR_SANYO, 589, 347, 0,
	    USB_VENDOR_SEAGATE, 595, 0,
	    USB_VENDOR_CONNECTIX, 603, 0,
	    USB_VENDOR_KENSINGTON, 613, 0,
	    USB_VENDOR_LUCENT, 624, 0,
	    USB_VENDOR_PLANTRONICS, 631, 0,
	    USB_VENDOR_KYOCERA, 643, 651, 413, 0,
	    USB_VENDOR_STMICRO, 660, 0,
	    USB_VENDOR_FOXCONN, 679, 687, 689, 693, 0,
	    USB_VENDOR_MEIZU, 697, 464, 0,
	    USB_VENDOR_YAMAHA, 703, 0,
	    USB_VENDOR_COMPAQ, 710, 0,
	    USB_VENDOR_HITACHI, 717, 0,
	    USB_VENDOR_ACERP, 136, 725, 0,
	    USB_VENDOR_DAVIDCOM, 737, 0,
	    USB_VENDOR_VISIONEER, 745, 0,
	    USB_VENDOR_CANON, 755, 0,
	    USB_VENDOR_NIKON, 761, 0,
	    USB_VENDOR_IBM, 767, 0,
	    USB_VENDOR_CYPRESS, 771, 122, 0,
	    USB_VENDOR_EPSON, 779, 785, 0,
	    USB_VENDOR_RAINBOW, 791, 799, 0,
	    USB_VENDOR_IODATA, 812, 816, 0,
	    USB_VENDOR_TDK, 821, 0,
	    USB_VENDOR_3COMUSR, 825, 830, 0,
	    USB_VENDOR_METHODE, 839, 464, 847, 851, 0,
	    USB_VENDOR_MAXISWITCH, 856, 861, 0,
	    USB_VENDOR_LOCKHEEDMER, 868, 877, 884, 891, 0,
	    USB_VENDOR_FUJITSU, 273, 0,
	    USB_VENDOR_TOSHIBAAM, 900, 908, 0,
	    USB_VENDOR_MICROMACRO, 308, 916, 799, 0,
	    USB_VENDOR_KONICA, 922, 0,
	    USB_VENDOR_LITEON, 929, 153, 0,
	    USB_VENDOR_FUJIPHOTO, 937, 942, 948, 0,
	    USB_VENDOR_PHILIPSSEMI, 553, 953, 0,
	    USB_VENDOR_TATUNG, 968, 61, 975, 908, 0,
	    USB_VENDOR_SCANLOGIC, 978, 0,
	    USB_VENDOR_MYSON, 988, 153, 0,
	    USB_VENDOR_DIGI2, 994, 0,
	    USB_VENDOR_ITTCANON, 999, 755, 0,
	    USB_VENDOR_ALTEC, 1003, 1009, 0,
	    USB_VENDOR_MICROCHIP, 1017, 153, 0,
	    USB_VENDOR_HOLTEK, 1027, 122, 0,
	    USB_VENDOR_PANASONIC, 1034, 1044, 0,
	    USB_VENDOR_HUANHSIN, 1057, 1062, 0,
	    USB_VENDOR_SHARP, 1067, 0,
	    USB_VENDOR_IIYAMA, 1073, 0,
	    USB_VENDOR_EXAR, 1080, 0,
	    USB_VENDOR_SHUTTLE, 1085, 153, 0,
	    USB_VENDOR_SAMSUNG, 1093, 464, 0,
	    USB_VENDOR_ANNABOOKS, 1101, 0,
	    USB_VENDOR_JVC, 1111, 0,
	    USB_VENDOR_CHICONY, 1115, 464, 0,
	    USB_VENDOR_ELAN, 1123, 44, 0,
	    USB_VENDOR_BROTHER, 1128, 1136, 0,
	    USB_VENDOR_DALLAS, 1147, 122, 0,
	    USB_VENDOR_AIPTEK2, 1154, 322, 0,
	    USB_VENDOR_ACER, 136, 0,
	    USB_VENDOR_3COM, 1161, 0,
	    USB_VENDOR_HOSIDEN, 1166, 1174, 0,
	    USB_VENDOR_AZTECH, 1186, 228, 0,
	    USB_VENDOR_BELKIN, 1193, 1200, 0,
	    USB_VENDOR_KAWATSU, 1211, 122, 0,
	    USB_VENDOR_COMPOSITE, 1219, 0,
	    USB_VENDOR_APC, 509, 1229, 1235, 0,
	    USB_VENDOR_CONNECTEK, 257, 1246, 1256, 0,
	    USB_VENDOR_NETCHIP, 1260, 153, 0,
	    USB_VENDOR_ALTRA, 1268, 0,
	    USB_VENDOR_ATI, 1274, 799, 0,
	    USB_VENDOR_AKS, 1278, 1286, 228, 0,
	    USB_VENDOR_UNIACCESS, 1296, 245, 0,
	    USB_VENDOR_VIEWSONIC, 1306, 0,
	    USB_VENDOR_XIRLINK, 1316, 0,
	    USB_VENDOR_ANCHOR, 1324, 1331, 0,
	    USB_VENDOR_SONY, 1337, 0,
	    USB_VENDOR_VISION, 1342, 1347, 0,
	    USB_VENDOR_ASAHIKASEI, 1354, 1360, 565, 0,
	    USB_VENDOR_ATEN, 1366, 322, 0,
	    USB_VENDOR_MUSTEK, 1371, 228, 0,
	    USB_VENDOR_TELEX, 1378, 1384, 0,
	    USB_VENDOR_PERACOM, 1399, 1407, 0,
	    USB_VENDOR_ALCOR2, 1416, 308, 0,
	    USB_VENDOR_XYRATEX, 1422, 0,
	    USB_VENDOR_WACOM, 1430, 0,
	    USB_VENDOR_ETEK, 1436, 141, 0,
	    USB_VENDOR_EIZO, 1442, 0,
	    USB_VENDOR_ELECOM, 1447, 0,
	    USB_VENDOR_CONEXANT, 1454, 0,
	    USB_VENDOR_HAUPPAUGE, 1463, 236, 1473, 0,
	    USB_VENDOR_BAFO, 1479, 236, 1492, 0,
	    USB_VENDOR_YEDATA, 1504, 816, 0,
	    USB_VENDOR_AVM, 1508, 0,
	    USB_VENDOR_NINTENDO, 1512, 0,
	    USB_VENDOR_QUICKSHOT, 1521, 0,
	    USB_VENDOR_ROLAND, 1531, 0,
	    USB_VENDOR_ROCKFIRE, 1538, 0,
	    USB_VENDOR_RATOC, 1547, 228, 0,
	    USB_VENDOR_ZYXEL, 1553, 1559, 0,
	    USB_VENDOR_ALCOR, 1416, 308, 0,
	    USB_VENDOR_IOMEGA, 1573, 0,
	    USB_VENDOR_ATREND, 1580, 153, 0,
	    USB_VENDOR_AID, 257, 1588, 164, 0,
	    USB_VENDOR_LACIE, 1594, 0,
	    USB_VENDOR_CISCOLINKSYS3, 1600, 0,
	    USB_VENDOR_OMNIVISION, 1614, 0,
	    USB_VENDOR_INSYSTEM, 1625, 1635, 0,
	    USB_VENDOR_APPLE, 1642, 236, 0,
	    USB_VENDOR_DIGI, 994, 322, 0,
	    USB_VENDOR_QUALCOMM2, 1648, 0,
	    USB_VENDOR_QTRONIX, 1657, 0,
	    USB_VENDOR_ELSA, 1665, 0,
	    USB_VENDOR_BRAINBOXES, 1670, 1681, 0,
	    USB_VENDOR_ULTIMA, 1689, 0,
	    USB_VENDOR_AXIOHM, 1696, 1703, 1715, 0,
	    USB_VENDOR_MICROTEK, 1725, 0,
	    USB_VENDOR_SUNTAC, 1734, 1174, 0,
	    USB_VENDOR_LEXAR, 1738, 1744, 0,
	    USB_VENDOR_ADDTRON, 1750, 0,
	    USB_VENDOR_SYMBOL, 1758, 799, 0,
	    USB_VENDOR_GENESYS, 1765, 1773, 0,
	    USB_VENDOR_FUJI, 937, 347, 0,
	    USB_VENDOR_KEITHLEY, 1779, 375, 0,
	    USB_VENDOR_EIZONANAO, 1442, 1788, 0,
	    USB_VENDOR_KLSI, 1794, 1803, 0,
	    USB_VENDOR_FFC, 1807, 0,
	    USB_VENDOR_ANKO, 1811, 1816, 0,
	    USB_VENDOR_PIENGINEERING, 1827, 1832, 0,
	    USB_VENDOR_AOC, 1844, 322, 0,
	    USB_VENDOR_CHIC, 1848, 153, 0,
	    USB_VENDOR_BARCO, 1853, 1859, 228, 0,
	    USB_VENDOR_BRIDGE, 1867, 1874, 0,
	    USB_VENDOR_SMK, 1886, 0,
	    USB_VENDOR_SOLIDYEAR, 1890, 1896, 0,
	    USB_VENDOR_BIORAD, 1901, 1909, 0,
	    USB_VENDOR_MACALLY, 1922, 0,
	    USB_VENDOR_ACTLABS, 1930, 141, 0,
	    USB_VENDOR_ALARIS, 1934, 0,
	    USB_VENDOR_APEX, 1941, 0,
	    USB_VENDOR_CREATIVE3, 209, 141, 0,
	    USB_VENDOR_VIVITAR, 1946, 0,
	    USB_VENDOR_AVISION, 1954, 0,
	    USB_VENDOR_TEAC, 1962, 0,
	    USB_VENDOR_SGI, 394, 1967, 0,
	    USB_VENDOR_SANWASUPPLY, 1976, 1982, 0,
	    USB_VENDOR_WAYTECH, 1989, 1997, 24, 0,
	    USB_VENDOR_LINKSYS, 2010, 0,
	    USB_VENDOR_ACERSA, 136, 122, 908, 0,
	    USB_VENDOR_SIGMATEL, 2018, 0,
	    USB_VENDOR_DRAYTEK, 2027, 0,
	    USB_VENDOR_AIWA, 2035, 0,
	    USB_VENDOR_ACARD, 2040, 153, 0,
	    USB_VENDOR_PROLIFIC, 2046, 153, 0,
	    USB_VENDOR_SIEMENS, 2055, 0,
	    USB_VENDOR_AVANCELOGIC, 2063, 1773, 0,
	    USB_VENDOR_SIEMENS2, 2055, 0,
	    USB_VENDOR_MINOLTA, 2070, 0,
	    USB_VENDOR_CHPRODUCTS, 2078, 2081, 0,
	    USB_VENDOR_HAGIWARA, 2090, 2099, 0,
	    USB_VENDOR_CTX, 2107, 0,
	    USB_VENDOR_ASKEY, 2115, 236, 0,
	    USB_VENDOR_SAITEK, 2121, 0,
	    USB_VENDOR_ALCATELT, 2128, 2136, 0,
	    USB_VENDOR_AGFA, 2144, 0,
	    USB_VENDOR_ASIAMD, 2157, 2162, 2178, 0,
	    USB_VENDOR_BIZLINK, 2190, 322, 0,
	    USB_VENDOR_KEYSPAN, 2198, 0,
	    USB_VENDOR_AASHIMA, 2206, 153, 0,
	    USB_VENDOR_MULTITECH, 2214, 0,
	    USB_VENDOR_ADS, 2224, 799, 0,
	    USB_VENDOR_ALCATELM, 2128, 44, 0,
	    USB_VENDOR_SIRIUS, 2228, 799, 0,
	    USB_VENDOR_GUILLEMOT, 2235, 0,
	    USB_VENDOR_BOSTON, 2245, 2252, 0,
	    USB_VENDOR_SMC, 2262, 565, 0,
	    USB_VENDOR_PUTERCOM, 2271, 0,
	    USB_VENDOR_MCT, 2280, 0,
	    USB_VENDOR_IMATION, 2284, 0,
	    USB_VENDOR_SUSTEEN, 2292, 0,
	    USB_VENDOR_EICON, 2300, 1407, 0,
	    USB_VENDOR_MADCATZ, 2306, 2310, 24, 0,
	    USB_VENDOR_DIGITALSTREAM, 2316, 2324, 0,
	    USB_VENDOR_AUREAL, 2331, 122, 0,
	    USB_VENDOR_MIDIMAN, 2338, 0,
	    USB_VENDOR_CYBERPOWER, 2346, 2357, 24, 0,
	    USB_VENDOR_XRITE, 2366, 0,
	    USB_VENDOR_SURECOM, 2373, 153, 0,
	    USB_VENDOR_LINKSYS2, 2010, 0,
	    USB_VENDOR_GRIFFIN, 2381, 153, 0,
	    USB_VENDOR_SANDISK, 2389, 0,
	    USB_VENDOR_JENOPTIK, 2397, 0,
	    USB_VENDOR_LOGITEC, 2406, 0,
	    USB_VENDOR_BRIMAX, 2414, 0,
	    USB_VENDOR_AXIS, 2421, 1384, 0,
	    USB_VENDOR_ABL, 2426, 464, 0,
	    USB_VENDOR_SAGEM, 2430, 0,
	    USB_VENDOR_SUNCOMM, 561, 2436, 24, 0,
	    USB_VENDOR_ALFADATA, 2452, 236, 0,
	    USB_VENDOR_NATIONALTECH, 113, 2461, 228, 0,
	    USB_VENDOR_ONNTO, 2471, 0,
	    USB_VENDOR_BE, 2477, 0,
	    USB_VENDOR_ADMTEK, 2480, 0,
	    USB_VENDOR_COREGA, 2487, 0,
	    USB_VENDOR_FREECOM, 2494, 0,
	    USB_VENDOR_MICROTECH, 2502, 0,
	    USB_VENDOR_GENERALINSTMNTS, 2512, 375, 2520, 0,
	    USB_VENDOR_OLYMPUS, 2531, 0,
	    USB_VENDOR_ABOCOM, 2539, 228, 0,
	    USB_VENDOR_KINGSUN, 2546, 0,
	    USB_VENDOR_KEISOKUGIKEN, 2554, 0,
	    USB_VENDOR_ONSPEC, 2567, 0,
	    USB_VENDOR_APG, 2574, 2578, 2583, 0,
	    USB_VENDOR_BUG, 2590, 0,
	    USB_VENDOR_ALLIEDTELESYN, 2597, 2604, 322, 0,
	    USB_VENDOR_AVERMEDIA, 2612, 799, 0,
	    USB_VENDOR_SIIG, 2622, 0,
	    USB_VENDOR_CASIO, 2627, 0,
	    USB_VENDOR_DLINK2, 2633, 0,
	    USB_VENDOR_APTIO, 2640, 2081, 0,
	    USB_VENDOR_ARASAN, 2646, 2653, 228, 0,
	    USB_VENDOR_ALLIEDCABLE, 2597, 2658, 0,
	    USB_VENDOR_STSN, 2664, 0,
	    USB_VENDOR_BEWAN, 2669, 0,
	    USB_VENDOR_CENTURY, 2675, 1174, 0,
	    USB_VENDOR_ZOOM, 2683, 2688, 0,
	    USB_VENDOR_ZORAN, 2700, 44, 0,
	    USB_VENDOR_SYNET, 2706, 464, 0,
	    USB_VENDOR_BROADLOGIC, 2712, 0,
	    USB_VENDOR_HANDSPRING, 2723, 0,
	    USB_VENDOR_PALM, 2734, 2739, 0,
	    USB_VENDOR_SOURCENEXT, 2749, 0,
	    USB_VENDOR_ACTIONSTAR, 2760, 2767, 2772, 0,
	    USB_VENDOR_ACCTON, 2783, 153, 0,
	    USB_VENDOR_DIAMOND, 423, 0,
	    USB_VENDOR_NETGEAR, 2790, 0,
	    USB_VENDOR_ACTIVEWIRE, 2801, 0,
	    USB_VENDOR_BBELECTRONICS, 2812, 464, 0,
	    USB_VENDOR_PORTGEAR, 2816, 0,
	    USB_VENDOR_NETGEAR2, 2825, 0,
	    USB_VENDOR_SYSTEMTALKS, 2833, 2840, 0,
	    USB_VENDOR_METRICOM, 2846, 0,
	    USB_VENDOR_ADESSOKBTEK, 2855, 908, 0,
	    USB_VENDOR_JATON, 2868, 0,
	    USB_VENDOR_APT, 2874, 799, 0,
	    USB_VENDOR_BOCARESEARCH, 2878, 891, 0,
	    USB_VENDOR_ANDREA, 2883, 464, 0,
	    USB_VENDOR_BURRBROWN, 2890, 2901, 0,
	    USB_VENDOR_2WIRE, 2907, 0,
	    USB_VENDOR_AIPTEK, 1154, 322, 0,
	    USB_VENDOR_SMARTBRIDGES, 2913, 0,
	    USB_VENDOR_BILLIONTON, 2926, 228, 0,
	    USB_VENDOR_EXTENDED, 2937, 228, 0,
	    USB_VENDOR_MSYSTEMS, 2946, 0,
	    USB_VENDOR_AUTHENTEC, 2956, 0,
	    USB_VENDOR_AUDIOTECHNICA, 2966, 0,
	    USB_VENDOR_TRUMPION, 2981, 44, 0,
	    USB_VENDOR_ALATION, 2990, 228, 0,
	    USB_VENDOR_GLOBESPAN, 2998, 0,
	    USB_VENDOR_CONCORDCAMERA, 3008, 3016, 0,
	    USB_VENDOR_GARMIN, 3023, 322, 0,
	    USB_VENDOR_GOHUBS, 3030, 0,
	    USB_VENDOR_BIOMETRIC, 509, 3037, 3047, 0,
	    USB_VENDOR_TOSHIBA, 900, 0,
	    USB_VENDOR_PIXART, 3055, 0,
	    USB_VENDOR_PLEXTOR, 3062, 0,
	    USB_VENDOR_INTREPIDCS, 3070, 0,
	    USB_VENDOR_KORG, 3079, 3084, 0,
	    USB_VENDOR_YANO, 3097, 0,
	    USB_VENDOR_KINGSTON, 3102, 153, 0,
	    USB_VENDOR_BLUEWATER, 3111, 228, 0,
	    USB_VENDOR_AGILENT, 3121, 799, 0,
	    USB_VENDOR_GUDE, 3129, 2224, 0,
	    USB_VENDOR_PORTSMITH, 3134, 0,
	    USB_VENDOR_ACERW, 136, 0,
	    USB_VENDOR_GRETAGMACBETH, 3144, 0,
	    USB_VENDOR_ADIRONDACK, 3158, 3169, 3174, 2658, 0,
	    USB_VENDOR_BECKHOFF, 3176, 0,
	    USB_VENDOR_MINDSATWORK, 3185, 3191, 3194, 0,
	    USB_VENDOR_ZIPPY, 3199, 153, 1174, 0,
	    USB_VENDOR_POINTCHIPS, 3205, 0,
	    USB_VENDOR_INTERSIL, 3216, 0,
	    USB_VENDOR_TRIPPLITE2, 3225, 3231, 0,
	    USB_VENDOR_ALTIUS, 3236, 1715, 0,
	    USB_VENDOR_ARRIS, 3243, 3249, 0,
	    USB_VENDOR_ACTIVCARD, 3261, 0,
	    USB_VENDOR_ACTISYS, 3271, 0,
	    USB_VENDOR_NOVATEL, 3279, 651, 0,
	    USB_VENDOR_AFOURTECH, 3287, 3294, 0,
	    USB_VENDOR_AIMEX, 3299, 0,
	    USB_VENDOR_ADDONICS, 3305, 799, 0,
	    USB_VENDOR_AKAI, 3314, 3319, 3332, 0,
	    USB_VENDOR_ARESCOM, 3337, 0,
	    USB_VENDOR_BAY, 3345, 3349, 0,
	    USB_VENDOR_ALTERA, 3360, 0,
	    USB_VENDOR_CSR, 3367, 394, 3377, 0,
	    USB_VENDOR_TREK, 3383, 153, 0,
	    USB_VENDOR_ASAHIOPTICAL, 1354, 3388, 0,
	    USB_VENDOR_BOCASYSTEMS, 2878, 228, 0,
	    USB_VENDOR_SHANTOU, 3396, 0,
	    USB_VENDOR_MEDIAGEAR, 3404, 0,
	    USB_VENDOR_BROADCOM, 3414, 0,
	    USB_VENDOR_GREENHOUSE, 3423, 0,
	    USB_VENDOR_GEOCAST, 3434, 3442, 228, 0,
	    USB_VENDOR_ZYDAS, 3450, 153, 1174, 0,
	    USB_VENDOR_NEODIO, 3456, 0,
	    USB_VENDOR_OPTIONNV, 3463, 3470, 0,
	    USB_VENDOR_ASUSTEK, 3475, 236, 0,
	    USB_VENDOR_TODOS, 3483, 816, 2833, 0,
	    USB_VENDOR_SIIG2, 2622, 0,
	    USB_VENDOR_TEKRAM, 3489, 153, 0,
	    USB_VENDOR_HAL, 3496, 1174, 0,
	    USB_VENDOR_EMS, 3500, 3504, 0,
	    USB_VENDOR_NEC2, 172, 0,
	    USB_VENDOR_ATI2, 1274, 799, 0,
	    USB_VENDOR_ZEEVO, 3515, 24, 0,
	    USB_VENDOR_KURUSUGAWA, 3522, 3533, 24, 0,
	    USB_VENDOR_ASIX, 3546, 464, 0,
	    USB_VENDOR_PROLIFIC2, 2046, 153, 3551, 0,
	    USB_VENDOR_O2MICRO, 3555, 308, 0,
	    USB_VENDOR_USR, 825, 830, 0,
	    USB_VENDOR_AMBIT, 3558, 565, 0,
	    USB_VENDOR_HTC, 3564, 0,
	    USB_VENDOR_REALTEK, 3568, 0,
	    USB_VENDOR_ADDONICS2, 3305, 153, 0,
	    USB_VENDOR_FSC, 273, 2055, 3576, 0,
	    USB_VENDOR_AGATE, 3586, 799, 0,
	    USB_VENDOR_DMI, 3592, 0,
	    USB_VENDOR_MICRODIA, 3596, 687, 3605, 153, 3611, 3616, 0,
	    USB_VENDOR_SEALEVEL, 3621, 2833, 0,
	    USB_VENDOR_LUWEN, 3630, 0,
	    USB_VENDOR_QUALCOMM_K, 1648, 643, 0,
	    USB_VENDOR_ZCOM, 3639, 0,
	    USB_VENDOR_ATHEROS2, 3645, 1384, 0,
	    USB_VENDOR_TANGTOP, 3653, 0,
	    USB_VENDOR_SMC3, 2262, 565, 0,
	    USB_VENDOR_PEN, 3661, 3665, 0,
	    USB_VENDOR_ACDC, 509, 236, 3174, 2316, 1200, 0,
	    USB_VENDOR_CMEDIA, 3671, 464, 24, 0,
	    USB_VENDOR_CONCEPTRONIC2, 3679, 0,
	    USB_VENDOR_MSI, 308, 2767, 0,
	    USB_VENDOR_ELCON, 3692, 3698, 0,
	    USB_VENDOR_NETWORKFAB, 3712, 1174, 0,
	    USB_VENDOR_SITECOMEU, 3723, 3731, 0,
	    USB_VENDOR_AMIGO, 3738, 153, 0,
	    USB_VENDOR_HAWKING, 3744, 0,
	    USB_VENDOR_GMATE, 3752, 3551, 0,
	    USB_VENDOR_MTK, 3760, 0,
	    USB_VENDOR_OTI, 3764, 153, 0,
	    USB_VENDOR_PILOTECH, 3769, 0,
	    USB_VENDOR_NOVATECH, 3778, 3783, 0,
	    USB_VENDOR_EGALAX, 3788, 0,
	    USB_VENDOR_TOD, 3795, 0,
	    USB_VENDOR_AIRPRIME, 3799, 3084, 0,
	    USB_VENDOR_VTECH, 3809, 0,
	    USB_VENDOR_FALCOM, 3815, 651, 1384, 3822, 0,
	    USB_VENDOR_RIM, 891, 3827, 3830, 0,
	    USB_VENDOR_DYNASTREAM, 3837, 3848, 0,
	    USB_VENDOR_SUNRISING, 3860, 0,
	    USB_VENDOR_DVICO, 3870, 0,
	    USB_VENDOR_LG, 3876, 464, 0,
	    USB_VENDOR_MOTOROLA4, 3879, 0,
	    USB_VENDOR_HP3, 89, 97, 0,
	    USB_VENDOR_GIGABYTE, 3888, 0,
	    USB_VENDOR_YUBICO, 3897, 0,
	    USB_VENDOR_WESTERN, 3907, 2316, 0,
	    USB_VENDOR_MOTOROLA, 3879, 0,
	    USB_VENDOR_CCYU, 3915, 153, 0,
	    USB_VENDOR_HYUNDAI, 3920, 3928, 0,
	    USB_VENDOR_SILABS2, 3936, 0,
	    USB_VENDOR_USI, 3944, 0,
	    USB_VENDOR_PLX, 3948, 0,
	    USB_VENDOR_ASANTE, 3952, 0,
	    USB_VENDOR_SILABS, 394, 141, 0,
	    USB_VENDOR_TENX, 3959, 3963, 3965, 24, 0,
	    USB_VENDOR_JRC, 2901, 3377, 3047, 0,
	    USB_VENDOR_SPHAIRON, 3977, 245, 228, 3822, 0,
	    USB_VENDOR_DELORME, 3986, 0,
	    USB_VENDOR_SERVERWORKS, 3994, 0,
	    USB_VENDOR_ACERCM, 136, 1384, 3174, 4006, 0,
	    USB_VENDOR_SIERRA, 4017, 651, 0,
	    USB_VENDOR_TOPFIELD, 4024, 3611, 4033, 0,
	    USB_VENDOR_NETINDEX, 4037, 0,
	    USB_VENDOR_INTERBIO, 4046, 0,
	    USB_VENDOR_FUJITSU2, 273, 3616, 0,
	    USB_VENDOR_UNKNOWN3, 1, 9, 0,
	    USB_VENDOR_TSUNAMI, 4062, 0,
	    USB_VENDOR_PHEENET, 4070, 0,
	    USB_VENDOR_TARGUS, 4078, 0,
	    USB_VENDOR_TWINMOS, 4085, 0,
	    USB_VENDOR_CREATIVE2, 209, 141, 0,
	    USB_VENDOR_BELKIN2, 1193, 1200, 0,
	    USB_VENDOR_CYBERTAN, 4093, 153, 0,
	    USB_VENDOR_HUAWEI, 4102, 799, 0,
	    USB_VENDOR_ARANEUS, 4109, 1874, 228, 4117, 0,
	    USB_VENDOR_AINCOMM, 4120, 0,
	    USB_VENDOR_MOBILITY, 4128, 0,
	    USB_VENDOR_DICKSMITH, 4137, 4142, 464, 0,
	    USB_VENDOR_NETGEAR3, 2825, 0,
	    USB_VENDOR_VALIDITY, 4148, 4157, 24, 0,
	    USB_VENDOR_BALTECH, 4166, 0,
	    USB_VENDOR_CISCOLINKSYS, 1600, 0,
	    USB_VENDOR_SHARK, 4174, 0,
	    USB_VENDOR_AZUREWAVE, 4180, 0,
	    USB_VENDOR_PHISON, 4190, 464, 413, 0,
	    USB_VENDOR_NOVATEL2, 3279, 0,
	    USB_VENDOR_OMNIVISION2, 1614, 4197, 24, 0,
	    USB_VENDOR_MERLIN, 4211, 0,
	    USB_VENDOR_WISTRONNEWEB, 4218, 4226, 0,
	    USB_VENDOR_HUAWEI3COM, 4232, 0,
	    USB_VENDOR_ABOCOM2, 2539, 228, 0,
	    USB_VENDOR_SILICOM, 4244, 0,
	    USB_VENDOR_RALINK, 4252, 153, 0,
	    USB_VENDOR_CONCEPTRONIC, 3679, 0,
	    USB_VENDOR_SUPERTOP, 4259, 0,
	    USB_VENDOR_PLANEX3, 4268, 1384, 0,
	    USB_VENDOR_SILICONPORTALS, 394, 4275, 0,
	    USB_VENDOR_TOPPING, 4283, 464, 3174, 153, 4291, 0,
	    USB_VENDOR_JMICRON, 4295, 0,
	    USB_VENDOR_OQO, 4303, 0,
	    USB_VENDOR_UMEDIA, 4307, 1384, 0,
	    USB_VENDOR_FIBERLINE, 4315, 0,
	    USB_VENDOR_SPARKLAN, 4325, 0,
	    USB_VENDOR_AMIT2, 4334, 0,
	    USB_VENDOR_SOHOWARE, 4339, 0,
	    USB_VENDOR_UMAX, 4348, 816, 228, 0,
	    USB_VENDOR_INSIDEOUT, 4353, 4360, 1407, 0,
	    USB_VENDOR_GOODWAY, 4364, 4369, 153, 0,
	    USB_VENDOR_ENTREGA, 4373, 0,
	    USB_VENDOR_ACTIONTEC, 4381, 464, 0,
	    USB_VENDOR_CISCOLINKSYS2, 1600, 0,
	    USB_VENDOR_ATHEROS, 3645, 1384, 0,
	    USB_VENDOR_GIGASET, 4391, 0,
	    USB_VENDOR_ANYDATA, 4399, 24, 0,
	    USB_VENDOR_JABLOTRON, 4407, 0,
	    USB_VENDOR_LINKSYS4, 2010, 0,
	    USB_VENDOR_SENAO, 4417, 0,
	    USB_VENDOR_ASMEDIA, 4423, 0,
	    USB_VENDOR_ASUSTEK2, 3475, 236, 0,
	    USB_VENDOR_SWEEX2, 4431, 0,
	    USB_VENDOR_MISC, 4437, 4442, 0,
	    USB_VENDOR_DISPLAYLINK, 4450, 0,
	    USB_VENDOR_LENOVO, 4462, 0,
	    USB_VENDOR_E3C, 4469, 799, 0,
	    USB_VENDOR_AMIT, 4334, 0,
	    USB_VENDOR_QCOM, 4473, 0,
	    USB_VENDOR_LINKSYS3, 2010, 0,
	    USB_VENDOR_MEINBERG, 4478, 4487, 0,
	    USB_VENDOR_BECEEM, 4497, 1384, 0,
	    USB_VENDOR_ZTE, 4504, 0,
	    USB_VENDOR_QUANTA, 4508, 0,
	    USB_VENDOR_TERMINUS, 4515, 153, 0,
	    USB_VENDOR_QINHENG, 4524, 464, 0,
	    USB_VENDOR_OVISLINK, 4532, 0,
	    USB_VENDOR_SIGMACHIP, 4541, 2653, 0,
	    USB_VENDOR_LONGCHEER, 4547, 153, 0,
	    USB_VENDOR_MPMAN, 4557, 0,
	    USB_VENDOR_PEGATRON, 4563, 0,
	    USB_VENDOR_FUTUREBITS, 146, 4572, 0,
	    USB_VENDOR_LINUXFOUNDATION, 4577, 4583, 0,
	    USB_VENDOR_CINTERION, 4594, 0,
	    USB_VENDOR_AIRTIES, 4604, 0,
	    USB_VENDOR_DLINK, 2633, 0,
	    USB_VENDOR_PLANEX2, 4268, 1384, 0,
	    USB_VENDOR_ENCORE, 4612, 0,
	    USB_VENDOR_HAUPPAUGE2, 1463, 236, 1473, 0,
	    USB_VENDOR_PARA, 4619, 4624, 0,
	    USB_VENDOR_TRENDNET, 4635, 0,
	    USB_VENDOR_RTSYS, 4644, 228, 0,
	    USB_VENDOR_DLINK3, 2633, 0,
	    USB_VENDOR_VIALABS, 199, 141, 0,
	    USB_VENDOR_ERICSSON, 4647, 0,
	    USB_VENDOR_MOTOROLA2, 3879, 0,
	    USB_VENDOR_PINNACLE, 4656, 228, 0,
	    USB_VENDOR_ARDUINO, 4665, 4673, 0,
	    USB_VENDOR_TPLINK, 4676, 0,
	    USB_VENDOR_WMR, 4684, 4689, 3377, 0,
	    USB_VENDOR_TRIPPLITE, 4698, 0,
	    USB_VENDOR_COOLERMASTER, 4709, 4716, 153, 24, 0,
	    USB_VENDOR_HAILUCK, 4723, 3611, 4033, 0,
	    USB_VENDOR_HIROSE, 4731, 347, 0,
	    USB_VENDOR_ONEPLUS, 4738, 0,
	    USB_VENDOR_NHJ, 4746, 0,
	    USB_VENDOR_PLANEX, 4268, 1384, 0,
	    USB_VENDOR_MERCUSYS, 4750, 0,
	    USB_VENDOR_VIDZMEDIA, 4759, 4769, 4033, 0,
	    USB_VENDOR_AEI, 4773, 0,
	    USB_VENDOR_HANK, 4777, 4782, 0,
	    USB_VENDOR_PQI, 4793, 0,
	    USB_VENDOR_DAISY, 4797, 153, 0,
	    USB_VENDOR_NI, 113, 375, 0,
	    USB_VENDOR_MICRONET, 4803, 1384, 0,
	    USB_VENDOR_IODATA2, 812, 816, 0,
	    USB_VENDOR_IRIVER, 4812, 0,
	    USB_VENDOR_DELL, 4819, 0,
	    USB_VENDOR_QINHENG2, 4524, 464, 0,
	    USB_VENDOR_FEIXUN, 4824, 1559, 0,
	    USB_VENDOR_AVERATEC, 4831, 0,
	    USB_VENDOR_SWEEX, 4431, 0,
	    USB_VENDOR_ONSPEC2, 2567, 1816, 24, 0,
	    USB_VENDOR_ZINWELL, 4840, 0,
	    USB_VENDOR_INGENIC, 4848, 122, 3616, 0,
	    USB_VENDOR_SITECOM, 3723, 0,
	    USB_VENDOR_SPRINGERDESIGN, 4856, 4865, 24, 0,
	    USB_VENDOR_ARKMICROCHIPS, 4873, 0,
	    USB_VENDOR_3COM2, 1161, 0,
	    USB_VENDOR_EDIMAX, 4887, 0,
	    USB_VENDOR_INTEL, 4894, 0,
	    USB_VENDOR_INTEL2, 4894, 0,
	    USB_VENDOR_ALLWIN, 4900, 3783, 0,
	    USB_VENDOR_MOSCHIP, 4907, 122, 0,
	    USB_VENDOR_NETGEAR4, 2825, 0,
	    USB_VENDOR_xxFTDI, 4915, 0,
	    USB_VENDOR_CACE, 4920, 799, 0,
	    USB_VENDOR_COMPARE, 4925, 0,
	    USB_VENDOR_DATAAPEX, 4933, 0,
	    USB_VENDOR_EVOLUTION, 4942, 830, 0,
	    USB_VENDOR_EMPIA, 4952, 153, 0,
	    USB_VENDOR_HP2, 89, 97, 0,
	    USB_VENDOR_USRP, 4958, 3377, 4962, 0,
};

static const uint32_t usb_products[] = {
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_HOMECONN, 
	    4967, 4979, 3016, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3CREB96, 
	    4983, 4979, 4993, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3C19250, 
	    5001, 5009, 5018, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3CRSHEW696, 
	    5026, 651, 4993, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3C460, 
	    4967, 5037, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_USR56K, 
	    5043, 5056, 5062, 5068, 5077, 0,
	    USB_VENDOR_3COM, USB_PRODUCT_3COM_3C460B, 
	    4967, 5081, 0,
	    USB_VENDOR_3COM2, USB_PRODUCT_3COM2_3CRUSB10075, 
	    5088, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_OFFICECONN, 
	    1161, 5100, 387, 5114, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_USRISDN, 
	    1161, 825, 830, 5077, 5120, 5125, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_HOMECONN, 
	    1161, 4967, 5128, 0,
	    USB_VENDOR_3COMUSR, USB_PRODUCT_3COMUSR_USR56K, 
	    5043, 5056, 5062, 5068, 5077, 0,
	    USB_VENDOR_ACDC, USB_PRODUCT_ACDC_HUB, 
	    4979, 3661, 3665, 5135, 0,
	    USB_VENDOR_ACDC, USB_PRODUCT_ACDC_SECWRITE, 
	    4979, 3661, 3665, 5139, 5146, 0,
	    USB_VENDOR_ACDC, USB_PRODUCT_ACDC_PEN, 
	    4979, 3661, 3665, 5152, 5139, 5146, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX1, 
	    5157, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX2, 
	    5161, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2770, 
	    5165, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2870, 
	    5172, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT3070, 
	    5179, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT3071, 
	    5186, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT3072, 
	    5193, 0,
	    USB_VENDOR_ABOCOM2, USB_PRODUCT_ABOCOM2_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_URE450, 
	    5200, 5009, 4993, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_UFE1000, 
	    5207, 5215, 5009, 4993, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_DSB650TX_PNA, 
	    5220, 5229, 5018, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX4, 
	    5238, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX5, 
	    5242, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX6, 
	    5246, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX7, 
	    5250, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_LCS8138TX, 
	    5254, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX8, 
	    5265, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX9, 
	    5269, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_UFE2000, 
	    5273, 5281, 5215, 5009, 4993, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_WL54, 
	    5288, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8188EU, 
	    5303, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8188CU_1, 
	    5313, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RTL8188CU_2, 
	    5313, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_XX10, 
	    5323, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_BWU613, 
	    5328, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_HWU54DM, 
	    5335, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2573_2, 
	    5343, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2573_3, 
	    5343, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_RT2573_4, 
	    5343, 0,
	    USB_VENDOR_ABOCOM, USB_PRODUCT_ABOCOM_WUG2700, 
	    5350, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_USB320_EC, 
	    5358, 5009, 4993, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_2664W, 
	    5368, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_111, 
	    5374, 5382, 5386, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SMCWUSBG, 
	    5391, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SMCWUSBTG2, 
	    5401, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SMCWUSBTG2_NF, 
	    5401, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_PRISM_GT, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_SS1001, 
	    5425, 5009, 4993, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2770, 
	    5165, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_5, 
	    5172, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_4, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_4, 
	    5172, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_1, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_6, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_AR9280, 
	    5437, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RTL8192SU, 
	    5451, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_RT3070_5, 
	    5179, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_WN4501H_LF_IR, 
	    5469, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_WUS201, 
	    5483, 0,
	    USB_VENDOR_ACCTON, USB_PRODUCT_ACCTON_WN7512, 
	    5491, 0,
	    USB_VENDOR_ACERCM, USB_PRODUCT_ACERCM_EP1427X2, 
	    5498, 5009, 0,
	    USB_VENDOR_ACERLABS, USB_PRODUCT_ACERLABS_M5632, 
	    4979, 5421, 816, 5509, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_C310U, 
	    5514, 5523, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_320U, 
	    5514, 5529, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_640U, 
	    5514, 5534, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ACERSCAN_620U, 
	    5514, 5539, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_ATAPI, 
	    5544, 5018, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_AWL300, 
	    5554, 0,
	    USB_VENDOR_ACERP, USB_PRODUCT_ACERP_AWL400, 
	    5561, 0,
	    USB_VENDOR_ACERW, USB_PRODUCT_ACERW_WARPLINK, 
	    5568, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_PRISM_25, 
	    5577, 5386, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_PRISM_25A, 
	    5577, 5386, 5586, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_AR9287, 
	    5588, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_FREELAN, 
	    5602, 5608, 5616, 0,
	    USB_VENDOR_ACTIONTEC, USB_PRODUCT_ACTIONTEC_UAT1, 
	    5624, 651, 5009, 5018, 0,
	    USB_VENDOR_ACTISYS, USB_PRODUCT_ACTISYS_IR2000U, 
	    5629, 5641, 0,
	    USB_VENDOR_ACTIVEWIRE, USB_PRODUCT_ACTIVEWIRE_IOBOARD, 
	    5645, 5649, 0,
	    USB_VENDOR_ACTIVEWIRE, USB_PRODUCT_ACTIVEWIRE_IOBOARD_FW1, 
	    5645, 5655, 5662, 5667, 5669, 0,
	    USB_VENDOR_ADAPTEC, USB_PRODUCT_ADAPTEC_AWN8020, 
	    5678, 5386, 0,
	    USB_VENDOR_ADDONICS2, USB_PRODUCT_ADDONICS2_205, 
	    2658, 5687, 0,
	    USB_VENDOR_ADDTRON, USB_PRODUCT_ADDTRON_AWU120, 
	    5691, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII_4, 
	    5699, 5009, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUS, 
	    5706, 4979, 5009, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII, 
	    5712, 4979, 5009, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII_2, 
	    5719, 5009, 0,
	    USB_VENDOR_ADMTEK, USB_PRODUCT_ADMTEK_PEGASUSII_3, 
	    5726, 4979, 5421, 5009, 0,
	    USB_VENDOR_ADS, USB_PRODUCT_ADS_UBS10BT, 
	    5734, 5009, 0,
	    USB_VENDOR_ADS, USB_PRODUCT_ADS_UBS10BTX, 
	    5734, 5009, 0,
	    USB_VENDOR_ADS, USB_PRODUCT_ADS_RDX155, 
	    5743, 5753, 0,
	    USB_VENDOR_AEI, USB_PRODUCT_AEI_USBTOLAN, 
	    4773, 4979, 5759, 5762, 5018, 0,
	    USB_VENDOR_AGATE, USB_PRODUCT_AGATE_QDRIVE, 
	    5766, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCAN1212U, 
	    5774, 5783, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCAN1236U, 
	    5774, 5789, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANTOUCH, 
	    5774, 5795, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCAN1212U2, 
	    5774, 5783, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE40, 
	    5774, 5801, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE50, 
	    5774, 5805, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE20, 
	    5774, 5809, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE25, 
	    5774, 5813, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE26, 
	    5774, 5817, 0,
	    USB_VENDOR_AGFA, USB_PRODUCT_AGFA_SNAPSCANE52, 
	    5774, 5821, 0,
	    USB_VENDOR_ARANEUS, USB_PRODUCT_ARANEUS_ALEA, 
	    5825, 5830, 5835, 0,
	    USB_VENDOR_AINCOMM, USB_PRODUCT_AINCOMM_AWU2000B, 
	    5840, 0,
	    USB_VENDOR_AIPTEK2, USB_PRODUCT_AIPTEK2_PENCAM_MEGA_1_3, 
	    5849, 5856, 5861, 0,
	    USB_VENDOR_AIRPRIME, USB_PRODUCT_AIRPRIME_PC5220, 
	    5865, 651, 5870, 5873, 0,
	    USB_VENDOR_AIRTIES, USB_PRODUCT_AIRTIES_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_AIRTIES, USB_PRODUCT_AIRTIES_RT3070, 
	    5179, 0,
	    USB_VENDOR_AKS, USB_PRODUCT_AKS_USBHASP, 
	    5878, 5887, 0,
	    USB_VENDOR_ALCATELT, USB_PRODUCT_ALCATELT_ST120G, 
	    5892, 5903, 0,
	    USB_VENDOR_ALCATELT, USB_PRODUCT_ALCATELT_ST121G, 
	    5892, 5908, 0,
	    USB_VENDOR_ALCOR2, USB_PRODUCT_ALCOR2_KBD_HUB, 
	    5913, 5917, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_AU6366, 
	    5921, 5281, 5928, 5935, 5939, 5948, 5873, 5954, 5961, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_MA_KBD_HUB, 
	    5972, 5913, 5917, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_AU9814, 
	    5980, 5917, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_SM_KBD, 
	    5987, 6013, 0,
	    USB_VENDOR_ALCOR, USB_PRODUCT_ALCOR_NEC_KBD_HUB, 
	    172, 5913, 5917, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT2070, 
	    6022, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT2770, 
	    5165, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT2870, 
	    5172, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3070, 
	    5179, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3071, 
	    5186, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3072, 
	    5193, 0,
	    USB_VENDOR_ALLWIN, USB_PRODUCT_ALLWIN_RT3572, 
	    6029, 0,
	    USB_VENDOR_ALTEC, USB_PRODUCT_ALTEC_ADA70, 
	    6036, 6042, 0,
	    USB_VENDOR_ALTEC, USB_PRODUCT_ALTEC_ASC495, 
	    6051, 6042, 0,
	    USB_VENDOR_APC, USB_PRODUCT_APC_UPS, 
	    6058, 1229, 1982, 0,
	    USB_VENDOR_APC, USB_PRODUCT_APC_UPS3, 
	    6058, 1229, 1982, 0,
	    USB_VENDOR_AMBIT, USB_PRODUCT_AMBIT_NTL_250, 
	    6074, 6078, 6082, 6088, 0,
	    USB_VENDOR_AMD, USB_PRODUCT_AMD_TV_WONDER_600_USB, 
	    6094, 6097, 6104, 4979, 0,
	    USB_VENDOR_AMD, USB_PRODUCT_AMD_ROOT_HUB, 
	    4979, 6108, 5917, 0,
	    USB_VENDOR_AMIGO, USB_PRODUCT_AMIGO_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_AMIGO, USB_PRODUCT_AMIGO_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_AMIT, USB_PRODUCT_AMIT_CGWLUSB2GO, 
	    6113, 0,
	    USB_VENDOR_AMIT, USB_PRODUCT_AMIT_CGWLUSB2GNR, 
	    6125, 0,
	    USB_VENDOR_AMIT, USB_PRODUCT_AMIT_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_AMIT2, USB_PRODUCT_AMIT2_RT2870, 
	    5172, 0,
	    USB_VENDOR_ANCHOR, USB_PRODUCT_ANCHOR_EZUSB, 
	    6138, 0,
	    USB_VENDOR_ANCHOR, USB_PRODUCT_ANCHOR_EZLINK, 
	    6144, 0,
	    USB_VENDOR_ANYDATA, USB_PRODUCT_ANYDATA_A2502, 
	    6151, 6155, 6162, 0,
	    USB_VENDOR_ANYDATA, USB_PRODUCT_ANYDATA_ADU_E100H, 
	    6168, 0,
	    USB_VENDOR_ANYDATA, USB_PRODUCT_ANYDATA_ADU_500A, 
	    6178, 0,
	    USB_VENDOR_AOX, USB_PRODUCT_AOX_USB101, 
	    4979, 5229, 6188, 6199, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_EXT_KBD, 
	    1642, 2937, 4979, 6013, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_FOUNTAIN_ANSI, 
	    1642, 6206, 6215, 6233, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_FOUNTAIN_ISO, 
	    1642, 6206, 6215, 6249, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER_ANSI, 
	    1642, 6206, 6215, 6264, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER_ISO, 
	    1642, 6206, 6215, 6278, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER_JIS, 
	    1642, 6206, 6215, 6291, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER3_ANSI, 
	    1642, 6206, 6215, 6304, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER3_ISO, 
	    1642, 6206, 6215, 6319, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER3_JIS, 
	    1642, 6206, 6215, 6333, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER4_ANSI, 
	    1642, 6206, 6215, 6347, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER4_ISO, 
	    1642, 6206, 6215, 6362, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER4_JIS, 
	    1642, 6206, 6215, 6376, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING_ANSI, 
	    1642, 6206, 6215, 6390, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING_ISO, 
	    1642, 6206, 6215, 6408, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING_JIS, 
	    1642, 6206, 6215, 6425, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING2_ANSI, 
	    1642, 6206, 6215, 6442, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING2_ISO, 
	    1642, 6206, 6215, 6461, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_WELLSPRING2_JIS, 
	    1642, 6206, 6215, 6479, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_OPTMOUSE, 
	    3388, 6497, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_MIGHTYMOUSE, 
	    6503, 6510, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_FOUNTAIN_TP, 
	    1642, 6206, 6516, 6525, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_GEYSER1_TP, 
	    1642, 6206, 6516, 6536, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_MAGICMOUSE, 
	    6545, 6510, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_MAGICTRACKPAD, 
	    6545, 6516, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HIDMODE, 
	    4983, 6551, 6555, 6566, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_EXT_KBD_HUB, 
	    5917, 6572, 1642, 2937, 4979, 6013, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_SPEAKERS, 
	    6042, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_SHUFFLE2, 
	    6575, 6580, 6588, 6593, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE, 
	    6605, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPOD_TOUCH, 
	    6575, 5795, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPOD_TOUCH_4G, 
	    6575, 5795, 6612, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_3G, 
	    6605, 6615, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_3GS, 
	    6605, 6618, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_4, 
	    6605, 6622, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_4_VZW, 
	    6605, 6622, 6624, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_4S, 
	    6605, 6630, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPHONE_5, 
	    6605, 6633, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD, 
	    1642, 6635, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD_2, 
	    1642, 6635, 6640, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD_3, 
	    1642, 6635, 6642, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_IPAD_MINI, 
	    1642, 6635, 6644, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_ETHERNET, 
	    1642, 4979, 5759, 5009, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH1, 
	    4983, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH2, 
	    4983, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_1, 
	    4983, 4979, 6649, 5961, 6654, 6665, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_2, 
	    4983, 4979, 6649, 5961, 6669, 6674, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_3, 
	    4983, 4979, 6649, 5961, 6654, 6679, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_4, 
	    4983, 4979, 6649, 5961, 6683, 6694, 6698, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_5, 
	    4983, 4979, 6649, 5961, 6683, 6702, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_6, 
	    4983, 4979, 6649, 5961, 6706, 6714, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_7, 
	    4983, 4979, 6649, 5961, 6683, 6718, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH_HOST_8, 
	    4983, 4979, 6649, 5961, 6654, 6722, 0,
	    USB_VENDOR_APPLE, USB_PRODUCT_APPLE_BLUETOOTH, 
	    4983, 0,
	    USB_VENDOR_ARKMICROCHIPS, USB_PRODUCT_ARKMICROCHIPS_USBSERIAL, 
	    6726, 5961, 0,
	    USB_VENDOR_ASAHIOPTICAL, USB_PRODUCT_ASAHIOPTICAL_OPTIO230, 
	    6735, 6742, 0,
	    USB_VENDOR_ASAHIOPTICAL, USB_PRODUCT_ASAHIOPTICAL_OPTIO330, 
	    2316, 5128, 0,
	    USB_VENDOR_ASANTE, USB_PRODUCT_ASANTE_EA, 
	    5009, 4993, 0,
	    USB_VENDOR_ASKEY, USB_PRODUCT_ASKEY_WLL013I, 
	    6751, 6758, 0,
	    USB_VENDOR_ASKEY, USB_PRODUCT_ASKEY_WLL013, 
	    6751, 0,
	    USB_VENDOR_ASKEY, USB_PRODUCT_ASKEY_VOYAGER1010, 
	    6769, 6777, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88172, 
	    6782, 4979, 5421, 6790, 5229, 6188, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88178, 
	    6797, 4979, 5421, 6805, 5229, 6188, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88178A, 
	    6813, 4979, 5421, 6805, 5229, 6188, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88179, 
	    6822, 4979, 6830, 6805, 5229, 6188, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772, 
	    6834, 4979, 5421, 6790, 5229, 6188, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772A, 
	    6842, 4979, 5421, 6790, 5009, 5018, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772B, 
	    6851, 4979, 5421, 6790, 5009, 5018, 0,
	    USB_VENDOR_ASIX, USB_PRODUCT_ASIX_AX88772B_1, 
	    6860, 4979, 5421, 6790, 5009, 5018, 0,
	    USB_VENDOR_ASMEDIA, USB_PRODUCT_ASMEDIA_ASM1051, 
	    6870, 6888, 1867, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2570, 
	    6893, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL167G, 
	    6900, 5281, 5386, 4993, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL159G, 
	    6908, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_A9T_WIFI, 
	    6916, 6920, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_P5B_WIFI, 
	    6929, 6920, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL167G_2, 
	    6900, 5281, 5386, 4993, 6933, 6942, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_WL167G_3, 
	    6900, 5281, 5386, 4993, 6933, 6942, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_U3100, 
	    6945, 6948, 6955, 6644, 6961, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_4, 
	    5172, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT2870_5, 
	    5172, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT3070, 
	    5179, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN10, 
	    6967, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RT3070_1, 
	    5179, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN53, 
	    6975, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN66, 
	    6983, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN10NANO, 
	    6967, 6991, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_RTL8192CU_3, 
	    6996, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBAC53_NANO, 
	    7008, 6991, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_USBN10NANO_B1, 
	    6967, 6991, 7017, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_AURALED, 
	    7020, 7025, 0,
	    USB_VENDOR_ASUSTEK, USB_PRODUCT_ASUSTEK_MYPAL_A730, 
	    7029, 7035, 0,
	    USB_VENDOR_ASUSTEK2, USB_PRODUCT_ASUSTEK2_USBN11, 
	    7040, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC1284, 
	    7048, 7057, 5018, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC10T, 
	    7065, 5229, 5018, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC232A, 
	    7072, 5018, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC210T, 
	    7079, 5009, 5018, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_UC2324, 
	    7086, 4979, 5759, 7072, 5917, 0,
	    USB_VENDOR_ATEN, USB_PRODUCT_ATEN_DSB650C, 
	    7093, 0,
	    USB_VENDOR_ATHEROS, USB_PRODUCT_ATHEROS_AR5523, 
	    7102, 0,
	    USB_VENDOR_ATHEROS, USB_PRODUCT_ATHEROS_AR5523_NF, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_1, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_1_NF, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_2, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_2_NF, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_3, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR5523_3_NF, 
	    7102, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_TG121N, 
	    7109, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_WN821NV2, 
	    7116, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9271_1, 
	    7125, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_3CRUSBN275, 
	    7132, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_WN612, 
	    7143, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR3011, 
	    7149, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR3012, 
	    7156, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9280, 
	    5437, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9287, 
	    5588, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9170, 
	    7163, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9271_2, 
	    7125, 0,
	    USB_VENDOR_ATHEROS2, USB_PRODUCT_ATHEROS2_AR9271_3, 
	    7125, 0,
	    USB_VENDOR_ATI2, USB_PRODUCT_ATI2_205, 
	    4979, 2658, 5687, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_UHB124, 
	    7170, 7177, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_WN210, 
	    7181, 7190, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_DWL900AP, 
	    7196, 651, 7206, 7213, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_SAM_BA, 
	    7219, 7223, 7230, 7242, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_DWL120, 
	    7247, 651, 5018, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C503I1, 
	    7255, 7264, 7274, 7279, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C503I2, 
	    7255, 7264, 7286, 7279, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C503RFMD, 
	    7255, 7291, 7279, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505RFMD, 
	    7297, 7291, 7279, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505RFMD2958, 
	    7297, 7291, 7306, 7279, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505A, 
	    7311, 7291, 7306, 7279, 0,
	    USB_VENDOR_ATMEL, USB_PRODUCT_ATMEL_AT76C505AS, 
	    7321, 7291, 7306, 7279, 0,
	    USB_VENDOR_AUDIOTECHNICA, USB_PRODUCT_AUDIOTECHNICA_ATCHA4USB, 
	    7332, 4979, 7343, 0,
	    USB_VENDOR_AVANCELOGIC, USB_PRODUCT_AVANCELOGIC_USBAUDIO, 
	    4979, 7353, 7359, 0,
	    USB_VENDOR_AVERATEC, USB_PRODUCT_AVERATEC_USBWLAN, 
	    5386, 0,
	    USB_VENDOR_AVISION, USB_PRODUCT_AVISION_1200U, 
	    7367, 7373, 0,
	    USB_VENDOR_AVM, USB_PRODUCT_AVM_FRITZWLAN, 
	    7381, 7392, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070, 
	    5179, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_4, 
	    5179, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_3, 
	    5451, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_4, 
	    5451, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RT3070_5, 
	    5179, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8192SU_5, 
	    5451, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_1, 
	    7125, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_2, 
	    7125, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_3, 
	    7125, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_4, 
	    7125, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_5, 
	    7125, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_AR9271_6, 
	    7125, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8188CE_1, 
	    7394, 0,
	    USB_VENDOR_AZUREWAVE, USB_PRODUCT_AZUREWAVE_RTL8188CE_2, 
	    7394, 0,
	    USB_VENDOR_BALTECH, USB_PRODUCT_BALTECH_CARDREADER, 
	    5873, 7404, 0,
	    USB_VENDOR_BBELECTRONICS, USB_PRODUCT_BBELECTRONICS_USOTL4, 
	    7411, 7418, 0,
	    USB_VENDOR_BECEEM, USB_PRODUCT_BECEEM_250U, 
	    7429, 7436, 7442, 0,
	    USB_VENDOR_BELKIN2, USB_PRODUCT_BELKIN2_F5U002, 
	    7445, 7048, 7057, 5018, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D6050, 
	    7452, 5616, 651, 5018, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U103, 
	    7460, 7072, 5018, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U109, 
	    7467, 7072, 5018, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_SCSI, 
	    7474, 7479, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_USB2LAN, 
	    4979, 5759, 7487, 7491, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U208, 
	    7501, 7508, 7517, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U237, 
	    7520, 4979, 5421, 7527, 5917, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U409, 
	    7534, 7072, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_UPS, 
	    480, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192CU_2, 
	    5293, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8188CUS, 
	    7541, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U120, 
	    7552, 5917, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5U258, 
	    7562, 6649, 5759, 7576, 5018, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F7D2102, 
	    7581, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192CU_1, 
	    5293, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D5055, 
	    7589, 5009, 5018, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050, 
	    7597, 7605, 4979, 3442, 4993, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7051, 
	    7609, 7605, 4979, 3442, 4993, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050A, 
	    7617, 7605, 4979, 3442, 4993, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050C, 
	    7625, 7605, 4979, 3442, 4993, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D7050E, 
	    7633, 7605, 4979, 3442, 4993, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D8053V3, 
	    7641, 7649, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D8055, 
	    7652, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D8055V2, 
	    7652, 7660, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D9050V3, 
	    7663, 7671, 6642, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F5D9050C, 
	    7675, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F6D4050V1, 
	    7684, 7671, 5667, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F6D4050V2, 
	    7684, 7671, 6640, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_RTL8192SU_3, 
	    5451, 0,
	    USB_VENDOR_BELKIN, USB_PRODUCT_BELKIN_F7D1101V2, 
	    7692, 7660, 0,
	    USB_VENDOR_CENTURY, USB_PRODUCT_CENTURY_CTUSB1HUB, 
	    7700, 0,
	    USB_VENDOR_BEWAN, USB_PRODUCT_BEWAN_BWIFI_USB54AR, 
	    7711, 0,
	    USB_VENDOR_BEWAN, USB_PRODUCT_BEWAN_RT3070, 
	    5179, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USB100, 
	    7725, 6790, 7733, 4993, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USBLP100, 
	    7746, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USBEL100, 
	    7755, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USBE100, 
	    7764, 0,
	    USB_VENDOR_BILLIONTON, USB_PRODUCT_BILLIONTON_USB2AR, 
	    7772, 5009, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US101, 
	    7779, 7786, 7797, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US159, 
	    7805, 7786, 7797, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US235, 
	    7812, 7786, 7797, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US257, 
	    7819, 7786, 7826, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_12, 
	    7834, 7786, 7841, 7849, 5667, 7855, 6942, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_34, 
	    7834, 7786, 7841, 7849, 6642, 7855, 7859, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_56, 
	    7834, 7786, 7841, 7849, 6633, 7855, 7862, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US279_78, 
	    7834, 7786, 7841, 7849, 7865, 7855, 7867, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US313, 
	    7870, 7786, 7877, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US320, 
	    7889, 7786, 7896, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US324, 
	    7908, 7786, 7896, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US346_12, 
	    7915, 7786, 7922, 7849, 5667, 7855, 6942, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US346_34, 
	    7915, 7786, 7922, 7849, 6642, 7855, 7859, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US701_12, 
	    7934, 7786, 7941, 7849, 5667, 7855, 6942, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US701_34, 
	    7934, 7786, 7941, 7849, 6642, 7855, 7859, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_12, 
	    7949, 7786, 7956, 7849, 5667, 7855, 6942, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_34, 
	    7949, 7786, 7956, 7849, 6642, 7855, 7859, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_56, 
	    7949, 7786, 7956, 7849, 6633, 7855, 7862, 0,
	    USB_VENDOR_BRAINBOXES, USB_PRODUCT_BRAINBOXES_US842_78, 
	    7949, 7786, 7956, 7849, 7865, 7855, 7867, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCMFW, 
	    7968, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM2033, 
	    7974, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM2033NF, 
	    7974, 7982, 7986, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43236, 
	    7996, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43143, 
	    8005, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43242, 
	    8014, 0,
	    USB_VENDOR_BROADCOM, USB_PRODUCT_BROADCOM_BCM43569, 
	    8023, 0,
	    USB_VENDOR_BROTHER, USB_PRODUCT_BROTHER_HL1050, 
	    8032, 8040, 7057, 0,
	    USB_VENDOR_BTC, USB_PRODUCT_BTC_BTC7932, 
	    6013, 5152, 6497, 7242, 0,
	    USB_VENDOR_CACE, USB_PRODUCT_CACE_AIRPCAPNX, 
	    8046, 8054, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N656U, 
	    8057, 8066, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N1220U, 
	    8057, 8072, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N670U, 
	    8057, 8079, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_N1240U, 
	    8057, 8085, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S10, 
	    8092, 8102, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S20, 
	    8092, 8106, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S100_US, 
	    8092, 8110, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S100_EU, 
	    8092, 8110, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_G1, 
	    8092, 8115, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_A20, 
	    8092, 8118, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_S200, 
	    8092, 8122, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_EOS300D, 
	    8127, 8131, 687, 2316, 8136, 0,
	    USB_VENDOR_CANON, USB_PRODUCT_CANON_SD630, 
	    8092, 8142, 0,
	    USB_VENDOR_CASIO, USB_PRODUCT_CASIO_QV, 
	    8148, 8151, 0,
	    USB_VENDOR_CASIO, USB_PRODUCT_CASIO_BE300, 
	    8165, 8172, 0,
	    USB_VENDOR_CASIO, USB_PRODUCT_CASIO_NAMELAND, 
	    2627, 8176, 8185, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_NETMATE, 
	    8192, 5229, 5018, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_NETMATE2, 
	    8200, 5229, 5018, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_CHIEF, 
	    4979, 8209, 8215, 3174, 8219, 8228, 0,
	    USB_VENDOR_CATC, USB_PRODUCT_CATC_ANDROMEDA, 
	    8237, 7177, 0,
	    USB_VENDOR_CCYU, USB_PRODUCT_CCYU_EASYDISK, 
	    3630, 8247, 8256, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_MY3000KBD, 
	    8263, 8270, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_MY3000HUB, 
	    8263, 7177, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_CYBOARD, 
	    8279, 6013, 0,
	    USB_VENDOR_CHERRY, USB_PRODUCT_CHERRY_MY6000KBD, 
	    8287, 8270, 0,
	    USB_VENDOR_CHIC, USB_PRODUCT_CHIC_MOUSE1, 
	    6497, 0,
	    USB_VENDOR_CHIC, USB_PRODUCT_CHIC_CYPRESS, 
	    771, 4979, 6510, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_KB8933, 
	    8294, 8270, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_OPTMOUSE0939, 
	    4979, 3388, 6510, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_1, 
	    7541, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_2, 
	    7541, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_3, 
	    7541, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_4, 
	    7541, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_5, 
	    7541, 0,
	    USB_VENDOR_CHICONY, USB_PRODUCT_CHICONY_RTL8188CUS_6, 
	    7541, 0,
	    USB_VENDOR_MICRODIA, USB_PRODUCT_MICRODIA_TWINKLECAM, 
	    8302, 4979, 5128, 0,
	    USB_VENDOR_MICRODIA, USB_PRODUCT_MICRODIA_BWC35HL01, 
	    8313, 8321, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_PROTHROTTLE, 
	    5077, 8333, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_PROPEDALS, 
	    5077, 8342, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_FIGHTERSTICK, 
	    8349, 0,
	    USB_VENDOR_CHPRODUCTS, USB_PRODUCT_CHPRODUCTS_FLIGHTYOKE, 
	    8362, 8369, 8373, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GV2, 
	    8378, 7660, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54AG, 
	    8386, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54G, 
	    8378, 8395, 4979, 3442, 4993, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GP, 
	    8406, 8395, 4979, 3442, 4993, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_USB200MV2, 
	    8415, 7660, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_HU200TS, 
	    8423, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GC, 
	    8432, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB54GR, 
	    8441, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSBF54G, 
	    8450, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_WUSB200, 
	    8459, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_AE1000, 
	    8467, 0,
	    USB_VENDOR_CISCOLINKSYS, USB_PRODUCT_CISCOLINKSYS_AM10, 
	    8474, 0,
	    USB_VENDOR_CISCOLINKSYS2, USB_PRODUCT_CISCOLINKSYS2_RT3070, 
	    5179, 0,
	    USB_VENDOR_CISCOLINKSYS3, USB_PRODUCT_CISCOLINKSYS3_RT3070, 
	    5179, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_IPAQPOCKETPC, 
	    8479, 8484, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_A1500, 
	    8493, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_IPAQWLAN, 
	    8479, 5386, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_W100, 
	    8499, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_W200, 
	    5386, 8504, 8514, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_PJB100, 
	    8519, 8528, 8536, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_IPAQLINUX, 
	    8479, 4577, 0,
	    USB_VENDOR_COMPAQ, USB_PRODUCT_COMPAQ_HNE200, 
	    8543, 4979, 5009, 5018, 0,
	    USB_VENDOR_COMPARE, USB_PRODUCT_COMPARE_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_COMPOSITE, USB_PRODUCT_COMPOSITE_USBPS2, 
	    4979, 5759, 8551, 7479, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RTL8192SU_3, 
	    5451, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_C54RU, 
	    8555, 5386, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT3070_1, 
	    5179, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_7, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_8, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_C54RU2, 
	    8555, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2573, 
	    8561, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_4, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_5, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT2870_6, 
	    5172, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_CONCEPTRONIC2, USB_PRODUCT_CONCEPTRONIC2_PRISM_GT, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_C11U, 
	    8569, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_WL210, 
	    8574, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_1, 
	    7102, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_1_NF, 
	    7102, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_2, 
	    7102, 0,
	    USB_VENDOR_CONCEPTRONIC, USB_PRODUCT_CONCEPTRONIC_AR5523_2_NF, 
	    7102, 0,
	    USB_VENDOR_CONCORDCAMERA, USB_PRODUCT_CONCORDCAMERA_EYE_Q_3X, 
	    8581, 8585, 8587, 0,
	    USB_VENDOR_CONNECTIX, USB_PRODUCT_CONNECTIX_QUICKCAM, 
	    8590, 0,
	    USB_VENDOR_COOLERMASTER, USB_PRODUCT_COOLERMASTER_AMD_SR4_LAMPLIGHT, 
	    8599, 8603, 8607, 8617, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_ETHER_USB_T, 
	    8625, 8631, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB_TX, 
	    8637, 8644, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLAN_USB_USB_11, 
	    8651, 8663, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB_TXS, 
	    8637, 8670, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLANUSB, 
	    651, 7487, 4979, 8678, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB2_TX, 
	    8637, 8687, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLUSB_11_KEY, 
	    8695, 8704, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB2GTST, 
	    8708, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGUSBRS232R, 
	    8722, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB2GL, 
	    8735, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB2GPX, 
	    8747, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RT3070, 
	    5179, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSBNM, 
	    8760, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_CGWLUSB300GNM, 
	    8771, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_WLUSB_11_STICK, 
	    5386, 4979, 8786, 8792, 0,
	    USB_VENDOR_COREGA, USB_PRODUCT_COREGA_FETHER_USB_TXC, 
	    8637, 8795, 0,
	    USB_VENDOR_CREATIVE, USB_PRODUCT_CREATIVE_NOMAD_II, 
	    8803, 7517, 8809, 8813, 0,
	    USB_VENDOR_CREATIVE, USB_PRODUCT_CREATIVE_NOMAD_IIMG, 
	    8803, 7517, 8820, 0,
	    USB_VENDOR_CREATIVE, USB_PRODUCT_CREATIVE_NOMAD, 
	    8803, 0,
	    USB_VENDOR_CREATIVE2, USB_PRODUCT_CREATIVE2_VOIP_BLASTER, 
	    8823, 8828, 0,
	    USB_VENDOR_CREATIVE3, USB_PRODUCT_CREATIVE3_OPTICAL_MOUSE, 
	    8836, 3388, 6510, 0,
	    USB_VENDOR_CSR, USB_PRODUCT_CSR_BLUETOOTH, 
	    4983, 4979, 4993, 0,
	    USB_VENDOR_CSR, USB_PRODUCT_CSR_BLUETOOTH_NF, 
	    4983, 4979, 4993, 0,
	    USB_VENDOR_CMEDIA, USB_PRODUCT_CMEDIA_USBAUDIO, 
	    4979, 8845, 8849, 0,
	    USB_VENDOR_CTX, USB_PRODUCT_CTX_EX1300, 
	    8855, 7177, 0,
	    USB_VENDOR_CYBERPOWER, USB_PRODUCT_CYBERPOWER_UPS0, 
	    6058, 1229, 1982, 0,
	    USB_VENDOR_CYBERPOWER, USB_PRODUCT_CYBERPOWER_UPS, 
	    6058, 1229, 1982, 0,
	    USB_VENDOR_CYBERPOWER, USB_PRODUCT_CYBERPOWER_UPS2, 
	    6058, 1229, 1982, 0,
	    USB_VENDOR_CYBERTAN, USB_PRODUCT_CYBERTAN_TG54USB, 
	    8862, 0,
	    USB_VENDOR_CYBERTAN, USB_PRODUCT_CYBERTAN_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_CYBERTAN, USB_PRODUCT_CYBERTAN_RT2870, 
	    5172, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_MOUSE, 
	    6497, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_THERMO, 
	    8870, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_KBDHUB, 
	    8882, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_FMRADIO, 
	    8895, 3377, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_USBRS232, 
	    8898, 8908, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_HUB2, 
	    8918, 5917, 0,
	    USB_VENDOR_CYPRESS, USB_PRODUCT_CYPRESS_LPRDK, 
	    8923, 8930, 8933, 1867, 0,
	    USB_VENDOR_DAISY, USB_PRODUCT_DAISY_DMC, 
	    8937, 8947, 0,
	    USB_VENDOR_DALLAS, USB_PRODUCT_DALLAS_J6502, 
	    8962, 8969, 0,
	    USB_VENDOR_DALLAS, USB_PRODUCT_DALLAS_USB_FOB_IBUTTON, 
	    8978, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_PORT, 
	    8994, 8999, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_SK8125, 
	    9010, 8270, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_X3, 
	    9018, 9023, 8172, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_X30, 
	    9018, 9026, 8172, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_BC02, 
	    9030, 4983, 4979, 4993, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_TM1180, 
	    9035, 9046, 5386, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_PRISM_GT_1, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_TM350, 
	    9035, 9051, 4983, 4979, 4993, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_PRISM_GT_2, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_HSDPA, 
	    9055, 651, 9068, 5114, 0,
	    USB_VENDOR_DELL, USB_PRODUCT_DELL_W5500, 
	    4819, 651, 9074, 9068, 5114, 0,
	    USB_VENDOR_DELORME, USB_PRODUCT_DELORME_EARTHMATE, 
	    9080, 9090, 0,
	    USB_VENDOR_DELORME, USB_PRODUCT_DELORME_EARTHMATE_LT20, 
	    9080, 9094, 9090, 0,
	    USB_VENDOR_DIAMOND, USB_PRODUCT_DIAMOND_RIO500USB, 
	    9100, 9104, 4979, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_WL200U, 
	    9108, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_CHUSB611G, 
	    9116, 9122, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_WL240U, 
	    9127, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_XH1153, 
	    9135, 5616, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_RT2573, 
	    5343, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_CWD854F, 
	    9142, 9148, 9156, 9160, 0,
	    USB_VENDOR_DICKSMITH, USB_PRODUCT_DICKSMITH_RTL8187, 
	    9162, 0,
	    USB_VENDOR_DIGI, USB_PRODUCT_DIGI_ACCELEPORT2, 
	    9170, 4979, 6640, 0,
	    USB_VENDOR_DIGI, USB_PRODUCT_DIGI_ACCELEPORT4, 
	    9170, 4979, 6622, 0,
	    USB_VENDOR_DIGI, USB_PRODUCT_DIGI_ACCELEPORT8, 
	    9170, 4979, 9181, 0,
	    USB_VENDOR_DIGITALSTREAM, USB_PRODUCT_DIGITALSTREAM_PS2, 
	    9183, 9188, 4993, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_GUC2020, 
	    9195, 9202, 9206, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LD220, 
	    1093, 9214, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LD190, 
	    1093, 9220, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_U70, 
	    1093, 9226, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_POLARIS2, 
	    9230, 4979, 9239, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_VCUD60, 
	    9244, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_CONV, 
	    9252, 9261, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_DLDVI, 
	    4450, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_USBRGB, 
	    9274, 9282, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCDUSB7X, 
	    9274, 9290, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCDUSB10X, 
	    9274, 9300, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_VGA10, 
	    9314, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_WSDVI, 
	    9327, 3783, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_EC008, 
	    9330, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_FYDVI2, 
	    4450, 9341, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_GXDVIU2, 
	    9349, 9357, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCD4300U, 
	    9367, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCD8000U, 
	    9377, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_HPDOCK, 
	    9387, 4979, 9390, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_NL571, 
	    9387, 4979, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_M01061, 
	    4462, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_NBDOCK, 
	    9398, 9408, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_GXDVIU2B, 
	    9349, 9419, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_SWDVI, 
	    9430, 9202, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LUM70, 
	    9438, 9447, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LCD8000UD_DVI, 
	    9453, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LDEWX015U, 
	    2406, 9468, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_KC002N, 
	    9479, 9485, 9492, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_MIMO, 
	    4450, 9503, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_PLUGABLE, 
	    9508, 9517, 9525, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_LT1421WIDE, 
	    4462, 9533, 9545, 9552, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_SD_U2VDH, 
	    9557, 9562, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_UM7X0, 
	    9571, 9582, 0,
	    USB_VENDOR_DISPLAYLINK, USB_PRODUCT_DISPLAYLINK_FYDVI, 
	    4450, 9587, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUBE100, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUBE100C1, 
	    9594, 9156, 9603, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUB1312, 
	    9606, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX4, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWL120E, 
	    7247, 9156, 9615, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA130C, 
	    9617, 9156, 9625, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_1, 
	    5293, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_2, 
	    5293, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_3, 
	    5293, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RTL8192CU_4, 
	    5293, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA131B, 
	    9627, 9156, 9635, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA125D1, 
	    9637, 9156, 9645, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA131E, 
	    9627, 9156, 9615, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA121B1, 
	    9648, 9156, 7017, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWL122, 
	    651, 9656, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG120, 
	    9663, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWL120F, 
	    7247, 9156, 9160, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG122A2, 
	    9672, 9156, 9681, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG132, 
	    9684, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG132_NF, 
	    9684, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG132, 
	    9694, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG132_NF, 
	    9694, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG122, 
	    9703, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLAG122_NF, 
	    9703, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWLG122, 
	    9713, 9721, 651, 4979, 4993, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DUBE100B1, 
	    9594, 9156, 7017, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RT2870, 
	    5172, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_RT3072, 
	    5193, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA140B3, 
	    9723, 9156, 9731, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA160B2, 
	    9734, 9156, 9742, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA127, 
	    9745, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWA162, 
	    9753, 651, 4993, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650C, 
	    7065, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX1, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX_PNA, 
	    5220, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX3, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650TX2, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DSB650, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157E_CD, 
	    9761, 9769, 9776, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157_CD, 
	    9761, 9769, 9776, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157, 
	    9761, 9781, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM157E, 
	    9761, 9781, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM222_CD, 
	    9785, 9769, 9776, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM222_CD_2, 
	    9785, 9769, 9776, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM222, 
	    9785, 9781, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWM222_2, 
	    9785, 9781, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWR510_CD, 
	    9793, 9769, 9776, 0,
	    USB_VENDOR_DLINK, USB_PRODUCT_DLINK_DWR510, 
	    9793, 9781, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA131A1, 
	    9627, 9801, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_WUA2340, 
	    9804, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_WUA2340_NF, 
	    9804, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA160A2, 
	    9734, 9681, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA130D1, 
	    9617, 9156, 9645, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_AR9271, 
	    7125, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWLG122C1, 
	    9672, 9156, 9603, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_WUA1340, 
	    9813, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DUBE100B1, 
	    9594, 9156, 7017, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA111, 
	    9822, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA110, 
	    9830, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3072, 
	    5193, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3072_1, 
	    5193, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_1, 
	    5179, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA160A1, 
	    9734, 9801, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_DWA130, 
	    9617, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_4, 
	    5179, 0,
	    USB_VENDOR_DLINK2, USB_PRODUCT_DLINK2_RT3070_5, 
	    5179, 0,
	    USB_VENDOR_DLINK3, USB_PRODUCT_DLINK3_KVM221, 
	    9838, 0,
	    USB_VENDOR_DMI, USB_PRODUCT_DMI_SA2_0, 
	    9846, 4993, 0,
	    USB_VENDOR_DRAYTEK, USB_PRODUCT_DRAYTEK_VIGOR550, 
	    9854, 0,
	    USB_VENDOR_DVICO, USB_PRODUCT_DVICO_RT3070, 
	    5179, 0,
	    USB_VENDOR_DYNASTREAM, USB_PRODUCT_DYNASTREAM_ANTDEVBOARD, 
	    9863, 9867, 9871, 0,
	    USB_VENDOR_E3C, USB_PRODUCT_E3C_EC168, 
	    9877, 6961, 4993, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7318, 
	    9883, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_MT7610U, 
	    9891, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7618, 
	    9899, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192SU_3, 
	    5451, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7717, 
	    9907, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7718, 
	    9915, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7722UTN, 
	    9923, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7811UTC_1, 
	    9934, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7811UTC_2, 
	    9934, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_ELECOM_WDC433SU2M, 
	    9945, 9952, 0,
	    USB_VENDOR_EDIMAX, USB_PRODUCT_EDIMAX_EW7811UNV2, 
	    9964, 9974, 0,
	    USB_VENDOR_EGALAX, USB_PRODUCT_EGALAX_TPANEL, 
	    5795, 9977, 0,
	    USB_VENDOR_EGALAX, USB_PRODUCT_EGALAX_TPANEL2, 
	    5795, 9977, 0,
	    USB_VENDOR_EGALAX2, USB_PRODUCT_EGALAX2_TPANEL, 
	    5795, 9977, 0,
	    USB_VENDOR_EICON, USB_PRODUCT_EICON_DIVA852, 
	    9983, 9988, 5120, 5125, 0,
	    USB_VENDOR_EIZO, USB_PRODUCT_EIZO_HUB, 
	    7177, 0,
	    USB_VENDOR_EIZO, USB_PRODUCT_EIZO_MONITOR, 
	    9992, 0,
	    USB_VENDOR_ELAN, USB_PRODUCT_ELAN_ACTIVEJET, 
	    10000, 10010, 4006, 6013, 0,
	    USB_VENDOR_ELCON, USB_PRODUCT_ELCON_PLAN, 
	    10017, 10027, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_MOUSE29UO, 
	    6497, 10033, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX0, 
	    10038, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX1, 
	    10038, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBLTX, 
	    10048, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_WDC150SU2M, 
	    10059, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX2, 
	    10038, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_WDC433SU2M2, 
	    10071, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSB20, 
	    10084, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_UCSGT, 
	    10093, 10100, 5018, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_UCSGT0, 
	    10107, 7072, 0,
	    USB_VENDOR_ELECOM, USB_PRODUCT_ELECOM_LDUSBTX3, 
	    10038, 0,
	    USB_VENDOR_ELSA, USB_PRODUCT_ELSA_MODEM1, 
	    1665, 5114, 5649, 0,
	    USB_VENDOR_ELSA, USB_PRODUCT_ELSA_USB2ETHERNET, 
	    10115, 10125, 0,
	    USB_VENDOR_EMPIA, USB_PRODUCT_EMPIA_CAMERA, 
	    3016, 0,
	    USB_VENDOR_EMPIA, USB_PRODUCT_EMPIA_EM2883, 
	    10138, 0,
	    USB_VENDOR_EMS, USB_PRODUCT_EMS_DUAL_SHOOTER, 
	    10145, 10149, 6188, 10153, 0,
	    USB_VENDOR_ENCORE, USB_PRODUCT_ENCORE_RT3070, 
	    5179, 0,
	    USB_VENDOR_ENCORE, USB_PRODUCT_ENCORE_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_ENCORE, USB_PRODUCT_ENCORE_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_1S, 
	    10163, 10100, 10166, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_2S, 
	    10176, 10100, 10166, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_1S25, 
	    10179, 10100, 10166, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_4S, 
	    6630, 10100, 10166, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_E45, 
	    10184, 5009, 5018, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_CENTRONICS, 
	    10188, 10166, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_XX1, 
	    5009, 4993, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_1S9, 
	    10199, 10100, 10166, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_EZUSB, 
	    8185, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_2U4S, 
	    10203, 10100, 10208, 7177, 0,
	    USB_VENDOR_ENTREGA, USB_PRODUCT_ENTREGA_XX2, 
	    5009, 4993, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER1, 
	    4979, 10222, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER2, 
	    10230, 4979, 10234, 2658, 10240, 10244, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER3, 
	    10230, 4979, 10234, 2658, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_PRINTER5, 
	    4979, 10222, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_636, 
	    10248, 10259, 687, 10264, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_610, 
	    10248, 10273, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1200, 
	    10248, 7367, 687, 10277, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1600, 
	    10287, 10298, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1640, 
	    10248, 10303, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1240, 
	    10248, 10310, 687, 10316, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_640U, 
	    10248, 5534, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1250, 
	    10248, 10326, 687, 10332, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1650, 
	    10248, 10342, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_GT9700F, 
	    10347, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_2400, 
	    10248, 10356, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1260, 
	    10248, 10361, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1660, 
	    10248, 10366, 7373, 0,
	    USB_VENDOR_EPSON, USB_PRODUCT_EPSON_1670, 
	    10248, 10371, 7373, 0,
	    USB_VENDOR_ETEK, USB_PRODUCT_ETEK_1COM, 
	    7072, 7242, 0,
	    USB_VENDOR_EXAR, USB_PRODUCT_EXAR_XR21V1410, 
	    10376, 5667, 10386, 10394, 0,
	    USB_VENDOR_EXAR, USB_PRODUCT_EXAR_XR21V1412, 
	    10399, 6640, 10386, 10394, 0,
	    USB_VENDOR_EXAR, USB_PRODUCT_EXAR_XR21V1414, 
	    10409, 6622, 10386, 10394, 0,
	    USB_VENDOR_EXTENDED, USB_PRODUCT_EXTENDED_XTNDACCESS, 
	    10419, 10430, 0,
	    USB_VENDOR_FALCOM, USB_PRODUCT_FALCOM_TWIST, 
	    10435, 10441, 6088, 0,
	    USB_VENDOR_FALCOM, USB_PRODUCT_FALCOM_SAMBA, 
	    10450, 10456, 10441, 6088, 0,
	    USB_VENDOR_FEIXUN, USB_PRODUCT_FEIXUN_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_FEIXUN, USB_PRODUCT_FEIXUN_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_FIBERLINE, USB_PRODUCT_FIBERLINE_WL430U, 
	    10462, 0,
	    USB_VENDOR_FOXCONN, USB_PRODUCT_FOXCONN_AR3012, 
	    4983, 7156, 0,
	    USB_VENDOR_FREECOM, USB_PRODUCT_FREECOM_DVD, 
	    10470, 10240, 10480, 10484, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_8U232AM, 
	    10490, 7072, 10153, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_232RL, 
	    10498, 7072, 10153, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_2232C, 
	    10506, 4979, 10512, 10517, 10522, 10529, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_4232H, 
	    10537, 4979, 10543, 10517, 10522, 10529, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_232H, 
	    10548, 4979, 10555, 10394, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_230X, 
	    10568, 7072, 10153, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_PS2KBDMS, 
	    9183, 10575, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SERIAL_8U100AX, 
	    10590, 7072, 10153, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_OPENRD_JTAGKEY, 
	    10598, 10605, 10613, 9635, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_BEAGLEBONE, 
	    10621, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MAXSTREAM_PKG_U, 
	    10632, 10642, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_KW, 
	    10648, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_YS, 
	    10651, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_Y6, 
	    10654, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_Y8, 
	    10657, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_IC, 
	    10660, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_DB9, 
	    10663, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_RS232, 
	    10667, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_MHAM_Y9, 
	    10673, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_COASTAL_TNCX, 
	    10676, 10684, 10694, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_CTI_485_MINI, 
	    10700, 10704, 6644, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_CTI_NANO_485, 
	    10700, 6991, 10704, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_MX200_USB, 
	    10708, 10715, 10723, 10735, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_MX4_MX5_USB, 
	    10708, 10715, 10742, 10735, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_LK202_24_USB, 
	    10708, 10715, 10754, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_LK204_24_USB, 
	    10708, 10715, 10769, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_632, 
	    10781, 10794, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_634, 
	    10781, 10802, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_633, 
	    10781, 10810, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_631, 
	    10781, 10818, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_LCD_CFA_635, 
	    10781, 10826, 10750, 0,
	    USB_VENDOR_FTDI, USB_PRODUCT_FTDI_SEMC_DSS20, 
	    10834, 10839, 10846, 0,
	    USB_VENDOR_xxFTDI, USB_PRODUCT_xxFTDI_SHEEVAPLUG_JTAG, 
	    10858, 10605, 0,
	    USB_VENDOR_FUJIPHOTO, USB_PRODUCT_FUJIPHOTO_MASS0100, 
	    10869, 9846, 0,
	    USB_VENDOR_FUJITSU, USB_PRODUCT_FUJITSU_AH_F401U, 
	    10874, 10883, 10887, 10889, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_KEYBOARD6, 
	    10896, 10901, 6013, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_KEYBOARD7, 
	    10896, 7865, 6013, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_MOUSE, 
	    10896, 10901, 6510, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_FX5204PS, 
	    10234, 1229, 10903, 10909, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_FX5251WB, 
	    10919, 10924, 10932, 0,
	    USB_VENDOR_FUJITSUCOMP, USB_PRODUCT_FUJITSUCOMP_VIRTETH, 
	    10942, 10950, 8256, 0,
	    USB_VENDOR_FSC, USB_PRODUCT_FSC_E5400, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_GENERALINSTMNTS, USB_PRODUCT_GENERALINSTMNTS_SB5100, 
	    10954, 10964, 2658, 6088, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GENELINK, 
	    10971, 10980, 1867, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL650, 
	    10990, 5917, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL641USB, 
	    10996, 11005, 5873, 5954, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL641USB2IDE_2, 
	    10996, 11018, 1867, 0,
	    USB_VENDOR_GENESYS, USB_PRODUCT_GENESYS_GL641USB2IDE, 
	    10996, 11018, 1867, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GN54G, 
	    11026, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNBR402W, 
	    11033, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWLBM101, 
	    11043, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWBKG, 
	    11054, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWB01GS, 
	    11062, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWI05GS, 
	    11072, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWB31N, 
	    11082, 0,
	    USB_VENDOR_GIGABYTE, USB_PRODUCT_GIGABYTE_GNWB32L, 
	    11091, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_WLAN, 
	    5386, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_SMCWUSBTG, 
	    11100, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_SMCWUSBTG_NF, 
	    11100, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_AR5523, 
	    7102, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_AR5523_NF, 
	    7102, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_RT2573, 
	    5343, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_RT3070_1, 
	    5179, 0,
	    USB_VENDOR_GIGASET, USB_PRODUCT_GIGASET_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_GMATE, USB_PRODUCT_GMATE_YP3X00, 
	    11111, 8172, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_GPS_RECEIVER, 
	    9090, 11118, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_MT7610U, 
	    9891, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_MT7630U, 
	    11127, 0,
	    USB_VENDOR_MTK, USB_PRODUCT_MTK_MT7650U, 
	    11135, 0,
	    USB_VENDOR_GARMIN, USB_PRODUCT_GARMIN_FORERUNNER305, 
	    11143, 11154, 0,
	    USB_VENDOR_GLOBESPAN, USB_PRODUCT_GLOBESPAN_PRISM_GT_1, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_GLOBESPAN, USB_PRODUCT_GLOBESPAN_PRISM_GT_2, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_GOHUBS, USB_PRODUCT_GOHUBS_GOCOM232, 
	    11158, 7072, 10153, 0,
	    USB_VENDOR_GOODWAY, USB_PRODUCT_GOODWAY_GWUSB2E, 
	    11167, 0,
	    USB_VENDOR_GOODWAY, USB_PRODUCT_GOODWAY_RT2573, 
	    5343, 0,
	    USB_VENDOR_GRAVIS, USB_PRODUCT_GRAVIS_GAMEPADPRO, 
	    11175, 5077, 0,
	    USB_VENDOR_GREENHOUSE, USB_PRODUCT_GREENHOUSE_KANA21, 
	    11183, 5152, 8247, 8809, 11193, 0,
	    USB_VENDOR_GRETAGMACBETH, USB_PRODUCT_GRETAGMACBETH_HUEY, 
	    11200, 0,
	    USB_VENDOR_GRIFFIN, USB_PRODUCT_GRIFFIN_IMATE, 
	    11205, 11212, 5018, 0,
	    USB_VENDOR_GRIFFIN, USB_PRODUCT_GRIFFIN_POWERMATE, 
	    11216, 11226, 5961, 0,
	    USB_VENDOR_GUDE, USB_PRODUCT_GUDE_DCF, 
	    11237, 11243, 4979, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_DALEADER, 
	    11254, 11257, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUSB254, 
	    11264, 5386, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUSB254LB, 
	    11275, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUSB254V2AP, 
	    11289, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWNU300, 
	    11305, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWNUM300, 
	    11314, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWGUN54, 
	    11324, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_HWNUP150, 
	    11333, 0,
	    USB_VENDOR_GUILLEMOT, USB_PRODUCT_GUILLEMOT_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_HAGIWARA, USB_PRODUCT_HAGIWARA_FGSM, 
	    11343, 11353, 5873, 5954, 0,
	    USB_VENDOR_HAGIWARA, USB_PRODUCT_HAGIWARA_FGCF, 
	    11343, 11005, 5873, 5954, 0,
	    USB_VENDOR_HAGIWARA, USB_PRODUCT_HAGIWARA_FG, 
	    11343, 0,
	    USB_VENDOR_HAILUCK, USB_PRODUCT_HAILUCK_KEYBOARD, 
	    6013, 0,
	    USB_VENDOR_HAL, USB_PRODUCT_HAL_IMR001, 
	    11364, 11377, 11380, 0,
	    USB_VENDOR_HANDSPRING, USB_PRODUCT_HANDSPRING_VISOR, 
	    2723, 11390, 0,
	    USB_VENDOR_HANDSPRING, USB_PRODUCT_HANDSPRING_TREO, 
	    2723, 11396, 0,
	    USB_VENDOR_HANDSPRING, USB_PRODUCT_HANDSPRING_TREO600, 
	    2723, 11396, 6104, 0,
	    USB_VENDOR_HANK, USB_PRODUCT_HANK_HP5187, 
	    9387, 651, 11401, 0,
	    USB_VENDOR_HAUPPAUGE, USB_PRODUCT_HAUPPAUGE_WINTV_USB_FM, 
	    11416, 4979, 8895, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_USB2_FM, 
	    11416, 8918, 8895, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_NOVAT_7700M, 
	    11416, 11422, 6961, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_NOVAT_7700PC, 
	    11416, 11422, 6961, 0,
	    USB_VENDOR_HAUPPAUGE2, USB_PRODUCT_HAUPPAUGE2_WINTV_NOVAT_7070P, 
	    11416, 11422, 6961, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_HWUN2, 
	    11429, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT3070, 
	    5179, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_4, 
	    5172, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RT2870_5, 
	    5172, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_RTL8192CU_2, 
	    5293, 0,
	    USB_VENDOR_HAWKING, USB_PRODUCT_HAWKING_UF100, 
	    6790, 4979, 5009, 0,
	    USB_VENDOR_HITACHI, USB_PRODUCT_HITACHI_DZMV100A, 
	    11435, 11443, 11453, 0,
	    USB_VENDOR_HITACHI, USB_PRODUCT_HITACHI_DVDCAM_USB, 
	    11463, 4979, 11470, 8908, 0,
	    USB_VENDOR_HOLTEK, USB_PRODUCT_HOLTEK_MOP35, 
	    11473, 0,
	    USB_VENDOR_HOSIDEN, USB_PRODUCT_HOSIDEN_PPP, 
	    11480, 5961, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_895C, 
	    11497, 11505, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4100C, 
	    11510, 11518, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_S20, 
	    11524, 8106, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_880C, 
	    11497, 11535, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4200C, 
	    11540, 11548, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_CDWRITERPLUS, 
	    11554, 11564, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_KBDHUB, 
	    4006, 6013, 5917, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_HN210W, 
	    11569, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_6200C, 
	    11540, 11576, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_S20b, 
	    11582, 8106, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_815C, 
	    11497, 11593, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_3300C, 
	    11540, 11598, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_CDW8200, 
	    11554, 11564, 11604, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_1220C, 
	    11497, 11610, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_810C, 
	    11497, 11616, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4300C, 
	    11510, 11626, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_CD4E, 
	    11632, 11643, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_G85XI, 
	    11649, 11659, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_1200, 
	    11665, 11674, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_5200C, 
	    11510, 11679, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_830C, 
	    11497, 11685, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_3400CSE, 
	    11540, 11690, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_885C, 
	    11497, 11698, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_6300C, 
	    11510, 11703, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_840C, 
	    11497, 11709, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_2200C, 
	    11540, 11714, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_5300C, 
	    11510, 11720, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4400C, 
	    11510, 11726, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_816C, 
	    11497, 11732, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_2300D, 
	    11737, 11746, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_970CSE, 
	    11752, 11760, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_5400C, 
	    11510, 11767, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_2215, 
	    8479, 11773, 11786, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_959C, 
	    11752, 11790, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_568J, 
	    11795, 11803, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_930C, 
	    11497, 11807, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_P2000U, 
	    11812, 11819, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_RNDIS, 
	    11827, 11835, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_640C, 
	    11497, 11841, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_LP2275W, 
	    11846, 7177, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_LP2475W, 
	    11854, 7177, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_4670V, 
	    11540, 11862, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_P1100, 
	    11524, 11868, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_V125W, 
	    11874, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_6127, 
	    11752, 11880, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_UN2430, 
	    4017, 11885, 11892, 11901, 0,
	    USB_VENDOR_HP, USB_PRODUCT_HP_HN210E, 
	    5009, 11908, 0,
	    USB_VENDOR_HP3, USB_PRODUCT_HP3_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_HP2, USB_PRODUCT_HP2_C500, 
	    11582, 11915, 0,
	    USB_VENDOR_HTC, USB_PRODUCT_HTC_ANDROID, 
	    11920, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_MOBILE, 
	    4102, 7429, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E220, 
	    4102, 11928, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_U8150, 
	    4102, 11933, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_EM770W, 
	    4102, 11939, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E1750, 
	    4102, 11946, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E182, 
	    4102, 11952, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E353, 
	    4102, 11957, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E1750INIT, 
	    4102, 11946, 4979, 11962, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_K3765, 
	    4102, 11965, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E1820, 
	    4102, 11971, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_HWD12_RNDIS, 
	    4102, 11977, 11835, 11983, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E171INIT, 
	    4102, 11988, 4979, 11962, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E392INIT, 
	    4102, 11993, 11998, 12004, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E171, 
	    4102, 11988, 687, 11977, 12014, 11983, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E353_HiLink, 
	    4102, 12018, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_K3765INIT, 
	    4102, 11965, 4979, 11962, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E3272, 
	    4102, 12030, 12036, 687, 12041, 12050, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_E353INIT, 
	    4102, 11957, 4979, 11962, 0,
	    USB_VENDOR_HUAWEI, USB_PRODUCT_HUAWEI_HWD12_INSTALLER, 
	    4102, 11977, 12004, 0,
	    USB_VENDOR_HUAWEI3COM, USB_PRODUCT_HUAWEI3COM_RT2573, 
	    5343, 0,
	    USB_VENDOR_HYUNDAI, USB_PRODUCT_HYUNDAI_PC5740, 
	    12056, 12063, 0,
	    USB_VENDOR_HYUNDAI, USB_PRODUCT_HYUNDAI_UM175, 
	    12068, 12063, 0,
	    USB_VENDOR_IBM, USB_PRODUCT_IBM_OPTTRAVELMOUSE, 
	    3388, 0,
	    USB_VENDOR_IBM, USB_PRODUCT_IBM_USBCDROMDRIVE, 
	    4979, 9769, 3665, 0,
	    USB_VENDOR_IIYAMA, USB_PRODUCT_IIYAMA_HUB, 
	    5917, 0,
	    USB_VENDOR_IMATION, USB_PRODUCT_IMATION_FLASHGO, 
	    5948, 12074, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4, 
	    12078, 10667, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_HUBPORT7, 
	    12089, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_RAPIDPORT4, 
	    12099, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4T, 
	    12111, 10667, 10240, 12122, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT2, 
	    12129, 10667, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4I, 
	    12111, 12140, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT2I, 
	    12129, 12146, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_HUBPORT4, 
	    12158, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8HAND, 
	    12168, 12179, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_MULTIMODEM, 
	    2214, 12190, 12198, 12201, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORTPPORT, 
	    12206, 7048, 7242, 12221, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT421, 
	    12230, 12243, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT21, 
	    12262, 12274, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8DC, 
	    12289, 12179, 12293, 12296, 12302, 5667, 12305, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8, 
	    12179, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT2DIN, 
	    12129, 10667, 687, 1642, 12310, 10166, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT4DIN, 
	    12111, 10667, 687, 1642, 12310, 10166, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT16DC, 
	    12289, 12314, 12293, 12326, 12302, 5667, 12332, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORTCOMP, 
	    12338, 12347, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_EDGEPORT8I, 
	    12179, 12140, 0,
	    USB_VENDOR_INSIDEOUT, USB_PRODUCT_INSIDEOUT_MT4X56USB, 
	    12358, 10889, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_F5U002, 
	    7048, 7057, 5018, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ATAPI, 
	    12362, 5018, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_IDEUSB2, 
	    8918, 9846, 4993, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ISD110, 
	    12368, 5018, 12372, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ISD105, 
	    12368, 5018, 12379, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_DRIVEV2, 
	    8247, 4979, 12386, 9974, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_DRIVEV2_5, 
	    8247, 4979, 12386, 9974, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_USBCABLE, 
	    4979, 6082, 0,
	    USB_VENDOR_INSYSTEM, USB_PRODUCT_INSYSTEM_ADAPTERV2, 
	    4979, 9846, 4993, 9974, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_EASYPC_CAMERA, 
	    12396, 5870, 3016, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_AP310, 
	    12401, 12407, 7517, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_I2011B, 
	    651, 12416, 0,
	    USB_VENDOR_INTEL, USB_PRODUCT_INTEL_TESTBOARD, 
	    12422, 12428, 9871, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH2, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_GPBT54, 
	    12447, 12452, 4983, 12457, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH3, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH4, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH5, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH6, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH7, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_RMH8, 
	    12433, 12438, 5917, 0,
	    USB_VENDOR_INTEL2, USB_PRODUCT_INTEL2_N_6235_BT, 
	    12461, 12472, 12477, 4983, 0,
	    USB_VENDOR_INTERSIL, USB_PRODUCT_INTERSIL_PRISM_GT, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_INTERSIL, USB_PRODUCT_INTERSIL_PRISM_2X, 
	    12483, 5386, 0,
	    USB_VENDOR_INTREPIDCS, USB_PRODUCT_INTREPIDCS_VALUECAN, 
	    12492, 0,
	    USB_VENDOR_INTREPIDCS, USB_PRODUCT_INTREPIDCS_NEOVI, 
	    12501, 12507, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_IU_CD2, 
	    10480, 12512, 12523, 12528, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_DVR_UEH8, 
	    10480, 12512, 12523, 12535, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBSSMRW, 
	    12544, 12554, 5018, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBSDRW, 
	    12562, 12554, 5018, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBETT, 
	    4979, 12571, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBETTX, 
	    4979, 12576, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBETTXS, 
	    4979, 12582, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNB11A, 
	    4979, 12590, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNB11, 
	    4979, 12597, 12590, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNG54US, 
	    4979, 12605, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBWNG54US_NF, 
	    4979, 12605, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_ETXUS2, 
	    12615, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_ETGUS2, 
	    12623, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_FT232R, 
	    12631, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_WNGDNUS2, 
	    12638, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_1, 
	    5193, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_2, 
	    5193, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_3, 
	    5193, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RT3072_4, 
	    5193, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_WNG150UM, 
	    12649, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBRSAQ, 
	    4979, 10100, 5018, 12659, 0,
	    USB_VENDOR_IODATA, USB_PRODUCT_IODATA_USBRSAQ5, 
	    4979, 10100, 5018, 12669, 0,
	    USB_VENDOR_IODATA2, USB_PRODUCT_IODATA2_USB2SC, 
	    12679, 1867, 12691, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_ZIP100, 
	    12699, 12703, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_ZIP250, 
	    12699, 6078, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_ZIP250_2, 
	    12699, 6078, 0,
	    USB_VENDOR_IOMEGA, USB_PRODUCT_IOMEGA_CDRW, 
	    12707, 12712, 0,
	    USB_VENDOR_IRIVER, USB_PRODUCT_IRIVER_IFP_1XX, 
	    12717, 0,
	    USB_VENDOR_IRIVER, USB_PRODUCT_IRIVER_IFP_3XX, 
	    12725, 0,
	    USB_VENDOR_IRIVER, USB_PRODUCT_IRIVER_IFP_5XX, 
	    12733, 0,
	    USB_VENDOR_JABLOTRON, USB_PRODUCT_JABLOTRON_PC60B, 
	    12741, 0,
	    USB_VENDOR_JATON, USB_PRODUCT_JATON_EDA, 
	    5009, 8256, 4993, 0,
	    USB_VENDOR_JENOPTIK, USB_PRODUCT_JENOPTIK_JD350, 
	    12748, 9051, 12751, 8813, 0,
	    USB_VENDOR_JMICRON, USB_PRODUCT_JMICRON_JM20329, 
	    4979, 5759, 5544, 1867, 0,
	    USB_VENDOR_JMICRON, USB_PRODUCT_JMICRON_JM20336, 
	    4979, 5759, 6888, 1867, 0,
	    USB_VENDOR_JMICRON, USB_PRODUCT_JMICRON_JM20337, 
	    4979, 5759, 5544, 1867, 0,
	    USB_VENDOR_JRC, USB_PRODUCT_JRC_AH_J3001V_J3002V, 
	    12762, 12773, 0,
	    USB_VENDOR_JVC, USB_PRODUCT_JVC_GR_DX95, 
	    12790, 0,
	    USB_VENDOR_JVC, USB_PRODUCT_JVC_MP_PRX1, 
	    12798, 5009, 0,
	    USB_VENDOR_JVC, USB_PRODUCT_JVC_MP_XP7250_WL, 
	    12806, 12816, 5386, 0,
	    USB_VENDOR_KLSI, USB_PRODUCT_KLSI_DUH3E10BT, 
	    12824, 5009, 12829, 6572, 12838, 12842, 0,
	    USB_VENDOR_KLSI, USB_PRODUCT_KLSI_DUH3E10BTN, 
	    12824, 5009, 12829, 6572, 12838, 12842, 0,
	    USB_VENDOR_KAWATSU, USB_PRODUCT_KAWATSU_MH4000P, 
	    12849, 12857, 0,
	    USB_VENDOR_KAWATSU, USB_PRODUCT_KAWATSU_KC180, 
	    12863, 10430, 0,
	    USB_VENDOR_KEISOKUGIKEN, USB_PRODUCT_KEISOKUGIKEN_USBDAQ, 
	    12870, 12879, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_ORBIT, 
	    12886, 12892, 12900, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_TURBOBALL, 
	    12910, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_ORBIT_MAC, 
	    12886, 4979, 12900, 10240, 10244, 0,
	    USB_VENDOR_KENSINGTON, USB_PRODUCT_KENSINGTON_VIDEOCAM_VGA, 
	    12920, 12929, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28_NF, 
	    12933, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28X_NF, 
	    12940, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19_NF, 
	    12948, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18_NF, 
	    12955, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18X_NF, 
	    12962, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19W_NF, 
	    12970, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19, 
	    12948, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19W, 
	    12970, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA49W_NF, 
	    12978, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA49W, 
	    12978, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QI_NF, 
	    12986, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QI, 
	    12986, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19Q_NF, 
	    12995, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19Q, 
	    12995, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28, 
	    12933, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XXB, 
	    13003, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18, 
	    12955, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18X, 
	    12962, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XB_NF, 
	    13014, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XA_NF, 
	    13014, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA28XA, 
	    13023, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18XA_NF, 
	    13032, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA18XA, 
	    13032, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QW_NF, 
	    13041, 10100, 5018, 7982, 7986, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19QW, 
	    13041, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_USA19H, 
	    13050, 10100, 5018, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_UIA10, 
	    13058, 13065, 13072, 0,
	    USB_VENDOR_KEYSPAN, USB_PRODUCT_KEYSPAN_UIA11, 
	    13080, 13065, 13072, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_XX1, 
	    5009, 4993, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_KNU101TX, 
	    13087, 4979, 5009, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT102_G2, 
	    13096, 13099, 13103, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT101_II, 
	    13096, 13106, 7517, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DTMINI10, 
	    13096, 6644, 13110, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT101_G2, 
	    13096, 13106, 13103, 0,
	    USB_VENDOR_KINGSTON, USB_PRODUCT_KINGSTON_DT100_G2, 
	    13096, 12703, 13103, 0,
	    USB_VENDOR_KINGSUN, USB_PRODUCT_KINGSUN_IRDA, 
	    13113, 10430, 0,
	    USB_VENDOR_KORG, USB_PRODUCT_KORG_MINILOGUE_XD, 
	    13130, 13140, 0,
	    USB_VENDOR_KORG, USB_PRODUCT_KORG_MICROKORG_XL, 
	    13143, 13153, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC220, 
	    2316, 13156, 13164, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC260, 
	    2316, 13156, 13170, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC265, 
	    2316, 13156, 13176, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC290, 
	    2316, 13156, 13182, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC240, 
	    2316, 13156, 13188, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DC280, 
	    2316, 13156, 13194, 0,
	    USB_VENDOR_KODAK, USB_PRODUCT_KODAK_DX4900, 
	    13200, 13210, 0,
	    USB_VENDOR_KONICA, USB_PRODUCT_KONICA_CAMERA, 
	    2316, 13217, 3016, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_NICHE, 
	    13223, 6497, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_NETSCROLL, 
	    13229, 13236, 6497, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_G07, 
	    13246, 13254, 13259, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_FLIGHT2000, 
	    8362, 13267, 13272, 0,
	    USB_VENDOR_KYE, USB_PRODUCT_KYE_VIVIDPRO, 
	    13281, 13291, 7373, 0,
	    USB_VENDOR_KYOCERA, USB_PRODUCT_KYOCERA_AHK3001V, 
	    13301, 0,
	    USB_VENDOR_LACIE, USB_PRODUCT_LACIE_PKTDRV, 
	    13311, 0,
	    USB_VENDOR_LACIE, USB_PRODUCT_LACIE_HD, 
	    13323, 13328, 0,
	    USB_VENDOR_LACIE, USB_PRODUCT_LACIE_CDRW, 
	    11962, 13333, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_AX88179, 
	    6822, 4979, 6830, 6805, 5229, 6188, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_COMPACTKBDWTP, 
	    13337, 13346, 4979, 8270, 5152, 13354, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_ETHERNET, 
	    4979, 5421, 5009, 0,
	    USB_VENDOR_LEXAR, USB_PRODUCT_LEXAR_JUMPSHOT, 
	    13365, 11005, 5954, 0,
	    USB_VENDOR_LEXAR, USB_PRODUCT_LEXAR_2662WAR, 
	    13374, 0,
	    USB_VENDOR_LEXAR, USB_PRODUCT_LEXAR_MCR, 
	    13383, 5954, 0,
	    USB_VENDOR_LEXMARK, USB_PRODUCT_LEXMARK_S2450, 
	    13394, 13400, 13402, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_CDMA_MSM, 
	    5865, 799, 13407, 13411, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L05A_MODEM, 
	    6151, 13417, 13424, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L05A_STORAGE, 
	    6151, 13417, 13424, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L02C_MODEM, 
	    6151, 13417, 13430, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_NTT_DOCOMO_L02C_STORAGE, 
	    6151, 13417, 13430, 0,
	    USB_VENDOR_LG, USB_PRODUCT_LG_MSM_HSDPA, 
	    9068, 13407, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_MAUSB2, 
	    13436, 13444, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10TX1, 
	    13452, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_HG20F9, 
	    13460, 5009, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10T, 
	    13467, 5009, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB100TX, 
	    13474, 5009, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB100H1, 
	    13483, 13492, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10TA, 
	    13506, 5009, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_WUSB11, 
	    13514, 651, 4979, 3442, 4993, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_WUSB11_25, 
	    13514, 651, 4979, 3442, 4993, 6933, 13521, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_WUSB12_11, 
	    13526, 5616, 13533, 0,
	    USB_VENDOR_LINKSYS, USB_PRODUCT_LINKSYS_USB10TX2, 
	    13452, 0,
	    USB_VENDOR_LINKSYS2, USB_PRODUCT_LINKSYS2_WUSB11, 
	    13514, 0,
	    USB_VENDOR_LINKSYS2, USB_PRODUCT_LINKSYS2_NWU11B, 
	    3442, 13538, 13549, 0,
	    USB_VENDOR_LINKSYS2, USB_PRODUCT_LINKSYS2_USB200M, 
	    4979, 5421, 6790, 5229, 6188, 0,
	    USB_VENDOR_LINKSYS3, USB_PRODUCT_LINKSYS3_WUSB11V28, 
	    13556, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_USB1000, 
	    13567, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB100, 
	    13575, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB600N, 
	    13583, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB54GC_2, 
	    8432, 7660, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB54GC_3, 
	    8432, 7649, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_RT3070, 
	    5179, 0,
	    USB_VENDOR_LINKSYS4, USB_PRODUCT_LINKSYS4_WUSB600NV2, 
	    13583, 7660, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_ROOT_HUB_11, 
	    13592, 13596, 7177, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_ROOT_HUB_20, 
	    5421, 13596, 7177, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_ROOT_HUB_30, 
	    6830, 13596, 7177, 0,
	    USB_VENDOR_LINUXFOUNDATION, USB_PRODUCT_LINUXFOUNDATION_USB3DEBUG, 
	    4979, 6830, 13601, 7242, 0,
	    USB_VENDOR_LITEON, USB_PRODUCT_LITEON_AR9271, 
	    7125, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LDR_H443SU2, 
	    10480, 12512, 12523, 13607, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LDR_H443U2, 
	    10480, 12512, 12523, 13619, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LAN_GTJU2, 
	    13630, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LANTX, 
	    13641, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RTL8187, 
	    9162, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LANW300NU2, 
	    13648, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_RT3020, 
	    13661, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LANW300NU2S, 
	    13668, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LAN_W450ANU2E, 
	    13682, 0,
	    USB_VENDOR_LOGITEC, USB_PRODUCT_LOGITEC_LAN_W300ANU2, 
	    13696, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_M2452, 
	    13710, 8270, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_M4848, 
	    13716, 6497, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_PAGESCAN, 
	    13722, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMWEB, 
	    8590, 13731, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO, 
	    8590, 5077, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMEXP, 
	    8590, 13735, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAM, 
	    8590, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMEXP2, 
	    8590, 13735, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO3k, 
	    8590, 5077, 13743, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRONB, 
	    8590, 10240, 8836, 5077, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO4K, 
	    8590, 5077, 13748, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMMESS, 
	    8590, 13753, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_N43, 
	    13763, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_N48, 
	    13767, 6497, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MBA47, 
	    13771, 6497, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMMOUSE, 
	    13778, 13786, 6510, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_BD58, 
	    13793, 6497, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_USBPS2MOUSE, 
	    13798, 3388, 6510, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MUV55A, 
	    13807, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_UN58A, 
	    13815, 6510, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_B100_1, 
	    13821, 3388, 6510, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_B100_2, 
	    13821, 3388, 6510, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMPAD, 
	    13778, 11175, 13826, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMRPAD, 
	    13778, 13834, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMJOY, 
	    13778, 13844, 13272, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_WMFFGP, 
	    13778, 13850, 13844, 13858, 13861, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_BB13, 
	    13798, 13872, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_BB18, 
	    13882, 13891, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MARBLEMOUSE, 
	    13897, 6510, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_RK53, 
	    13904, 6497, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_RB6, 
	    13904, 8270, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_CDO, 
	    13904, 13913, 3388, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_MX700, 
	    13904, 13921, 6497, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_CBT44, 
	    13929, 13936, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_QUICKCAMPRO2, 
	    8590, 5077, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_GF310, 
	    13945, 13953, 0,
	    USB_VENDOR_LOGITECH, USB_PRODUCT_LOGITECH_DAG, 
	    13958, 2760, 13945, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_WM66, 
	    4547, 13963, 9068, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_D21LCMASS, 
	    13968, 13976, 10869, 13982, 11983, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_D21LC, 
	    13968, 13976, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_XSSTICK_W14, 
	    6612, 228, 13987, 13995, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_XSSTICK_P14, 
	    6612, 228, 13987, 13999, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_510FU, 
	    14003, 14013, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_510FUMASS, 
	    14003, 14013, 10869, 13982, 11983, 0,
	    USB_VENDOR_LONGCHEER, USB_PRODUCT_LONGCHEER_XSSTICK_P14_INSTALLER, 
	    6612, 228, 13987, 13999, 14019, 14021, 14029, 0,
	    USB_VENDOR_LUCENT, USB_PRODUCT_LUCENT_EVALKIT, 
	    14036, 14044, 14055, 0,
	    USB_VENDOR_LUWEN, USB_PRODUCT_LUWEN_EASYDISK, 
	    14059, 0,
	    USB_VENDOR_MACALLY, USB_PRODUCT_MACALLY_MOUSE1, 
	    6497, 0,
	    USB_VENDOR_MADCATZ, USB_PRODUCT_MADCATZ_CYBORG_RAT7, 
	    14068, 14075, 7865, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_HUB0100, 
	    5917, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_DU_H3SP_USB232, 
	    2633, 14082, 4979, 14090, 5917, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_USB232, 
	    14094, 8908, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_SITECOM_USB232, 
	    3723, 14094, 2081, 0,
	    USB_VENDOR_MCT, USB_PRODUCT_MCT_ML_4500, 
	    14102, 0,
	    USB_VENDOR_MEDIAGEAR, USB_PRODUCT_MEDIAGEAR_READER9IN1, 
	    5281, 14110, 6572, 5667, 5954, 0,
	    USB_VENDOR_WAYTECH, USB_PRODUCT_WAYTECH_USB2SERIAL, 
	    4979, 5759, 7072, 0,
	    USB_VENDOR_MEINBERG, USB_PRODUCT_MEINBERG_USB5131, 
	    4979, 14112, 14117, 14019, 3377, 14123, 0,
	    USB_VENDOR_MEIZU, USB_PRODUCT_MEIZU_M6_SL, 
	    14129, 14140, 14143, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUATX1, 
	    14148, 5009, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUATX5, 
	    14148, 5009, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUA2TX5, 
	    14155, 5009, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUAKTX, 
	    14163, 5009, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_S11, 
	    14171, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_MCRSM2, 
	    14183, 11353, 5873, 14191, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_DUBPXXG, 
	    11018, 14205, 14213, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KS11G, 
	    14222, 14236, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUAU2KTX, 
	    14245, 5009, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KB11, 
	    14256, 5386, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54YB, 
	    14269, 5386, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54, 
	    14284, 5386, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54AI, 
	    14296, 5386, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_LUAU2GT, 
	    14311, 5009, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_NINWIFI, 
	    1512, 14321, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_PCOPRS1, 
	    14327, 14341, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_SG54HP, 
	    14351, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_G54HP, 
	    14365, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_KG54L, 
	    14378, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCG300N, 
	    14391, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_SG54HG, 
	    14404, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCAG300N, 
	    14418, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCG, 
	    14432, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGNHP, 
	    14441, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGN, 
	    14453, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCG301N, 
	    14463, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_CEWL_1, 
	    1337, 14476, 5386, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGNM, 
	    14486, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WLIUCGNM2T, 
	    14497, 0,
	    USB_VENDOR_MELCO, USB_PRODUCT_MELCO_WIU2300D, 
	    14510, 0,
	    USB_VENDOR_MERCUSYS, USB_PRODUCT_MERCUSYS_MW150USV2, 
	    14521, 9974, 0,
	    USB_VENDOR_MERLIN, USB_PRODUCT_MERLIN_V620, 
	    4211, 14529, 0,
	    USB_VENDOR_METRICOM, USB_PRODUCT_METRICOM_RICOCHET_GS, 
	    14534, 14543, 0,
	    USB_VENDOR_MGE, USB_PRODUCT_MGE_UPS1, 
	    476, 480, 14546, 14554, 5667, 0,
	    USB_VENDOR_MGE, USB_PRODUCT_MGE_UPS2, 
	    476, 480, 14546, 14554, 6640, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_WLAN, 
	    5386, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_BLUETOOTH, 
	    4983, 4979, 4993, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_8, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_9, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MEGASKY580, 
	    14571, 14575, 6961, 4993, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MEGASKY580_55801, 
	    14571, 14575, 6961, 4993, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MS6861, 
	    14583, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MS6865, 
	    14591, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_MS6869, 
	    14599, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573, 
	    5343, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573_2, 
	    5343, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_4, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_5, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_10, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_12, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_13, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_6, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_11, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_14, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_15, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT3070_7, 
	    5179, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573_3, 
	    5343, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_RT2573_4, 
	    5343, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_AX88772A, 
	    6842, 4979, 5421, 6790, 5009, 5018, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_BLUETOOTH_2, 
	    4983, 0,
	    USB_VENDOR_MSI, USB_PRODUCT_MSI_BLUETOOTH_3, 
	    4983, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_PICKIT1, 
	    14607, 5667, 14618, 14624, 14632, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_PICKIT2, 
	    14636, 6640, 14643, 14659, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_PICKIT3, 
	    14636, 6642, 14643, 14659, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_MCP2221, 
	    4979, 5759, 14670, 8219, 7491, 0,
	    USB_VENDOR_MICROCHIP, USB_PRODUCT_MICROCHIP_MCP2210, 
	    4979, 5759, 14679, 8219, 7491, 0,
	    USB_VENDOR_MICRODIA, USB_PRODUCT_MICRODIA_YUREX, 
	    14683, 0,
	    USB_VENDOR_MICRONET, USB_PRODUCT_MICRONET_SP128AR, 
	    14689, 14697, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_SIDEPREC, 
	    14707, 14718, 5077, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INTELLIMOUSE, 
	    14728, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_NATURALKBD, 
	    14741, 6013, 14749, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_DDS80, 
	    2316, 8849, 2833, 14755, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_SIDEWINDER, 
	    14758, 14718, 14769, 13891, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INETPRO, 
	    14776, 6013, 5077, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_TBEXPLORER, 
	    13872, 14785, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INTELLIEYE, 
	    14794, 6497, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_INETPRO2, 
	    14776, 6013, 5077, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_MN510, 
	    14805, 651, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_MN110, 
	    6790, 4979, 14811, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_NATURAL_6000, 
	    651, 14815, 6510, 14821, 13936, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_MEMORY_UNIT, 
	    14826, 14831, 14838, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_DVD_PLAYBACK, 
	    14826, 10480, 14843, 14849, 14632, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_CONTROLLER_S10, 
	    14826, 5961, 13400, 14858, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_CONTROLLER_HUB, 
	    14826, 5961, 5917, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_CONTROLLER_S12, 
	    14826, 5961, 13400, 14864, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_360_CONTROLLER, 
	    14826, 14870, 5961, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_XBOX_360_WIRELESS_RECEIVER, 
	    14826, 14870, 651, 13936, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR10, 
	    14874, 14881, 14893, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR20, 
	    14874, 14881, 14898, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR70, 
	    14874, 14881, 14903, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR80, 
	    14874, 14881, 14908, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_24GHZ_XCVR90, 
	    14874, 14881, 14913, 0,
	    USB_VENDOR_MICROSOFT, USB_PRODUCT_MICROSOFT_CM6000, 
	    14918, 6510, 14821, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_SCSIDB25, 
	    14926, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_SCSIHD50, 
	    14940, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_DPCM, 
	    4979, 14954, 0,
	    USB_VENDOR_MICROTECH, USB_PRODUCT_MICROTECH_FREECOM, 
	    2494, 11018, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_336CX, 
	    14965, 14973, 14019, 14979, 7373, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_X6U, 
	    14982, 14992, 14019, 14995, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_C6, 
	    14965, 14999, 7373, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_336CX2, 
	    14965, 14973, 14019, 14979, 7373, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_V6USL, 
	    14982, 15002, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_6000, 
	    14982, 14821, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_V6USL2, 
	    14982, 15002, 0,
	    USB_VENDOR_MICROTEK, USB_PRODUCT_MICROTEK_V6UL, 
	    14982, 15008, 0,
	    USB_VENDOR_MIDIMAN, USB_PRODUCT_MIDIMAN_MIDISPORT2X2, 
	    15013, 15023, 0,
	    USB_VENDOR_MIDIMAN, USB_PRODUCT_MIDIMAN_MIDISPORT2X4, 
	    15013, 15027, 0,
	    USB_VENDOR_MINDSATWORK, USB_PRODUCT_MINDSATWORK_DW, 
	    2316, 15031, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_2300, 
	    15038, 15045, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_S304, 
	    15038, 15050, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_X, 
	    15038, 3963, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_DIMAGE7I, 
	    15038, 15055, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_5400, 
	    15038, 15058, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_DIMAGEA1, 
	    15038, 9801, 0,
	    USB_VENDOR_MINOLTA, USB_PRODUCT_MINOLTA_XT, 
	    15038, 15063, 0,
	    USB_VENDOR_MISC, USB_PRODUCT_MISC_WISPY_24X, 
	    15066, 15075, 15082, 0,
	    USB_VENDOR_MISC, USB_PRODUCT_MISC_TELLSTICK, 
	    15087, 15095, 0,
	    USB_VENDOR_MISC, USB_PRODUCT_MISC_TELLSTICK_DUO, 
	    15087, 15095, 15105, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_CDRRW, 
	    15109, 3665, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_MOUSE, 
	    6510, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_SONY_MOUSE, 
	    15117, 15123, 6510, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_BT_DONGLE, 
	    4983, 4979, 15130, 0,
	    USB_VENDOR_MITSUMI, USB_PRODUCT_MITSUMI_FDD, 
	    15137, 0,
	    USB_VENDOR_MOBILITY, USB_PRODUCT_MOBILITY_EA, 
	    5009, 4993, 0,
	    USB_VENDOR_MOBILITY, USB_PRODUCT_MOBILITY_EASIDOCK, 
	    15141, 5009, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7703, 
	    15150, 4979, 7072, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7720, 
	    15158, 4979, 7072, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7730, 
	    15166, 5009, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7780, 
	    15174, 5215, 10430, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7781, 
	    15182, 5215, 10430, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7784, 
	    15190, 15198, 10430, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7810, 
	    15203, 4979, 7072, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7820, 
	    15211, 4979, 7072, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7830, 
	    15219, 5009, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7832, 
	    15227, 5009, 4993, 0,
	    USB_VENDOR_MOSCHIP, USB_PRODUCT_MOSCHIP_MCS7840, 
	    15235, 4979, 7072, 4993, 0,
	    USB_VENDOR_MOTOROLA, USB_PRODUCT_MOTOROLA_MC141555, 
	    15243, 7177, 6188, 0,
	    USB_VENDOR_MOTOROLA, USB_PRODUCT_MOTOROLA_SB4100, 
	    15252, 4979, 2658, 5114, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_T720C, 
	    15259, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_A920, 
	    15265, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_USBLAN, 
	    15270, 15277, 15284, 15290, 0,
	    USB_VENDOR_MOTOROLA2, USB_PRODUCT_MOTOROLA2_USBLAN2, 
	    15270, 15295, 15302, 15309, 15314, 15309, 15318, 15290, 0,
	    USB_VENDOR_MOTOROLA4, USB_PRODUCT_MOTOROLA4_RT2770, 
	    5165, 0,
	    USB_VENDOR_MOTOROLA4, USB_PRODUCT_MOTOROLA4_RT3070, 
	    5179, 0,
	    USB_VENDOR_MSYSTEMS, USB_PRODUCT_MSYSTEMS_DISKONKEY, 
	    15322, 0,
	    USB_VENDOR_MSYSTEMS, USB_PRODUCT_MSYSTEMS_DISKONKEY2, 
	    15322, 0,
	    USB_VENDOR_MSYSTEMS, USB_PRODUCT_MSYSTEMS_DISKONKEY3, 
	    15322, 0,
	    USB_VENDOR_MULTITECH, USB_PRODUCT_MULTITECH_ATLAS, 
	    15332, 6088, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200CU, 
	    11674, 15346, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_600CU, 
	    6104, 15346, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200USB, 
	    11674, 4979, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200UB, 
	    11674, 15349, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200USBPLUS, 
	    11674, 4979, 11564, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_1200CUPLUS, 
	    11674, 15346, 11564, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_BEARPAW1200F, 
	    15352, 15360, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_BEARPAW1200TA, 
	    15352, 15366, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_600USB, 
	    6104, 4979, 7373, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_MDC800, 
	    15373, 15381, 5128, 0,
	    USB_VENDOR_MUSTEK, USB_PRODUCT_MUSTEK_DV2000, 
	    15389, 15381, 5128, 0,
	    USB_VENDOR_NI, USB_PRODUCT_NI_GPIB_USB_A, 
	    15396, 0,
	    USB_VENDOR_NI, USB_PRODUCT_NI_HTOH_7825, 
	    6649, 5759, 6649, 4993, 0,
	    USB_VENDOR_NATIONAL, USB_PRODUCT_NATIONAL_BEARPAW1200, 
	    15352, 11674, 0,
	    USB_VENDOR_NATIONAL, USB_PRODUCT_NATIONAL_BEARPAW2400, 
	    15352, 10356, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_HUB_20, 
	    5421, 7177, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_WL300NUG, 
	    15407, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_HUB, 
	    7177, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_HUB_B, 
	    7177, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY760, 
	    15417, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY900, 
	    15426, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY920, 
	    15435, 0,
	    USB_VENDOR_NEC, USB_PRODUCT_NEC_PICTY800, 
	    15444, 0,
	    USB_VENDOR_NEC2, USB_PRODUCT_NEC2_HUB2_0, 
	    5281, 5917, 5961, 0,
	    USB_VENDOR_NEODIO, USB_PRODUCT_NEODIO_ND3050, 
	    15453, 5948, 8256, 5961, 0,
	    USB_VENDOR_NEODIO, USB_PRODUCT_NEODIO_ND5010, 
	    15460, 5948, 5961, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_TURBOCONNECT, 
	    15473, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_CLIK40, 
	    15487, 15493, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_ETHERNETGADGET, 
	    4577, 15496, 15511, 12302, 15518, 0,
	    USB_VENDOR_NETCHIP, USB_PRODUCT_NETCHIP_NET2270, 
	    11018, 1867, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_EA101, 
	    5009, 5018, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_EA101X, 
	    5009, 5018, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_FA101, 
	    6790, 5009, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_FA120, 
	    4979, 5421, 5215, 5009, 4993, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_MA111NA, 
	    5616, 4993, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_MA111V2, 
	    5616, 9974, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111V2_2, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111V3, 
	    15533, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111U, 
	    15541, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111U_NF, 
	    15541, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WG111V2, 
	    15548, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_XA601, 
	    4979, 5759, 15556, 4993, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WN111V2, 
	    15559, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNDA3100, 
	    15567, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNDA3200, 
	    15576, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNA1100, 
	    15585, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNA1000, 
	    15593, 0,
	    USB_VENDOR_NETGEAR, USB_PRODUCT_NETGEAR_WNA1000M, 
	    15601, 0,
	    USB_VENDOR_NETGEAR2, USB_PRODUCT_NETGEAR2_MA101, 
	    15610, 0,
	    USB_VENDOR_NETGEAR2, USB_PRODUCT_NETGEAR2_MA101B, 
	    15610, 15616, 9635, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WG111T, 
	    15620, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WG111T_NF, 
	    15620, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WPN111, 
	    15627, 0,
	    USB_VENDOR_NETGEAR3, USB_PRODUCT_NETGEAR3_WPN111_NF, 
	    15627, 0,
	    USB_VENDOR_NETGEAR4, USB_PRODUCT_NETGEAR4_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_NETINDEX, USB_PRODUCT_NETINDEX_RTWJ02, 
	    15634, 0,
	    USB_VENDOR_NETINDEX, USB_PRODUCT_NETINDEX_UX312NC, 
	    15642, 0,
	    USB_VENDOR_NETINDEX, USB_PRODUCT_NETINDEX_WS002IN, 
	    15650, 15658, 15666, 0,
	    USB_VENDOR_NHJ, USB_PRODUCT_NHJ_CAM2, 
	    3016, 0,
	    USB_VENDOR_NIKON, USB_PRODUCT_NIKON_E990, 
	    2316, 3016, 15671, 0,
	    USB_VENDOR_NIKON, USB_PRODUCT_NIKON_E880, 
	    2316, 3016, 15676, 0,
	    USB_VENDOR_NIKON, USB_PRODUCT_NIKON_E885, 
	    2316, 3016, 15681, 0,
	    USB_VENDOR_NINTENDO, USB_PRODUCT_NINTENDO_BCM2045A, 
	    3414, 15686, 4983, 3377, 0,
	    USB_VENDOR_NINTENDO, USB_PRODUCT_NINTENDO_RVLCNT01, 
	    15695, 15699, 15706, 15717, 0,
	    USB_VENDOR_NINTENDO, USB_PRODUCT_NINTENDO_RVLCNT01TR, 
	    15695, 15699, 11564, 15726, 15717, 0,
	    USB_VENDOR_NOKIA, USB_PRODUCT_NOKIA_CA42, 
	    7429, 15740, 5018, 0,
	    USB_VENDOR_NOVATECH, USB_PRODUCT_NOVATECH_NV902W, 
	    15746, 0,
	    USB_VENDOR_NOVATECH, USB_PRODUCT_NOVATECH_RT2573, 
	    5343, 0,
	    USB_VENDOR_NOVATECH, USB_PRODUCT_NOVATECH_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_NOVATEL, USB_PRODUCT_NOVATEL_FLEXPACKGPS, 
	    15754, 15762, 9090, 11118, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_EXPRESSCARD, 
	    15771, 6615, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MERLINV620, 
	    3279, 651, 4211, 5865, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_V740, 
	    4211, 15783, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_S720, 
	    15788, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MERLINU740, 
	    3279, 4211, 15793, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U740_2, 
	    4211, 15793, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U870, 
	    4211, 15798, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_XU870, 
	    4211, 15803, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_X950D, 
	    4211, 15809, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_ES620, 
	    15815, 5865, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U720, 
	    15821, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_EU8X0D, 
	    15826, 15835, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U727, 
	    15856, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MC950D, 
	    3279, 651, 15861, 5114, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_MC950D_DRIVER, 
	    3279, 651, 15861, 5114, 14021, 15867, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U760_DRIVER, 
	    3279, 651, 15874, 15879, 15867, 0,
	    USB_VENDOR_NOVATEL2, USB_PRODUCT_NOVATEL2_U760, 
	    3279, 15891, 0,
	    USB_VENDOR_OLYMPUS, USB_PRODUCT_OLYMPUS_C1, 
	    15898, 2316, 3016, 0,
	    USB_VENDOR_OLYMPUS, USB_PRODUCT_OLYMPUS_C700, 
	    15902, 15908, 2683, 0,
	    USB_VENDOR_OMNIVISION, USB_PRODUCT_OMNIVISION_OV511, 
	    15914, 3016, 0,
	    USB_VENDOR_OMNIVISION, USB_PRODUCT_OMNIVISION_OV511PLUS, 
	    15920, 3016, 0,
	    USB_VENDOR_OMNIVISION2, USB_PRODUCT_OMNIVISION2_PSEYE, 
	    1337, 15927, 8581, 0,
	    USB_VENDOR_ONEPLUS, USB_PRODUCT_ONEPLUS_A5010, 
	    15942, 15950, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_MD2, 
	    15953, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_MDCFEB, 
	    15958, 4979, 15966, 5954, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_SIIGMS, 
	    14831, 15969, 14191, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_DATAFAB3, 
	    15978, 5954, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_DATAFAB4, 
	    15978, 5954, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_PNYCFSM, 
	    15992, 16004, 5954, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_STECHCFSM, 
	    16010, 16017, 16004, 5954, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_LC1, 
	    15966, 16030, 16032, 12477, 16035, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_UCF100, 
	    16041, 16051, 11005, 5954, 0,
	    USB_VENDOR_ONSPEC, USB_PRODUCT_ONSPEC_MD1II, 
	    16059, 16067, 16074, 5954, 0,
	    USB_VENDOR_ONSPEC2, USB_PRODUCT_ONSPEC2_8IN2, 
	    16082, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_MC3G, 
	    16087, 7429, 16096, 6615, 16104, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_QUADUMTS2, 
	    16113, 16126, 16133, 3231, 16138, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_QUADUMTS, 
	    16113, 16126, 16133, 3231, 16148, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_QUADPLUSUMTS, 
	    16113, 6615, 16133, 11564, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_HSDPA, 
	    16113, 9068, 5114, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GSICON72, 
	    16151, 16163, 16168, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON225, 
	    16163, 16172, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTMAXHSUPA, 
	    16113, 15861, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GEHSUPA, 
	    16113, 13735, 15861, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTHSUPA, 
	    16113, 15861, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GSHSUPA, 
	    16151, 15861, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X1, 
	    16176, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X2, 
	    16176, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X3, 
	    16176, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON401, 
	    16163, 16182, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTM382, 
	    16186, 16190, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GE40X4, 
	    16176, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_GTHSUPAM, 
	    16194, 15861, 5114, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICONEDGE, 
	    16163, 16207, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_MODHSXPA, 
	    11901, 16212, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON321, 
	    16163, 16218, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON322, 
	    16163, 16222, 0,
	    USB_VENDOR_OPTIONNV, USB_PRODUCT_OPTIONNV_ICON505, 
	    16163, 16226, 0,
	    USB_VENDOR_OQO, USB_PRODUCT_OQO_WIFI01, 
	    16230, 16236, 16239, 16244, 0,
	    USB_VENDOR_OQO, USB_PRODUCT_OQO_ETHER01PLUS, 
	    16230, 16254, 5009, 0,
	    USB_VENDOR_OQO, USB_PRODUCT_OQO_ETHER01, 
	    16230, 16236, 5009, 16244, 0,
	    USB_VENDOR_OTI, USB_PRODUCT_OTI_SOLID, 
	    1890, 16258, 15953, 0,
	    USB_VENDOR_OTI, USB_PRODUCT_OTI_FLASHDISK, 
	    5948, 13328, 16264, 0,
	    USB_VENDOR_OVISLINK, USB_PRODUCT_OVISLINK_RT3071, 
	    5186, 0,
	    USB_VENDOR_OVISLINK, USB_PRODUCT_OVISLINK_RT3072, 
	    5193, 0,
	    USB_VENDOR_SIGMACHIP, USB_PRODUCT_SIGMACHIP_USBMOUSE, 
	    4979, 6510, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_SERIAL, 
	    4979, 7072, 7479, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M500, 
	    2734, 16269, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M505, 
	    2734, 16274, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M515, 
	    2734, 16279, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_I705, 
	    2734, 16284, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_TUNGSTEN_Z, 
	    2734, 16289, 16298, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M125, 
	    2734, 16300, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_M130, 
	    2734, 16305, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_TUNGSTEN_T, 
	    2734, 16289, 16310, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_ZIRE31, 
	    2734, 16312, 16317, 0,
	    USB_VENDOR_PALM, USB_PRODUCT_PALM_ZIRE, 
	    2734, 16312, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_LS120, 
	    16320, 3016, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_KXLRW32AN, 
	    16327, 3665, 16332, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_KXLCB20AN, 
	    16327, 3665, 16343, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_KXLCB35AN, 
	    16354, 3174, 15109, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_SDCAAE, 
	    16362, 4993, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_N5HBZ0000055, 
	    651, 7487, 4979, 4993, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_DMCFS45, 
	    16377, 3016, 16383, 0,
	    USB_VENDOR_PANASONIC, USB_PRODUCT_PANASONIC_TYTP50P6S, 
	    16392, 16404, 5795, 9977, 0,
	    USB_VENDOR_PARA, USB_PRODUCT_PARA_RT3070, 
	    5179, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT2870, 
	    5172, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3070, 
	    5179, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3070_2, 
	    5179, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_PEGATRON, USB_PRODUCT_PEGATRON_RT3072, 
	    5193, 0,
	    USB_VENDOR_FUTUREBITS, USB_PRODUCT_FUTUREBITS_4PI, 
	    16409, 16413, 0,
	    USB_VENDOR_FUTUREBITS, USB_PRODUCT_FUTUREBITS_CDL_CAN, 
	    16420, 4979, 16432, 16436, 0,
	    USB_VENDOR_FUTUREBITS, USB_PRODUCT_FUTUREBITS_ONERNG, 
	    16447, 16454, 16461, 16468, 0,
	    USB_VENDOR_INTERBIO, USB_PRODUCT_INTERBIO_CDL_CAN, 
	    16420, 4979, 16432, 16436, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_USBDISKPRO, 
	    4979, 13328, 5077, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_USBREADER, 
	    4979, 10901, 6572, 5667, 5873, 14191, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_MOBILEDRIVE, 
	    4979, 6642, 6572, 5667, 5873, 14191, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_USBDISK, 
	    4979, 13328, 0,
	    USB_VENDOR_PEN, USB_PRODUCT_PEN_ATTACHE, 
	    4979, 5421, 5948, 3665, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_SERIAL1, 
	    7072, 7491, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_ENET, 
	    5009, 5018, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_ENET3, 
	    3191, 16478, 5009, 4993, 0,
	    USB_VENDOR_PERACOM, USB_PRODUCT_PERACOM_ENET2, 
	    5009, 5018, 0,
	    USB_VENDOR_PHEENET, USB_PRODUCT_PHEENET_GWU513, 
	    16483, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DSS350, 
	    16490, 9051, 2316, 7359, 2833, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DSS, 
	    16490, 16494, 2316, 7359, 2833, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_SA235, 
	    16498, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_HUB, 
	    7177, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCA645VC, 
	    16504, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCA646VC, 
	    16513, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC675K, 
	    16522, 16531, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC680K, 
	    16537, 16531, 5077, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC690K, 
	    16546, 16531, 5077, 16555, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC730K, 
	    16560, 16569, 16576, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC740K, 
	    16580, 16569, 5077, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_PCVC750K, 
	    16589, 16569, 5077, 16555, 5870, 3016, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DSS150, 
	    16490, 16598, 2316, 7359, 2833, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_CPWUA054, 
	    16602, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_SNU5600, 
	    16611, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_SNU5630NS05, 
	    16619, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_DIVAUSB, 
	    16632, 4979, 16637, 8813, 0,
	    USB_VENDOR_PHILIPS, USB_PRODUCT_PHILIPS_RT2870, 
	    5172, 0,
	    USB_VENDOR_PHILIPSSEMI, USB_PRODUCT_PHILIPSSEMI_HUB1122, 
	    7177, 0,
	    USB_VENDOR_PHILIPSSEMI, USB_PRODUCT_PHILIPSSEMI_PN533, 
	    16641, 16645, 0,
	    USB_VENDOR_PIENGINEERING, USB_PRODUCT_PIENGINEERING_PS2USB, 
	    8551, 5759, 10244, 4979, 4993, 0,
	    USB_VENDOR_PIENGINEERING, USB_PRODUCT_PIENGINEERING_XKEYS58, 
	    16651, 16657, 6013, 16670, 16674, 0,
	    USB_VENDOR_PIENGINEERING, USB_PRODUCT_PIENGINEERING_XKEYS, 
	    16651, 16657, 6013, 0,
	    USB_VENDOR_PILOTECH, USB_PRODUCT_PILOTECH_CRW600, 
	    16680, 15453, 5954, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTV800E, 
	    16688, 16693, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTVDVBTFLASH, 
	    4656, 16688, 6961, 5948, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTV72E, 
	    4656, 16688, 16698, 0,
	    USB_VENDOR_PINNACLE, USB_PRODUCT_PINNACLE_PCTV73E, 
	    4656, 16688, 16702, 0,
	    USB_VENDOR_PIXART, USB_PRODUCT_PIXART_RPIMOUSE, 
	    16706, 16716, 6510, 0,
	    USB_VENDOR_LENOVO, USB_PRODUCT_LENOVO_OPTUSBMOUSE, 
	    4462, 4979, 3388, 6510, 0,
	    USB_VENDOR_PLANEX, USB_PRODUCT_PLANEX_GW_US11H, 
	    16719, 5386, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CUS, 
	    7541, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW_US11S, 
	    16728, 5386, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_3, 
	    5313, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSFANG300, 
	    16737, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54GXS, 
	    16750, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW_US300, 
	    16761, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54HP, 
	    16770, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS300MINIS, 
	    16780, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RT3070, 
	    5179, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSNANO, 
	    16794, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMICRO300, 
	    16804, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_1, 
	    16818, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8192CU, 
	    16829, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_4, 
	    5313, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW900D, 
	    16841, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW450D, 
	    16849, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GW450S, 
	    16857, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54MINI2, 
	    16865, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54SG, 
	    16878, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54GZL, 
	    16888, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS54GD, 
	    16899, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMM, 
	    16909, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUS300MINIX, 
	    16917, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMICRON, 
	    16938, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSMICRON2, 
	    16950, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_RTL8188CU_2, 
	    5313, 0,
	    USB_VENDOR_PLANEX2, USB_PRODUCT_PLANEX2_GWUSH300N, 
	    16963, 0,
	    USB_VENDOR_PLANEX3, USB_PRODUCT_PLANEX3_GWUS54GZ, 
	    16974, 0,
	    USB_VENDOR_PLANEX3, USB_PRODUCT_PLANEX3_GU1000T, 
	    16984, 0,
	    USB_VENDOR_PLANEX3, USB_PRODUCT_PLANEX3_GWUS54MINI, 
	    16993, 0,
	    USB_VENDOR_PLANTRONICS, USB_PRODUCT_PLANTRONICS_HEADSET, 
	    17005, 17016, 17024, 0,
	    USB_VENDOR_PLEXTOR, USB_PRODUCT_PLEXTOR_40_12_40U, 
	    17032, 17043, 0,
	    USB_VENDOR_PLX, USB_PRODUCT_PLX_TESTBOARD, 
	    12428, 9871, 0,
	    USB_VENDOR_POINTCHIPS, USB_PRODUCT_POINTCHIPS_FLASH, 
	    5948, 0,
	    USB_VENDOR_PORTGEAR, USB_PRODUCT_PORTGEAR_EA8, 
	    5009, 4993, 0,
	    USB_VENDOR_PORTGEAR, USB_PRODUCT_PORTGEAR_EA9, 
	    5009, 4993, 0,
	    USB_VENDOR_PORTSMITH, USB_PRODUCT_PORTSMITH_EEA, 
	    13735, 5009, 4993, 0,
	    USB_VENDOR_PQI, USB_PRODUCT_PQI_TRAVELFLASH, 
	    17053, 5948, 3665, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2X300, 
	    17060, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2E300, 
	    17067, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2300, 
	    17075, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2E3002, 
	    17067, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_9600, 
	    17082, 4979, 17091, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_600U, 
	    17082, 17096, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_6200, 
	    745, 17101, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_19200, 
	    17082, 4979, 17106, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_1200U, 
	    17082, 17112, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G600, 
	    17118, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_636I, 
	    17125, 17135, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2600, 
	    17118, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_G2E600, 
	    17140, 7373, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_COMFORT, 
	    14918, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_MOUSEINABOX, 
	    17148, 0,
	    USB_VENDOR_PRIMAX, USB_PRODUCT_PRIMAX_PCGAUMS1, 
	    1337, 17163, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2301, 
	    17173, 10980, 16244, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2302, 
	    17180, 10980, 16244, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_RSAQ2, 
	    17187, 7072, 5018, 17194, 17202, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303, 
	    17187, 7072, 5018, 17213, 17226, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2305, 
	    7048, 7057, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_ATAPI4, 
	    17234, 1867, 5961, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GC, 
	    17187, 7072, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GB, 
	    17187, 7072, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GT, 
	    17187, 7072, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GL, 
	    17187, 7072, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GE, 
	    17187, 7072, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303GS, 
	    17187, 7072, 5018, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2501, 
	    17242, 10980, 16244, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL25A1, 
	    17249, 10980, 16244, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_PL2303X, 
	    17187, 7072, 5018, 17256, 17264, 0,
	    USB_VENDOR_PROLIFIC, USB_PRODUCT_PROLIFIC_RSAQ3, 
	    17187, 7072, 5018, 17194, 17269, 0,
	    USB_VENDOR_PROLIFIC2, USB_PRODUCT_PROLIFIC2_PL2303, 
	    17187, 7072, 5018, 17280, 17287, 0,
	    USB_VENDOR_PUTERCOM, USB_PRODUCT_PUTERCOM_UPA100, 
	    17301, 17310, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2573, 
	    5343, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2573_2, 
	    5343, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2573_3, 
	    5343, 0,
	    USB_VENDOR_QCOM, USB_PRODUCT_QCOM_RT2870, 
	    5172, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH341_EPP, 
	    17317, 17323, 1867, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH341_ASP, 
	    17317, 17335, 1867, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH341_UPC, 
	    17317, 17346, 1867, 0,
	    USB_VENDOR_QINHENG, USB_PRODUCT_QINHENG_CH340, 
	    17358, 17335, 1867, 0,
	    USB_VENDOR_QINHENG2, USB_PRODUCT_QINHENG2_CH341SER, 
	    17364, 17335, 1867, 0,
	    USB_VENDOR_QTRONIX, USB_PRODUCT_QTRONIX_980N, 
	    17376, 8270, 0,
	    USB_VENDOR_QUALCOMM2, USB_PRODUCT_QUALCOMM2_RWT_FCT, 
	    17390, 17394, 13267, 17403, 6088, 0,
	    USB_VENDOR_QUALCOMM2, USB_PRODUCT_QUALCOMM2_CDMA_MSM, 
	    5865, 799, 13407, 6088, 0,
	    USB_VENDOR_QUALCOMM_K, USB_PRODUCT_QUALCOMM_K_CDMA_MSM_K, 
	    1648, 643, 5865, 799, 13407, 0,
	    USB_VENDOR_QUAN, USB_PRODUCT_QUAN_DM9601, 
	    4979, 5229, 0,
	    USB_VENDOR_QUANTA, USB_PRODUCT_QUANTA_RT3070, 
	    5179, 0,
	    USB_VENDOR_QUICKSHOT, USB_PRODUCT_QUICKSHOT_STRIKEPAD, 
	    4979, 17409, 0,
	    USB_VENDOR_RAINBOW, USB_PRODUCT_RAINBOW_IKEY2000, 
	    17419, 13267, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2570, 
	    6893, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2070, 
	    6022, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2570_2, 
	    6893, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2573, 
	    5343, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT73, 
	    17425, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2671, 
	    17430, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2770, 
	    5165, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2870, 
	    5172, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3070, 
	    5179, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3071, 
	    5186, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3072, 
	    5193, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3370, 
	    17437, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3572, 
	    6029, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT3573, 
	    17444, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT5370, 
	    17451, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT5572, 
	    17458, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_MT7610U, 
	    9891, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT8070, 
	    17465, 0,
	    USB_VENDOR_RALINK, USB_PRODUCT_RALINK_RT2570_3, 
	    6893, 0,
	    USB_VENDOR_RATOC, USB_PRODUCT_RATOC_REXUSB60, 
	    4979, 10100, 5018, 17472, 0,
	    USB_VENDOR_RATOC, USB_PRODUCT_RATOC_REXUSB60F, 
	    4979, 10100, 5018, 17482, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188ETV, 
	    17493, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CTV, 
	    17504, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188RU_2, 
	    17515, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8150L, 
	    17525, 17534, 1867, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8151, 
	    17547, 17555, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8152, 
	    17559, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8153, 
	    17567, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8156, 
	    17575, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CE_0, 
	    7394, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8171, 
	    17583, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8172, 
	    17591, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8173, 
	    17599, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8174, 
	    17607, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_0, 
	    5313, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8191CU, 
	    17615, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188EU, 
	    5303, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_1, 
	    5313, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_2, 
	    5313, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192CE, 
	    17625, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188RU, 
	    17515, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CE_1, 
	    7394, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188RU_3, 
	    17515, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187, 
	    9162, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187B_0, 
	    17635, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CUS, 
	    7541, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192EU, 
	    17644, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_3, 
	    5313, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187B_1, 
	    17635, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8187B_2, 
	    17635, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8712, 
	    17654, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8713, 
	    17662, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188CU_COMBO, 
	    5313, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8192SU, 
	    5451, 0,
	    USB_VENDOR_REALTEK, USB_PRODUCT_REALTEK_RTL8188FU, 
	    17670, 0,
	    USB_VENDOR_RIM, USB_PRODUCT_RIM_BLACKBERRY, 
	    17680, 0,
	    USB_VENDOR_RIM, USB_PRODUCT_RIM_BLACKBERRY_PEARL_DUAL, 
	    17680, 17691, 13958, 0,
	    USB_VENDOR_RIM, USB_PRODUCT_RIM_BLACKBERRY_PEARL, 
	    17680, 17691, 0,
	    USB_VENDOR_ROCKFIRE, USB_PRODUCT_ROCKFIRE_GAMEPAD, 
	    13259, 17697, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA100, 
	    17704, 4979, 7353, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM4, 
	    17715, 17720, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SC8850, 
	    17725, 17734, 17742, 17748, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_U8, 
	    17762, 4979, 7353, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM2, 
	    17766, 17720, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SC8820, 
	    17771, 17783, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PC300, 
	    17791, 17720, 6013, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM1, 
	    17798, 17720, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SK500, 
	    17771, 17803, 17720, 6013, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SCD70, 
	    17810, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA3, 
	    17817, 17824, 4979, 17829, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_XV5050, 
	    17835, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM880N, 
	    17817, 17843, 17720, 17711, 17850, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM880G, 
	    17817, 17843, 17720, 17711, 17859, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SD90, 
	    17817, 17869, 17875, 17748, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA1A, 
	    17881, 4979, 7353, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM550, 
	    17887, 17720, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SD20, 
	    17894, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SD80, 
	    17900, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA700, 
	    17906, 4979, 7353, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PCRA, 
	    17817, 17913, 17720, 8270, 17917, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PCR, 
	    17817, 17913, 17720, 8270, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_M1000, 
	    17928, 17829, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA1000, 
	    17817, 17935, 4979, 17829, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA3FXA, 
	    17817, 17943, 4979, 17829, 17711, 17917, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA3FX, 
	    17817, 17943, 4979, 17829, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_FANTOMX, 
	    17950, 17720, 17755, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA25, 
	    17817, 17959, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA101, 
	    17817, 17965, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PC50A, 
	    17817, 17972, 17917, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_PC50, 
	    17817, 17972, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA101F, 
	    17817, 17965, 17978, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA1EX, 
	    17817, 17983, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UM3, 
	    17817, 17990, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA4FX, 
	    17817, 17995, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_SONICCELL, 
	    18002, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA25EXA, 
	    17817, 18012, 17917, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UA25EX, 
	    17817, 18012, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_UMONE, 
	    18020, 17720, 17711, 0,
	    USB_VENDOR_ROLAND, USB_PRODUCT_ROLAND_QUADCAPTURE, 
	    18027, 0,
	    USB_VENDOR_RTSYS, USB_PRODUCT_RTSYS_RTS03, 
	    18040, 0,
	    USB_VENDOR_RTSYS, USB_PRODUCT_RTSYS_CT57A, 
	    18047, 3377, 2658, 0,
	    USB_VENDOR_SAGEM, USB_PRODUCT_SAGEM_XG760A, 
	    18053, 0,
	    USB_VENDOR_SAGEM, USB_PRODUCT_SAGEM_XG76NA, 
	    18061, 0,
	    USB_VENDOR_SAITEK, USB_PRODUCT_SAITEK_CYBORG_3D_GOLD, 
	    14068, 16148, 18069, 18074, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_MIGHTYDRIVE, 
	    6503, 3665, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_ML6060, 
	    18083, 8040, 7057, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_ANDROID, 
	    11920, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_GTB3710, 
	    18091, 18100, 16104, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_ANDROID2, 
	    11920, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_GTB3730, 
	    18107, 18100, 16104, 0,
	    USB_VENDOR_SAMSUNG, USB_PRODUCT_SAMSUNG_SWL2100W, 
	    18116, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR05A, 
	    18126, 18136, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR31, 
	    18126, 18145, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR05, 
	    18126, 18153, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR12, 
	    18126, 18161, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR09, 
	    18126, 18169, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR86, 
	    18126, 18177, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SDDR75, 
	    18126, 18185, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_CRUZER, 
	    18193, 0,
	    USB_VENDOR_SANDISK, USB_PRODUCT_SANDISK_SANSA_CLIP, 
	    18200, 18206, 0,
	    USB_VENDOR_SANWASUPPLY, USB_PRODUCT_SANWASUPPLY_JYDV9USB, 
	    18211, 13259, 0,
	    USB_VENDOR_SANYO, USB_PRODUCT_SANYO_SCP4900, 
	    589, 18221, 4979, 15740, 0,
	    USB_VENDOR_SCANLOGIC, USB_PRODUCT_SCANLOGIC_SL11R, 
	    18230, 0,
	    USB_VENDOR_SCANLOGIC, USB_PRODUCT_SCANLOGIC_336CX, 
	    14965, 14973, 14019, 14979, 7373, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_USBSERIAL, 
	    17335, 10153, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P1, 
	    18240, 8994, 5667, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P2, 
	    18240, 8994, 6640, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P3, 
	    18240, 8994, 6642, 0,
	    USB_VENDOR_SEALEVEL, USB_PRODUCT_SEALEVEL_SEAPORT4P4, 
	    18240, 8994, 6622, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_4, 
	    5172, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_NUB8301, 
	    18250, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RTL8192SU_1, 
	    5451, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RTL8192SU_2, 
	    5451, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3070, 
	    5179, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3071, 
	    5186, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072, 
	    5193, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_2, 
	    5193, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_3, 
	    5193, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_4, 
	    5193, 0,
	    USB_VENDOR_SENAO, USB_PRODUCT_SENAO_RT3072_5, 
	    5193, 0,
	    USB_VENDOR_SGI, USB_PRODUCT_SGI_SN1_L1_SC, 
	    18259, 18263, 2833, 5961, 0,
	    USB_VENDOR_SHANTOU, USB_PRODUCT_SHANTOU_ST268_USB_NIC, 
	    18266, 4979, 14811, 0,
	    USB_VENDOR_SHANTOU, USB_PRODUCT_SHANTOU_ADM8515, 
	    5726, 5009, 0,
	    USB_VENDOR_SHARK, USB_PRODUCT_SHARK_PA, 
	    18272, 4993, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_CE175TU, 
	    18279, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_SL5500, 
	    18287, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_A300, 
	    18294, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_SL5600, 
	    18299, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_C700, 
	    18306, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_C750, 
	    18311, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_RUITZ1016YCZZ, 
	    18316, 5386, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_WS007SH, 
	    18324, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_WS011SH, 
	    18332, 0,
	    USB_VENDOR_SHARP, USB_PRODUCT_SHARP_NWKBD, 
	    18340, 6013, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSB, 
	    18350, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSCSI, 
	    18356, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SDDR09, 
	    18126, 18363, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSBSMCF, 
	    18370, 11353, 687, 11005, 4993, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_ZIOMMC, 
	    18370, 16362, 4993, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_HIFD, 
	    1337, 18375, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSBATAPI, 
	    18370, 5544, 4993, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_CF, 
	    18370, 11005, 4993, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSCSI_B, 
	    18356, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_EUSCSI_C, 
	    18356, 1867, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_CDRW, 
	    18380, 8256, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_ORCA, 
	    18370, 18386, 16133, 5954, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SCM, 
	    18391, 308, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SCL3711, 
	    18391, 308, 18395, 0,
	    USB_VENDOR_SHUTTLE, USB_PRODUCT_SHUTTLE_SCL3712, 
	    18391, 308, 18410, 0,
	    USB_VENDOR_SIEMENS, USB_PRODUCT_SIEMENS_SPEEDSTREAM, 
	    5425, 4979, 0,
	    USB_VENDOR_SIEMENS, USB_PRODUCT_SIEMENS_SPEEDSTREAM22, 
	    5425, 4979, 18425, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_WLL013, 
	    6751, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_MC75, 
	    651, 18430, 18438, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_HC28MDMNET, 
	    18443, 18448, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_HC28MS, 
	    18443, 10869, 9846, 8256, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_HC28MDM, 
	    18443, 18455, 0,
	    USB_VENDOR_SIEMENS2, USB_PRODUCT_SIEMENS2_WL54G, 
	    7605, 4979, 3442, 4993, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_EM5625, 
	    18459, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC5720_2, 
	    18466, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AIRCARD595, 
	    4017, 651, 18473, 18481, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC5725, 
	    18485, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC597E, 
	    4017, 651, 18473, 18492, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_C597, 
	    4017, 651, 18497, 18505, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AIRCARD580, 
	    4017, 651, 18473, 18509, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC595U, 
	    4017, 651, 18473, 18513, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC5720, 
	    18466, 651, 5114, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MINI5725, 
	    4017, 651, 18518, 18526, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_250U, 
	    18531, 651, 18538, 6615, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_INSTALLER, 
	    18543, 15867, 12004, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8755_2, 
	    18551, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8765, 
	    18558, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8755, 
	    18551, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC875U, 
	    18565, 9068, 4979, 5114, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8755_3, 
	    18551, 9068, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8775_2, 
	    18572, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AIRCARD875, 
	    18543, 18579, 9068, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8780, 
	    18583, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC8781, 
	    18590, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC880, 
	    4017, 651, 18473, 18597, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC881, 
	    4017, 651, 18473, 18601, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC880E, 
	    4017, 651, 18473, 18605, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC881E, 
	    4017, 651, 18473, 18610, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC880U, 
	    4017, 651, 18473, 18615, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC881U, 
	    4017, 651, 18473, 18620, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_AC885U, 
	    4017, 651, 18473, 18625, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_C01SW, 
	    18630, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_USB305, 
	    4017, 651, 18473, 4979, 11154, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_MC7304, 
	    18636, 0,
	    USB_VENDOR_SIERRA, USB_PRODUCT_SIERRA_EM7455, 
	    18643, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_SIR4116, 
	    18650, 18659, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_IRDA, 
	    10430, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_FIR4210, 
	    18663, 5641, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_VFIR4220, 
	    18672, 18681, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_I_BEAD100, 
	    18686, 12703, 8809, 11193, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_I_BEAD150, 
	    18686, 16598, 8809, 11193, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_DNSSF7X, 
	    18693, 1407, 18699, 18706, 18712, 0,
	    USB_VENDOR_SIGMATEL, USB_PRODUCT_SIGMATEL_MUSICSTICK, 
	    18720, 18729, 0,
	    USB_VENDOR_ALLIEDTELESYN, USB_PRODUCT_ALLIEDTELESYN_AT_USB10, 
	    18740, 4979, 5009, 4993, 0,
	    USB_VENDOR_SIIG, USB_PRODUCT_SIIG_DIGIFILMREADER, 
	    18749, 5954, 0,
	    USB_VENDOR_SIIG, USB_PRODUCT_SIIG_UISDMC2S, 
	    18764, 0,
	    USB_VENDOR_SIIG, USB_PRODUCT_SIIG_MULTICARDREADER, 
	    18764, 0,
	    USB_VENDOR_SIIG2, USB_PRODUCT_SIIG2_USBTOETHER, 
	    4979, 18780, 5009, 0,
	    USB_VENDOR_SIIG2, USB_PRODUCT_SIIG2_US2308, 
	    7072, 0,
	    USB_VENDOR_SILICOM, USB_PRODUCT_SILICOM_U2E, 
	    18783, 0,
	    USB_VENDOR_SILICOM, USB_PRODUCT_SILICOM_GPE, 
	    18787, 18069, 8994, 5009, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_POLOLU, 
	    18793, 7072, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_ARGUSISP, 
	    18800, 18810, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CRUMB128, 
	    18814, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_DEGREECONT, 
	    18823, 18830, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_SUNNTO, 
	    18839, 18846, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_DESKTOPMOBILE, 
	    18853, 13913, 18862, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_IPLINK1220, 
	    18869, 18877, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_LIPOWSKY_JTAG, 
	    18882, 18891, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_LIPOWSKY_LIN, 
	    18882, 18901, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_LIPOWSKY_HARP, 
	    18882, 18910, 0,
	    USB_VENDOR_SILABS2, USB_PRODUCT_SILABS2_DCU11CLONE, 
	    18917, 18924, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CP210X_1, 
	    18930, 7072, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CP210X_2, 
	    18930, 7072, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_CP210X_3, 
	    18930, 7072, 0,
	    USB_VENDOR_SILABS, USB_PRODUCT_SILABS_EC3, 
	    18937, 4979, 18941, 4993, 0,
	    USB_VENDOR_SILICONPORTALS, USB_PRODUCT_SILICONPORTALS_YAPPH_NF, 
	    18947, 15740, 7982, 7986, 0,
	    USB_VENDOR_SILICONPORTALS, USB_PRODUCT_SILICONPORTALS_YAPPHONE, 
	    18947, 15740, 0,
	    USB_VENDOR_SIS, USB_PRODUCT_SIS_SIS_163U, 
	    18951, 651, 7487, 4993, 0,
	    USB_VENDOR_SIRIUS, USB_PRODUCT_SIRIUS_ROADSTER, 
	    18959, 18967, 7517, 18976, 4979, 0,
	    USB_VENDOR_SITECOM, USB_PRODUCT_SITECOM_LN029, 
	    18979, 0,
	    USB_VENDOR_SITECOM, USB_PRODUCT_SITECOM_CN104, 
	    18985, 10100, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL168V1, 
	    18991, 18998, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_LN030, 
	    19001, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL168V4, 
	    18991, 19008, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT2870_3, 
	    5172, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL302, 
	    19011, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL603, 
	    19018, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL315, 
	    19025, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL321, 
	    19032, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3070_3, 
	    5179, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL324, 
	    19039, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL343, 
	    19046, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL608, 
	    19053, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL344, 
	    19060, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL329, 
	    19067, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL345, 
	    19074, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL353, 
	    19081, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_3, 
	    5193, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_4, 
	    5193, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL349V1, 
	    19088, 18998, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_6, 
	    5193, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL349V4, 
	    19088, 19008, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3070_1, 
	    5179, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_LN031, 
	    19095, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8188CU_2, 
	    5313, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RT3072_5, 
	    5193, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WLA4000, 
	    19102, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WLA5000, 
	    19111, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_AX88179, 
	    6822, 4979, 6830, 6805, 5229, 6188, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_LN028, 
	    19120, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_RTL8192CUR2, 
	    5293, 9156, 19127, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL113, 
	    19131, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL172, 
	    19138, 0,
	    USB_VENDOR_SITECOMEU, USB_PRODUCT_SITECOMEU_WL113R2, 
	    19131, 9156, 6640, 0,
	    USB_VENDOR_SMARTBRIDGES, USB_PRODUCT_SMARTBRIDGES_SMARTLINK, 
	    19145, 4979, 5229, 5018, 0,
	    USB_VENDOR_SMARTBRIDGES, USB_PRODUCT_SMARTBRIDGES_SMARTNIC, 
	    19155, 6640, 19164, 4993, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2102USB, 
	    7065, 5229, 5018, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2202USB, 
	    6790, 5229, 5018, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2206USB, 
	    19168, 16096, 4979, 5009, 4993, 0,
	    USB_VENDOR_SMC3, USB_PRODUCT_SMC3_2662WV1, 
	    19168, 16096, 19171, 0,
	    USB_VENDOR_SMC3, USB_PRODUCT_SMC3_2662WV2, 
	    19168, 16096, 19171, 7660, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2862WG, 
	    19168, 16096, 19178, 7660, 4979, 5421, 0,
	    USB_VENDOR_SMC, USB_PRODUCT_SMC_2862WG_V1, 
	    19168, 16096, 19178, 18998, 4979, 19185, 0,
	    USB_VENDOR_SMK, USB_PRODUCT_SMK_MCE_IR, 
	    19189, 19195, 14881, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2020HUB, 
	    4979, 5917, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2512HUB, 
	    4979, 5421, 19204, 5917, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2513HUB, 
	    4979, 5421, 19211, 5917, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2514HUB, 
	    4979, 5421, 19218, 5917, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_2517HUB, 
	    4979, 5421, 7527, 5917, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7500, 
	    19225, 4979, 5421, 6805, 5229, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7505, 
	    19233, 4979, 5421, 6805, 5229, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7800, 
	    19241, 4979, 19249, 6805, 5229, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7801, 
	    19253, 4979, 19249, 6805, 5229, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN7850, 
	    19261, 4979, 5421, 6805, 5229, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500, 
	    19269, 5009, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505, 
	    19278, 5009, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512, 
	    19287, 4979, 5917, 3174, 5009, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9514, 
	    19296, 4979, 5917, 3174, 5009, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN9530, 
	    19305, 5009, 8256, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN9730, 
	    19313, 5009, 8256, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500_SAL10, 
	    19269, 5009, 10889, 19321, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505_SAL10, 
	    19278, 5009, 10889, 19321, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A_SAL10, 
	    19329, 5009, 10889, 19321, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505A_SAL10, 
	    19339, 5009, 10889, 19321, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512_14_SAL10, 
	    19349, 5917, 3174, 5009, 8256, 19321, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A_HAL, 
	    19329, 5009, 8256, 19361, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505A_HAL, 
	    19339, 5009, 8256, 19361, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500_ALT, 
	    19269, 5009, 8256, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A_ALT, 
	    19329, 5009, 8256, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512_14_ALT, 
	    19287, 5917, 3174, 5009, 8256, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9500A, 
	    19329, 5009, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9505A, 
	    19339, 5009, 10889, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_LAN89530, 
	    19367, 0,
	    USB_VENDOR_SMSC, USB_PRODUCT_SMSC_SMSC9512_14, 
	    19376, 4979, 5917, 3174, 5009, 10889, 0,
	    USB_VENDOR_SOHOWARE, USB_PRODUCT_SOHOWARE_NUB100, 
	    6790, 4979, 5009, 0,
	    USB_VENDOR_SOHOWARE, USB_PRODUCT_SOHOWARE_NUB110, 
	    19390, 5009, 0,
	    USB_VENDOR_SOLIDYEAR, USB_PRODUCT_SOLIDYEAR_KEYBOARD, 
	    1890, 1896, 4979, 8270, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_DSC, 
	    19397, 19401, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_NWMS7, 
	    19409, 19421, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_DRIVEV2, 
	    12386, 9974, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_MSACUS1, 
	    19409, 19428, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_HANDYCAM, 
	    19437, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_MSC, 
	    19446, 19450, 19457, 19463, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_35, 
	    1337, 19468, 19473, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2KEYBOARD, 
	    19478, 8270, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2KEYBOARDHUB, 
	    19478, 8270, 7177, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2MOUSE, 
	    19478, 6497, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_40, 
	    1337, 19468, 19491, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_MSC_U03, 
	    19446, 19450, 19457, 19463, 19496, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_40_MS, 
	    1337, 19468, 19491, 14831, 8786, 19463, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_S360, 
	    1337, 19468, 19504, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_41_MS, 
	    1337, 19468, 19509, 14831, 8786, 19463, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_41, 
	    1337, 19468, 19509, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_NX60, 
	    1337, 19468, 19514, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2EYETOY4, 
	    19478, 19519, 19526, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS2EYETOY5, 
	    19478, 19519, 19531, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_CLIE_TJ25, 
	    1337, 19468, 19536, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_IFU_WLM2, 
	    19541, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_PS3CONTROLLER, 
	    1337, 19550, 5961, 0,
	    USB_VENDOR_SONY, USB_PRODUCT_SONY_GPS_CS1, 
	    1337, 9090, 19566, 0,
	    USB_VENDOR_SOURCENEXT, USB_PRODUCT_SOURCENEXT_KEIKAI8_CHG, 
	    19574, 9181, 5152, 19586, 0,
	    USB_VENDOR_SOURCENEXT, USB_PRODUCT_SOURCENEXT_KEIKAI8, 
	    19574, 9181, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT2573, 
	    5343, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT3070, 
	    5179, 0,
	    USB_VENDOR_SPARKLAN, USB_PRODUCT_SPARKLAN_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_SPRINGERDESIGN, USB_PRODUCT_SPRINGERDESIGN_TTSMP3PLAYER, 
	    4856, 1635, 19594, 0,
	    USB_VENDOR_SPHAIRON, USB_PRODUCT_SPHAIRON_UB801R, 
	    19607, 0,
	    USB_VENDOR_SPHAIRON, USB_PRODUCT_SPHAIRON_RTL8187, 
	    9162, 0,
	    USB_VENDOR_STMICRO, USB_PRODUCT_STMICRO_COMMUNICATOR, 
	    4979, 19614, 0,
	    USB_VENDOR_STSN, USB_PRODUCT_STSN_STSN0001, 
	    14776, 245, 8256, 0,
	    USB_VENDOR_SUNCOMM, USB_PRODUCT_SUNCOMM_MB_ADAPTOR, 
	    7429, 7479, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_DS96L, 
	    19627, 19634, 19642, 19647, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_PS64P1, 
	    19627, 19634, 19642, 19650, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_VS10U, 
	    19627, 19653, 19661, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_IS96U, 
	    19627, 19663, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_AS64LX, 
	    19627, 19634, 19642, 19674, 0,
	    USB_VENDOR_SUNTAC, USB_PRODUCT_SUNTAC_AS144L4, 
	    19634, 19642, 19677, 0,
	    USB_VENDOR_SUNRISING, USB_PRODUCT_SUNRISING_SR9600, 
	    19680, 5009, 0,
	    USB_VENDOR_SUNRISING, USB_PRODUCT_SUNRISING_QF9700, 
	    19687, 5009, 0,
	    USB_VENDOR_SUPERTOP, USB_PRODUCT_SUPERTOP_IDEBRIDGE, 
	    4259, 12368, 1867, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_SUPRAEXPRESS56K, 
	    19694, 13735, 19700, 6088, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_SUPRA2890, 
	    19704, 19713, 19700, 5114, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_RIO600USB, 
	    9100, 6104, 4979, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_RIO800USB, 
	    9100, 19718, 4979, 0,
	    USB_VENDOR_DIAMOND2, USB_PRODUCT_DIAMOND2_PSAPLAY120, 
	    19722, 19727, 19736, 0,
	    USB_VENDOR_SURECOM, USB_PRODUCT_SURECOM_EP9001G2A, 
	    19740, 9156, 19750, 0,
	    USB_VENDOR_SURECOM, USB_PRODUCT_SURECOM_EP9001G, 
	    19740, 0,
	    USB_VENDOR_SURECOM, USB_PRODUCT_SURECOM_RT2573, 
	    5343, 0,
	    USB_VENDOR_SUSTEEN, USB_PRODUCT_SUSTEEN_DCU10, 
	    4979, 2658, 0,
	    USB_VENDOR_SWEEX, USB_PRODUCT_SWEEX_ZD1211, 
	    19753, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW153, 
	    19760, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW154, 
	    19766, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW303, 
	    19772, 0,
	    USB_VENDOR_SWEEX2, USB_PRODUCT_SWEEX2_LW313, 
	    19778, 0,
	    USB_VENDOR_SYNET, USB_PRODUCT_SYNET_MWP54SS, 
	    19784, 4979, 651, 19793, 19803, 0,
	    USB_VENDOR_SYSTEMTALKS, USB_PRODUCT_SYSTEMTALKS_SGCX2UL, 
	    19810, 0,
	    USB_VENDOR_TANGTOP, USB_PRODUCT_TANGTOP_USBPS2, 
	    19819, 0,
	    USB_VENDOR_TARGUS, USB_PRODUCT_TARGUS_PAUM004, 
	    19826, 6510, 0,
	    USB_VENDOR_TAUGA, USB_PRODUCT_TAUGA_CAMERAMATE, 
	    14954, 19834, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UPA9664, 
	    19845, 4993, 19853, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UCA1464, 
	    19861, 4993, 19873, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UHA6400, 
	    19881, 4993, 19889, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_UPA6400, 
	    19881, 4993, 19897, 0,
	    USB_VENDOR_TDK, USB_PRODUCT_TDK_BT_DONGLE, 
	    4983, 4979, 15130, 0,
	    USB_VENDOR_TEAC, USB_PRODUCT_TEAC_FD05PUB, 
	    19905, 19914, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_0193, 
	    19921, 19928, 5386, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_ZYAIR_B200, 
	    1553, 19933, 19939, 5386, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_U300C, 
	    19944, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_QUICKWLAN, 
	    19951, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_ZD1211_1, 
	    19753, 0,
	    USB_VENDOR_TEKRAM, USB_PRODUCT_TEKRAM_ZD1211_2, 
	    19753, 0,
	    USB_VENDOR_TELEX, USB_PRODUCT_TELEX_MIC1, 
	    19961, 4979, 19970, 0,
	    USB_VENDOR_TENX, USB_PRODUCT_TENX_MISSILE, 
	    19981, 19989, 0,
	    USB_VENDOR_TENX, USB_PRODUCT_TENX_TEMPER, 
	    19998, 20005, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_UTUSB41, 
	    20012, 7177, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_TUSB2046, 
	    20021, 7177, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_TUSB3410, 
	    20030, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_NEXII, 
	    20039, 7517, 2316, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_MSP430_JTAG, 
	    20043, 20057, 0,
	    USB_VENDOR_TI, USB_PRODUCT_TI_MSP430, 
	    20043, 0,
	    USB_VENDOR_THRUST, USB_PRODUCT_THRUST_FUSION_PAD, 
	    16126, 2316, 13945, 0,
	    USB_VENDOR_TOD, USB_PRODUCT_TOD_DOOGI_SLIM, 
	    20062, 20068, 4979, 6013, 0,
	    USB_VENDOR_TODOS, USB_PRODUCT_TODOS_ARGOS_MINI, 
	    20073, 6644, 20079, 5954, 0,
	    USB_VENDOR_TOPFIELD, USB_PRODUCT_TOPFIELD_TF5000PVR, 
	    20089, 2316, 20099, 20105, 0,
	    USB_VENDOR_TOPPING, USB_PRODUCT_TOPPING_DX3_PRO, 
	    20114, 5077, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_POCKETPC_E740, 
	    8484, 20118, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_RT3070, 
	    5179, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_AX88179, 
	    6822, 4979, 6830, 6805, 5229, 6188, 0,
	    USB_VENDOR_TOSHIBA, USB_PRODUCT_TOSHIBA_HSDPA_MODEM_EU870DT1, 
	    9068, 6615, 5114, 5873, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_WN821NV5, 
	    20123, 20133, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_WN822NV4, 
	    20136, 19008, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_WN823NV2, 
	    20146, 7660, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_RTL8188EU, 
	    5303, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_T4UV2, 
	    20156, 20163, 7671, 6640, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_T4UHV2, 
	    20156, 20167, 7671, 6640, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_T2UNANO, 
	    20156, 20172, 6991, 0,
	    USB_VENDOR_TPLINK, USB_PRODUCT_TPLINK_UE300, 
	    20176, 20182, 7487, 0,
	    USB_VENDOR_TREK, USB_PRODUCT_TREK_THUMBDRIVE, 
	    20194, 0,
	    USB_VENDOR_TREK, USB_PRODUCT_TREK_THUMBDRIVE_8MB, 
	    20194, 20205, 0,
	    USB_VENDOR_TRENDNET, USB_PRODUCT_TRENDNET_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_TRENDNET, USB_PRODUCT_TRENDNET_RTL8188CU, 
	    5313, 0,
	    USB_VENDOR_TRENDNET, USB_PRODUCT_TRENDNET_TEW648UBM, 
	    20209, 0,
	    USB_VENDOR_TRIPPLITE, USB_PRODUCT_TRIPPLITE_U209, 
	    20220, 7072, 5018, 0,
	    USB_VENDOR_TRIPPLITE2, USB_PRODUCT_TRIPPLITE2_UPS, 
	    3225, 3231, 480, 0,
	    USB_VENDOR_TRIPPLITE2, USB_PRODUCT_TRIPPLITE2_SMARTLCD, 
	    20225, 480, 0,
	    USB_VENDOR_TRIPPLITE2, USB_PRODUCT_TRIPPLITE2_AVR550U, 
	    3225, 3231, 20234, 0,
	    USB_VENDOR_TRUMPION, USB_PRODUCT_TRUMPION_T33521, 
	    20242, 20250, 0,
	    USB_VENDOR_TRUMPION, USB_PRODUCT_TRUMPION_XXX1100, 
	    16494, 20258, 0,
	    USB_VENDOR_TSUNAMI, USB_PRODUCT_TSUNAMI_SM2000, 
	    20263, 0,
	    USB_VENDOR_TWINMOS, USB_PRODUCT_TWINMOS_G240, 
	    20271, 0,
	    USB_VENDOR_ULTIMA, USB_PRODUCT_ULTIMA_1200UBPLUS, 
	    11674, 15349, 11564, 7373, 0,
	    USB_VENDOR_ULTIMA, USB_PRODUCT_ULTIMA_T14BR, 
	    20276, 20282, 6961, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA1236U, 
	    20288, 5789, 20294, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA1220U, 
	    20288, 20302, 20294, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA2000U, 
	    20288, 20308, 20294, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA3400, 
	    20288, 20314, 20294, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA2100U, 
	    20288, 20319, 20294, 0,
	    USB_VENDOR_UMAX, USB_PRODUCT_UMAX_ASTRA2200U, 
	    20288, 20325, 20294, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW429UB_A, 
	    20331, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW429UB, 
	    20343, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW429UBC1, 
	    20343, 9603, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_TEW645UB, 
	    20353, 0,
	    USB_VENDOR_UMEDIA, USB_PRODUCT_UMEDIA_ALL0298V2, 
	    20363, 7660, 0,
	    USB_VENDOR_UNIACCESS, USB_PRODUCT_UNIACCESS_PANACHE, 
	    20371, 20379, 4979, 5120, 4993, 0,
	    USB_VENDOR_UNKNOWN1, USB_PRODUCT_UNKNOWN1_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_UNKNOWN2, USB_PRODUCT_UNKNOWN2_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_UNKNOWN2, USB_PRODUCT_UNKNOWN2_NW3100, 
	    20384, 0,
	    USB_VENDOR_UNKNOWN3, USB_PRODUCT_UNKNOWN3_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_NETWORKFAB, USB_PRODUCT_NETWORKFAB_NF_RIC, 
	    20392, 20395, 0,
	    USB_VENDOR_USR, USB_PRODUCT_USR_USR1120, 
	    20399, 5386, 0,
	    USB_VENDOR_USR, USB_PRODUCT_USR_USR5422, 
	    20407, 5386, 0,
	    USB_VENDOR_USR, USB_PRODUCT_USR_USR5423, 
	    20415, 5386, 0,
	    USB_VENDOR_USI, USB_PRODUCT_USI_MC60, 
	    20423, 7072, 0,
	    USB_VENDOR_USRP, USB_PRODUCT_USRP_USRPv2, 
	    4962, 20428, 6640, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS101, 
	    20437, 20444, 5954, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS301, 
	    20456, 20444, 5954, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS451, 
	    20463, 20444, 5954, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS300, 
	    20470, 20444, 5954, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS5011, 
	    20477, 20444, 5954, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS471, 
	    20485, 20444, 5954, 0,
	    USB_VENDOR_VALIDITY, USB_PRODUCT_VALIDITY_VFS491, 
	    20492, 20444, 5954, 0,
	    USB_VENDOR_VIDZMEDIA, USB_PRODUCT_VIDZMEDIA_MONSTERTV, 
	    20499, 20509, 0,
	    USB_VENDOR_VIA, USB_PRODUCT_VIA_AR9271, 
	    7125, 0,
	    USB_VENDOR_VIEWSONIC, USB_PRODUCT_VIEWSONIC_G773HUB, 
	    20513, 20518, 5917, 0,
	    USB_VENDOR_VIEWSONIC, USB_PRODUCT_VIEWSONIC_P815HUB, 
	    20526, 20518, 5917, 0,
	    USB_VENDOR_VIEWSONIC, USB_PRODUCT_VIEWSONIC_G773CTRL, 
	    20513, 20518, 8617, 0,
	    USB_VENDOR_VISION, USB_PRODUCT_VISION_VC6452V002, 
	    20531, 3016, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_7600, 
	    20536, 20545, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_5300, 
	    20536, 20550, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_3000, 
	    20555, 13743, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_6100, 
	    20536, 20564, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_6200, 
	    20536, 17101, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_8100, 
	    20536, 20569, 0,
	    USB_VENDOR_VISIONEER, USB_PRODUCT_VISIONEER_8600, 
	    20536, 20574, 0,
	    USB_VENDOR_VIVITAR, USB_PRODUCT_VIVITAR_DSC350, 
	    20579, 3016, 0,
	    USB_VENDOR_VTECH, USB_PRODUCT_VTECH_RT2570, 
	    6893, 0,
	    USB_VENDOR_VTECH, USB_PRODUCT_VTECH_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CT0405U, 
	    20586, 20596, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE, 
	    20603, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE2, 
	    20612, 20622, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE3_4X5, 
	    20633, 20643, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE3_6X8, 
	    20633, 20647, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GRAPHIRE4_4X5, 
	    20651, 20643, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_INTUOSA5, 
	    20661, 20668, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_GD0912U, 
	    20661, 20671, 1967, 20596, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_XD0912U, 
	    20676, 19677, 20684, 20690, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTL671, 
	    20700, 20596, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTH490K0, 
	    20661, 20708, 20712, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTH690K0, 
	    20661, 20708, 20723, 0,
	    USB_VENDOR_WACOM, USB_PRODUCT_WACOM_CTL6100WL, 
	    20661, 20734, 0,
	    USB_VENDOR_WELTREND, USB_PRODUCT_WELTREND_HID, 
	    20736, 8256, 0,
	    USB_VENDOR_WMR, USB_PRODUCT_WMR_RIGBLASTER, 
	    20740, 0,
	    USB_VENDOR_WESTERN, USB_PRODUCT_WESTERN_EXTHDD, 
	    20751, 20760, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_WNC0600, 
	    20764, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_UR045G, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_UR055G, 
	    20776, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_O8494, 
	    20783, 20791, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_1, 
	    7102, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_1_NF, 
	    7102, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_2, 
	    7102, 0,
	    USB_VENDOR_WISTRONNEWEB, USB_PRODUCT_WISTRONNEWEB_AR5523_2_NF, 
	    7102, 0,
	    USB_VENDOR_XIRLINK, USB_PRODUCT_XIRLINK_IMAGING, 
	    20799, 20807, 0,
	    USB_VENDOR_XIRLINK, USB_PRODUCT_XIRLINK_PCCAM, 
	    767, 5870, 3016, 0,
	    USB_VENDOR_XRITE, USB_PRODUCT_XRITE_HUEY_1, 
	    11200, 0,
	    USB_VENDOR_XRITE, USB_PRODUCT_XRITE_HUEY_2, 
	    11200, 0,
	    USB_VENDOR_CONEXANT, USB_PRODUCT_CONEXANT_MODEM_1, 
	    4979, 5114, 0,
	    USB_VENDOR_CONEXANT, USB_PRODUCT_CONEXANT_PRISM_GT_1, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_CONEXANT, USB_PRODUCT_CONEXANT_PRISM_GT_2, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UX256, 
	    20814, 17720, 17711, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MU1000, 
	    20820, 17720, 17755, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MU2000, 
	    20827, 17720, 17755, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MU500, 
	    20834, 17720, 17755, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UW500, 
	    20840, 4979, 7353, 17711, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MOTIF6, 
	    20846, 17720, 17755, 20853, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MOTIF7, 
	    20865, 17720, 17755, 20853, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_MOTIF8, 
	    20872, 17720, 17755, 20853, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UX96, 
	    20879, 17720, 17711, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_UX16, 
	    20884, 17720, 17711, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_S08, 
	    20889, 17720, 6013, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_CLP150, 
	    20893, 15381, 20901, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_CLP170, 
	    20907, 15381, 20901, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RPU200, 
	    20915, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTA54I, 
	    20923, 20934, 20941, 19803, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTW65B, 
	    20923, 20956, 19793, 651, 19803, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTW65I, 
	    20923, 20963, 20941, 651, 19803, 0,
	    USB_VENDOR_YAMAHA, USB_PRODUCT_YAMAHA_RTA55I, 
	    20923, 20970, 19793, 20977, 19803, 0,
	    USB_VENDOR_YANO, USB_PRODUCT_YANO_U640MO, 
	    20982, 0,
	    USB_VENDOR_YEDATA, USB_PRODUCT_YEDATA_FLASHBUSTERU, 
	    20992, 0,
	    USB_VENDOR_YUBICO, USB_PRODUCT_YUBICO_YUBIKEY4MODE1, 
	    21006, 6622, 21014, 0,
	    USB_VENDOR_YUBICO, USB_PRODUCT_YUBICO_YUBIKEY4MODE2, 
	    21006, 6622, 21019, 0,
	    USB_VENDOR_YUBICO, USB_PRODUCT_YUBICO_YUBIKEY4MODE6, 
	    21006, 6622, 21028, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_M4Y750, 
	    21041, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_725, 
	    21049, 5577, 5386, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_XI735, 
	    21057, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_MD40900, 
	    21064, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_XG703A, 
	    5413, 4979, 5421, 5386, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_ZD1211, 
	    19753, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_AR5523, 
	    7102, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_AR5523_NF, 
	    7102, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_UB81, 
	    21072, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_ZCOM, USB_PRODUCT_ZCOM_UB82, 
	    21077, 0,
	    USB_VENDOR_ZEEVO, USB_PRODUCT_ZEEVO_BLUETOOTH, 
	    21082, 4983, 4979, 4993, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_ZWXG261, 
	    21089, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT3072, 
	    5193, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT3072_2, 
	    5193, 0,
	    USB_VENDOR_ZINWELL, USB_PRODUCT_ZINWELL_RT3070, 
	    5179, 0,
	    USB_VENDOR_ZOOM, USB_PRODUCT_ZOOM_2986L, 
	    21098, 21104, 6088, 0,
	    USB_VENDOR_ZOOM, USB_PRODUCT_ZOOM_3095, 
	    21108, 4979, 21104, 6088, 0,
	    USB_VENDOR_ZORAN, USB_PRODUCT_ZORAN_EX20DSC, 
	    2316, 3016, 21113, 19397, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF622, 
	    21119, 6088, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF628, 
	    21125, 6088, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF633, 
	    21131, 21137, 4979, 6088, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF626, 
	    21143, 6088, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_UMASS_INSTALLER2, 
	    4979, 13407, 21149, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF112, 
	    21159, 21165, 21171, 21177, 6088, 687, 12041, 21183, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_UMASS_INSTALLER3, 
	    4979, 13407, 21149, 21188, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF820D_INSTALLER, 
	    21196, 11962, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MF820D, 
	    21196, 6088, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_INSTALLER, 
	    21203, 11962, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_MC2718, 
	    21208, 6088, 0,
	    USB_VENDOR_ZTE, USB_PRODUCT_ZTE_AC8700, 
	    5865, 21215, 4979, 6088, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1201, 
	    21222, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1211, 
	    19753, 5386, 21229, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1211B, 
	    5461, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1221, 
	    21233, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ALL0298, 
	    20363, 0,
	    USB_VENDOR_ZYDAS, USB_PRODUCT_ZYDAS_ZD1211B_2, 
	    5461, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_OMNI56K, 
	    21240, 19700, 11564, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_980N, 
	    17376, 8270, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_ZYAIRG220, 
	    19933, 21245, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G200V2, 
	    21251, 7660, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_AG225H, 
	    21257, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_M202, 
	    21265, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G270S, 
	    21271, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G220V2, 
	    21245, 7660, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_G202, 
	    21278, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT2573, 
	    5343, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT2870_1, 
	    5172, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD271N, 
	    21284, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD211AN, 
	    21293, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT2870_2, 
	    5172, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD2105, 
	    21303, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RTL8192CU, 
	    5293, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD2705, 
	    21311, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_NWD6605, 
	    21319, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_RT3070, 
	    5179, 0,
	    USB_VENDOR_ZYXEL, USB_PRODUCT_ZYXEL_PRESTIGE, 
	    21326, 0,
};
static const char usb_words[] = { "." 
	    "Unknown\0" /* 3 refs @ 1 */
	    "vendor\0" /* 3 refs @ 9 */
	    "eGalax,\0" /* 1 refs @ 16 */
	    "Inc.\0" /* 15 refs @ 24 */
	    "Quan\0" /* 1 refs @ 29 */
	    "Chipsbank\0" /* 1 refs @ 34 */
	    "Microelectronics\0" /* 5 refs @ 44 */
	    "Co.\0" /* 2 refs @ 61 */
	    "HUMAX\0" /* 1 refs @ 65 */
	    "AOX\0" /* 1 refs @ 71 */
	    "Atmel\0" /* 1 refs @ 75 */
	    "Mitsumi\0" /* 1 refs @ 81 */
	    "Hewlett\0" /* 3 refs @ 89 */
	    "Packard\0" /* 3 refs @ 97 */
	    "Adaptec\0" /* 1 refs @ 105 */
	    "National\0" /* 3 refs @ 113 */
	    "Semiconductor\0" /* 10 refs @ 122 */
	    "Acer\0" /* 6 refs @ 136 */
	    "Labs\0" /* 8 refs @ 141 */
	    "Future\0" /* 2 refs @ 146 */
	    "Technology\0" /* 35 refs @ 153 */
	    "Devices\0" /* 4 refs @ 164 */
	    "NEC\0" /* 3 refs @ 172 */
	    "Eastman\0" /* 1 refs @ 176 */
	    "Kodak\0" /* 1 refs @ 184 */
	    "Weltrend\0" /* 1 refs @ 190 */
	    "VIA\0" /* 2 refs @ 199 */
	    "Melco\0" /* 1 refs @ 203 */
	    "Creative\0" /* 3 refs @ 209 */
	    "Nokia\0" /* 1 refs @ 218 */
	    "ADI\0" /* 1 refs @ 224 */
	    "Systems\0" /* 27 refs @ 228 */
	    "Computer\0" /* 12 refs @ 236 */
	    "Access\0" /* 4 refs @ 245 */
	    "SMSC\0" /* 1 refs @ 252 */
	    "Advanced\0" /* 4 refs @ 257 */
	    "Gravis\0" /* 1 refs @ 266 */
	    "Fujitsu\0" /* 4 refs @ 273 */
	    "Component\0" /* 1 refs @ 281 */
	    "Taugagreining\0" /* 1 refs @ 291 */
	    "HF\0" /* 1 refs @ 305 */
	    "Micro\0" /* 9 refs @ 308 */
	    "Lexmark\0" /* 1 refs @ 314 */
	    "International\0" /* 9 refs @ 322 */
	    "NANAO\0" /* 1 refs @ 336 */
	    "Alps\0" /* 1 refs @ 342 */
	    "Electric\0" /* 4 refs @ 347 */
	    "Thrustmaster\0" /* 1 refs @ 356 */
	    "Texas\0" /* 1 refs @ 369 */
	    "Instruments\0" /* 4 refs @ 375 */
	    "Analog\0" /* 2 refs @ 387 */
	    "Silicon\0" /* 5 refs @ 394 */
	    "Integrated\0" /* 1 refs @ 402 */
	    "Corp.\0" /* 3 refs @ 413 */
	    "KYE\0" /* 1 refs @ 419 */
	    "Diamond\0" /* 2 refs @ 423 */
	    "(Supra)\0" /* 1 refs @ 431 */
	    "Renesas\0" /* 1 refs @ 439 */
	    "Microsoft\0" /* 1 refs @ 447 */
	    "Primax\0" /* 1 refs @ 457 */
	    "Electronics\0" /* 18 refs @ 464 */
	    "MGE\0" /* 3 refs @ 476 */
	    "UPS\0" /* 6 refs @ 480 */
	    "AMP\0" /* 1 refs @ 484 */
	    "Cherry\0" /* 1 refs @ 488 */
	    "Mikroschalter\0" /* 1 refs @ 495 */
	    "American\0" /* 4 refs @ 509 */
	    "Megatrends\0" /* 1 refs @ 518 */
	    "Logitech\0" /* 1 refs @ 529 */
	    "Behavior\0" /* 1 refs @ 538 */
	    "Tech.\0" /* 1 refs @ 547 */
	    "Philips\0" /* 2 refs @ 553 */
	    "Sun\0" /* 2 refs @ 561 */
	    "Microsystems\0" /* 5 refs @ 565 */
	    "(official)\0" /* 1 refs @ 578 */
	    "Sanyo\0" /* 2 refs @ 589 */
	    "Seagate\0" /* 1 refs @ 595 */
	    "Connectix\0" /* 1 refs @ 603 */
	    "Kensington\0" /* 1 refs @ 613 */
	    "Lucent\0" /* 1 refs @ 624 */
	    "Plantronics\0" /* 1 refs @ 631 */
	    "Kyocera\0" /* 3 refs @ 643 */
	    "Wireless\0" /* 49 refs @ 651 */
	    "STMicroelectronics\0" /* 1 refs @ 660 */
	    "Foxconn\0" /* 1 refs @ 679 */
	    "/\0" /* 13 refs @ 687 */
	    "Hon\0" /* 1 refs @ 689 */
	    "Hai\0" /* 1 refs @ 693 */
	    "Meizu\0" /* 1 refs @ 697 */
	    "YAMAHA\0" /* 1 refs @ 703 */
	    "Compaq\0" /* 1 refs @ 710 */
	    "Hitachi\0" /* 1 refs @ 717 */
	    "Peripherals\0" /* 1 refs @ 725 */
	    "Davicom\0" /* 1 refs @ 737 */
	    "Visioneer\0" /* 2 refs @ 745 */
	    "Canon\0" /* 2 refs @ 755 */
	    "Nikon\0" /* 1 refs @ 761 */
	    "IBM\0" /* 2 refs @ 767 */
	    "Cypress\0" /* 2 refs @ 771 */
	    "Seiko\0" /* 1 refs @ 779 */
	    "Epson\0" /* 1 refs @ 785 */
	    "Rainbow\0" /* 1 refs @ 791 */
	    "Technologies\0" /* 18 refs @ 799 */
	    "I-O\0" /* 2 refs @ 812 */
	    "Data\0" /* 6 refs @ 816 */
	    "TDK\0" /* 1 refs @ 821 */
	    "U.S.\0" /* 3 refs @ 825 */
	    "Robotics\0" /* 4 refs @ 830 */
	    "Methode\0" /* 1 refs @ 839 */
	    "Far\0" /* 1 refs @ 847 */
	    "East\0" /* 1 refs @ 851 */
	    "Maxi\0" /* 1 refs @ 856 */
	    "Switch\0" /* 1 refs @ 861 */
	    "Lockheed\0" /* 1 refs @ 868 */
	    "Martin\0" /* 1 refs @ 877 */
	    "Energy\0" /* 1 refs @ 884 */
	    "Research\0" /* 3 refs @ 891 */
	    "Toshiba\0" /* 2 refs @ 900 */
	    "America\0" /* 4 refs @ 908 */
	    "Macro\0" /* 1 refs @ 916 */
	    "Konica\0" /* 1 refs @ 922 */
	    "Lite-On\0" /* 1 refs @ 929 */
	    "Fuji\0" /* 2 refs @ 937 */
	    "Photo\0" /* 1 refs @ 942 */
	    "Film\0" /* 1 refs @ 948 */
	    "Semiconductors\0" /* 1 refs @ 953 */
	    "Tatung\0" /* 1 refs @ 968 */
	    "Of\0" /* 1 refs @ 975 */
	    "ScanLogic\0" /* 1 refs @ 978 */
	    "Myson\0" /* 1 refs @ 988 */
	    "Digi\0" /* 2 refs @ 994 */
	    "ITT\0" /* 1 refs @ 999 */
	    "Altec\0" /* 1 refs @ 1003 */
	    "Lansing\0" /* 1 refs @ 1009 */
	    "Microchip\0" /* 1 refs @ 1017 */
	    "Holtek\0" /* 1 refs @ 1027 */
	    "Panasonic\0" /* 1 refs @ 1034 */
	    "(Matsushita)\0" /* 1 refs @ 1044 */
	    "Huan\0" /* 1 refs @ 1057 */
	    "Hsin\0" /* 1 refs @ 1062 */
	    "Sharp\0" /* 1 refs @ 1067 */
	    "Iiyama\0" /* 1 refs @ 1073 */
	    "Exar\0" /* 1 refs @ 1080 */
	    "Shuttle\0" /* 1 refs @ 1085 */
	    "Samsung\0" /* 4 refs @ 1093 */
	    "Annabooks\0" /* 1 refs @ 1101 */
	    "JVC\0" /* 1 refs @ 1111 */
	    "Chicony\0" /* 1 refs @ 1115 */
	    "ELAN\0" /* 1 refs @ 1123 */
	    "Brother\0" /* 1 refs @ 1128 */
	    "Industries\0" /* 1 refs @ 1136 */
	    "Dallas\0" /* 1 refs @ 1147 */
	    "AIPTEK\0" /* 2 refs @ 1154 */
	    "3Com\0" /* 5 refs @ 1161 */
	    "Hosiden\0" /* 1 refs @ 1166 */
	    "Corporation\0" /* 7 refs @ 1174 */
	    "Aztech\0" /* 1 refs @ 1186 */
	    "Belkin\0" /* 2 refs @ 1193 */
	    "Components\0" /* 3 refs @ 1200 */
	    "Kawatsu\0" /* 1 refs @ 1211 */
	    "Composite\0" /* 1 refs @ 1219 */
	    "Power\0" /* 7 refs @ 1229 */
	    "Conversion\0" /* 1 refs @ 1235 */
	    "Connectek\0" /* 1 refs @ 1246 */
	    "USA\0" /* 1 refs @ 1256 */
	    "NetChip\0" /* 1 refs @ 1260 */
	    "ALTRA\0" /* 1 refs @ 1268 */
	    "ATI\0" /* 2 refs @ 1274 */
	    "Aladdin\0" /* 1 refs @ 1278 */
	    "Knowledge\0" /* 1 refs @ 1286 */
	    "Universal\0" /* 1 refs @ 1296 */
	    "ViewSonic\0" /* 1 refs @ 1306 */
	    "Xirlink\0" /* 1 refs @ 1316 */
	    "Anchor\0" /* 1 refs @ 1324 */
	    "Chips\0" /* 1 refs @ 1331 */
	    "Sony\0" /* 15 refs @ 1337 */
	    "VLSI\0" /* 1 refs @ 1342 */
	    "Vision\0" /* 1 refs @ 1347 */
	    "Asahi\0" /* 2 refs @ 1354 */
	    "Kasei\0" /* 1 refs @ 1360 */
	    "ATEN\0" /* 1 refs @ 1366 */
	    "Mustek\0" /* 1 refs @ 1371 */
	    "Telex\0" /* 1 refs @ 1378 */
	    "Communications\0" /* 12 refs @ 1384 */
	    "Peracom\0" /* 1 refs @ 1399 */
	    "Networks\0" /* 4 refs @ 1407 */
	    "Alcor\0" /* 2 refs @ 1416 */
	    "Xyratex\0" /* 1 refs @ 1422 */
	    "WACOM\0" /* 1 refs @ 1430 */
	    "e-TEK\0" /* 1 refs @ 1436 */
	    "EIZO\0" /* 2 refs @ 1442 */
	    "Elecom\0" /* 1 refs @ 1447 */
	    "Conexant\0" /* 1 refs @ 1454 */
	    "Hauppauge\0" /* 2 refs @ 1463 */
	    "Works\0" /* 2 refs @ 1473 */
	    "BAFO/Quality\0" /* 1 refs @ 1479 */
	    "Accessories\0" /* 1 refs @ 1492 */
	    "Y-E\0" /* 1 refs @ 1504 */
	    "AVM\0" /* 1 refs @ 1508 */
	    "Nintendo\0" /* 2 refs @ 1512 */
	    "Quickshot\0" /* 1 refs @ 1521 */
	    "Roland\0" /* 1 refs @ 1531 */
	    "Rockfire\0" /* 1 refs @ 1538 */
	    "RATOC\0" /* 1 refs @ 1547 */
	    "ZyXEL\0" /* 2 refs @ 1553 */
	    "Communication\0" /* 2 refs @ 1559 */
	    "Iomega\0" /* 1 refs @ 1573 */
	    "A-Trend\0" /* 1 refs @ 1580 */
	    "Input\0" /* 1 refs @ 1588 */
	    "LaCie\0" /* 1 refs @ 1594 */
	    "Cisco-Linksys\0" /* 3 refs @ 1600 */
	    "OmniVision\0" /* 2 refs @ 1614 */
	    "In-System\0" /* 1 refs @ 1625 */
	    "Design\0" /* 2 refs @ 1635 */
	    "Apple\0" /* 29 refs @ 1642 */
	    "Qualcomm\0" /* 3 refs @ 1648 */
	    "Qtronix\0" /* 1 refs @ 1657 */
	    "ELSA\0" /* 2 refs @ 1665 */
	    "Brainboxes\0" /* 1 refs @ 1670 */
	    "Limited\0" /* 1 refs @ 1681 */
	    "Ultima\0" /* 1 refs @ 1689 */
	    "Axiohm\0" /* 1 refs @ 1696 */
	    "Transaction\0" /* 1 refs @ 1703 */
	    "Solutions\0" /* 2 refs @ 1715 */
	    "Microtek\0" /* 1 refs @ 1725 */
	    "SUN\0" /* 1 refs @ 1734 */
	    "Lexar\0" /* 1 refs @ 1738 */
	    "Media\0" /* 1 refs @ 1744 */
	    "Addtron\0" /* 1 refs @ 1750 */
	    "Symbol\0" /* 1 refs @ 1758 */
	    "Genesys\0" /* 1 refs @ 1765 */
	    "Logic\0" /* 2 refs @ 1773 */
	    "Keithley\0" /* 1 refs @ 1779 */
	    "Nanao\0" /* 1 refs @ 1788 */
	    "Kawasaki\0" /* 1 refs @ 1794 */
	    "LSI\0" /* 1 refs @ 1803 */
	    "FFC\0" /* 1 refs @ 1807 */
	    "Anko\0" /* 1 refs @ 1811 */
	    "Electronic\0" /* 2 refs @ 1816 */
	    "P.I.\0" /* 1 refs @ 1827 */
	    "Engineering\0" /* 1 refs @ 1832 */
	    "AOC\0" /* 1 refs @ 1844 */
	    "Chic\0" /* 1 refs @ 1848 */
	    "Barco\0" /* 1 refs @ 1853 */
	    "Display\0" /* 1 refs @ 1859 */
	    "Bridge\0" /* 23 refs @ 1867 */
	    "Information\0" /* 2 refs @ 1874 */
	    "SMK\0" /* 1 refs @ 1886 */
	    "Solid\0" /* 3 refs @ 1890 */
	    "Year\0" /* 2 refs @ 1896 */
	    "Bio-Rad\0" /* 1 refs @ 1901 */
	    "Laboratories\0" /* 1 refs @ 1909 */
	    "Macally\0" /* 1 refs @ 1922 */
	    "Act\0" /* 1 refs @ 1930 */
	    "Alaris\0" /* 1 refs @ 1934 */
	    "Apex\0" /* 1 refs @ 1941 */
	    "Vivitar\0" /* 1 refs @ 1946 */
	    "Avision\0" /* 1 refs @ 1954 */
	    "TEAC\0" /* 1 refs @ 1962 */
	    "Graphics\0" /* 2 refs @ 1967 */
	    "Sanwa\0" /* 1 refs @ 1976 */
	    "Supply\0" /* 6 refs @ 1982 */
	    "WayTech\0" /* 1 refs @ 1989 */
	    "Development,\0" /* 1 refs @ 1997 */
	    "Linksys\0" /* 4 refs @ 2010 */
	    "Sigmatel\0" /* 1 refs @ 2018 */
	    "DrayTek\0" /* 1 refs @ 2027 */
	    "Aiwa\0" /* 1 refs @ 2035 */
	    "ACARD\0" /* 1 refs @ 2040 */
	    "Prolific\0" /* 2 refs @ 2046 */
	    "Siemens\0" /* 3 refs @ 2055 */
	    "Avance\0" /* 1 refs @ 2063 */
	    "Minolta\0" /* 1 refs @ 2070 */
	    "CH\0" /* 1 refs @ 2078 */
	    "Products\0" /* 3 refs @ 2081 */
	    "Hagiwara\0" /* 1 refs @ 2090 */
	    "Sys-Com\0" /* 1 refs @ 2099 */
	    "Chuntex\0" /* 1 refs @ 2107 */
	    "Askey\0" /* 1 refs @ 2115 */
	    "Saitek\0" /* 1 refs @ 2121 */
	    "Alcatel\0" /* 2 refs @ 2128 */
	    "Telecom\0" /* 1 refs @ 2136 */
	    "AGFA-Gevaert\0" /* 1 refs @ 2144 */
	    "Asia\0" /* 1 refs @ 2157 */
	    "Microelectronic\0" /* 1 refs @ 2162 */
	    "Development\0" /* 1 refs @ 2178 */
	    "Bizlink\0" /* 1 refs @ 2190 */
	    "Keyspan\0" /* 1 refs @ 2198 */
	    "Aashima\0" /* 1 refs @ 2206 */
	    "MultiTech\0" /* 2 refs @ 2214 */
	    "ADS\0" /* 2 refs @ 2224 */
	    "Sirius\0" /* 1 refs @ 2228 */
	    "Guillemot\0" /* 1 refs @ 2235 */
	    "Boston\0" /* 1 refs @ 2245 */
	    "Acoustics\0" /* 1 refs @ 2252 */
	    "Standard\0" /* 2 refs @ 2262 */
	    "Putercom\0" /* 1 refs @ 2271 */
	    "MCT\0" /* 1 refs @ 2280 */
	    "Imation\0" /* 1 refs @ 2284 */
	    "Susteen\0" /* 1 refs @ 2292 */
	    "Eicon\0" /* 1 refs @ 2300 */
	    "Mad\0" /* 1 refs @ 2306 */
	    "Catz,\0" /* 1 refs @ 2310 */
	    "Digital\0" /* 25 refs @ 2316 */
	    "Stream\0" /* 1 refs @ 2324 */
	    "Aureal\0" /* 1 refs @ 2331 */
	    "Midiman\0" /* 1 refs @ 2338 */
	    "CyberPower\0" /* 1 refs @ 2346 */
	    "Systems,\0" /* 1 refs @ 2357 */
	    "X-Rite\0" /* 1 refs @ 2366 */
	    "Surecom\0" /* 1 refs @ 2373 */
	    "Griffin\0" /* 1 refs @ 2381 */
	    "SanDisk\0" /* 1 refs @ 2389 */
	    "Jenoptik\0" /* 1 refs @ 2397 */
	    "Logitec\0" /* 2 refs @ 2406 */
	    "Brimax\0" /* 1 refs @ 2414 */
	    "Axis\0" /* 1 refs @ 2421 */
	    "ABL\0" /* 1 refs @ 2426 */
	    "Sagem\0" /* 1 refs @ 2430 */
	    "Communications,\0" /* 1 refs @ 2436 */
	    "Alfadata\0" /* 1 refs @ 2452 */
	    "Technical\0" /* 1 refs @ 2461 */
	    "Onnto\0" /* 1 refs @ 2471 */
	    "Be\0" /* 1 refs @ 2477 */
	    "ADMtek\0" /* 1 refs @ 2480 */
	    "Corega\0" /* 1 refs @ 2487 */
	    "Freecom\0" /* 2 refs @ 2494 */
	    "Microtech\0" /* 1 refs @ 2502 */
	    "General\0" /* 1 refs @ 2512 */
	    "(Motorola)\0" /* 1 refs @ 2520 */
	    "Olympus\0" /* 1 refs @ 2531 */
	    "AboCom\0" /* 2 refs @ 2539 */
	    "KingSun\0" /* 1 refs @ 2546 */
	    "Keisokugiken\0" /* 1 refs @ 2554 */
	    "OnSpec\0" /* 2 refs @ 2567 */
	    "APG\0" /* 1 refs @ 2574 */
	    "Cash\0" /* 1 refs @ 2578 */
	    "Drawer\0" /* 1 refs @ 2583 */
	    "B.U.G.\0" /* 1 refs @ 2590 */
	    "Allied\0" /* 2 refs @ 2597 */
	    "Telesyn\0" /* 1 refs @ 2604 */
	    "AVerMedia\0" /* 1 refs @ 2612 */
	    "SIIG\0" /* 2 refs @ 2622 */
	    "CASIO\0" /* 2 refs @ 2627 */
	    "D-Link\0" /* 4 refs @ 2633 */
	    "Aptio\0" /* 1 refs @ 2640 */
	    "Arasan\0" /* 1 refs @ 2646 */
	    "Chip\0" /* 2 refs @ 2653 */
	    "Cable\0" /* 10 refs @ 2658 */
	    "STSN\0" /* 1 refs @ 2664 */
	    "Bewan\0" /* 1 refs @ 2669 */
	    "CENTURY\0" /* 1 refs @ 2675 */
	    "Zoom\0" /* 2 refs @ 2683 */
	    "Telephonics\0" /* 1 refs @ 2688 */
	    "Zoran\0" /* 1 refs @ 2700 */
	    "Synet\0" /* 1 refs @ 2706 */
	    "BroadLogic\0" /* 1 refs @ 2712 */
	    "Handspring\0" /* 4 refs @ 2723 */
	    "Palm\0" /* 11 refs @ 2734 */
	    "Computing\0" /* 1 refs @ 2739 */
	    "SOURCENEXT\0" /* 1 refs @ 2749 */
	    "Action\0" /* 2 refs @ 2760 */
	    "Star\0" /* 2 refs @ 2767 */
	    "Enterprise\0" /* 1 refs @ 2772 */
	    "Accton\0" /* 1 refs @ 2783 */
	    "BayNETGEAR\0" /* 1 refs @ 2790 */
	    "ActiveWire\0" /* 1 refs @ 2801 */
	    "B&B\0" /* 1 refs @ 2812 */
	    "PortGear\0" /* 1 refs @ 2816 */
	    "Netgear\0" /* 3 refs @ 2825 */
	    "System\0" /* 8 refs @ 2833 */
	    "Talks\0" /* 1 refs @ 2840 */
	    "Metricom\0" /* 1 refs @ 2846 */
	    "ADESSO/Kbtek\0" /* 1 refs @ 2855 */
	    "Jaton\0" /* 1 refs @ 2868 */
	    "APT\0" /* 1 refs @ 2874 */
	    "Boca\0" /* 2 refs @ 2878 */
	    "Andrea\0" /* 1 refs @ 2883 */
	    "Burr-Brown\0" /* 1 refs @ 2890 */
	    "Japan\0" /* 2 refs @ 2901 */
	    "2Wire\0" /* 1 refs @ 2907 */
	    "SmartBridges\0" /* 1 refs @ 2913 */
	    "Billionton\0" /* 1 refs @ 2926 */
	    "Extended\0" /* 3 refs @ 2937 */
	    "M-Systems\0" /* 1 refs @ 2946 */
	    "AuthenTec\0" /* 1 refs @ 2956 */
	    "Audio-Technica\0" /* 1 refs @ 2966 */
	    "Trumpion\0" /* 1 refs @ 2981 */
	    "Alation\0" /* 1 refs @ 2990 */
	    "Globespan\0" /* 1 refs @ 2998 */
	    "Concord\0" /* 1 refs @ 3008 */
	    "Camera\0" /* 26 refs @ 3016 */
	    "Garmin\0" /* 1 refs @ 3023 */
	    "GoHubs\0" /* 1 refs @ 3030 */
	    "Biometric\0" /* 1 refs @ 3037 */
	    "Company\0" /* 2 refs @ 3047 */
	    "PixArt\0" /* 1 refs @ 3055 */
	    "Plextor\0" /* 1 refs @ 3062 */
	    "Intrepid\0" /* 1 refs @ 3070 */
	    "KORG\0" /* 1 refs @ 3079 */
	    "Incorporated\0" /* 2 refs @ 3084 */
	    "Yano\0" /* 1 refs @ 3097 */
	    "Kingston\0" /* 1 refs @ 3102 */
	    "BlueWater\0" /* 1 refs @ 3111 */
	    "Agilent\0" /* 1 refs @ 3121 */
	    "Gude\0" /* 1 refs @ 3129 */
	    "Portsmith\0" /* 1 refs @ 3134 */
	    "GretagMacbeth\0" /* 1 refs @ 3144 */
	    "Adirondack\0" /* 1 refs @ 3158 */
	    "Wire\0" /* 1 refs @ 3169 */
	    "&\0" /* 11 refs @ 3174 */
	    "Beckhoff\0" /* 1 refs @ 3176 */
	    "Minds\0" /* 1 refs @ 3185 */
	    "At\0" /* 2 refs @ 3191 */
	    "Work\0" /* 1 refs @ 3194 */
	    "Zippy\0" /* 1 refs @ 3199 */
	    "PointChips\0" /* 1 refs @ 3205 */
	    "Intersil\0" /* 1 refs @ 3216 */
	    "Tripp\0" /* 3 refs @ 3225 */
	    "Lite\0" /* 5 refs @ 3231 */
	    "Altius\0" /* 1 refs @ 3236 */
	    "Arris\0" /* 1 refs @ 3243 */
	    "Interactive\0" /* 1 refs @ 3249 */
	    "ACTIVCARD\0" /* 1 refs @ 3261 */
	    "ACTiSYS\0" /* 1 refs @ 3271 */
	    "Novatel\0" /* 8 refs @ 3279 */
	    "A-FOUR\0" /* 1 refs @ 3287 */
	    "TECH\0" /* 1 refs @ 3294 */
	    "AIMEX\0" /* 1 refs @ 3299 */
	    "Addonics\0" /* 2 refs @ 3305 */
	    "AKAI\0" /* 1 refs @ 3314 */
	    "professional\0" /* 1 refs @ 3319 */
	    "M.I.\0" /* 1 refs @ 3332 */
	    "ARESCOM\0" /* 1 refs @ 3337 */
	    "Bay\0" /* 1 refs @ 3345 */
	    "Associates\0" /* 1 refs @ 3349 */
	    "Altera\0" /* 1 refs @ 3360 */
	    "Cambridge\0" /* 1 refs @ 3367 */
	    "Radio\0" /* 8 refs @ 3377 */
	    "Trek\0" /* 1 refs @ 3383 */
	    "Optical\0" /* 10 refs @ 3388 */
	    "ShanTou\0" /* 1 refs @ 3396 */
	    "MediaGear\0" /* 1 refs @ 3404 */
	    "Broadcom\0" /* 2 refs @ 3414 */
	    "GREENHOUSE\0" /* 1 refs @ 3423 */
	    "Geocast\0" /* 1 refs @ 3434 */
	    "Network\0" /* 12 refs @ 3442 */
	    "Zydas\0" /* 1 refs @ 3450 */
	    "Neodio\0" /* 1 refs @ 3456 */
	    "Option\0" /* 1 refs @ 3463 */
	    "N.V.\0" /* 1 refs @ 3470 */
	    "ASUSTeK\0" /* 2 refs @ 3475 */
	    "Todos\0" /* 1 refs @ 3483 */
	    "Tekram\0" /* 1 refs @ 3489 */
	    "HAL\0" /* 1 refs @ 3496 */
	    "EMS\0" /* 1 refs @ 3500 */
	    "Production\0" /* 1 refs @ 3504 */
	    "Zeevo,\0" /* 1 refs @ 3515 */
	    "Kurusugawa\0" /* 1 refs @ 3522 */
	    "Electronics,\0" /* 1 refs @ 3533 */
	    "ASIX\0" /* 1 refs @ 3546 */
	    "Inc\0" /* 2 refs @ 3551 */
	    "O2\0" /* 1 refs @ 3555 */
	    "Ambit\0" /* 1 refs @ 3558 */
	    "HTC\0" /* 1 refs @ 3564 */
	    "Realtek\0" /* 1 refs @ 3568 */
	    "Computers\0" /* 1 refs @ 3576 */
	    "Agate\0" /* 1 refs @ 3586 */
	    "DMI\0" /* 1 refs @ 3592 */
	    "Microdia\0" /* 1 refs @ 3596 */
	    "Sonix\0" /* 1 refs @ 3605 */
	    "Co.,\0" /* 3 refs @ 3611 */
	    "Ltd.\0" /* 3 refs @ 3616 */
	    "Sealevel\0" /* 1 refs @ 3621 */
	    "EasyDisk\0" /* 2 refs @ 3630 */
	    "Z-Com\0" /* 1 refs @ 3639 */
	    "Atheros\0" /* 2 refs @ 3645 */
	    "Tangtop\0" /* 1 refs @ 3653 */
	    "Pen\0" /* 4 refs @ 3661 */
	    "Drive\0" /* 11 refs @ 3665 */
	    "C-Media\0" /* 1 refs @ 3671 */
	    "Conceptronic\0" /* 2 refs @ 3679 */
	    "ELCON\0" /* 1 refs @ 3692 */
	    "Systemtechnik\0" /* 1 refs @ 3698 */
	    "NetworkFab\0" /* 1 refs @ 3712 */
	    "Sitecom\0" /* 3 refs @ 3723 */
	    "Europe\0" /* 1 refs @ 3731 */
	    "Amigo\0" /* 1 refs @ 3738 */
	    "Hawking\0" /* 1 refs @ 3744 */
	    "G.Mate,\0" /* 1 refs @ 3752 */
	    "MTK\0" /* 1 refs @ 3760 */
	    "Ours\0" /* 1 refs @ 3764 */
	    "Pilotech\0" /* 1 refs @ 3769 */
	    "Nova\0" /* 1 refs @ 3778 */
	    "Tech\0" /* 3 refs @ 3783 */
	    "eGalax\0" /* 1 refs @ 3788 */
	    "TOD\0" /* 1 refs @ 3795 */
	    "AirPrime,\0" /* 1 refs @ 3799 */
	    "VTech\0" /* 1 refs @ 3809 */
	    "Falcom\0" /* 1 refs @ 3815 */
	    "GmbH\0" /* 2 refs @ 3822 */
	    "In\0" /* 1 refs @ 3827 */
	    "Motion\0" /* 1 refs @ 3830 */
	    "Dynastream\0" /* 1 refs @ 3837 */
	    "Innovations\0" /* 1 refs @ 3848 */
	    "SUNRISING\0" /* 1 refs @ 3860 */
	    "DViCO\0" /* 1 refs @ 3870 */
	    "LG\0" /* 1 refs @ 3876 */
	    "Motorola\0" /* 3 refs @ 3879 */
	    "GIGABYTE\0" /* 1 refs @ 3888 */
	    "Yubico.se\0" /* 1 refs @ 3897 */
	    "Western\0" /* 1 refs @ 3907 */
	    "CCYU\0" /* 1 refs @ 3915 */
	    "Hyundai\0" /* 1 refs @ 3920 */
	    "CuriTel\0" /* 1 refs @ 3928 */
	    "SILABS2\0" /* 1 refs @ 3936 */
	    "USI\0" /* 1 refs @ 3944 */
	    "PLX\0" /* 1 refs @ 3948 */
	    "Asante\0" /* 1 refs @ 3952 */
	    "Ten\0" /* 1 refs @ 3959 */
	    "X\0" /* 2 refs @ 3963 */
	    "Technology,\0" /* 1 refs @ 3965 */
	    "Sphairon\0" /* 1 refs @ 3977 */
	    "DeLorme\0" /* 1 refs @ 3986 */
	    "ServerWorks\0" /* 1 refs @ 3994 */
	    "Multimedia\0" /* 3 refs @ 4006 */
	    "Sierra\0" /* 16 refs @ 4017 */
	    "Topfield\0" /* 1 refs @ 4024 */
	    "Ltd\0" /* 3 refs @ 4033 */
	    "NetIndex\0" /* 1 refs @ 4037 */
	    "InterBiometrics\0" /* 1 refs @ 4046 */
	    "Tsunami\0" /* 1 refs @ 4062 */
	    "Pheenet\0" /* 1 refs @ 4070 */
	    "Targus\0" /* 1 refs @ 4078 */
	    "TwinMOS\0" /* 1 refs @ 4085 */
	    "CyberTAN\0" /* 1 refs @ 4093 */
	    "Huawei\0" /* 20 refs @ 4102 */
	    "Araneus\0" /* 1 refs @ 4109 */
	    "Oy\0" /* 1 refs @ 4117 */
	    "Aincomm\0" /* 1 refs @ 4120 */
	    "Mobility\0" /* 1 refs @ 4128 */
	    "Dick\0" /* 1 refs @ 4137 */
	    "Smith\0" /* 1 refs @ 4142 */
	    "Validity\0" /* 1 refs @ 4148 */
	    "Sensors,\0" /* 1 refs @ 4157 */
	    "Baltech\0" /* 1 refs @ 4166 */
	    "Shark\0" /* 1 refs @ 4174 */
	    "AzureWave\0" /* 1 refs @ 4180 */
	    "Phison\0" /* 1 refs @ 4190 */
	    "Technologies,\0" /* 1 refs @ 4197 */
	    "Merlin\0" /* 9 refs @ 4211 */
	    "Wistron\0" /* 1 refs @ 4218 */
	    "NeWeb\0" /* 1 refs @ 4226 */
	    "Huawei-3Com\0" /* 1 refs @ 4232 */
	    "Silicom\0" /* 1 refs @ 4244 */
	    "Ralink\0" /* 1 refs @ 4252 */
	    "SuperTop\0" /* 2 refs @ 4259 */
	    "Planex\0" /* 3 refs @ 4268 */
	    "Portals\0" /* 1 refs @ 4275 */
	    "TOPPING\0" /* 1 refs @ 4283 */
	    "co.\0" /* 1 refs @ 4291 */
	    "JMicron\0" /* 1 refs @ 4295 */
	    "OQO\0" /* 1 refs @ 4303 */
	    "U-MEDIA\0" /* 1 refs @ 4307 */
	    "Fiberline\0" /* 1 refs @ 4315 */
	    "SparkLAN\0" /* 1 refs @ 4325 */
	    "AMIT\0" /* 2 refs @ 4334 */
	    "SOHOware\0" /* 1 refs @ 4339 */
	    "UMAX\0" /* 1 refs @ 4348 */
	    "Inside\0" /* 1 refs @ 4353 */
	    "Out\0" /* 1 refs @ 4360 */
	    "Good\0" /* 1 refs @ 4364 */
	    "Way\0" /* 1 refs @ 4369 */
	    "Entrega\0" /* 1 refs @ 4373 */
	    "Actiontec\0" /* 1 refs @ 4381 */
	    "Gigaset\0" /* 1 refs @ 4391 */
	    "AnyDATA\0" /* 1 refs @ 4399 */
	    "Jablotron\0" /* 1 refs @ 4407 */
	    "Senao\0" /* 1 refs @ 4417 */
	    "ASMedia\0" /* 1 refs @ 4423 */
	    "Sweex\0" /* 2 refs @ 4431 */
	    "Misc\0" /* 1 refs @ 4437 */
	    "Vendors\0" /* 1 refs @ 4442 */
	    "DisplayLink\0" /* 5 refs @ 4450 */
	    "Lenovo\0" /* 4 refs @ 4462 */
	    "E3C\0" /* 1 refs @ 4469 */
	    "Qcom\0" /* 1 refs @ 4473 */
	    "Meinberg\0" /* 1 refs @ 4478 */
	    "Funkuhren\0" /* 1 refs @ 4487 */
	    "Beceem\0" /* 1 refs @ 4497 */
	    "ZTE\0" /* 1 refs @ 4504 */
	    "Quanta\0" /* 1 refs @ 4508 */
	    "Terminus\0" /* 1 refs @ 4515 */
	    "QinHeng\0" /* 2 refs @ 4524 */
	    "OvisLink\0" /* 1 refs @ 4532 */
	    "Sigma\0" /* 1 refs @ 4541 */
	    "Longcheer\0" /* 2 refs @ 4547 */
	    "MPMan\0" /* 1 refs @ 4557 */
	    "Pegatron\0" /* 1 refs @ 4563 */
	    "Bits\0" /* 1 refs @ 4572 */
	    "Linux\0" /* 3 refs @ 4577 */
	    "Foundation\0" /* 1 refs @ 4583 */
	    "Cinterion\0" /* 1 refs @ 4594 */
	    "AirTies\0" /* 1 refs @ 4604 */
	    "Encore\0" /* 1 refs @ 4612 */
	    "PARA\0" /* 1 refs @ 4619 */
	    "Industrial\0" /* 1 refs @ 4624 */
	    "TRENDnet\0" /* 1 refs @ 4635 */
	    "RT\0" /* 1 refs @ 4644 */
	    "Ericsson\0" /* 1 refs @ 4647 */
	    "Pinnacle\0" /* 4 refs @ 4656 */
	    "Arduino\0" /* 1 refs @ 4665 */
	    "SA\0" /* 1 refs @ 4673 */
	    "TP-Link\0" /* 1 refs @ 4676 */
	    "West\0" /* 1 refs @ 4684 */
	    "Mountain\0" /* 1 refs @ 4689 */
	    "Tripp-Lite\0" /* 1 refs @ 4698 */
	    "Cooler\0" /* 1 refs @ 4709 */
	    "Master\0" /* 1 refs @ 4716 */
	    "HAILUCK\0" /* 1 refs @ 4723 */
	    "Hirose\0" /* 1 refs @ 4731 */
	    "ONEPLUS\0" /* 1 refs @ 4738 */
	    "NHJ\0" /* 1 refs @ 4746 */
	    "Mercusys\0" /* 1 refs @ 4750 */
	    "VidzMedia\0" /* 1 refs @ 4759 */
	    "Pte\0" /* 1 refs @ 4769 */
	    "AEI\0" /* 2 refs @ 4773 */
	    "Hank\0" /* 1 refs @ 4777 */
	    "Connection\0" /* 1 refs @ 4782 */
	    "PQI\0" /* 1 refs @ 4793 */
	    "Daisy\0" /* 1 refs @ 4797 */
	    "Micronet\0" /* 1 refs @ 4803 */
	    "iRiver\0" /* 1 refs @ 4812 */
	    "Dell\0" /* 2 refs @ 4819 */
	    "FeiXun\0" /* 1 refs @ 4824 */
	    "Averatec\0" /* 1 refs @ 4831 */
	    "Zinwell\0" /* 1 refs @ 4840 */
	    "Ingenic\0" /* 1 refs @ 4848 */
	    "Springer\0" /* 2 refs @ 4856 */
	    "Design,\0" /* 1 refs @ 4865 */
	    "ArkMicroChips\0" /* 1 refs @ 4873 */
	    "EDIMAX\0" /* 1 refs @ 4887 */
	    "Intel\0" /* 2 refs @ 4894 */
	    "ALLWIN\0" /* 1 refs @ 4900 */
	    "MosChip\0" /* 1 refs @ 4907 */
	    "FTDI\0" /* 1 refs @ 4915 */
	    "CACE\0" /* 1 refs @ 4920 */
	    "Compare\0" /* 1 refs @ 4925 */
	    "DataApex\0" /* 1 refs @ 4933 */
	    "Evolution\0" /* 1 refs @ 4942 */
	    "eMPIA\0" /* 1 refs @ 4952 */
	    "GNU\0" /* 1 refs @ 4958 */
	    "USRP\0" /* 2 refs @ 4962 */
	    "HomeConnect\0" /* 4 refs @ 4967 */
	    "USB\0" /* 218 refs @ 4979 */
	    "Bluetooth\0" /* 27 refs @ 4983 */
	    "Adapter\0" /* 79 refs @ 4993 */
	    "3C19250\0" /* 1 refs @ 5001 */
	    "Ethernet\0" /* 92 refs @ 5009 */
	    "adapter\0" /* 92 refs @ 5018 */
	    "3CRSHEW696\0" /* 1 refs @ 5026 */
	    "3C460\0" /* 1 refs @ 5037 */
	    "U.S.Robotics\0" /* 2 refs @ 5043 */
	    "56000\0" /* 2 refs @ 5056 */
	    "Voice\0" /* 2 refs @ 5062 */
	    "Faxmodem\0" /* 2 refs @ 5068 */
	    "Pro\0" /* 20 refs @ 5077 */
	    "3C460B\0" /* 1 refs @ 5081 */
	    "3CRUSB10075\0" /* 1 refs @ 5088 */
	    "OfficeConnect\0" /* 1 refs @ 5100 */
	    "Modem\0" /* 14 refs @ 5114 */
	    "ISDN\0" /* 3 refs @ 5120 */
	    "TA\0" /* 2 refs @ 5125 */
	    "camera\0" /* 5 refs @ 5128 */
	    "HUB\0" /* 1 refs @ 5135 */
	    "Secure\0" /* 2 refs @ 5139 */
	    "Write\0" /* 2 refs @ 5146 */
	    "with\0" /* 5 refs @ 5152 */
	    "XX1\0" /* 1 refs @ 5157 */
	    "XX2\0" /* 1 refs @ 5161 */
	    "RT2770\0" /* 5 refs @ 5165 */
	    "RT2870\0" /* 69 refs @ 5172 */
	    "RT3070\0" /* 68 refs @ 5179 */
	    "RT3071\0" /* 5 refs @ 5186 */
	    "RT3072\0" /* 23 refs @ 5193 */
	    "URE450\0" /* 1 refs @ 5200 */
	    "UFE1000\0" /* 1 refs @ 5207 */
	    "Fast\0" /* 5 refs @ 5215 */
	    "1/10/100\0" /* 2 refs @ 5220 */
	    "ethernet\0" /* 32 refs @ 5229 */
	    "XX4\0" /* 1 refs @ 5238 */
	    "XX5\0" /* 1 refs @ 5242 */
	    "XX6\0" /* 1 refs @ 5246 */
	    "XX7\0" /* 1 refs @ 5250 */
	    "LCS-8138TX\0" /* 1 refs @ 5254 */
	    "XX8\0" /* 1 refs @ 5265 */
	    "XX9\0" /* 1 refs @ 5269 */
	    "UFE2000\0" /* 1 refs @ 5273 */
	    "USB2.0\0" /* 7 refs @ 5281 */
	    "WL54\0" /* 1 refs @ 5288 */
	    "RTL8192CU\0" /* 24 refs @ 5293 */
	    "RTL8188EU\0" /* 3 refs @ 5303 */
	    "RTL8188CU\0" /* 21 refs @ 5313 */
	    "XX10\0" /* 1 refs @ 5323 */
	    "BWU613\0" /* 1 refs @ 5328 */
	    "HWU54DM\0" /* 1 refs @ 5335 */
	    "RT2573\0" /* 19 refs @ 5343 */
	    "WUG2700\0" /* 1 refs @ 5350 */
	    "USB320-EC\0" /* 1 refs @ 5358 */
	    "2664W\0" /* 1 refs @ 5368 */
	    "T-Sinus\0" /* 1 refs @ 5374 */
	    "111\0" /* 1 refs @ 5382 */
	    "WLAN\0" /* 46 refs @ 5386 */
	    "SMCWUSB-G\0" /* 1 refs @ 5391 */
	    "SMCWUSBT-G2\0" /* 2 refs @ 5401 */
	    "PrismGT\0" /* 13 refs @ 5413 */
	    "2.0\0" /* 38 refs @ 5421 */
	    "SpeedStream\0" /* 3 refs @ 5425 */
	    "AR9280+AR7010\0" /* 2 refs @ 5437 */
	    "RTL8192SU\0" /* 23 refs @ 5451 */
	    "ZD1211B\0" /* 11 refs @ 5461 */
	    "WN4501H-LF-IR\0" /* 1 refs @ 5469 */
	    "WUS-201\0" /* 1 refs @ 5483 */
	    "WN7512\0" /* 1 refs @ 5491 */
	    "EP-1427X-2\0" /* 1 refs @ 5498 */
	    "Link\0" /* 1 refs @ 5509 */
	    "Acerscan\0" /* 4 refs @ 5514 */
	    "C310U\0" /* 1 refs @ 5523 */
	    "320U\0" /* 1 refs @ 5529 */
	    "640U\0" /* 2 refs @ 5534 */
	    "620U\0" /* 1 refs @ 5539 */
	    "ATA/ATAPI\0" /* 4 refs @ 5544 */
	    "AWL300\0" /* 1 refs @ 5554 */
	    "AWL400\0" /* 1 refs @ 5561 */
	    "Warplink\0" /* 1 refs @ 5568 */
	    "Prism2.5\0" /* 3 refs @ 5577 */
	    "A\0" /* 1 refs @ 5586 */
	    "AR9287+AR7010\0" /* 2 refs @ 5588 */
	    "ROPEX\0" /* 1 refs @ 5602 */
	    "FreeLan\0" /* 1 refs @ 5608 */
	    "802.11b\0" /* 6 refs @ 5616 */
	    "UAT1\0" /* 1 refs @ 5624 */
	    "ACT-IR2000U\0" /* 1 refs @ 5629 */
	    "FIR\0" /* 2 refs @ 5641 */
	    "I/O\0" /* 2 refs @ 5645 */
	    "Board\0" /* 2 refs @ 5649 */
	    "Board,\0" /* 1 refs @ 5655 */
	    "rev.\0" /* 1 refs @ 5662 */
	    "1\0" /* 15 refs @ 5667 */
	    "firmware\0" /* 1 refs @ 5669 */
	    "AWN-8020\0" /* 1 refs @ 5678 */
	    "205\0" /* 2 refs @ 5687 */
	    "AWU-120\0" /* 1 refs @ 5691 */
	    "AN986A\0" /* 1 refs @ 5699 */
	    "AN986\0" /* 1 refs @ 5706 */
	    "AN8511\0" /* 1 refs @ 5712 */
	    "AN8513\0" /* 1 refs @ 5719 */
	    "ADM8515\0" /* 2 refs @ 5726 */
	    "UBS-10BT\0" /* 2 refs @ 5734 */
	    "InstantFM\0" /* 1 refs @ 5743 */
	    "Music\0" /* 1 refs @ 5753 */
	    "to\0" /* 15 refs @ 5759 */
	    "Lan\0" /* 1 refs @ 5762 */
	    "Q-Drive\0" /* 1 refs @ 5766 */
	    "SnapScan\0" /* 10 refs @ 5774 */
	    "1212U\0" /* 2 refs @ 5783 */
	    "1236U\0" /* 2 refs @ 5789 */
	    "Touch\0" /* 7 refs @ 5795 */
	    "e40\0" /* 1 refs @ 5801 */
	    "e50\0" /* 1 refs @ 5805 */
	    "e20\0" /* 1 refs @ 5809 */
	    "e25\0" /* 1 refs @ 5813 */
	    "e26\0" /* 1 refs @ 5817 */
	    "e52\0" /* 1 refs @ 5821 */
	    "Alea\0" /* 1 refs @ 5825 */
	    "I/II\0" /* 1 refs @ 5830 */
	    "TRNG\0" /* 1 refs @ 5835 */
	    "AWU2000B\0" /* 1 refs @ 5840 */
	    "PenCam\0" /* 1 refs @ 5849 */
	    "Mega\0" /* 1 refs @ 5856 */
	    "1.3\0" /* 1 refs @ 5861 */
	    "CDMA\0" /* 7 refs @ 5865 */
	    "PC\0" /* 11 refs @ 5870 */
	    "Card\0" /* 10 refs @ 5873 */
	    "USB-HASP\0" /* 1 refs @ 5878 */
	    "0.06\0" /* 1 refs @ 5887 */
	    "SpeedTouch\0" /* 2 refs @ 5892 */
	    "120g\0" /* 1 refs @ 5903 */
	    "121g\0" /* 1 refs @ 5908 */
	    "Kbd\0" /* 3 refs @ 5913 */
	    "Hub\0" /* 37 refs @ 5917 */
	    "AU6366\0" /* 1 refs @ 5921 */
	    "Single\0" /* 1 refs @ 5928 */
	    "LUN\0" /* 1 refs @ 5935 */
	    "Multiple\0" /* 1 refs @ 5939 */
	    "Flash\0" /* 9 refs @ 5948 */
	    "Reader\0" /* 25 refs @ 5954 */
	    "Controller\0" /* 22 refs @ 5961 */
	    "MacAlly\0" /* 1 refs @ 5972 */
	    "AU9814\0" /* 1 refs @ 5980 */
	    "MicroConnectors/StrongMan\0" /* 1 refs @ 5987 */
	    "Keyboard\0" /* 20 refs @ 6013 */
	    "RT2070\0" /* 2 refs @ 6022 */
	    "RT3572\0" /* 2 refs @ 6029 */
	    "ADA70\0" /* 1 refs @ 6036 */
	    "Speakers\0" /* 3 refs @ 6042 */
	    "ASC495\0" /* 1 refs @ 6051 */
	    "Uninterruptible\0" /* 5 refs @ 6058 */
	    "NTL\0" /* 1 refs @ 6074 */
	    "250\0" /* 3 refs @ 6078 */
	    "cable\0" /* 2 refs @ 6082 */
	    "modem\0" /* 18 refs @ 6088 */
	    "TV\0" /* 1 refs @ 6094 */
	    "Wonder\0" /* 1 refs @ 6097 */
	    "600\0" /* 5 refs @ 6104 */
	    "Root\0" /* 1 refs @ 6108 */
	    "CG-WLUSB2GO\0" /* 1 refs @ 6113 */
	    "CG-WLUSB2GNR\0" /* 1 refs @ 6125 */
	    "EZUSB\0" /* 1 refs @ 6138 */
	    "EZLINK\0" /* 1 refs @ 6144 */
	    "NTT\0" /* 5 refs @ 6151 */
	    "DoCoMo\0" /* 1 refs @ 6155 */
	    "A2502\0" /* 1 refs @ 6162 */
	    "ADU-E100H\0" /* 1 refs @ 6168 */
	    "ADU-E500A\0" /* 1 refs @ 6178 */
	    "controller\0" /* 12 refs @ 6188 */
	    "engine\0" /* 1 refs @ 6199 */
	    "Internal\0" /* 19 refs @ 6206 */
	    "Keyboard/Trackpad\0" /* 17 refs @ 6215 */
	    "(Fountain/ANSI)\0" /* 1 refs @ 6233 */
	    "(Fountain/ISO)\0" /* 1 refs @ 6249 */
	    "(Geyser/ANSI)\0" /* 1 refs @ 6264 */
	    "(Geyser/ISO)\0" /* 1 refs @ 6278 */
	    "(Geyser/JIS)\0" /* 1 refs @ 6291 */
	    "(Geyser3/ANSI)\0" /* 1 refs @ 6304 */
	    "(Geyser3/ISO)\0" /* 1 refs @ 6319 */
	    "(Geyser3/JIS)\0" /* 1 refs @ 6333 */
	    "(Geyser4/ANSI)\0" /* 1 refs @ 6347 */
	    "(Geyser4/ISO)\0" /* 1 refs @ 6362 */
	    "(Geyser4/JIS)\0" /* 1 refs @ 6376 */
	    "(Wellspring/ANSI)\0" /* 1 refs @ 6390 */
	    "(Wellspring/ISO)\0" /* 1 refs @ 6408 */
	    "(Wellspring/JIS)\0" /* 1 refs @ 6425 */
	    "(Wellspring2/ANSI)\0" /* 1 refs @ 6442 */
	    "(Wellspring2/ISO)\0" /* 1 refs @ 6461 */
	    "(Wellspring2/JIS)\0" /* 1 refs @ 6479 */
	    "mouse\0" /* 16 refs @ 6497 */
	    "Mighty\0" /* 2 refs @ 6503 */
	    "Mouse\0" /* 20 refs @ 6510 */
	    "Trackpad\0" /* 3 refs @ 6516 */
	    "(Fountain)\0" /* 1 refs @ 6525 */
	    "(Geyser)\0" /* 1 refs @ 6536 */
	    "Magic\0" /* 2 refs @ 6545 */
	    "HCI\0" /* 1 refs @ 6551 */
	    "(HID-proxy\0" /* 1 refs @ 6555 */
	    "mode)\0" /* 1 refs @ 6566 */
	    "in\0" /* 6 refs @ 6572 */
	    "iPod\0" /* 3 refs @ 6575 */
	    "Shuffle\0" /* 1 refs @ 6580 */
	    "(2nd\0" /* 1 refs @ 6588 */
	    "generation)\0" /* 1 refs @ 6593 */
	    "iPhone\0" /* 7 refs @ 6605 */
	    "4G\0" /* 4 refs @ 6612 */
	    "3G\0" /* 6 refs @ 6615 */
	    "3GS\0" /* 1 refs @ 6618 */
	    "4\0" /* 8 refs @ 6622 */
	    "(VZW)\0" /* 1 refs @ 6624 */
	    "4S\0" /* 2 refs @ 6630 */
	    "5\0" /* 3 refs @ 6633 */
	    "iPad\0" /* 4 refs @ 6635 */
	    "2\0" /* 12 refs @ 6640 */
	    "3\0" /* 9 refs @ 6642 */
	    "Mini\0" /* 5 refs @ 6644 */
	    "Host\0" /* 11 refs @ 6649 */
	    "MacBookPro\0" /* 3 refs @ 6654 */
	    "7,1\0" /* 1 refs @ 6665 */
	    "iMac\0" /* 1 refs @ 6669 */
	    "11,1\0" /* 1 refs @ 6674 */
	    "8,2\0" /* 1 refs @ 6679 */
	    "MacBookAir\0" /* 3 refs @ 6683 */
	    "3,1\0" /* 1 refs @ 6694 */
	    "3,2\0" /* 1 refs @ 6698 */
	    "4,1\0" /* 1 refs @ 6702 */
	    "MacMini\0" /* 1 refs @ 6706 */
	    "5,1\0" /* 1 refs @ 6714 */
	    "6,1\0" /* 1 refs @ 6718 */
	    "9,2\0" /* 1 refs @ 6722 */
	    "USB-UART\0" /* 1 refs @ 6726 */
	    "PENTAX\0" /* 1 refs @ 6735 */
	    "Optio230\0" /* 1 refs @ 6742 */
	    "WLL013\0" /* 3 refs @ 6751 */
	    "(Intersil)\0" /* 1 refs @ 6758 */
	    "Voyager\0" /* 1 refs @ 6769 */
	    "1010\0" /* 1 refs @ 6777 */
	    "AX88172\0" /* 1 refs @ 6782 */
	    "10/100\0" /* 20 refs @ 6790 */
	    "AX88178\0" /* 1 refs @ 6797 */
	    "gigabit\0" /* 11 refs @ 6805 */
	    "AX88178A\0" /* 1 refs @ 6813 */
	    "AX88179\0" /* 4 refs @ 6822 */
	    "3.0\0" /* 6 refs @ 6830 */
	    "AX88772\0" /* 1 refs @ 6834 */
	    "AX88772A\0" /* 2 refs @ 6842 */
	    "AX88772B\0" /* 1 refs @ 6851 */
	    "AX88772B1\0" /* 1 refs @ 6860 */
	    "ASM1051,1053,1153\0" /* 1 refs @ 6870 */
	    "SATA\0" /* 2 refs @ 6888 */
	    "RT2570\0" /* 5 refs @ 6893 */
	    "WL-167g\0" /* 3 refs @ 6900 */
	    "WL-159g\0" /* 1 refs @ 6908 */
	    "A9T\0" /* 1 refs @ 6916 */
	    "wireless\0" /* 2 refs @ 6920 */
	    "P5B\0" /* 1 refs @ 6929 */
	    "(version\0" /* 3 refs @ 6933 */
	    "2)\0" /* 6 refs @ 6942 */
	    "My\0" /* 1 refs @ 6945 */
	    "Cinema\0" /* 1 refs @ 6948 */
	    "U3100\0" /* 1 refs @ 6955 */
	    "DVB-T\0" /* 9 refs @ 6961 */
	    "USB-N10\0" /* 3 refs @ 6967 */
	    "USB-N53\0" /* 1 refs @ 6975 */
	    "USB-N66\0" /* 1 refs @ 6983 */
	    "Nano\0" /* 5 refs @ 6991 */
	    "RTL8192CU_3\0" /* 1 refs @ 6996 */
	    "USB-AC53\0" /* 1 refs @ 7008 */
	    "B1\0" /* 4 refs @ 7017 */
	    "AURA\0" /* 1 refs @ 7020 */
	    "LED\0" /* 1 refs @ 7025 */
	    "MyPal\0" /* 1 refs @ 7029 */
	    "A730\0" /* 1 refs @ 7035 */
	    "USB-N11\0" /* 1 refs @ 7040 */
	    "Parallel\0" /* 5 refs @ 7048 */
	    "printer\0" /* 6 refs @ 7057 */
	    "10Mbps\0" /* 3 refs @ 7065 */
	    "Serial\0" /* 38 refs @ 7072 */
	    "UC210T\0" /* 1 refs @ 7079 */
	    "UC2324\0" /* 1 refs @ 7086 */
	    "DSB-650C\0" /* 1 refs @ 7093 */
	    "AR5523\0" /* 20 refs @ 7102 */
	    "TG121N\0" /* 1 refs @ 7109 */
	    "WN821NV2\0" /* 1 refs @ 7116 */
	    "AR9271\0" /* 12 refs @ 7125 */
	    "3CRUSBN275\0" /* 1 refs @ 7132 */
	    "WN612\0" /* 1 refs @ 7143 */
	    "AR3011\0" /* 1 refs @ 7149 */
	    "AR3012\0" /* 2 refs @ 7156 */
	    "AR9170\0" /* 1 refs @ 7163 */
	    "UHB124\0" /* 1 refs @ 7170 */
	    "hub\0" /* 20 refs @ 7177 */
	    "W-Buddie\0" /* 1 refs @ 7181 */
	    "WN210\0" /* 1 refs @ 7190 */
	    "DWL-900AP\0" /* 1 refs @ 7196 */
	    "access\0" /* 1 refs @ 7206 */
	    "point\0" /* 1 refs @ 7213 */
	    "ARM\0" /* 1 refs @ 7219 */
	    "SAM-BA\0" /* 1 refs @ 7223 */
	    "programming\0" /* 1 refs @ 7230 */
	    "port\0" /* 5 refs @ 7242 */
	    "DWL-120\0" /* 3 refs @ 7247 */
	    "AT76C503\0" /* 3 refs @ 7255 */
	    "(Intersil\0" /* 2 refs @ 7264 */
	    "3861\0" /* 1 refs @ 7274 */
	    "Radio)\0" /* 7 refs @ 7279 */
	    "3863\0" /* 1 refs @ 7286 */
	    "(RFMD\0" /* 5 refs @ 7291 */
	    "AT76C505\0" /* 2 refs @ 7297 */
	    "2958\0" /* 3 refs @ 7306 */
	    "AT76C505A\0" /* 1 refs @ 7311 */
	    "AT76C505AS\0" /* 1 refs @ 7321 */
	    "ATC-HA4USB\0" /* 1 refs @ 7332 */
	    "headphone\0" /* 1 refs @ 7343 */
	    "Audio\0" /* 6 refs @ 7353 */
	    "Speaker\0" /* 4 refs @ 7359 */
	    "1200U\0" /* 2 refs @ 7367 */
	    "scanner\0" /* 42 refs @ 7373 */
	    "FRITZ!WLAN\0" /* 1 refs @ 7381 */
	    "N\0" /* 1 refs @ 7392 */
	    "RTL8188CE\0" /* 4 refs @ 7394 */
	    "reader\0" /* 1 refs @ 7404 */
	    "uLinks\0" /* 1 refs @ 7411 */
	    "RS-422/485\0" /* 1 refs @ 7418 */
	    "Mobile\0" /* 5 refs @ 7429 */
	    "WiMax\0" /* 1 refs @ 7436 */
	    "SS\0" /* 1 refs @ 7442 */
	    "F5U002\0" /* 1 refs @ 7445 */
	    "F5D6050\0" /* 1 refs @ 7452 */
	    "F5U103\0" /* 1 refs @ 7460 */
	    "F5U109\0" /* 1 refs @ 7467 */
	    "SCSI\0" /* 1 refs @ 7474 */
	    "Adaptor\0" /* 4 refs @ 7479 */
	    "LAN\0" /* 5 refs @ 7487 */
	    "Converter\0" /* 4 refs @ 7491 */
	    "F5U208\0" /* 1 refs @ 7501 */
	    "VideoBus\0" /* 1 refs @ 7508 */
	    "II\0" /* 7 refs @ 7517 */
	    "F5U237\0" /* 1 refs @ 7520 */
	    "7-Port\0" /* 2 refs @ 7527 */
	    "F5U409\0" /* 1 refs @ 7534 */
	    "RTL8188CUS\0" /* 9 refs @ 7541 */
	    "F5U120-PC\0" /* 1 refs @ 7552 */
	    "F5U258/F5U279\0" /* 1 refs @ 7562 */
	    "host\0" /* 1 refs @ 7576 */
	    "F7D2102\0" /* 1 refs @ 7581 */
	    "F5D5055\0" /* 1 refs @ 7589 */
	    "F5D7050\0" /* 1 refs @ 7597 */
	    "54g\0" /* 6 refs @ 7605 */
	    "F5D7051\0" /* 1 refs @ 7609 */
	    "F5D705A\0" /* 1 refs @ 7617 */
	    "F5D705C\0" /* 1 refs @ 7625 */
	    "F5D705E\0" /* 1 refs @ 7633 */
	    "F5D8053\0" /* 1 refs @ 7641 */
	    "v3\0" /* 2 refs @ 7649 */
	    "F5D8055\0" /* 2 refs @ 7652 */
	    "v2\0" /* 12 refs @ 7660 */
	    "F5D9050\0" /* 1 refs @ 7663 */
	    "ver\0" /* 5 refs @ 7671 */
	    "F5D9050C\0" /* 1 refs @ 7675 */
	    "F6D4050\0" /* 2 refs @ 7684 */
	    "F7D1101\0" /* 1 refs @ 7692 */
	    "CT-USB1HUB\0" /* 1 refs @ 7700 */
	    "BWIFI-USB54AR\0" /* 1 refs @ 7711 */
	    "USB100N\0" /* 1 refs @ 7725 */
	    "FastEthernet\0" /* 1 refs @ 7733 */
	    "USB100LP\0" /* 1 refs @ 7746 */
	    "USB100EL\0" /* 1 refs @ 7755 */
	    "USBE100\0" /* 1 refs @ 7764 */
	    "USB2AR\0" /* 1 refs @ 7772 */
	    "US-101\0" /* 1 refs @ 7779 */
	    "USB2Serial\0" /* 19 refs @ 7786 */
	    "1xRS232\0" /* 3 refs @ 7797 */
	    "US-159\0" /* 1 refs @ 7805 */
	    "US-235\0" /* 1 refs @ 7812 */
	    "US-257\0" /* 1 refs @ 7819 */
	    "2xRS232\0" /* 1 refs @ 7826 */
	    "US-279\0" /* 4 refs @ 7834 */
	    "8xRS232\0" /* 4 refs @ 7841 */
	    "(Port\0" /* 12 refs @ 7849 */
	    "and\0" /* 12 refs @ 7855 */
	    "4)\0" /* 4 refs @ 7859 */
	    "6)\0" /* 2 refs @ 7862 */
	    "7\0" /* 4 refs @ 7865 */
	    "8)\0" /* 2 refs @ 7867 */
	    "US-313\0" /* 1 refs @ 7870 */
	    "2xRS422/485\0" /* 1 refs @ 7877 */
	    "US-320\0" /* 1 refs @ 7889 */
	    "1xRS422/485\0" /* 2 refs @ 7896 */
	    "US-324\0" /* 1 refs @ 7908 */
	    "US-346\0" /* 2 refs @ 7915 */
	    "4xRS422/485\0" /* 2 refs @ 7922 */
	    "US-701\0" /* 2 refs @ 7934 */
	    "4xRS232\0" /* 2 refs @ 7941 */
	    "US-842\0" /* 4 refs @ 7949 */
	    "8xRS422/485\0" /* 4 refs @ 7956 */
	    "BCMFW\0" /* 1 refs @ 7968 */
	    "BCM2033\0" /* 2 refs @ 7974 */
	    "(no\0" /* 15 refs @ 7982 */
	    "firmware)\0" /* 15 refs @ 7986 */
	    "BCM43236\0" /* 1 refs @ 7996 */
	    "BCM43143\0" /* 1 refs @ 8005 */
	    "BCM43242\0" /* 1 refs @ 8014 */
	    "BCM43569\0" /* 1 refs @ 8023 */
	    "HL-1050\0" /* 1 refs @ 8032 */
	    "laser\0" /* 2 refs @ 8040 */
	    "AirPcap\0" /* 1 refs @ 8046 */
	    "Nx\0" /* 1 refs @ 8054 */
	    "CanoScan\0" /* 4 refs @ 8057 */
	    "N656U\0" /* 1 refs @ 8066 */
	    "N1220U\0" /* 1 refs @ 8072 */
	    "N670U\0" /* 1 refs @ 8079 */
	    "N1240U\0" /* 1 refs @ 8085 */
	    "PowerShot\0" /* 8 refs @ 8092 */
	    "S10\0" /* 1 refs @ 8102 */
	    "S20\0" /* 3 refs @ 8106 */
	    "S100\0" /* 2 refs @ 8110 */
	    "G1\0" /* 1 refs @ 8115 */
	    "A20\0" /* 1 refs @ 8118 */
	    "S200\0" /* 1 refs @ 8122 */
	    "EOS\0" /* 1 refs @ 8127 */
	    "300D\0" /* 1 refs @ 8131 */
	    "Rebel\0" /* 1 refs @ 8136 */
	    "SD630\0" /* 1 refs @ 8142 */
	    "QV\0" /* 1 refs @ 8148 */
	    "DigitalCamera\0" /* 1 refs @ 8151 */
	    "BE-300\0" /* 1 refs @ 8165 */
	    "PDA\0" /* 4 refs @ 8172 */
	    "Nameland\0" /* 1 refs @ 8176 */
	    "EZ-USB\0" /* 2 refs @ 8185 */
	    "Netmate\0" /* 1 refs @ 8192 */
	    "Netmate2\0" /* 1 refs @ 8200 */
	    "Chief\0" /* 1 refs @ 8209 */
	    "Bus\0" /* 1 refs @ 8215 */
	    "Protocol\0" /* 3 refs @ 8219 */
	    "Analyzer\0" /* 1 refs @ 8228 */
	    "Andromeda\0" /* 1 refs @ 8237 */
	    "Portable\0" /* 4 refs @ 8247 */
	    "Device\0" /* 16 refs @ 8256 */
	    "My3000\0" /* 2 refs @ 8263 */
	    "keyboard\0" /* 14 refs @ 8270 */
	    "CyBoard\0" /* 1 refs @ 8279 */
	    "My6000\0" /* 1 refs @ 8287 */
	    "KB-8933\0" /* 1 refs @ 8294 */
	    "TwinkleCam\0" /* 1 refs @ 8302 */
	    "Buffalo\0" /* 1 refs @ 8313 */
	    "WBC-35H/L01\0" /* 1 refs @ 8321 */
	    "Throttle\0" /* 1 refs @ 8333 */
	    "Pedals\0" /* 1 refs @ 8342 */
	    "Fighterstick\0" /* 1 refs @ 8349 */
	    "Flight\0" /* 2 refs @ 8362 */
	    "Sim\0" /* 1 refs @ 8369 */
	    "Yoke\0" /* 1 refs @ 8373 */
	    "WUSB54G\0" /* 2 refs @ 8378 */
	    "WUSB54AG\0" /* 1 refs @ 8386 */
	    "Wireless-G\0" /* 2 refs @ 8395 */
	    "WUSB54GP\0" /* 1 refs @ 8406 */
	    "USB200M\0" /* 1 refs @ 8415 */
	    "HU200-TS\0" /* 1 refs @ 8423 */
	    "WUSB54GC\0" /* 3 refs @ 8432 */
	    "WUSB54GR\0" /* 1 refs @ 8441 */
	    "WUSBF54G\0" /* 1 refs @ 8450 */
	    "WUSB200\0" /* 1 refs @ 8459 */
	    "AE1000\0" /* 1 refs @ 8467 */
	    "AM10\0" /* 1 refs @ 8474 */
	    "iPAQ\0" /* 4 refs @ 8479 */
	    "PocketPC\0" /* 2 refs @ 8484 */
	    "A1500\0" /* 1 refs @ 8493 */
	    "W100\0" /* 1 refs @ 8499 */
	    "MultiPort\0" /* 1 refs @ 8504 */
	    "W200\0" /* 1 refs @ 8514 */
	    "Personal\0" /* 1 refs @ 8519 */
	    "Jukebox\0" /* 1 refs @ 8528 */
	    "PJB100\0" /* 1 refs @ 8536 */
	    "HNE-200\0" /* 1 refs @ 8543 */
	    "PS2\0" /* 2 refs @ 8551 */
	    "C54RU\0" /* 2 refs @ 8555 */
	    "RT2573M\0" /* 1 refs @ 8561 */
	    "C11U\0" /* 1 refs @ 8569 */
	    "WL-210\0" /* 1 refs @ 8574 */
	    "Eye\0" /* 2 refs @ 8581 */
	    "Q\0" /* 1 refs @ 8585 */
	    "3x\0" /* 1 refs @ 8587 */
	    "QuickCam\0" /* 11 refs @ 8590 */
	    "AMD\0" /* 1 refs @ 8599 */
	    "SR4\0" /* 1 refs @ 8603 */
	    "lamplight\0" /* 1 refs @ 8607 */
	    "Control\0" /* 2 refs @ 8617 */
	    "Ether\0" /* 1 refs @ 8625 */
	    "USB-T\0" /* 1 refs @ 8631 */
	    "FEther\0" /* 4 refs @ 8637 */
	    "USB-TX\0" /* 1 refs @ 8644 */
	    "WirelessLAN\0" /* 1 refs @ 8651 */
	    "USB-11\0" /* 1 refs @ 8663 */
	    "USB-TXS\0" /* 1 refs @ 8670 */
	    "Stick-11\0" /* 1 refs @ 8678 */
	    "USB2-TX\0" /* 1 refs @ 8687 */
	    "ULUSB-11\0" /* 1 refs @ 8695 */
	    "Key\0" /* 1 refs @ 8704 */
	    "CG-WLUSB2GTST\0" /* 1 refs @ 8708 */
	    "CG-USBRS232R\0" /* 1 refs @ 8722 */
	    "CG-WLUSB2GL\0" /* 1 refs @ 8735 */
	    "CG-WLUSB2GPX\0" /* 1 refs @ 8747 */
	    "CG-WLUSBNM\0" /* 1 refs @ 8760 */
	    "CG-WLUSB300GNM\0" /* 1 refs @ 8771 */
	    "Stick\0" /* 3 refs @ 8786 */
	    "11\0" /* 1 refs @ 8792 */
	    "USB-TXC\0" /* 1 refs @ 8795 */
	    "Nomad\0" /* 3 refs @ 8803 */
	    "MP3\0" /* 4 refs @ 8809 */
	    "player\0" /* 3 refs @ 8813 */
	    "MG\0" /* 1 refs @ 8820 */
	    "Voip\0" /* 1 refs @ 8823 */
	    "Blaster\0" /* 1 refs @ 8828 */
	    "Notebook\0" /* 2 refs @ 8836 */
	    "Pnp\0" /* 1 refs @ 8845 */
	    "Sound\0" /* 2 refs @ 8849 */
	    "Ex1300\0" /* 1 refs @ 8855 */
	    "TG54USB\0" /* 1 refs @ 8862 */
	    "thermometer\0" /* 1 refs @ 8870 */
	    "Keyboard/Hub\0" /* 1 refs @ 8882 */
	    "FM\0" /* 3 refs @ 8895 */
	    "USB-RS232\0" /* 1 refs @ 8898 */
	    "Interface\0" /* 3 refs @ 8908 */
	    "USB2\0" /* 3 refs @ 8918 */
	    "CY4636\0" /* 1 refs @ 8923 */
	    "LP\0" /* 1 refs @ 8930 */
	    "RDK\0" /* 1 refs @ 8933 */
	    "PhotoClip\0" /* 1 refs @ 8937 */
	    "USBMediaReader\0" /* 1 refs @ 8947 */
	    "J-6502\0" /* 1 refs @ 8962 */
	    "speakers\0" /* 1 refs @ 8969 */
	    "USB-FOB/iBUTTON\0" /* 1 refs @ 8978 */
	    "Port\0" /* 6 refs @ 8994 */
	    "Replicator\0" /* 1 refs @ 8999 */
	    "SK-8125\0" /* 1 refs @ 9010 */
	    "Axim\0" /* 2 refs @ 9018 */
	    "X3\0" /* 1 refs @ 9023 */
	    "X30\0" /* 1 refs @ 9026 */
	    "BC02\0" /* 1 refs @ 9030 */
	    "TrueMobile\0" /* 2 refs @ 9035 */
	    "1180\0" /* 1 refs @ 9046 */
	    "350\0" /* 3 refs @ 9051 */
	    "Dell/Novatel\0" /* 1 refs @ 9055 */
	    "HSDPA\0" /* 9 refs @ 9068 */
	    "W5500\0" /* 1 refs @ 9074 */
	    "Earthmate\0" /* 2 refs @ 9080 */
	    "GPS\0" /* 5 refs @ 9090 */
	    "LT-20\0" /* 1 refs @ 9094 */
	    "Rio\0" /* 3 refs @ 9100 */
	    "500\0" /* 1 refs @ 9104 */
	    "WL-200U\0" /* 1 refs @ 9108 */
	    "CHUSB\0" /* 1 refs @ 9116 */
	    "611G\0" /* 1 refs @ 9122 */
	    "WL-240U\0" /* 1 refs @ 9127 */
	    "XH1153\0" /* 1 refs @ 9135 */
	    "C-Net\0" /* 1 refs @ 9142 */
	    "CWD-854\0" /* 1 refs @ 9148 */
	    "rev\0" /* 19 refs @ 9156 */
	    "F\0" /* 2 refs @ 9160 */
	    "RTL8187\0" /* 4 refs @ 9162 */
	    "AccelePort\0" /* 3 refs @ 9170 */
	    "8\0" /* 3 refs @ 9181 */
	    "PS/2\0" /* 2 refs @ 9183 */
	    "Active\0" /* 1 refs @ 9188 */
	    "IOGEAR\0" /* 1 refs @ 9195 */
	    "DVI\0" /* 8 refs @ 9202 */
	    "GUC2020\0" /* 1 refs @ 9206 */
	    "LD220\0" /* 1 refs @ 9214 */
	    "LD190\0" /* 1 refs @ 9220 */
	    "U70\0" /* 1 refs @ 9226 */
	    "Polaris2\0" /* 1 refs @ 9230 */
	    "dock\0" /* 1 refs @ 9239 */
	    "Rextron\0" /* 1 refs @ 9244 */
	    "StarTech\0" /* 1 refs @ 9252 */
	    "CONV-USB2DVI\0" /* 1 refs @ 9261 */
	    "IO-DATA\0" /* 3 refs @ 9274 */
	    "USB-RGB\0" /* 1 refs @ 9282 */
	    "LCD-USB7X\0" /* 1 refs @ 9290 */
	    "LCD-USB10XB-T\0" /* 1 refs @ 9300 */
	    "CMP-USBVGA10\0" /* 1 refs @ 9314 */
	    "WS\0" /* 1 refs @ 9327 */
	    "EasyCAP008\0" /* 1 refs @ 9330 */
	    "FY-DVI2\0" /* 1 refs @ 9341 */
	    "BUFFALO\0" /* 2 refs @ 9349 */
	    "GX-DVI/U2\0" /* 1 refs @ 9357 */
	    "LCD-4300U\0" /* 1 refs @ 9367 */
	    "LCD-8000U\0" /* 1 refs @ 9377 */
	    "HP\0" /* 3 refs @ 9387 */
	    "Docking\0" /* 1 refs @ 9390 */
	    "VideoHome\0" /* 1 refs @ 9398 */
	    "NBdock1920\0" /* 1 refs @ 9408 */
	    "GX-DVI/U2B\0" /* 1 refs @ 9419 */
	    "SUNWEIT\0" /* 1 refs @ 9430 */
	    "Lilliput\0" /* 1 refs @ 9438 */
	    "UM-70\0" /* 1 refs @ 9447 */
	    "LCD-8000UD-DVI\0" /* 1 refs @ 9453 */
	    "LDE-WX015U\0" /* 1 refs @ 9468 */
	    "SANWA\0" /* 1 refs @ 9479 */
	    "SUPPLY\0" /* 1 refs @ 9485 */
	    "500-KC002N\0" /* 1 refs @ 9492 */
	    "MIMO\0" /* 1 refs @ 9503 */
	    "Plugable\0" /* 1 refs @ 9508 */
	    "docking\0" /* 1 refs @ 9517 */
	    "station\0" /* 1 refs @ 9525 */
	    "ThinkVision\0" /* 1 refs @ 9533 */
	    "LT1421\0" /* 1 refs @ 9545 */
	    "Wide\0" /* 1 refs @ 9552 */
	    "AREA\0" /* 1 refs @ 9557 */
	    "SD-U2VDH\0" /* 1 refs @ 9562 */
	    "nanovision\0" /* 1 refs @ 9571 */
	    "MiMo\0" /* 1 refs @ 9582 */
	    "FY-DVI\0" /* 1 refs @ 9587 */
	    "DUB-E100\0" /* 3 refs @ 9594 */
	    "C1\0" /* 3 refs @ 9603 */
	    "DUB-1312\0" /* 1 refs @ 9606 */
	    "E\0" /* 2 refs @ 9615 */
	    "DWA-130\0" /* 3 refs @ 9617 */
	    "C\0" /* 1 refs @ 9625 */
	    "DWA-131\0" /* 3 refs @ 9627 */
	    "B\0" /* 3 refs @ 9635 */
	    "DWA-125\0" /* 1 refs @ 9637 */
	    "D1\0" /* 2 refs @ 9645 */
	    "DWA-121\0" /* 1 refs @ 9648 */
	    "DWL122\0" /* 1 refs @ 9656 */
	    "DWL-G120\0" /* 1 refs @ 9663 */
	    "DWL-G122\0" /* 2 refs @ 9672 */
	    "A2\0" /* 2 refs @ 9681 */
	    "DWL-AG132\0" /* 2 refs @ 9684 */
	    "DWL-G132\0" /* 2 refs @ 9694 */
	    "DWL-AG122\0" /* 2 refs @ 9703 */
	    "AirPlus\0" /* 1 refs @ 9713 */
	    "G\0" /* 1 refs @ 9721 */
	    "DWA-140\0" /* 1 refs @ 9723 */
	    "B3\0" /* 1 refs @ 9731 */
	    "DWA-160\0" /* 3 refs @ 9734 */
	    "B2\0" /* 1 refs @ 9742 */
	    "DWA-127\0" /* 1 refs @ 9745 */
	    "DWA-162\0" /* 1 refs @ 9753 */
	    "DWM-157\0" /* 4 refs @ 9761 */
	    "CD-ROM\0" /* 6 refs @ 9769 */
	    "Mode\0" /* 5 refs @ 9776 */
	    "LTE\0" /* 5 refs @ 9781 */
	    "DWM-222\0" /* 4 refs @ 9785 */
	    "DWR-510\0" /* 2 refs @ 9793 */
	    "A1\0" /* 3 refs @ 9801 */
	    "WUA-2340\0" /* 2 refs @ 9804 */
	    "WUA-1340\0" /* 1 refs @ 9813 */
	    "DWA-111\0" /* 1 refs @ 9822 */
	    "DWA-110\0" /* 1 refs @ 9830 */
	    "KVM-221\0" /* 1 refs @ 9838 */
	    "Storage\0" /* 5 refs @ 9846 */
	    "Vigor550\0" /* 1 refs @ 9854 */
	    "ANT\0" /* 1 refs @ 9863 */
	    "dev\0" /* 1 refs @ 9867 */
	    "board\0" /* 3 refs @ 9871 */
	    "EC168\0" /* 1 refs @ 9877 */
	    "EW-7318\0" /* 1 refs @ 9883 */
	    "MT7610U\0" /* 3 refs @ 9891 */
	    "EW-7618\0" /* 1 refs @ 9899 */
	    "EW-7717\0" /* 1 refs @ 9907 */
	    "EW-7718\0" /* 1 refs @ 9915 */
	    "EW-7722UTn\0" /* 1 refs @ 9923 */
	    "EW-7811UTC\0" /* 2 refs @ 9934 */
	    "ELECOM\0" /* 1 refs @ 9945 */
	    "WDC-433SU2M\0" /* 1 refs @ 9952 */
	    "EW-7811Un\0" /* 1 refs @ 9964 */
	    "V2\0" /* 7 refs @ 9974 */
	    "Panel\0" /* 4 refs @ 9977 */
	    "Diva\0" /* 1 refs @ 9983 */
	    "852\0" /* 1 refs @ 9988 */
	    "monitor\0" /* 1 refs @ 9992 */
	    "ActiveJet\0" /* 1 refs @ 10000 */
	    "K-2024\0" /* 1 refs @ 10010 */
	    "Goldpfeil\0" /* 1 refs @ 10017 */
	    "P-LAN\0" /* 1 refs @ 10027 */
	    "29UO\0" /* 1 refs @ 10033 */
	    "LD-USB/TX\0" /* 4 refs @ 10038 */
	    "LD-USBL/TX\0" /* 1 refs @ 10048 */
	    "WDC-150SU2M\0" /* 1 refs @ 10059 */
	    "WDC-433SU2M2\0" /* 1 refs @ 10071 */
	    "LD-USB20\0" /* 1 refs @ 10084 */
	    "UC-SGT\0" /* 1 refs @ 10093 */
	    "serial\0" /* 38 refs @ 10100 */
	    "UC-SGT0\0" /* 1 refs @ 10107 */
	    "Microlink\0" /* 1 refs @ 10115 */
	    "USB2Ethernet\0" /* 1 refs @ 10125 */
	    "EM2883\0" /* 1 refs @ 10138 */
	    "PSX\0" /* 1 refs @ 10145 */
	    "gun\0" /* 1 refs @ 10149 */
	    "converter\0" /* 7 refs @ 10153 */
	    "1S\0" /* 1 refs @ 10163 */
	    "connector\0" /* 8 refs @ 10166 */
	    "2S\0" /* 1 refs @ 10176 */
	    "1S25\0" /* 1 refs @ 10179 */
	    "E45\0" /* 1 refs @ 10184 */
	    "Centronics\0" /* 1 refs @ 10188 */
	    "1S9\0" /* 1 refs @ 10199 */
	    "2U4S\0" /* 1 refs @ 10203 */
	    "connector/usb\0" /* 1 refs @ 10208 */
	    "Printer\0" /* 2 refs @ 10222 */
	    "ISD\0" /* 2 refs @ 10230 */
	    "Smart\0" /* 3 refs @ 10234 */
	    "for\0" /* 5 refs @ 10240 */
	    "Mac\0" /* 3 refs @ 10244 */
	    "Perfection\0" /* 12 refs @ 10248 */
	    "636U\0" /* 1 refs @ 10259 */
	    "636Photo\0" /* 1 refs @ 10264 */
	    "610\0" /* 1 refs @ 10273 */
	    "1200Photo\0" /* 1 refs @ 10277 */
	    "Expression\0" /* 1 refs @ 10287 */
	    "1600\0" /* 1 refs @ 10298 */
	    "1640SU\0" /* 1 refs @ 10303 */
	    "1240U\0" /* 1 refs @ 10310 */
	    "1240Photo\0" /* 1 refs @ 10316 */
	    "1250U\0" /* 1 refs @ 10326 */
	    "1250Photo\0" /* 1 refs @ 10332 */
	    "1650\0" /* 1 refs @ 10342 */
	    "GT-9700F\0" /* 1 refs @ 10347 */
	    "2400\0" /* 2 refs @ 10356 */
	    "1260\0" /* 1 refs @ 10361 */
	    "1660\0" /* 1 refs @ 10366 */
	    "1670\0" /* 1 refs @ 10371 */
	    "XR21V1410\0" /* 1 refs @ 10376 */
	    "channel\0" /* 3 refs @ 10386 */
	    "UART\0" /* 4 refs @ 10394 */
	    "XR21V1412\0" /* 1 refs @ 10399 */
	    "XR21V1414\0" /* 1 refs @ 10409 */
	    "XTNDAccess\0" /* 1 refs @ 10419 */
	    "IrDA\0" /* 7 refs @ 10430 */
	    "Twist\0" /* 1 refs @ 10435 */
	    "GSM/GPRS\0" /* 2 refs @ 10441 */
	    "Samba\0" /* 1 refs @ 10450 */
	    "55/56\0" /* 1 refs @ 10456 */
	    "WL-430U\0" /* 1 refs @ 10462 */
	    "Connector\0" /* 1 refs @ 10470 */
	    "DVD\0" /* 6 refs @ 10480 */
	    "drive\0" /* 1 refs @ 10484 */
	    "8U232AM\0" /* 1 refs @ 10490 */
	    "FT232RL\0" /* 1 refs @ 10498 */
	    "2232C\0" /* 1 refs @ 10506 */
	    "dual\0" /* 1 refs @ 10512 */
	    "FAST\0" /* 2 refs @ 10517 */
	    "SERIAL\0" /* 2 refs @ 10522 */
	    "ADAPTER\0" /* 2 refs @ 10529 */
	    "2232H\0" /* 1 refs @ 10537 */
	    "quad\0" /* 1 refs @ 10543 */
	    "C232HM\0" /* 1 refs @ 10548 */
	    "Multipurpose\0" /* 1 refs @ 10555 */
	    "FT230X\0" /* 1 refs @ 10568 */
	    "Keyboard/Mouse\0" /* 1 refs @ 10575 */
	    "8U100AX\0" /* 1 refs @ 10590 */
	    "OpenRD\0" /* 1 refs @ 10598 */
	    "JTAGKey\0" /* 2 refs @ 10605 */
	    "FT2232D\0" /* 1 refs @ 10613 */
	    "BeagleBone\0" /* 1 refs @ 10621 */
	    "MaxStream\0" /* 1 refs @ 10632 */
	    "PKG-U\0" /* 1 refs @ 10642 */
	    "KW\0" /* 1 refs @ 10648 */
	    "YS\0" /* 1 refs @ 10651 */
	    "Y6\0" /* 1 refs @ 10654 */
	    "Y8\0" /* 1 refs @ 10657 */
	    "IC\0" /* 1 refs @ 10660 */
	    "DB9\0" /* 1 refs @ 10663 */
	    "RS232\0" /* 6 refs @ 10667 */
	    "Y9\0" /* 1 refs @ 10673 */
	    "Coastal\0" /* 1 refs @ 10676 */
	    "ChipWorks\0" /* 1 refs @ 10684 */
	    "TNC-X\0" /* 1 refs @ 10694 */
	    "CTI\0" /* 2 refs @ 10700 */
	    "485\0" /* 2 refs @ 10704 */
	    "Matrix\0" /* 4 refs @ 10708 */
	    "Orbital\0" /* 4 refs @ 10715 */
	    "MX2/MX3/MX6\0" /* 1 refs @ 10723 */
	    "Series\0" /* 2 refs @ 10735 */
	    "MX4/MX5\0" /* 1 refs @ 10742 */
	    "LCD\0" /* 8 refs @ 10750 */
	    "LK/VK/PK202-24\0" /* 1 refs @ 10754 */
	    "LK/VK204-24\0" /* 1 refs @ 10769 */
	    "Crystalfontz\0" /* 5 refs @ 10781 */
	    "CFA-632\0" /* 1 refs @ 10794 */
	    "CFA-634\0" /* 1 refs @ 10802 */
	    "CFA-633\0" /* 1 refs @ 10810 */
	    "CFA-631\0" /* 1 refs @ 10818 */
	    "CFA-635\0" /* 1 refs @ 10826 */
	    "SEMC\0" /* 1 refs @ 10834 */
	    "DSS-20\0" /* 1 refs @ 10839 */
	    "SyncStation\0" /* 1 refs @ 10846 */
	    "SheevaPlug\0" /* 1 refs @ 10858 */
	    "Mass\0" /* 4 refs @ 10869 */
	    "AH-F401U\0" /* 1 refs @ 10874 */
	    "Air\0" /* 1 refs @ 10883 */
	    "H\0" /* 1 refs @ 10887 */
	    "device\0" /* 18 refs @ 10889 */
	    "Type\0" /* 3 refs @ 10896 */
	    "6\0" /* 3 refs @ 10901 */
	    "Strip\0" /* 1 refs @ 10903 */
	    "FX-5204PS\0" /* 1 refs @ 10909 */
	    "Base\0" /* 1 refs @ 10919 */
	    "Station\0" /* 1 refs @ 10924 */
	    "FX-5251WB\0" /* 1 refs @ 10932 */
	    "Virtual\0" /* 1 refs @ 10942 */
	    "Eth\0" /* 1 refs @ 10950 */
	    "SURFboard\0" /* 1 refs @ 10954 */
	    "SB5100\0" /* 1 refs @ 10964 */
	    "GeneLink\0" /* 1 refs @ 10971 */
	    "Host-Host\0" /* 5 refs @ 10980 */
	    "GL650\0" /* 1 refs @ 10990 */
	    "GL641USB\0" /* 3 refs @ 10996 */
	    "CompactFlash\0" /* 6 refs @ 11005 */
	    "USB-IDE\0" /* 5 refs @ 11018 */
	    "GN-54G\0" /* 1 refs @ 11026 */
	    "GN-BR402W\0" /* 1 refs @ 11033 */
	    "GN-WLBM101\0" /* 1 refs @ 11043 */
	    "GN-WBKG\0" /* 1 refs @ 11054 */
	    "GN-WB01GS\0" /* 1 refs @ 11062 */
	    "GN-WI05GS\0" /* 1 refs @ 11072 */
	    "GN-WB31N\0" /* 1 refs @ 11082 */
	    "GN-WB32L\0" /* 1 refs @ 11091 */
	    "SMCWUSBT-G\0" /* 2 refs @ 11100 */
	    "YP3X00\0" /* 1 refs @ 11111 */
	    "receiver\0" /* 2 refs @ 11118 */
	    "MT7630U\0" /* 1 refs @ 11127 */
	    "MT7650U\0" /* 1 refs @ 11135 */
	    "Forerunner\0" /* 1 refs @ 11143 */
	    "305\0" /* 2 refs @ 11154 */
	    "GoCOM232\0" /* 1 refs @ 11158 */
	    "GWUSB2E\0" /* 1 refs @ 11167 */
	    "GamePad\0" /* 2 refs @ 11175 */
	    "CF-writer\0" /* 1 refs @ 11183 */
	    "Player\0" /* 3 refs @ 11193 */
	    "Huey\0" /* 3 refs @ 11200 */
	    "iMate,\0" /* 1 refs @ 11205 */
	    "ADB\0" /* 1 refs @ 11212 */
	    "PowerMate\0" /* 1 refs @ 11216 */
	    "Assignable\0" /* 1 refs @ 11226 */
	    "Exper\0" /* 1 refs @ 11237 */
	    "mouseCLOCK\0" /* 1 refs @ 11243 */
	    "DA\0" /* 1 refs @ 11254 */
	    "Leader\0" /* 1 refs @ 11257 */
	    "HWGUSB2-54\0" /* 1 refs @ 11264 */
	    "HWGUSB2-54-LB\0" /* 1 refs @ 11275 */
	    "HWGUSB2-54V2-AP\0" /* 1 refs @ 11289 */
	    "HWNU-300\0" /* 1 refs @ 11305 */
	    "HWNUm-300\0" /* 1 refs @ 11314 */
	    "HWGUn-54\0" /* 1 refs @ 11324 */
	    "HWNUP-150\0" /* 1 refs @ 11333 */
	    "FlashGate\0" /* 3 refs @ 11343 */
	    "SmartMedia\0" /* 3 refs @ 11353 */
	    "Crossam2+USB\0" /* 1 refs @ 11364 */
	    "IR\0" /* 1 refs @ 11377 */
	    "commander\0" /* 1 refs @ 11380 */
	    "Visor\0" /* 1 refs @ 11390 */
	    "Treo\0" /* 2 refs @ 11396 */
	    "Keyboard&Mouse\0" /* 1 refs @ 11401 */
	    "WinTV\0" /* 5 refs @ 11416 */
	    "Nova-T\0" /* 3 refs @ 11422 */
	    "HWUN2\0" /* 1 refs @ 11429 */
	    "DVD-CAM\0" /* 1 refs @ 11435 */
	    "DZ-MV100A\0" /* 1 refs @ 11443 */
	    "Camcorder\0" /* 1 refs @ 11453 */
	    "DVDCAM\0" /* 1 refs @ 11463 */
	    "HS\0" /* 1 refs @ 11470 */
	    "MOP-35\0" /* 1 refs @ 11473 */
	    "ParaParaParadise\0" /* 1 refs @ 11480 */
	    "DeskJet\0" /* 11 refs @ 11497 */
	    "895C\0" /* 1 refs @ 11505 */
	    "Scanjet\0" /* 7 refs @ 11510 */
	    "4100C\0" /* 1 refs @ 11518 */
	    "Photosmart\0" /* 2 refs @ 11524 */
	    "880C\0" /* 1 refs @ 11535 */
	    "ScanJet\0" /* 6 refs @ 11540 */
	    "4200C\0" /* 1 refs @ 11548 */
	    "CD-Writer\0" /* 2 refs @ 11554 */
	    "Plus\0" /* 8 refs @ 11564 */
	    "HN210W\0" /* 1 refs @ 11569 */
	    "6200C\0" /* 1 refs @ 11576 */
	    "PhotoSmart\0" /* 2 refs @ 11582 */
	    "815C\0" /* 1 refs @ 11593 */
	    "3300C\0" /* 1 refs @ 11598 */
	    "8200e\0" /* 1 refs @ 11604 */
	    "1220C\0" /* 1 refs @ 11610 */
	    "810C/812C\0" /* 1 refs @ 11616 */
	    "4300C\0" /* 1 refs @ 11626 */
	    "CD-Writer+\0" /* 1 refs @ 11632 */
	    "CD-4e\0" /* 1 refs @ 11643 */
	    "OfficeJet\0" /* 1 refs @ 11649 */
	    "G85xi\0" /* 1 refs @ 11659 */
	    "LaserJet\0" /* 1 refs @ 11665 */
	    "1200\0" /* 8 refs @ 11674 */
	    "5200C\0" /* 1 refs @ 11679 */
	    "830C\0" /* 1 refs @ 11685 */
	    "3400cse\0" /* 1 refs @ 11690 */
	    "885C\0" /* 1 refs @ 11698 */
	    "6300C\0" /* 1 refs @ 11703 */
	    "840c\0" /* 1 refs @ 11709 */
	    "2200C\0" /* 1 refs @ 11714 */
	    "5300C\0" /* 1 refs @ 11720 */
	    "4400C\0" /* 1 refs @ 11726 */
	    "816C\0" /* 1 refs @ 11732 */
	    "Laserjet\0" /* 1 refs @ 11737 */
	    "2300d\0" /* 1 refs @ 11746 */
	    "Deskjet\0" /* 3 refs @ 11752 */
	    "970Cse\0" /* 1 refs @ 11760 */
	    "5400C\0" /* 1 refs @ 11767 */
	    "22xx/Jornada\0" /* 1 refs @ 11773 */
	    "548\0" /* 1 refs @ 11786 */
	    "959C\0" /* 1 refs @ 11790 */
	    "Jornada\0" /* 1 refs @ 11795 */
	    "568\0" /* 1 refs @ 11803 */
	    "930c\0" /* 1 refs @ 11807 */
	    "Inkjet\0" /* 1 refs @ 11812 */
	    "P-2000U\0" /* 1 refs @ 11819 */
	    "Generic\0" /* 1 refs @ 11827 */
	    "RNDIS\0" /* 2 refs @ 11835 */
	    "640c\0" /* 1 refs @ 11841 */
	    "LP2275w\0" /* 1 refs @ 11846 */
	    "LP2475w\0" /* 1 refs @ 11854 */
	    "4670v\0" /* 1 refs @ 11862 */
	    "P1100\0" /* 1 refs @ 11868 */
	    "v125w\0" /* 1 refs @ 11874 */
	    "6127\0" /* 1 refs @ 11880 */
	    "un2430\0" /* 1 refs @ 11885 */
	    "WWAN/GPS\0" /* 1 refs @ 11892 */
	    "Module\0" /* 2 refs @ 11901 */
	    "HN210E\0" /* 1 refs @ 11908 */
	    "C500\0" /* 1 refs @ 11915 */
	    "Android\0" /* 3 refs @ 11920 */
	    "E220\0" /* 1 refs @ 11928 */
	    "U8150\0" /* 1 refs @ 11933 */
	    "EM770W\0" /* 1 refs @ 11939 */
	    "E1750\0" /* 2 refs @ 11946 */
	    "E182\0" /* 1 refs @ 11952 */
	    "E353\0" /* 2 refs @ 11957 */
	    "CD\0" /* 7 refs @ 11962 */
	    "K3765\0" /* 2 refs @ 11965 */
	    "E1820\0" /* 1 refs @ 11971 */
	    "HWD12\0" /* 3 refs @ 11977 */
	    "mode\0" /* 4 refs @ 11983 */
	    "E171\0" /* 2 refs @ 11988 */
	    "E392\0" /* 1 refs @ 11993 */
	    "EC156\0" /* 1 refs @ 11998 */
	    "Installer\0" /* 3 refs @ 12004 */
	    "RAS\0" /* 1 refs @ 12014 */
	    "E353_HiLink\0" /* 1 refs @ 12018 */
	    "E3272\0" /* 1 refs @ 12030 */
	    "E355\0" /* 1 refs @ 12036 */
	    "Softbank\0" /* 2 refs @ 12041 */
	    "203HW\0" /* 1 refs @ 12050 */
	    "PC5740\0" /* 1 refs @ 12056 */
	    "EVDO\0" /* 2 refs @ 12063 */
	    "UM175\0" /* 1 refs @ 12068 */
	    "Go!\0" /* 1 refs @ 12074 */
	    "EdgePort/4\0" /* 1 refs @ 12078 */
	    "Hubport/7\0" /* 1 refs @ 12089 */
	    "Rapidport/4\0" /* 1 refs @ 12099 */
	    "Edgeport/4\0" /* 3 refs @ 12111 */
	    "Telxon\0" /* 1 refs @ 12122 */
	    "Edgeport/2\0" /* 3 refs @ 12129 */
	    "RS422\0" /* 2 refs @ 12140 */
	    "RS422/RS485\0" /* 1 refs @ 12146 */
	    "Hubport/4\0" /* 1 refs @ 12158 */
	    "Hand-built\0" /* 1 refs @ 12168 */
	    "Edgeport/8\0" /* 4 refs @ 12179 */
	    "version\0" /* 1 refs @ 12190 */
	    "of\0" /* 1 refs @ 12198 */
	    "RP/4\0" /* 1 refs @ 12201 */
	    "Edgeport/(4)21\0" /* 1 refs @ 12206 */
	    "(USS720)\0" /* 1 refs @ 12221 */
	    "Edgeport/421\0" /* 1 refs @ 12230 */
	    "Hub+RS232+Parallel\0" /* 1 refs @ 12243 */
	    "Edgeport/21\0" /* 1 refs @ 12262 */
	    "RS232+Parallel\0" /* 1 refs @ 12274 */
	    "1/2\0" /* 2 refs @ 12289 */
	    "(2\0" /* 2 refs @ 12293 */
	    "EP/4s\0" /* 1 refs @ 12296 */
	    "on\0" /* 3 refs @ 12302 */
	    "PCB)\0" /* 1 refs @ 12305 */
	    "DIN\0" /* 2 refs @ 12310 */
	    "Edgeport/16\0" /* 1 refs @ 12314 */
	    "EP/8s\0" /* 1 refs @ 12326 */
	    "PCB))\0" /* 1 refs @ 12332 */
	    "Edgeport\0" /* 1 refs @ 12338 */
	    "Compatible\0" /* 1 refs @ 12347 */
	    "OEM\0" /* 1 refs @ 12358 */
	    "ATAPI\0" /* 1 refs @ 12362 */
	    "IDE\0" /* 3 refs @ 12368 */
	    "ISD110\0" /* 1 refs @ 12372 */
	    "ISD105\0" /* 1 refs @ 12379 */
	    "Harddrive\0" /* 3 refs @ 12386 */
	    "Easy\0" /* 1 refs @ 12396 */
	    "AP310\0" /* 1 refs @ 12401 */
	    "AnyPoint\0" /* 1 refs @ 12407 */
	    "2011B\0" /* 1 refs @ 12416 */
	    "82930\0" /* 1 refs @ 12422 */
	    "test\0" /* 2 refs @ 12428 */
	    "Rate\0" /* 8 refs @ 12433 */
	    "Matching\0" /* 8 refs @ 12438 */
	    "Gale\0" /* 1 refs @ 12447 */
	    "Peak\0" /* 1 refs @ 12452 */
	    "5.4\0" /* 1 refs @ 12457 */
	    "Advanced-N\0" /* 1 refs @ 12461 */
	    "6235\0" /* 1 refs @ 12472 */
	    "Combo\0" /* 2 refs @ 12477 */
	    "Prism2.x\0" /* 1 refs @ 12483 */
	    "ValueCAN\0" /* 1 refs @ 12492 */
	    "NeoVI\0" /* 1 refs @ 12501 */
	    "Blue\0" /* 1 refs @ 12507 */
	    "Multi-plus\0" /* 4 refs @ 12512 */
	    "unit\0" /* 4 refs @ 12523 */
	    "iU-CD2\0" /* 1 refs @ 12528 */
	    "DVR-UEH8\0" /* 1 refs @ 12535 */
	    "USB-SSMRW\0" /* 1 refs @ 12544 */
	    "SD-card\0" /* 2 refs @ 12554 */
	    "USB-SDRW\0" /* 1 refs @ 12562 */
	    "ET/T\0" /* 1 refs @ 12571 */
	    "ET/TX\0" /* 1 refs @ 12576 */
	    "ET/TX-S\0" /* 1 refs @ 12582 */
	    "WN-B11\0" /* 2 refs @ 12590 */
	    "Airport\0" /* 1 refs @ 12597 */
	    "WN-G54/US\0" /* 2 refs @ 12605 */
	    "ETX-US2\0" /* 1 refs @ 12615 */
	    "ETG-US2\0" /* 1 refs @ 12623 */
	    "FT232R\0" /* 1 refs @ 12631 */
	    "WN-GDN/US2\0" /* 1 refs @ 12638 */
	    "WN-G150UM\0" /* 1 refs @ 12649 */
	    "USB-RSAQ1\0" /* 1 refs @ 12659 */
	    "USB-RSAQ5\0" /* 1 refs @ 12669 */
	    "USB2.0-SCSI\0" /* 1 refs @ 12679 */
	    "USB2-SC\0" /* 1 refs @ 12691 */
	    "Zip\0" /* 3 refs @ 12699 */
	    "100\0" /* 3 refs @ 12703 */
	    "CDRW\0" /* 1 refs @ 12707 */
	    "9602\0" /* 1 refs @ 12712 */
	    "iFP-1xx\0" /* 1 refs @ 12717 */
	    "iFP-3xx\0" /* 1 refs @ 12725 */
	    "iFP-5xx\0" /* 1 refs @ 12733 */
	    "PC-60B\0" /* 1 refs @ 12741 */
	    "JD\0" /* 1 refs @ 12748 */
	    "Camera/mp3\0" /* 1 refs @ 12751 */
	    "AirH\"PHONE\0" /* 1 refs @ 12762 */
	    "AH-J3001V/J3002V\0" /* 1 refs @ 12773 */
	    "GR-DX95\0" /* 1 refs @ 12790 */
	    "MP-PRX1\0" /* 1 refs @ 12798 */
	    "MP-XP7250\0" /* 1 refs @ 12806 */
	    "Builtin\0" /* 1 refs @ 12816 */
	    "10BT\0" /* 2 refs @ 12824 */
	    "adapter,\0" /* 2 refs @ 12829 */
	    "the\0" /* 2 refs @ 12838 */
	    "DU-H3E\0" /* 2 refs @ 12842 */
	    "MiniHub\0" /* 1 refs @ 12849 */
	    "4000P\0" /* 1 refs @ 12857 */
	    "KC-180\0" /* 1 refs @ 12863 */
	    "HKS-0200\0" /* 1 refs @ 12870 */
	    "USBDAQ\0" /* 1 refs @ 12879 */
	    "Orbit\0" /* 2 refs @ 12886 */
	    "USB/PS2\0" /* 1 refs @ 12892 */
	    "trackball\0" /* 2 refs @ 12900 */
	    "TurboBall\0" /* 1 refs @ 12910 */
	    "VideoCAM\0" /* 1 refs @ 12920 */
	    "VGA\0" /* 1 refs @ 12929 */
	    "USA-28\0" /* 2 refs @ 12933 */
	    "USA-28X\0" /* 1 refs @ 12940 */
	    "USA-19\0" /* 2 refs @ 12948 */
	    "USA-18\0" /* 2 refs @ 12955 */
	    "USA-18X\0" /* 2 refs @ 12962 */
	    "USA-19W\0" /* 2 refs @ 12970 */
	    "USA-49W\0" /* 2 refs @ 12978 */
	    "USA-19QI\0" /* 2 refs @ 12986 */
	    "USA-19Q\0" /* 2 refs @ 12995 */
	    "USA-28X/XB\0" /* 1 refs @ 13003 */
	    "USA-28XB\0" /* 2 refs @ 13014 */
	    "USA-28XA\0" /* 1 refs @ 13023 */
	    "USA-18XA\0" /* 2 refs @ 13032 */
	    "USA-19QW\0" /* 2 refs @ 13041 */
	    "USA-19H\0" /* 1 refs @ 13050 */
	    "UIA-10\0" /* 1 refs @ 13058 */
	    "remote\0" /* 2 refs @ 13065 */
	    "control\0" /* 2 refs @ 13072 */
	    "UIA-11\0" /* 1 refs @ 13080 */
	    "KNU101TX\0" /* 1 refs @ 13087 */
	    "DT\0" /* 5 refs @ 13096 */
	    "102\0" /* 1 refs @ 13099 */
	    "G2\0" /* 3 refs @ 13103 */
	    "101\0" /* 2 refs @ 13106 */
	    "10\0" /* 1 refs @ 13110 */
	    "KingSun/DonShine\0" /* 1 refs @ 13113 */
	    "minilogue\0" /* 1 refs @ 13130 */
	    "xd\0" /* 1 refs @ 13140 */
	    "microKORG\0" /* 1 refs @ 13143 */
	    "XL\0" /* 1 refs @ 13153 */
	    "Science\0" /* 6 refs @ 13156 */
	    "DC220\0" /* 1 refs @ 13164 */
	    "DC260\0" /* 1 refs @ 13170 */
	    "DC265\0" /* 1 refs @ 13176 */
	    "DC290\0" /* 1 refs @ 13182 */
	    "DC240\0" /* 1 refs @ 13188 */
	    "DC280\0" /* 1 refs @ 13194 */
	    "EasyShare\0" /* 1 refs @ 13200 */
	    "DX4900\0" /* 1 refs @ 13210 */
	    "Color\0" /* 1 refs @ 13217 */
	    "Niche\0" /* 1 refs @ 13223 */
	    "Genius\0" /* 1 refs @ 13229 */
	    "NetScroll\0" /* 1 refs @ 13236 */
	    "MaxFire\0" /* 1 refs @ 13246 */
	    "G-07\0" /* 1 refs @ 13254 */
	    "gamepad\0" /* 3 refs @ 13259 */
	    "2000\0" /* 3 refs @ 13267 */
	    "joystick\0" /* 2 refs @ 13272 */
	    "ColorPage\0" /* 1 refs @ 13281 */
	    "Vivid-Pro\0" /* 1 refs @ 13291 */
	    "AH-K3001V\0" /* 1 refs @ 13301 */
	    "PocketDrive\0" /* 1 refs @ 13311 */
	    "Hard\0" /* 1 refs @ 13323 */
	    "Disk\0" /* 4 refs @ 13328 */
	    "R/W\0" /* 1 refs @ 13333 */
	    "ThinkPad\0" /* 1 refs @ 13337 */
	    "Compact\0" /* 1 refs @ 13346 */
	    "TrackPoint\0" /* 1 refs @ 13354 */
	    "jumpSHOT\0" /* 1 refs @ 13365 */
	    "2662W-AR\0" /* 1 refs @ 13374 */
	    "Multi-Card\0" /* 1 refs @ 13383 */
	    "Optra\0" /* 1 refs @ 13394 */
	    "S\0" /* 3 refs @ 13400 */
	    "2450\0" /* 1 refs @ 13402 */
	    "MSM\0" /* 6 refs @ 13407 */
	    "phone\0" /* 1 refs @ 13411 */
	    "DOCOMO\0" /* 4 refs @ 13417 */
	    "L-05A\0" /* 2 refs @ 13424 */
	    "L-02C\0" /* 2 refs @ 13430 */
	    "Camedia\0" /* 1 refs @ 13436 */
	    "MAUSB-2\0" /* 1 refs @ 13444 */
	    "USB10TX\0" /* 2 refs @ 13452 */
	    "HG20F9\0" /* 1 refs @ 13460 */
	    "USB10T\0" /* 1 refs @ 13467 */
	    "USB100TX\0" /* 1 refs @ 13474 */
	    "USB100H1\0" /* 1 refs @ 13483 */
	    "Ethernet/HPNA\0" /* 1 refs @ 13492 */
	    "USB10TA\0" /* 1 refs @ 13506 */
	    "WUSB11\0" /* 3 refs @ 13514 */
	    "2.5)\0" /* 1 refs @ 13521 */
	    "WUSB12\0" /* 1 refs @ 13526 */
	    "v1.1\0" /* 1 refs @ 13533 */
	    "Everywhere\0" /* 1 refs @ 13538 */
	    "NWU11B\0" /* 1 refs @ 13549 */
	    "WUSB11-V28\0" /* 1 refs @ 13556 */
	    "USB1000\0" /* 1 refs @ 13567 */
	    "WUSB100\0" /* 1 refs @ 13575 */
	    "WUSB600N\0" /* 2 refs @ 13583 */
	    "1.1\0" /* 1 refs @ 13592 */
	    "root\0" /* 3 refs @ 13596 */
	    "debug\0" /* 1 refs @ 13601 */
	    "LDR-H443SU2\0" /* 1 refs @ 13607 */
	    "LDR-H443U2\0" /* 1 refs @ 13619 */
	    "LAN-GTJ/U2\0" /* 1 refs @ 13630 */
	    "LAN-TX\0" /* 1 refs @ 13641 */
	    "LAN-W300N/U2\0" /* 1 refs @ 13648 */
	    "RT3020\0" /* 1 refs @ 13661 */
	    "LAN-W300N/U2S\0" /* 1 refs @ 13668 */
	    "LAN-W450ANU2E\0" /* 1 refs @ 13682 */
	    "LAN-W300AN/U2\0" /* 1 refs @ 13696 */
	    "M2452\0" /* 1 refs @ 13710 */
	    "M4848\0" /* 1 refs @ 13716 */
	    "PageScan\0" /* 1 refs @ 13722 */
	    "Web\0" /* 1 refs @ 13731 */
	    "Express\0" /* 5 refs @ 13735 */
	    "3000\0" /* 2 refs @ 13743 */
	    "4000\0" /* 1 refs @ 13748 */
	    "Messenger\0" /* 1 refs @ 13753 */
	    "N43\0" /* 1 refs @ 13763 */
	    "N48\0" /* 1 refs @ 13767 */
	    "M-BA47\0" /* 1 refs @ 13771 */
	    "WingMan\0" /* 5 refs @ 13778 */
	    "Gaming\0" /* 1 refs @ 13786 */
	    "BD58\0" /* 1 refs @ 13793 */
	    "USB-PS/2\0" /* 2 refs @ 13798 */
	    "M-UV55a\0" /* 1 refs @ 13807 */
	    "iFeel\0" /* 1 refs @ 13815 */
	    "B100\0" /* 2 refs @ 13821 */
	    "Extreme\0" /* 1 refs @ 13826 */
	    "RumblePad\0" /* 1 refs @ 13834 */
	    "Force\0" /* 2 refs @ 13844 */
	    "Formula\0" /* 1 refs @ 13850 */
	    "GP\0" /* 1 refs @ 13858 */
	    "(GT-Force)\0" /* 1 refs @ 13861 */
	    "Trackball\0" /* 2 refs @ 13872 */
	    "TrackMan\0" /* 1 refs @ 13882 */
	    "Wheel\0" /* 2 refs @ 13891 */
	    "Marble\0" /* 1 refs @ 13897 */
	    "Cordless\0" /* 4 refs @ 13904 */
	    "Desktop\0" /* 2 refs @ 13913 */
	    "optical\0" /* 1 refs @ 13921 */
	    "C-BT44\0" /* 1 refs @ 13929 */
	    "Receiver\0" /* 3 refs @ 13936 */
	    "Gamepad\0" /* 3 refs @ 13945 */
	    "F310\0" /* 1 refs @ 13953 */
	    "Dual\0" /* 2 refs @ 13958 */
	    "WM66\0" /* 1 refs @ 13963 */
	    "Emobile\0" /* 2 refs @ 13968 */
	    "D21LC\0" /* 2 refs @ 13976 */
	    "only\0" /* 2 refs @ 13982 */
	    "XSStick\0" /* 3 refs @ 13987 */
	    "W14\0" /* 1 refs @ 13995 */
	    "P14\0" /* 2 refs @ 13999 */
	    "IIJmobile\0" /* 2 refs @ 14003 */
	    "510FU\0" /* 2 refs @ 14013 */
	    "-\0" /* 6 refs @ 14019 */
	    "Windows\0" /* 2 refs @ 14021 */
	    "driver\0" /* 1 refs @ 14029 */
	    "USS-720\0" /* 1 refs @ 14036 */
	    "evaluation\0" /* 1 refs @ 14044 */
	    "kit\0" /* 1 refs @ 14055 */
	    "EasyDisc\0" /* 1 refs @ 14059 */
	    "Cyborg\0" /* 2 refs @ 14068 */
	    "R.A.T.\0" /* 1 refs @ 14075 */
	    "DU-H3SP\0" /* 1 refs @ 14082 */
	    "BAY\0" /* 1 refs @ 14090 */
	    "USB-232\0" /* 2 refs @ 14094 */
	    "ML-4500\0" /* 1 refs @ 14102 */
	    "9\0" /* 1 refs @ 14110 */
	    "5131\0" /* 1 refs @ 14112 */
	    "DCF77\0" /* 1 refs @ 14117 */
	    "Clock\0" /* 1 refs @ 14123 */
	    "MiniPlayer\0" /* 1 refs @ 14129 */
	    "M6\0" /* 1 refs @ 14140 */
	    "(SL)\0" /* 1 refs @ 14143 */
	    "LUA-TX\0" /* 2 refs @ 14148 */
	    "LUA2-TX\0" /* 1 refs @ 14155 */
	    "LUA-KTX\0" /* 1 refs @ 14163 */
	    "WLI-USB-S11\0" /* 1 refs @ 14171 */
	    "MCR-SM2\0" /* 1 refs @ 14183 */
	    "Reader/Writer\0" /* 4 refs @ 14191 */
	    "Bridge:\0" /* 1 refs @ 14205 */
	    "DUB-PxxG\0" /* 1 refs @ 14213 */
	    "WLI-USB-KS11G\0" /* 1 refs @ 14222 */
	    "USB-wlan\0" /* 1 refs @ 14236 */
	    "LUA-U2-KTX\0" /* 1 refs @ 14245 */
	    "WLI-USB-KB11\0" /* 1 refs @ 14256 */
	    "WLI-U2-KG54-YB\0" /* 1 refs @ 14269 */
	    "WLI-U2-KG54\0" /* 1 refs @ 14284 */
	    "WLI-U2-KG54-AI\0" /* 1 refs @ 14296 */
	    "LUA-U2-GT\0" /* 1 refs @ 14311 */
	    "Wi-Fi\0" /* 1 refs @ 14321 */
	    "RemoteStation\0" /* 1 refs @ 14327 */
	    "PC-OP-RS1\0" /* 1 refs @ 14341 */
	    "WLI-U2-SG54HP\0" /* 1 refs @ 14351 */
	    "WLI-U2-G54HP\0" /* 1 refs @ 14365 */
	    "WLI-U2-KG54L\0" /* 1 refs @ 14378 */
	    "WLI-UC-G300N\0" /* 1 refs @ 14391 */
	    "WLI-U2-SG54HG\0" /* 1 refs @ 14404 */
	    "WLI-UC-AG300N\0" /* 1 refs @ 14418 */
	    "WLI-UC-G\0" /* 1 refs @ 14432 */
	    "WLI-UC-GNHP\0" /* 1 refs @ 14441 */
	    "WLI-UC-GN\0" /* 1 refs @ 14453 */
	    "WLI-UC-G301N\0" /* 1 refs @ 14463 */
	    "UWA-BR100\0" /* 1 refs @ 14476 */
	    "WLI-UC-GNM\0" /* 1 refs @ 14486 */
	    "WLI-UC-GNM2T\0" /* 1 refs @ 14497 */
	    "WI-U2-300D\0" /* 1 refs @ 14510 */
	    "MW150US\0" /* 1 refs @ 14521 */
	    "V620\0" /* 1 refs @ 14529 */
	    "Ricochet\0" /* 1 refs @ 14534 */
	    "GS\0" /* 1 refs @ 14543 */
	    "SYSTEMS\0" /* 2 refs @ 14546 */
	    "PROTECTIONCENTER\0" /* 2 refs @ 14554 */
	    "MSI\0" /* 2 refs @ 14571 */
	    "MegaSky\0" /* 2 refs @ 14575 */
	    "MS-6861\0" /* 1 refs @ 14583 */
	    "MS-6865\0" /* 1 refs @ 14591 */
	    "MS-6869\0" /* 1 refs @ 14599 */
	    "PICkit(TM)\0" /* 1 refs @ 14607 */
	    "FLASH\0" /* 1 refs @ 14618 */
	    "Starter\0" /* 1 refs @ 14624 */
	    "Kit\0" /* 2 refs @ 14632 */
	    "PICkit\0" /* 2 refs @ 14636 */
	    "Microcontroller\0" /* 2 refs @ 14643 */
	    "Programmer\0" /* 2 refs @ 14659 */
	    "I2C/UART\0" /* 1 refs @ 14670 */
	    "SPI\0" /* 1 refs @ 14679 */
	    "YUREX\0" /* 1 refs @ 14683 */
	    "SP128AR\0" /* 1 refs @ 14689 */
	    "EtherFast\0" /* 1 refs @ 14697 */
	    "SideWinder\0" /* 1 refs @ 14707 */
	    "Precision\0" /* 2 refs @ 14718 */
	    "IntelliMouse\0" /* 1 refs @ 14728 */
	    "Natural\0" /* 1 refs @ 14741 */
	    "Elite\0" /* 1 refs @ 14749 */
	    "80\0" /* 1 refs @ 14755 */
	    "Sidewinder\0" /* 1 refs @ 14758 */
	    "Racing\0" /* 1 refs @ 14769 */
	    "Internet\0" /* 3 refs @ 14776 */
	    "Explorer\0" /* 1 refs @ 14785 */
	    "IntelliEye\0" /* 1 refs @ 14794 */
	    "MN510\0" /* 1 refs @ 14805 */
	    "NIC\0" /* 2 refs @ 14811 */
	    "Laser\0" /* 1 refs @ 14815 */
	    "6000\0" /* 3 refs @ 14821 */
	    "Xbox\0" /* 7 refs @ 14826 */
	    "Memory\0" /* 4 refs @ 14831 */
	    "Unit\0" /* 1 refs @ 14838 */
	    "Movie\0" /* 1 refs @ 14843 */
	    "Playback\0" /* 1 refs @ 14849 */
	    "(1.0)\0" /* 1 refs @ 14858 */
	    "(1.2)\0" /* 1 refs @ 14864 */
	    "360\0" /* 2 refs @ 14870 */
	    "2.4GHz\0" /* 5 refs @ 14874 */
	    "Transceiver\0" /* 6 refs @ 14881 */
	    "V1.0\0" /* 1 refs @ 14893 */
	    "V2.0\0" /* 1 refs @ 14898 */
	    "V7.0\0" /* 1 refs @ 14903 */
	    "V8.0\0" /* 1 refs @ 14908 */
	    "V9.0\0" /* 1 refs @ 14913 */
	    "Comfort\0" /* 2 refs @ 14918 */
	    "USB-SCSI-DB25\0" /* 1 refs @ 14926 */
	    "USB-SCSI-HD50\0" /* 1 refs @ 14940 */
	    "CameraMate\0" /* 2 refs @ 14954 */
	    "Phantom\0" /* 4 refs @ 14965 */
	    "336CX\0" /* 3 refs @ 14973 */
	    "C3\0" /* 3 refs @ 14979 */
	    "ScanMaker\0" /* 5 refs @ 14982 */
	    "X6\0" /* 1 refs @ 14992 */
	    "X6U\0" /* 1 refs @ 14995 */
	    "C6\0" /* 1 refs @ 14999 */
	    "V6USL\0" /* 2 refs @ 15002 */
	    "V6UL\0" /* 1 refs @ 15008 */
	    "Midisport\0" /* 2 refs @ 15013 */
	    "2x2\0" /* 1 refs @ 15023 */
	    "2x4\0" /* 1 refs @ 15027 */
	    "Wallet\0" /* 1 refs @ 15031 */
	    "Dimage\0" /* 7 refs @ 15038 */
	    "2300\0" /* 1 refs @ 15045 */
	    "S304\0" /* 1 refs @ 15050 */
	    "7i\0" /* 1 refs @ 15055 */
	    "5400\0" /* 1 refs @ 15058 */
	    "Xt\0" /* 1 refs @ 15063 */
	    "MetaGeek\0" /* 1 refs @ 15066 */
	    "Wi-Spy\0" /* 1 refs @ 15075 */
	    "2.4x\0" /* 1 refs @ 15082 */
	    "Telldus\0" /* 2 refs @ 15087 */
	    "Tellstick\0" /* 2 refs @ 15095 */
	    "Duo\0" /* 1 refs @ 15105 */
	    "CD-R/RW\0" /* 2 refs @ 15109 */
	    "Quick\0" /* 1 refs @ 15117 */
	    "Scroll\0" /* 1 refs @ 15123 */
	    "dongle\0" /* 2 refs @ 15130 */
	    "FDD\0" /* 1 refs @ 15137 */
	    "EasiDock\0" /* 1 refs @ 15141 */
	    "MCS7703\0" /* 1 refs @ 15150 */
	    "MCS7720\0" /* 1 refs @ 15158 */
	    "MCS7730\0" /* 1 refs @ 15166 */
	    "MCS7780\0" /* 1 refs @ 15174 */
	    "MCS7781\0" /* 1 refs @ 15182 */
	    "MCS7784\0" /* 1 refs @ 15190 */
	    "Slow\0" /* 1 refs @ 15198 */
	    "MCS7810\0" /* 1 refs @ 15203 */
	    "MCS7820\0" /* 1 refs @ 15211 */
	    "MCS7830\0" /* 1 refs @ 15219 */
	    "MCS7832\0" /* 1 refs @ 15227 */
	    "MCS7840\0" /* 1 refs @ 15235 */
	    "MC141555\0" /* 1 refs @ 15243 */
	    "SB4100\0" /* 1 refs @ 15252 */
	    "T720c\0" /* 1 refs @ 15259 */
	    "A920\0" /* 1 refs @ 15265 */
	    "USBLAN\0" /* 2 refs @ 15270 */
	    "(A780,\0" /* 1 refs @ 15277 */
	    "E680,\0" /* 1 refs @ 15284 */
	    "...)\0" /* 2 refs @ 15290 */
	    "(A910,\0" /* 1 refs @ 15295 */
	    "A1200,\0" /* 1 refs @ 15302 */
	    "Rokr\0" /* 2 refs @ 15309 */
	    "E2,\0" /* 1 refs @ 15314 */
	    "E6,\0" /* 1 refs @ 15318 */
	    "DiskOnKey\0" /* 3 refs @ 15322 */
	    "MT5634ZBA-USB\0" /* 1 refs @ 15332 */
	    "CU\0" /* 3 refs @ 15346 */
	    "UB\0" /* 2 refs @ 15349 */
	    "BearPaw\0" /* 4 refs @ 15352 */
	    "1200F\0" /* 1 refs @ 15360 */
	    "1200TA\0" /* 1 refs @ 15366 */
	    "MDC-800\0" /* 1 refs @ 15373 */
	    "digital\0" /* 4 refs @ 15381 */
	    "DV2000\0" /* 1 refs @ 15389 */
	    "GPIB-USB-A\0" /* 1 refs @ 15396 */
	    "WL300NU-G\0" /* 1 refs @ 15407 */
	    "Picty760\0" /* 1 refs @ 15417 */
	    "Picty900\0" /* 1 refs @ 15426 */
	    "Picty920\0" /* 1 refs @ 15435 */
	    "Picty800\0" /* 1 refs @ 15444 */
	    "6-in-1\0" /* 2 refs @ 15453 */
	    "Multi-format\0" /* 1 refs @ 15460 */
	    "Turbo-Connect\0" /* 1 refs @ 15473 */
	    "Clik!\0" /* 1 refs @ 15487 */
	    "40\0" /* 1 refs @ 15493 */
	    "Ethernet/RNDIS\0" /* 1 refs @ 15496 */
	    "gadget\0" /* 1 refs @ 15511 */
	    "pxa210/25x/26x\0" /* 1 refs @ 15518 */
	    "WG111v3\0" /* 1 refs @ 15533 */
	    "WG111U\0" /* 2 refs @ 15541 */
	    "WG111v2\0" /* 1 refs @ 15548 */
	    "PL\0" /* 1 refs @ 15556 */
	    "WN111V2\0" /* 1 refs @ 15559 */
	    "WNDA3100\0" /* 1 refs @ 15567 */
	    "WNDA3200\0" /* 1 refs @ 15576 */
	    "WNA1100\0" /* 1 refs @ 15585 */
	    "WNA1000\0" /* 1 refs @ 15593 */
	    "WNA1000M\0" /* 1 refs @ 15601 */
	    "MA101\0" /* 2 refs @ 15610 */
	    "Rev\0" /* 1 refs @ 15616 */
	    "WG111T\0" /* 2 refs @ 15620 */
	    "WPN111\0" /* 2 refs @ 15627 */
	    "RT-WJ02\0" /* 1 refs @ 15634 */
	    "UX312NC\0" /* 1 refs @ 15642 */
	    "Willcom\0" /* 1 refs @ 15650 */
	    "WS002IN\0" /* 1 refs @ 15658 */
	    "(DD)\0" /* 1 refs @ 15666 */
	    "E990\0" /* 1 refs @ 15671 */
	    "E880\0" /* 1 refs @ 15676 */
	    "E885\0" /* 1 refs @ 15681 */
	    "BCM2045A\0" /* 1 refs @ 15686 */
	    "Wii\0" /* 2 refs @ 15695 */
	    "Remote\0" /* 2 refs @ 15699 */
	    "RVL-CNT-01\0" /* 1 refs @ 15706 */
	    "(BT-HID)\0" /* 2 refs @ 15717 */
	    "RVL-CNT-01-TR\0" /* 1 refs @ 15726 */
	    "Phone\0" /* 4 refs @ 15740 */
	    "NV-902W\0" /* 1 refs @ 15746 */
	    "NovAtel\0" /* 1 refs @ 15754 */
	    "FlexPack\0" /* 1 refs @ 15762 */
	    "ExpressCard\0" /* 1 refs @ 15771 */
	    "V740\0" /* 1 refs @ 15783 */
	    "S720\0" /* 1 refs @ 15788 */
	    "U740\0" /* 2 refs @ 15793 */
	    "U870\0" /* 1 refs @ 15798 */
	    "XU870\0" /* 1 refs @ 15803 */
	    "X950D\0" /* 1 refs @ 15809 */
	    "ES620\0" /* 1 refs @ 15815 */
	    "U720\0" /* 1 refs @ 15821 */
	    "Expedite\0" /* 1 refs @ 15826 */
	    "EU850D/EU860D/EU870D\0" /* 1 refs @ 15835 */
	    "U727\0" /* 1 refs @ 15856 */
	    "HSUPA\0" /* 7 refs @ 15861 */
	    "Driver\0" /* 3 refs @ 15867 */
	    "U760\0" /* 1 refs @ 15874 */
	    "Windows/Mac\0" /* 1 refs @ 15879 */
	    "760USB\0" /* 1 refs @ 15891 */
	    "C-1\0" /* 1 refs @ 15898 */
	    "C-700\0" /* 1 refs @ 15902 */
	    "Ultra\0" /* 1 refs @ 15908 */
	    "OV511\0" /* 1 refs @ 15914 */
	    "OV511+\0" /* 1 refs @ 15920 */
	    "PLAYSTATION(R)\0" /* 1 refs @ 15927 */
	    "OnePlus\0" /* 1 refs @ 15942 */
	    "5T\0" /* 1 refs @ 15950 */
	    "disk\0" /* 2 refs @ 15953 */
	    "MDCFE-B\0" /* 1 refs @ 15958 */
	    "CF\0" /* 2 refs @ 15966 */
	    "Stick+CF\0" /* 1 refs @ 15969 */
	    "Datafab-based\0" /* 2 refs @ 15978 */
	    "PNY/Datafab\0" /* 1 refs @ 15992 */
	    "CF+SM\0" /* 2 refs @ 16004 */
	    "Simple\0" /* 1 refs @ 16010 */
	    "Tech/Datafab\0" /* 1 refs @ 16017 */
	    "+\0" /* 1 refs @ 16030 */
	    "SM\0" /* 1 refs @ 16032 */
	    "(LC1)\0" /* 1 refs @ 16035 */
	    "FlashLink\0" /* 1 refs @ 16041 */
	    "UCF-100\0" /* 1 refs @ 16051 */
	    "Datafab\0" /* 1 refs @ 16059 */
	    "MD1-II\0" /* 1 refs @ 16067 */
	    "PC-Card\0" /* 1 refs @ 16074 */
	    "8In2\0" /* 1 refs @ 16082 */
	    "Vodafone\0" /* 1 refs @ 16087 */
	    "Connect\0" /* 6 refs @ 16096 */
	    "datacard\0" /* 3 refs @ 16104 */
	    "GlobeTrotter\0" /* 7 refs @ 16113 */
	    "Fusion\0" /* 3 refs @ 16126 */
	    "Quad\0" /* 4 refs @ 16133 */
	    "UMTS/GPRS\0" /* 1 refs @ 16138 */
	    "3D\0" /* 2 refs @ 16148 */
	    "GlobeSurfer\0" /* 2 refs @ 16151 */
	    "iCON\0" /* 7 refs @ 16163 */
	    "7.2\0" /* 1 refs @ 16168 */
	    "225\0" /* 1 refs @ 16172 */
	    "GE40x\0" /* 4 refs @ 16176 */
	    "401\0" /* 1 refs @ 16182 */
	    "GTM\0" /* 1 refs @ 16186 */
	    "382\0" /* 1 refs @ 16190 */
	    "Globetrotter\0" /* 1 refs @ 16194 */
	    "EDGE\0" /* 1 refs @ 16207 */
	    "HSxPA\0" /* 1 refs @ 16212 */
	    "321\0" /* 1 refs @ 16218 */
	    "322\0" /* 1 refs @ 16222 */
	    "505\0" /* 1 refs @ 16226 */
	    "model\0" /* 3 refs @ 16230 */
	    "01\0" /* 2 refs @ 16236 */
	    "WiFi\0" /* 1 refs @ 16239 */
	    "interface\0" /* 6 refs @ 16244 */
	    "01+\0" /* 1 refs @ 16254 */
	    "state\0" /* 1 refs @ 16258 */
	    "128M\0" /* 1 refs @ 16264 */
	    "m500\0" /* 1 refs @ 16269 */
	    "m505\0" /* 1 refs @ 16274 */
	    "m515\0" /* 1 refs @ 16279 */
	    "i705\0" /* 1 refs @ 16284 */
	    "Tungsten\0" /* 2 refs @ 16289 */
	    "Z\0" /* 1 refs @ 16298 */
	    "m125\0" /* 1 refs @ 16300 */
	    "m130\0" /* 1 refs @ 16305 */
	    "T\0" /* 1 refs @ 16310 */
	    "Zire\0" /* 2 refs @ 16312 */
	    "31\0" /* 1 refs @ 16317 */
	    "LS-120\0" /* 1 refs @ 16320 */
	    "CD-R\0" /* 2 refs @ 16327 */
	    "KXL-RW32AN\0" /* 1 refs @ 16332 */
	    "KXL-CB20AN\0" /* 1 refs @ 16343 */
	    "DVD-ROM\0" /* 1 refs @ 16354 */
	    "MultiMediaCard\0" /* 2 refs @ 16362 */
	    "Lumix\0" /* 1 refs @ 16377 */
	    "DMC-FS45\0" /* 1 refs @ 16383 */
	    "TY-TP50P6-S\0" /* 1 refs @ 16392 */
	    "50in\0" /* 1 refs @ 16404 */
	    "4Pi\0" /* 1 refs @ 16409 */
	    "reprap\0" /* 1 refs @ 16413 */
	    "candleLight\0" /* 2 refs @ 16420 */
	    "CAN\0" /* 2 refs @ 16432 */
	    "interfaces\0" /* 2 refs @ 16436 */
	    "OneRNG\0" /* 1 refs @ 16447 */
	    "Random\0" /* 1 refs @ 16454 */
	    "Number\0" /* 1 refs @ 16461 */
	    "Generator\0" /* 1 refs @ 16468 */
	    "Home\0" /* 1 refs @ 16478 */
	    "GWU513\0" /* 1 refs @ 16483 */
	    "DSS\0" /* 3 refs @ 16490 */
	    "XXX\0" /* 2 refs @ 16494 */
	    "SA235\0" /* 1 refs @ 16498 */
	    "PCA645VC\0" /* 1 refs @ 16504 */
	    "PCA646VC\0" /* 1 refs @ 16513 */
	    "PCVC675K\0" /* 1 refs @ 16522 */
	    "Vesta\0" /* 3 refs @ 16531 */
	    "PCVC680K\0" /* 1 refs @ 16537 */
	    "PCVC690K\0" /* 1 refs @ 16546 */
	    "Scan\0" /* 2 refs @ 16555 */
	    "PCVC730K\0" /* 1 refs @ 16560 */
	    "ToUCam\0" /* 3 refs @ 16569 */
	    "Fun\0" /* 1 refs @ 16576 */
	    "PCVC740K\0" /* 1 refs @ 16580 */
	    "PCVC750K\0" /* 1 refs @ 16589 */
	    "150\0" /* 2 refs @ 16598 */
	    "CPWUA054\0" /* 1 refs @ 16602 */
	    "SNU5600\0" /* 1 refs @ 16611 */
	    "SNU5630NS/05\0" /* 1 refs @ 16619 */
	    "DIVA\0" /* 1 refs @ 16632 */
	    "mp3\0" /* 1 refs @ 16637 */
	    "NFC\0" /* 1 refs @ 16641 */
	    "PN533\0" /* 1 refs @ 16645 */
	    "Xkeys\0" /* 2 refs @ 16651 */
	    "Programmable\0" /* 2 refs @ 16657 */
	    "(58\0" /* 1 refs @ 16670 */
	    "Keys)\0" /* 1 refs @ 16674 */
	    "CRW-600\0" /* 1 refs @ 16680 */
	    "PCTV\0" /* 4 refs @ 16688 */
	    "800e\0" /* 1 refs @ 16693 */
	    "72e\0" /* 1 refs @ 16698 */
	    "73e\0" /* 1 refs @ 16702 */
	    "Raspberry\0" /* 1 refs @ 16706 */
	    "Pi\0" /* 1 refs @ 16716 */
	    "GW-US11H\0" /* 1 refs @ 16719 */
	    "GW-US11S\0" /* 1 refs @ 16728 */
	    "GW-USFang300\0" /* 1 refs @ 16737 */
	    "GW-US54GXS\0" /* 1 refs @ 16750 */
	    "GW-US300\0" /* 1 refs @ 16761 */
	    "GW-US54HP\0" /* 1 refs @ 16770 */
	    "GW-US300MiniS\0" /* 1 refs @ 16780 */
	    "GW-USNano\0" /* 1 refs @ 16794 */
	    "GW-USMicro300\0" /* 1 refs @ 16804 */
	    "GW-USNano2\0" /* 1 refs @ 16818 */
	    "GW-USEco300\0" /* 1 refs @ 16829 */
	    "GW-900D\0" /* 1 refs @ 16841 */
	    "GW-450D\0" /* 1 refs @ 16849 */
	    "GW-450S\0" /* 1 refs @ 16857 */
	    "GW-US54Mini2\0" /* 1 refs @ 16865 */
	    "GW-US54SG\0" /* 1 refs @ 16878 */
	    "GW-US54GZL\0" /* 1 refs @ 16888 */
	    "GW-US54GD\0" /* 1 refs @ 16899 */
	    "GW-USMM\0" /* 1 refs @ 16909 */
	    "GW-US300Mini-X/MiniW\0" /* 1 refs @ 16917 */
	    "GW-USMicroN\0" /* 1 refs @ 16938 */
	    "GW-USMicroN2\0" /* 1 refs @ 16950 */
	    "GW-USH300N\0" /* 1 refs @ 16963 */
	    "GW-US54GZ\0" /* 1 refs @ 16974 */
	    "GU-1000T\0" /* 1 refs @ 16984 */
	    "GW-US54Mini\0" /* 1 refs @ 16993 */
	    "Platronics\0" /* 1 refs @ 17005 */
	    "DSP-400\0" /* 1 refs @ 17016 */
	    "Headset\0" /* 1 refs @ 17024 */
	    "PlexWriter\0" /* 1 refs @ 17032 */
	    "40/12/40U\0" /* 1 refs @ 17043 */
	    "Travel\0" /* 1 refs @ 17053 */
	    "G2-200\0" /* 1 refs @ 17060 */
	    "G2E-300\0" /* 2 refs @ 17067 */
	    "G2-300\0" /* 1 refs @ 17075 */
	    "Colorado\0" /* 4 refs @ 17082 */
	    "9600\0" /* 1 refs @ 17091 */
	    "600u\0" /* 1 refs @ 17096 */
	    "6200\0" /* 2 refs @ 17101 */
	    "19200\0" /* 1 refs @ 17106 */
	    "1200u\0" /* 1 refs @ 17112 */
	    "G2-600\0" /* 2 refs @ 17118 */
	    "ReadyScan\0" /* 1 refs @ 17125 */
	    "636i\0" /* 1 refs @ 17135 */
	    "G2E-600\0" /* 1 refs @ 17140 */
	    "Mouse-in-a-Box\0" /* 1 refs @ 17148 */
	    "PCGA-UMS1\0" /* 1 refs @ 17163 */
	    "PL2301\0" /* 1 refs @ 17173 */
	    "PL2302\0" /* 1 refs @ 17180 */
	    "PL2303\0" /* 11 refs @ 17187 */
	    "(IODATA\0" /* 2 refs @ 17194 */
	    "USB-RSAQ2)\0" /* 1 refs @ 17202 */
	    "(ATEN/IOGEAR\0" /* 1 refs @ 17213 */
	    "UC232A)\0" /* 1 refs @ 17226 */
	    "ATAPI-4\0" /* 1 refs @ 17234 */
	    "PL2501\0" /* 1 refs @ 17242 */
	    "PL25A1\0" /* 1 refs @ 17249 */
	    "(Pharos\0" /* 1 refs @ 17256 */
	    "GPS)\0" /* 1 refs @ 17264 */
	    "USB-RSAQ3)\0" /* 1 refs @ 17269 */
	    "(SMART\0" /* 1 refs @ 17280 */
	    "Technologies)\0" /* 1 refs @ 17287 */
	    "USB-1284\0" /* 1 refs @ 17301 */
	    "BRIDGE\0" /* 1 refs @ 17310 */
	    "CH341\0" /* 3 refs @ 17317 */
	    "USB-EPP/SSP\0" /* 1 refs @ 17323 */
	    "USB-Serial\0" /* 4 refs @ 17335 */
	    "USB-Printer\0" /* 1 refs @ 17346 */
	    "CH340\0" /* 1 refs @ 17358 */
	    "CH341/CH340\0" /* 1 refs @ 17364 */
	    "Scorpion-980N\0" /* 2 refs @ 17376 */
	    "RWT\0" /* 1 refs @ 17390 */
	    "FCT-CDMA\0" /* 1 refs @ 17394 */
	    "1xRTT\0" /* 1 refs @ 17403 */
	    "StrikePad\0" /* 1 refs @ 17409 */
	    "i-Key\0" /* 1 refs @ 17419 */
	    "RT73\0" /* 1 refs @ 17425 */
	    "RT2671\0" /* 1 refs @ 17430 */
	    "RT3370\0" /* 1 refs @ 17437 */
	    "RT3573\0" /* 1 refs @ 17444 */
	    "RT5370\0" /* 1 refs @ 17451 */
	    "RT5572\0" /* 1 refs @ 17458 */
	    "RT8070\0" /* 1 refs @ 17465 */
	    "REX-USB60\0" /* 1 refs @ 17472 */
	    "REX-USB60F\0" /* 1 refs @ 17482 */
	    "RTL8188ETV\0" /* 1 refs @ 17493 */
	    "RTL8188CTV\0" /* 1 refs @ 17504 */
	    "RTL8188RU\0" /* 3 refs @ 17515 */
	    "RTL8150L\0" /* 1 refs @ 17525 */
	    "USB-Ethernet\0" /* 1 refs @ 17534 */
	    "RTL8151\0" /* 1 refs @ 17547 */
	    "PNA\0" /* 1 refs @ 17555 */
	    "RTL8152\0" /* 1 refs @ 17559 */
	    "RTL8153\0" /* 1 refs @ 17567 */
	    "RTL8156\0" /* 1 refs @ 17575 */
	    "RTL8171\0" /* 1 refs @ 17583 */
	    "RTL8172\0" /* 1 refs @ 17591 */
	    "RTL8173\0" /* 1 refs @ 17599 */
	    "RTL8174\0" /* 1 refs @ 17607 */
	    "RTL8191CU\0" /* 1 refs @ 17615 */
	    "RTL8192CE\0" /* 1 refs @ 17625 */
	    "RTL8187B\0" /* 3 refs @ 17635 */
	    "RTL8192EU\0" /* 1 refs @ 17644 */
	    "RTL8712\0" /* 1 refs @ 17654 */
	    "RTL8713\0" /* 1 refs @ 17662 */
	    "RTL8188FU\0" /* 1 refs @ 17670 */
	    "BlackBerry\0" /* 3 refs @ 17680 */
	    "Pearl\0" /* 2 refs @ 17691 */
	    "203USB\0" /* 1 refs @ 17697 */
	    "UA-100\0" /* 1 refs @ 17704 */
	    "I/F\0" /* 20 refs @ 17711 */
	    "UM-4\0" /* 1 refs @ 17715 */
	    "MIDI\0" /* 29 refs @ 17720 */
	    "RolandED\0" /* 1 refs @ 17725 */
	    "SC-8850\0" /* 1 refs @ 17734 */
	    "SOUND\0" /* 1 refs @ 17742 */
	    "Canvas\0" /* 2 refs @ 17748 */
	    "Synth.\0" /* 14 refs @ 17755 */
	    "U-8\0" /* 1 refs @ 17762 */
	    "UM-2\0" /* 1 refs @ 17766 */
	    "SoundCanvas\0" /* 2 refs @ 17771 */
	    "SC-8820\0" /* 1 refs @ 17783 */
	    "PC-300\0" /* 1 refs @ 17791 */
	    "UM-1\0" /* 1 refs @ 17798 */
	    "SK-500\0" /* 1 refs @ 17803 */
	    "SC-D70\0" /* 1 refs @ 17810 */
	    "EDIROL\0" /* 19 refs @ 17817 */
	    "UA-3\0" /* 1 refs @ 17824 */
	    "audio\0" /* 5 refs @ 17829 */
	    "XV-5050\0" /* 1 refs @ 17835 */
	    "UM-880\0" /* 2 refs @ 17843 */
	    "(native)\0" /* 1 refs @ 17850 */
	    "(generic)\0" /* 1 refs @ 17859 */
	    "SD-90\0" /* 1 refs @ 17869 */
	    "STDIO\0" /* 1 refs @ 17875 */
	    "UA-1A\0" /* 1 refs @ 17881 */
	    "UM-550\0" /* 1 refs @ 17887 */
	    "SD-20\0" /* 1 refs @ 17894 */
	    "SD-80\0" /* 1 refs @ 17900 */
	    "UA-700\0" /* 1 refs @ 17906 */
	    "PCR\0" /* 2 refs @ 17913 */
	    "(advanced)\0" /* 4 refs @ 17917 */
	    "M-1000\0" /* 1 refs @ 17928 */
	    "UA-1000\0" /* 1 refs @ 17935 */
	    "UA-3FX\0" /* 2 refs @ 17943 */
	    "Fantom-X\0" /* 1 refs @ 17950 */
	    "UA-25\0" /* 1 refs @ 17959 */
	    "UA-101\0" /* 2 refs @ 17965 */
	    "PC-50\0" /* 2 refs @ 17972 */
	    "USB1\0" /* 1 refs @ 17978 */
	    "UA-1EX\0" /* 1 refs @ 17983 */
	    "UM-3\0" /* 1 refs @ 17990 */
	    "UA-4FX\0" /* 1 refs @ 17995 */
	    "SonicCell\0" /* 1 refs @ 18002 */
	    "UA-25EX\0" /* 2 refs @ 18012 */
	    "UM-ONE\0" /* 1 refs @ 18020 */
	    "QUAD-CAPTURE\0" /* 1 refs @ 18027 */
	    "RTS-03\0" /* 1 refs @ 18040 */
	    "CT57A\0" /* 1 refs @ 18047 */
	    "XG-760A\0" /* 1 refs @ 18053 */
	    "XG-76NA\0" /* 1 refs @ 18061 */
	    "Gold\0" /* 2 refs @ 18069 */
	    "Joystick\0" /* 1 refs @ 18074 */
	    "ML-6060\0" /* 1 refs @ 18083 */
	    "GT-B3710\0" /* 1 refs @ 18091 */
	    "LTE/4G\0" /* 2 refs @ 18100 */
	    "GT-B3730\0" /* 1 refs @ 18107 */
	    "SWL-2100U\0" /* 1 refs @ 18116 */
	    "ImageMate\0" /* 8 refs @ 18126 */
	    "SDDR-05a\0" /* 1 refs @ 18136 */
	    "SDDR-31\0" /* 1 refs @ 18145 */
	    "SDDR-05\0" /* 1 refs @ 18153 */
	    "SDDR-12\0" /* 1 refs @ 18161 */
	    "SDDR-09\0" /* 1 refs @ 18169 */
	    "SDDR-86\0" /* 1 refs @ 18177 */
	    "SDDR-75\0" /* 1 refs @ 18185 */
	    "Cruzer\0" /* 1 refs @ 18193 */
	    "Sansa\0" /* 1 refs @ 18200 */
	    "Clip\0" /* 1 refs @ 18206 */
	    "JY-DV9USB\0" /* 1 refs @ 18211 */
	    "SCP-4900\0" /* 1 refs @ 18221 */
	    "SL11R-IDE\0" /* 1 refs @ 18230 */
	    "SeaPort+4\0" /* 4 refs @ 18240 */
	    "NUB-8301\0" /* 1 refs @ 18250 */
	    "SN1\0" /* 1 refs @ 18259 */
	    "L1\0" /* 1 refs @ 18263 */
	    "ST268\0" /* 1 refs @ 18266 */
	    "Pocket\0" /* 1 refs @ 18272 */
	    "CE175TU\0" /* 1 refs @ 18279 */
	    "SL5500\0" /* 1 refs @ 18287 */
	    "A300\0" /* 1 refs @ 18294 */
	    "SL5600\0" /* 1 refs @ 18299 */
	    "C700\0" /* 1 refs @ 18306 */
	    "C750\0" /* 1 refs @ 18311 */
	    "WS003SH\0" /* 1 refs @ 18316 */
	    "WS007SH\0" /* 1 refs @ 18324 */
	    "WS011SH\0" /* 1 refs @ 18332 */
	    "NetWalker\0" /* 1 refs @ 18340 */
	    "E-USB\0" /* 1 refs @ 18350 */
	    "eUSCSI\0" /* 3 refs @ 18356 */
	    "SDDR09\0" /* 1 refs @ 18363 */
	    "eUSB\0" /* 5 refs @ 18370 */
	    "Hifd\0" /* 1 refs @ 18375 */
	    "CD-RW\0" /* 1 refs @ 18380 */
	    "ORCA\0" /* 1 refs @ 18386 */
	    "SCM\0" /* 3 refs @ 18391 */
	    "SCL3711-NFC&RW\0" /* 1 refs @ 18395 */
	    "SCL3712-NFC&RW\0" /* 1 refs @ 18410 */
	    "1022\0" /* 1 refs @ 18425 */
	    "Modules\0" /* 1 refs @ 18430 */
	    "MC75\0" /* 1 refs @ 18438 */
	    "HC28\0" /* 3 refs @ 18443 */
	    "MdmNet\0" /* 1 refs @ 18448 */
	    "Mdm\0" /* 1 refs @ 18455 */
	    "EM5625\0" /* 1 refs @ 18459 */
	    "MC5720\0" /* 2 refs @ 18466 */
	    "AirCard\0" /* 12 refs @ 18473 */
	    "595\0" /* 1 refs @ 18481 */
	    "MC5725\0" /* 1 refs @ 18485 */
	    "597E\0" /* 1 refs @ 18492 */
	    "Compass\0" /* 1 refs @ 18497 */
	    "597\0" /* 1 refs @ 18505 */
	    "580\0" /* 1 refs @ 18509 */
	    "595U\0" /* 1 refs @ 18513 */
	    "miniPCI\0" /* 1 refs @ 18518 */
	    "5275\0" /* 1 refs @ 18526 */
	    "Sieral\0" /* 1 refs @ 18531 */
	    "250U\0" /* 1 refs @ 18538 */
	    "Aircard\0" /* 2 refs @ 18543 */
	    "MC8755\0" /* 3 refs @ 18551 */
	    "MC8765\0" /* 1 refs @ 18558 */
	    "AC875U\0" /* 1 refs @ 18565 */
	    "MC8775\0" /* 1 refs @ 18572 */
	    "875\0" /* 1 refs @ 18579 */
	    "MC8780\0" /* 1 refs @ 18583 */
	    "MC8781\0" /* 1 refs @ 18590 */
	    "880\0" /* 1 refs @ 18597 */
	    "881\0" /* 1 refs @ 18601 */
	    "880E\0" /* 1 refs @ 18605 */
	    "881E\0" /* 1 refs @ 18610 */
	    "880U\0" /* 1 refs @ 18615 */
	    "881U\0" /* 1 refs @ 18620 */
	    "885U\0" /* 1 refs @ 18625 */
	    "C01SW\0" /* 1 refs @ 18630 */
	    "MC7304\0" /* 1 refs @ 18636 */
	    "EM7455\0" /* 1 refs @ 18643 */
	    "StIR4116\0" /* 1 refs @ 18650 */
	    "SIR\0" /* 1 refs @ 18659 */
	    "StIR4210\0" /* 1 refs @ 18663 */
	    "StIR4220\0" /* 1 refs @ 18672 */
	    "VFIR\0" /* 1 refs @ 18681 */
	    "i-Bead\0" /* 2 refs @ 18686 */
	    "Datum\0" /* 1 refs @ 18693 */
	    "SSF-7X\0" /* 1 refs @ 18699 */
	    "Multi\0" /* 1 refs @ 18706 */
	    "Players\0" /* 1 refs @ 18712 */
	    "TrekStor\0" /* 1 refs @ 18720 */
	    "Musicstick\0" /* 1 refs @ 18729 */
	    "AT-USB10\0" /* 1 refs @ 18740 */
	    "DigiFilm-Combo\0" /* 1 refs @ 18749 */
	    "MULTICARDREADER\0" /* 2 refs @ 18764 */
	    "TO\0" /* 1 refs @ 18780 */
	    "U2E\0" /* 1 refs @ 18783 */
	    "Psion\0" /* 1 refs @ 18787 */
	    "Pololu\0" /* 1 refs @ 18793 */
	    "Argussoft\0" /* 1 refs @ 18800 */
	    "ISP\0" /* 1 refs @ 18810 */
	    "Crumb128\0" /* 1 refs @ 18814 */
	    "Degree\0" /* 1 refs @ 18823 */
	    "Controls\0" /* 1 refs @ 18830 */
	    "Suunto\0" /* 1 refs @ 18839 */
	    "sports\0" /* 1 refs @ 18846 */
	    "Burnside\0" /* 1 refs @ 18853 */
	    "mobile\0" /* 1 refs @ 18862 */
	    "IP-Link\0" /* 1 refs @ 18869 */
	    "1220\0" /* 1 refs @ 18877 */
	    "Lipowsky\0" /* 3 refs @ 18882 */
	    "Baby-JTAG\0" /* 1 refs @ 18891 */
	    "Baby-LIN\0" /* 1 refs @ 18901 */
	    "HARP-1\0" /* 1 refs @ 18910 */
	    "DCU-11\0" /* 1 refs @ 18917 */
	    "clone\0" /* 1 refs @ 18924 */
	    "CP210x\0" /* 3 refs @ 18930 */
	    "EC3\0" /* 1 refs @ 18937 */
	    "Debug\0" /* 1 refs @ 18941 */
	    "YAP\0" /* 2 refs @ 18947 */
	    "802.11g\0" /* 1 refs @ 18951 */
	    "NetComm\0" /* 1 refs @ 18959 */
	    "Roadster\0" /* 1 refs @ 18967 */
	    "56\0" /* 1 refs @ 18976 */
	    "LN029\0" /* 1 refs @ 18979 */
	    "CN104\0" /* 1 refs @ 18985 */
	    "WL-168\0" /* 2 refs @ 18991 */
	    "v1\0" /* 3 refs @ 18998 */
	    "LN-030\0" /* 1 refs @ 19001 */
	    "v4\0" /* 3 refs @ 19008 */
	    "WL-302\0" /* 1 refs @ 19011 */
	    "WL-603\0" /* 1 refs @ 19018 */
	    "WL-315\0" /* 1 refs @ 19025 */
	    "WL-321\0" /* 1 refs @ 19032 */
	    "WL-324\0" /* 1 refs @ 19039 */
	    "WL-343\0" /* 1 refs @ 19046 */
	    "WL-608\0" /* 1 refs @ 19053 */
	    "WL-344\0" /* 1 refs @ 19060 */
	    "WL-329\0" /* 1 refs @ 19067 */
	    "WL-345\0" /* 1 refs @ 19074 */
	    "WL-353\0" /* 1 refs @ 19081 */
	    "WL-349\0" /* 2 refs @ 19088 */
	    "LN-031\0" /* 1 refs @ 19095 */
	    "WLA-4000\0" /* 1 refs @ 19102 */
	    "WLA-5000\0" /* 1 refs @ 19111 */
	    "LN-028\0" /* 1 refs @ 19120 */
	    "2/2\0" /* 1 refs @ 19127 */
	    "WL-113\0" /* 2 refs @ 19131 */
	    "WL-172\0" /* 1 refs @ 19138 */
	    "SmartLink\0" /* 1 refs @ 19145 */
	    "smartNIC\0" /* 1 refs @ 19155 */
	    "PnP\0" /* 1 refs @ 19164 */
	    "EZ\0" /* 5 refs @ 19168 */
	    "11Mbps\0" /* 2 refs @ 19171 */
	    "54Mbps\0" /* 2 refs @ 19178 */
	    "1.0\0" /* 1 refs @ 19185 */
	    "eHome\0" /* 1 refs @ 19189 */
	    "Infrared\0" /* 1 refs @ 19195 */
	    "2-Port\0" /* 1 refs @ 19204 */
	    "3-Port\0" /* 1 refs @ 19211 */
	    "4-Port\0" /* 1 refs @ 19218 */
	    "LAN7500\0" /* 1 refs @ 19225 */
	    "LAN7505\0" /* 1 refs @ 19233 */
	    "LAN7800\0" /* 1 refs @ 19241 */
	    "3.1\0" /* 2 refs @ 19249 */
	    "LAN7801\0" /* 1 refs @ 19253 */
	    "LAN7850\0" /* 1 refs @ 19261 */
	    "SMSC9500\0" /* 3 refs @ 19269 */
	    "SMSC9505\0" /* 2 refs @ 19278 */
	    "SMSC9512\0" /* 2 refs @ 19287 */
	    "SMSC9514\0" /* 1 refs @ 19296 */
	    "LAN9530\0" /* 1 refs @ 19305 */
	    "LAN9730\0" /* 1 refs @ 19313 */
	    "(SAL10)\0" /* 5 refs @ 19321 */
	    "SMSC9500A\0" /* 4 refs @ 19329 */
	    "SMSC9505A\0" /* 3 refs @ 19339 */
	    "SMSC9512/14\0" /* 1 refs @ 19349 */
	    "(HAL)\0" /* 2 refs @ 19361 */
	    "LAN89530\0" /* 1 refs @ 19367 */
	    "SMSC9512/9514\0" /* 1 refs @ 19376 */
	    "NUB110\0" /* 1 refs @ 19390 */
	    "DSC\0" /* 2 refs @ 19397 */
	    "cameras\0" /* 1 refs @ 19401 */
	    "Memorystick\0" /* 2 refs @ 19409 */
	    "NW-MS7\0" /* 1 refs @ 19421 */
	    "MSAC-US1\0" /* 1 refs @ 19428 */
	    "Handycam\0" /* 1 refs @ 19437 */
	    "MSC\0" /* 2 refs @ 19446 */
	    "memory\0" /* 2 refs @ 19450 */
	    "stick\0" /* 2 refs @ 19457 */
	    "slot\0" /* 4 refs @ 19463 */
	    "Clie\0" /* 8 refs @ 19468 */
	    "v3.5\0" /* 1 refs @ 19473 */
	    "PlayStation2\0" /* 5 refs @ 19478 */
	    "v4.0\0" /* 2 refs @ 19491 */
	    "MSC-U03\0" /* 1 refs @ 19496 */
	    "s360\0" /* 1 refs @ 19504 */
	    "v4.1\0" /* 2 refs @ 19509 */
	    "nx60\0" /* 1 refs @ 19514 */
	    "EyeToy\0" /* 2 refs @ 19519 */
	    "v154\0" /* 1 refs @ 19526 */
	    "v155\0" /* 1 refs @ 19531 */
	    "tj25\0" /* 1 refs @ 19536 */
	    "IFU-WLM2\0" /* 1 refs @ 19541 */
	    "PLAYSTATION(R)3\0" /* 1 refs @ 19550 */
	    "GPS-CS1\0" /* 1 refs @ 19566 */
	    "KeikaiDenwa\0" /* 2 refs @ 19574 */
	    "charger\0" /* 1 refs @ 19586 */
	    "TTSMP3Player\0" /* 1 refs @ 19594 */
	    "UB801R\0" /* 1 refs @ 19607 */
	    "Communicator\0" /* 1 refs @ 19614 */
	    "SUNTAC\0" /* 5 refs @ 19627 */
	    "U-Cable\0" /* 4 refs @ 19634 */
	    "type\0" /* 4 refs @ 19642 */
	    "D2\0" /* 1 refs @ 19647 */
	    "P1\0" /* 1 refs @ 19650 */
	    "Slipper\0" /* 1 refs @ 19653 */
	    "U\0" /* 1 refs @ 19661 */
	    "Ir-Trinity\0" /* 1 refs @ 19663 */
	    "A3\0" /* 1 refs @ 19674 */
	    "A4\0" /* 2 refs @ 19677 */
	    "SR9600\0" /* 1 refs @ 19680 */
	    "QF9700\0" /* 1 refs @ 19687 */
	    "Supra\0" /* 1 refs @ 19694 */
	    "56K\0" /* 3 refs @ 19700 */
	    "SupraMax\0" /* 1 refs @ 19704 */
	    "2890\0" /* 1 refs @ 19713 */
	    "800\0" /* 1 refs @ 19718 */
	    "Nike\0" /* 1 refs @ 19722 */
	    "psa[play\0" /* 1 refs @ 19727 */
	    "120\0" /* 1 refs @ 19736 */
	    "EP-9001-g\0" /* 2 refs @ 19740 */
	    "2a\0" /* 1 refs @ 19750 */
	    "ZD1211\0" /* 5 refs @ 19753 */
	    "LW153\0" /* 1 refs @ 19760 */
	    "LW154\0" /* 1 refs @ 19766 */
	    "LW303\0" /* 1 refs @ 19772 */
	    "LW313\0" /* 1 refs @ 19778 */
	    "MW-P54SS\0" /* 1 refs @ 19784 */
	    "Broadband\0" /* 3 refs @ 19793 */
	    "Router\0" /* 5 refs @ 19803 */
	    "SGC-X2UL\0" /* 1 refs @ 19810 */
	    "USBPS2\0" /* 1 refs @ 19819 */
	    "PAUM004\0" /* 1 refs @ 19826 */
	    "(DPCM_USB)\0" /* 1 refs @ 19834 */
	    "USB-PDC\0" /* 1 refs @ 19845 */
	    "UPA9664\0" /* 1 refs @ 19853 */
	    "USB-cdmaOne\0" /* 1 refs @ 19861 */
	    "UCA1464\0" /* 1 refs @ 19873 */
	    "USB-PHS\0" /* 2 refs @ 19881 */
	    "UHA6400\0" /* 1 refs @ 19889 */
	    "UPA6400\0" /* 1 refs @ 19897 */
	    "FD-05PUB\0" /* 1 refs @ 19905 */
	    "floppy\0" /* 1 refs @ 19914 */
	    "ALLNET\0" /* 1 refs @ 19921 */
	    "0193\0" /* 1 refs @ 19928 */
	    "ZyAIR\0" /* 2 refs @ 19933 */
	    "B200\0" /* 1 refs @ 19939 */
	    "U-300C\0" /* 1 refs @ 19944 */
	    "QuickWLAN\0" /* 1 refs @ 19951 */
	    "Enhanced\0" /* 1 refs @ 19961 */
	    "Microphone\0" /* 1 refs @ 19970 */
	    "Missile\0" /* 1 refs @ 19981 */
	    "Launcher\0" /* 1 refs @ 19989 */
	    "TEMPer\0" /* 1 refs @ 19998 */
	    "sensor\0" /* 1 refs @ 20005 */
	    "UT-USB41\0" /* 1 refs @ 20012 */
	    "TUSB2046\0" /* 1 refs @ 20021 */
	    "TUSB3410\0" /* 1 refs @ 20030 */
	    "Nex\0" /* 1 refs @ 20039 */
	    "MSP-FET430UIF\0" /* 2 refs @ 20043 */
	    "JTAG\0" /* 1 refs @ 20057 */
	    "DOOGI\0" /* 1 refs @ 20062 */
	    "SLIM\0" /* 1 refs @ 20068 */
	    "Argos\0" /* 1 refs @ 20073 */
	    "Smartcard\0" /* 1 refs @ 20079 */
	    "TF5000PVR\0" /* 1 refs @ 20089 */
	    "Video\0" /* 1 refs @ 20099 */
	    "Recorder\0" /* 1 refs @ 20105 */
	    "DX3\0" /* 1 refs @ 20114 */
	    "e740\0" /* 1 refs @ 20118 */
	    "TL-WN821N\0" /* 1 refs @ 20123 */
	    "v5\0" /* 1 refs @ 20133 */
	    "TL-WN822N\0" /* 1 refs @ 20136 */
	    "TL-WN823N\0" /* 1 refs @ 20146 */
	    "Archer\0" /* 3 refs @ 20156 */
	    "T4U\0" /* 1 refs @ 20163 */
	    "T4UH\0" /* 1 refs @ 20167 */
	    "T2U\0" /* 1 refs @ 20172 */
	    "UE300\0" /* 1 refs @ 20176 */
	    "10/100/1000\0" /* 1 refs @ 20182 */
	    "ThumbDrive\0" /* 2 refs @ 20194 */
	    "8MB\0" /* 1 refs @ 20205 */
	    "TEW-648UBM\0" /* 1 refs @ 20209 */
	    "U209\0" /* 1 refs @ 20220 */
	    "SmartLCD\0" /* 1 refs @ 20225 */
	    "AVR550U\0" /* 1 refs @ 20234 */
	    "USB/MP3\0" /* 1 refs @ 20242 */
	    "decoder\0" /* 1 refs @ 20250 */
	    "1100\0" /* 1 refs @ 20258 */
	    "SM-2000\0" /* 1 refs @ 20263 */
	    "G240\0" /* 1 refs @ 20271 */
	    "Artec\0" /* 1 refs @ 20276 */
	    "T14BR\0" /* 1 refs @ 20282 */
	    "Astra\0" /* 6 refs @ 20288 */
	    "Scanner\0" /* 6 refs @ 20294 */
	    "1220U\0" /* 1 refs @ 20302 */
	    "2000U\0" /* 1 refs @ 20308 */
	    "3400\0" /* 1 refs @ 20314 */
	    "2100U\0" /* 1 refs @ 20319 */
	    "2200U\0" /* 1 refs @ 20325 */
	    "TEW-429UB_A\0" /* 1 refs @ 20331 */
	    "TEW-429UB\0" /* 2 refs @ 20343 */
	    "TEW-645UB\0" /* 1 refs @ 20353 */
	    "ALL0298\0" /* 2 refs @ 20363 */
	    "Panache\0" /* 1 refs @ 20371 */
	    "Surf\0" /* 1 refs @ 20379 */
	    "NW-3100\0" /* 1 refs @ 20384 */
	    "NF\0" /* 1 refs @ 20392 */
	    "RIC\0" /* 1 refs @ 20395 */
	    "USR1120\0" /* 1 refs @ 20399 */
	    "USR5422\0" /* 1 refs @ 20407 */
	    "USR5423\0" /* 1 refs @ 20415 */
	    "MC60\0" /* 1 refs @ 20423 */
	    "Revision\0" /* 1 refs @ 20428 */
	    "VFS101\0" /* 1 refs @ 20437 */
	    "Fingerprint\0" /* 7 refs @ 20444 */
	    "VFS301\0" /* 1 refs @ 20456 */
	    "VFS451\0" /* 1 refs @ 20463 */
	    "VFS300\0" /* 1 refs @ 20470 */
	    "VFS5011\0" /* 1 refs @ 20477 */
	    "VFS471\0" /* 1 refs @ 20485 */
	    "VFS491\0" /* 1 refs @ 20492 */
	    "MonsterTV\0" /* 1 refs @ 20499 */
	    "P2H\0" /* 1 refs @ 20509 */
	    "G773\0" /* 2 refs @ 20513 */
	    "Monitor\0" /* 3 refs @ 20518 */
	    "P815\0" /* 1 refs @ 20526 */
	    "CPiA\0" /* 1 refs @ 20531 */
	    "OneTouch\0" /* 6 refs @ 20536 */
	    "7600\0" /* 1 refs @ 20545 */
	    "5300\0" /* 1 refs @ 20550 */
	    "Scanport\0" /* 1 refs @ 20555 */
	    "6100\0" /* 1 refs @ 20564 */
	    "8100\0" /* 1 refs @ 20569 */
	    "8600\0" /* 1 refs @ 20574 */
	    "DSC350\0" /* 1 refs @ 20579 */
	    "CT-0405-U\0" /* 1 refs @ 20586 */
	    "Tablet\0" /* 3 refs @ 20596 */
	    "Graphire\0" /* 1 refs @ 20603 */
	    "Graphire2\0" /* 1 refs @ 20612 */
	    "ET-0405A-U\0" /* 1 refs @ 20622 */
	    "Graphire3\0" /* 2 refs @ 20633 */
	    "4x5\0" /* 2 refs @ 20643 */
	    "6x8\0" /* 1 refs @ 20647 */
	    "Graphire4\0" /* 1 refs @ 20651 */
	    "Intuos\0" /* 5 refs @ 20661 */
	    "A5\0" /* 1 refs @ 20668 */
	    "9x12\0" /* 1 refs @ 20671 */
	    "Intuos2\0" /* 1 refs @ 20676 */
	    "i-920\0" /* 1 refs @ 20684 */
	    "XD-0912-U\0" /* 1 refs @ 20690 */
	    "CTL-671\0" /* 1 refs @ 20700 */
	    "Art\0" /* 2 refs @ 20708 */
	    "CTH-490/K0\0" /* 1 refs @ 20712 */
	    "CTH-690/K0\0" /* 1 refs @ 20723 */
	    "M\0" /* 1 refs @ 20734 */
	    "HID\0" /* 1 refs @ 20736 */
	    "RIGblaster\0" /* 1 refs @ 20740 */
	    "External\0" /* 1 refs @ 20751 */
	    "HDD\0" /* 1 refs @ 20760 */
	    "WNC-0600USB\0" /* 1 refs @ 20764 */
	    "UR055G\0" /* 1 refs @ 20776 */
	    "ORiNOCO\0" /* 1 refs @ 20783 */
	    "802.11n\0" /* 1 refs @ 20791 */
	    "IMAGING\0" /* 1 refs @ 20799 */
	    "DEVICE\0" /* 1 refs @ 20807 */
	    "UX256\0" /* 1 refs @ 20814 */
	    "MU1000\0" /* 1 refs @ 20820 */
	    "MU2000\0" /* 1 refs @ 20827 */
	    "MU500\0" /* 1 refs @ 20834 */
	    "UW500\0" /* 1 refs @ 20840 */
	    "MOTIF6\0" /* 1 refs @ 20846 */
	    "Workstation\0" /* 3 refs @ 20853 */
	    "MOTIF7\0" /* 1 refs @ 20865 */
	    "MOTIF8\0" /* 1 refs @ 20872 */
	    "UX96\0" /* 1 refs @ 20879 */
	    "UX16\0" /* 1 refs @ 20884 */
	    "S08\0" /* 1 refs @ 20889 */
	    "CLP-150\0" /* 1 refs @ 20893 */
	    "piano\0" /* 2 refs @ 20901 */
	    "CLP-170\0" /* 1 refs @ 20907 */
	    "RP-U200\0" /* 1 refs @ 20915 */
	    "NetVolante\0" /* 4 refs @ 20923 */
	    "RTA54i\0" /* 1 refs @ 20934 */
	    "Broadband&ISDN\0" /* 2 refs @ 20941 */
	    "RTW65b\0" /* 1 refs @ 20956 */
	    "RTW65i\0" /* 1 refs @ 20963 */
	    "RTA55i\0" /* 1 refs @ 20970 */
	    "VoIP\0" /* 1 refs @ 20977 */
	    "U640MO-03\0" /* 1 refs @ 20982 */
	    "Flashbuster-U\0" /* 1 refs @ 20992 */
	    "YubiKey\0" /* 3 refs @ 21006 */
	    "CCID\0" /* 1 refs @ 21014 */
	    "OTP+CCID\0" /* 1 refs @ 21019 */
	    "OTP+CCID+U2F\0" /* 1 refs @ 21028 */
	    "M4Y-750\0" /* 1 refs @ 21041 */
	    "725/726\0" /* 1 refs @ 21049 */
	    "XI-735\0" /* 1 refs @ 21057 */
	    "MD40900\0" /* 1 refs @ 21064 */
	    "UB81\0" /* 1 refs @ 21072 */
	    "UB82\0" /* 1 refs @ 21077 */
	    "BT-500\0" /* 1 refs @ 21082 */
	    "ZWX-G261\0" /* 1 refs @ 21089 */
	    "2986L\0" /* 1 refs @ 21098 */
	    "Fax\0" /* 2 refs @ 21104 */
	    "3095\0" /* 1 refs @ 21108 */
	    "EX-20\0" /* 1 refs @ 21113 */
	    "MF622\0" /* 1 refs @ 21119 */
	    "MF628\0" /* 1 refs @ 21125 */
	    "MF633\0" /* 1 refs @ 21131 */
	    "USUPA\0" /* 1 refs @ 21137 */
	    "MF626\0" /* 1 refs @ 21143 */
	    "installer\0" /* 2 refs @ 21149 */
	    "MF112\0" /* 1 refs @ 21159 */
	    "MF119\0" /* 1 refs @ 21165 */
	    "MF190\0" /* 1 refs @ 21171 */
	    "MF228\0" /* 1 refs @ 21177 */
	    "004Z\0" /* 1 refs @ 21183 */
	    "(MF288)\0" /* 1 refs @ 21188 */
	    "MF820D\0" /* 2 refs @ 21196 */
	    "UMTS\0" /* 1 refs @ 21203 */
	    "MC2718\0" /* 1 refs @ 21208 */
	    "1xEVDO\0" /* 1 refs @ 21215 */
	    "ZD1201\0" /* 1 refs @ 21222 */
	    "abg\0" /* 1 refs @ 21229 */
	    "ZD1221\0" /* 1 refs @ 21233 */
	    "Omni\0" /* 1 refs @ 21240 */
	    "G-220\0" /* 2 refs @ 21245 */
	    "G-200\0" /* 1 refs @ 21251 */
	    "AG-225H\0" /* 1 refs @ 21257 */
	    "M-202\0" /* 1 refs @ 21265 */
	    "G-270S\0" /* 1 refs @ 21271 */
	    "G-202\0" /* 1 refs @ 21278 */
	    "NWD-271N\0" /* 1 refs @ 21284 */
	    "NWD-211AN\0" /* 1 refs @ 21293 */
	    "NWD2105\0" /* 1 refs @ 21303 */
	    "NWD2705\0" /* 1 refs @ 21311 */
	    "ND6605\0" /* 1 refs @ 21319 */
	    "Prestige\0" /* 1 refs @ 21326 */
};
const int usb_nwords = 2839;

