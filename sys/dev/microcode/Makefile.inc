#	$NetBSD: Makefile.inc,v 1.2.40.1 2006/09/09 02:52:03 rpaulo Exp $

FIRMPATH!=	basename ${.CURDIR}
FIRMPATH:=	${FIRMWAREDIR}/${FIRMPATH}

FILESDIR=	${FIRMPATH}
FILESOWN=	${FIRMWAREOWN}
FILESGRP=	${FIRMWAREGRP}
FILESMODE=	${FIRMWAREMODE}
