/*	$NetBSD: ds2413gpioreg.h,v 1.1 2026/11/18 18:04:25 brad Exp $	*/

/*
 * Copyright (c) 2026 Brad Spencer <brad@anduin.eldar.org>
 *
 * Permission to use, copy, modify, and distribute this software for any
 * purpose with or without fee is hereby granted, provided that the above
 * copyright notice and this permission notice appear in all copies.
 *
 * THE SOFTWARE IS PROVIDED "AS IS" AND THE AUTHOR DISCLAIMS ALL WARRANTIES
 * WITH REGARD TO THIS SOFTWARE INCLUDING ALL IMPLIED WARRANTIES OF
 * MERCHANTABILITY AND FITNESS. IN NO EVENT SHALL THE AUTHOR BE LIABLE FOR
 * ANY SPECIAL, DIRECT, INDIRECT, OR CONSEQUENTIAL DAMAGES OR ANY DAMAGES
 * WHATSOEVER RESULTING FROM LOSS OF USE, DATA OR PROFITS, WHETHER IN AN
 * ACTION OF CONTRACT, NEGLIGENCE OR OTHER TORTIOUS ACTION, ARISING OUT OF
 * OR IN CONNECTION WITH THE USE OR PERFORMANCE OF THIS SOFTWARE.
 */

#ifndef _DEV_GPIO_DS2413GPIOREG_H_
#define _DEV_GPIO_DS2413GPIOREG_H_

#define DS2413_CLONE_FAMILYID 0x85

#define DS2413GPIO_PIO_READ	0xF5
#define		DS2413GPIO_READ_PIOA_STATE		0x01
#define		DS2413GPIO_READ_PIOB_STATE		0x04
#define		DS2413GPIO_READ_PIOA_LATCH_STATE	0x02
#define		DS2413GPIO_READ_PIOB_LATCH_STATE	0x08

#define DS2413GPIO_PIO_WRITE	0x5A

#define DS2413GPIO_WRITE_VALID	0xAA

#endif
