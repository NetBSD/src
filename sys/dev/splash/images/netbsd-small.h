/* $NetBSD: netbsd-small.h,v 1.1.10.2 2006/04/22 11:39:31 simonb Exp $ */
static const unsigned _splash_width = 261;
static const unsigned _splash_height = 200;
static const unsigned _pulse_on_width = 20;
static const unsigned _pulse_on_height = 20;
static const unsigned _pulse_off_width = 20;
static const unsigned _pulse_off_height = 20;
#define _SPLASH_HEADER_PIXEL(_d,_p) { \
 _p[0] = _splash_header_data_cmap[(unsigned char)_d[0]][0]; \
 _p[1] = _splash_header_data_cmap[(unsigned char)_d[0]][1]; \
 _p[2] = _splash_header_data_cmap[(unsigned char)_d[0]][2]; \
 _d++; }
#define _PULSE_OFF_HEADER_PIXEL(_d,_p) { \
 _p[0] = _splash_header_data_cmap[(unsigned char)_d[0] + 64][0]; \
 _p[1] = _splash_header_data_cmap[(unsigned char)_d[0] + 64][1]; \
 _p[2] = _splash_header_data_cmap[(unsigned char)_d[0] + 64][2]; \
 _d++; }
#define _PULSE_ON_HEADER_PIXEL(_d,_p) { \
 _p[0] = _splash_header_data_cmap[(unsigned char)_d[0] + 64 + 16][0]; \
 _p[1] = _splash_header_data_cmap[(unsigned char)_d[0] + 64 + 16][1]; \
 _p[2] = _splash_header_data_cmap[(unsigned char)_d[0] + 64 + 16][2]; \
 _d++; }
const char _splash_header_data_cmap[64+32][3] = {
  { 118, 120, 117 },
  { 121, 123, 120 },
  { 124, 126, 123 },
  { 129, 131, 128 },
  { 133, 135, 132 },
  { 244, 101, 19 },
  { 243, 107, 22 },
  { 138, 140, 137 },
  { 242, 113, 24 },
  { 142, 144, 141 },
  { 244, 114, 36 },
  { 243, 120, 38 },
  { 149, 151, 148 },
  { 245, 122, 49 },
  { 244, 127, 50 },
  { 246, 129, 60 },
  { 158, 159, 156 },
  { 244, 134, 61 },
  { 246, 136, 70 },
  { 245, 141, 72 },
  { 164, 166, 163 },
  { 246, 143, 80 },
  { 168, 170, 167 },
  { 245, 148, 82 },
  { 247, 151, 91 },
  { 174, 176, 173 },
  { 247, 157, 101 },
  { 181, 183, 180 },
  { 248, 164, 111 },
  { 250, 168, 120 },
  { 186, 189, 185 },
  { 248, 172, 122 },
  { 249, 175, 131 },
  { 192, 194, 191 },
  { 197, 199, 196 },
  { 249, 183, 141 },
  { 248, 188, 151 },
  { 201, 203, 200 },
  { 252, 193, 155 },
  { 252, 194, 163 },
  { 209, 211, 207 },
  { 249, 199, 165 },
  { 252, 203, 175 },
  { 216, 218, 215 },
  { 250, 208, 178 },
  { 251, 211, 186 },
  { 222, 224, 221 },
  { 254, 215, 192 },
  { 252, 221, 200 },
  { 227, 229, 226 },
  { 254, 225, 210 },
  { 231, 233, 230 },
  { 252, 230, 213 },
  { 236, 238, 234 },
  { 252, 233, 222 },
  { 255, 237, 226 },
  { 241, 243, 239 },
  { 255, 240, 234 },
  { 244, 246, 243 },
  { 253, 244, 237 },
  { 255, 247, 240 },
  { 248, 250, 247 },
  { 255, 251, 249 },
  { 254, 255, 252 },
  { 102, 101, 101 },
  { 105, 104, 104 },
  { 106, 105, 105 },
  { 118, 117, 117 },
  { 142, 141, 141 },
  { 171, 170, 170 },
  { 182, 181, 181 },
  { 183, 183, 183 },
  { 194, 194, 194 },
  { 218, 218, 218 },
  { 232, 232, 232 },
  { 244, 244, 244 },
  { 255, 255, 255 },
  { 255, 255, 255 },
  { 255, 255, 255 },
  { 255, 255, 255 },
  { 105, 100, 99 },
  { 107, 102, 101 },
  { 113, 109, 107 },
  { 116, 112, 110 },
  { 122, 117, 116 },
  { 132, 127, 126 },
  { 157, 152, 150 },
  { 169, 164, 163 },
  { 184, 179, 178 },
  { 187, 189, 186 },
  { 194, 189, 187 },
  { 209, 204, 202 },
  { 220, 222, 219 },
  { 230, 232, 229 },
  { 249, 251, 248 },
  { 254, 255, 252 },
};
static const char _splash_header_data[] = {
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 54, 48, 41, 35, 29, 24, 19, 15, 11,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 8, 11, 15, 21, 26, 32, 38, 45, 54, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 50, 41, 31, 24,
 14, 8, 6, 5, 5, 5, 6, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 5, 6, 6, 5, 6, 5, 6, 5,
 8, 15, 26, 35, 48, 59, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 59, 48, 35, 26, 14, 6, 5, 5, 6,
 5, 5, 5, 6, 6, 6, 5, 5, 6, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 6, 6, 5, 6, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 6, 17, 31, 45,
 59, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 54, 41,
 28, 15, 6, 5, 6, 5, 5, 6, 6, 6,
 5, 6, 6, 6, 6, 6, 5, 6, 6, 6,
 6, 6, 6, 5, 5, 6, 6, 6, 6, 6,
 6, 5, 6, 5, 6, 6, 5, 6, 6, 6,
 5, 6, 5, 6, 6, 6, 5, 6, 5, 5,
 5, 10, 21, 36, 54, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 52, 38, 26, 11, 5,
 6, 6, 6, 6, 5, 6, 6, 5, 5, 5,
 6, 5, 6, 5, 5, 5, 6, 5, 6, 5,
 5, 5, 6, 6, 6, 5, 5, 6, 5, 5,
 5, 6, 5, 6, 5, 5, 6, 5, 5, 6,
 6, 6, 6, 5, 5, 6, 6, 5, 6, 6,
 6, 5, 5, 6, 5, 6, 17, 35, 54, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 54, 39, 26, 13, 5, 5, 6, 5,
 6, 5, 6, 5, 5, 6, 6, 5, 6, 6,
 6, 6, 6, 5, 6, 6, 6, 6, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 6, 6, 6, 6, 5, 6, 6, 6, 6, 6,
 5, 6, 5, 5, 6, 6, 5, 5, 6, 6,
 6, 5, 6, 6, 5, 6, 5, 5, 5, 6,
 21, 41, 59, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 59,
 45, 29, 14, 6, 5, 5, 6, 6, 5, 6,
 5, 6, 5, 6, 6, 5, 5, 6, 5, 6,
 5, 5, 6, 6, 5, 6, 5, 5, 6, 6,
 5, 6, 6, 6, 5, 6, 5, 6, 6, 5,
 6, 5, 5, 6, 6, 5, 6, 5, 8, 17,
 24, 28, 35, 36, 42, 45, 48, 48, 48, 48,
 48, 48, 48, 45, 44, 38, 35, 31, 26, 18,
 10, 6, 5, 10, 31, 54, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 50, 35, 21,
 6, 5, 6, 5, 6, 6, 6, 6, 5, 6,
 5, 6, 5, 6, 6, 5, 6, 6, 6, 6,
 5, 6, 6, 5, 5, 6, 5, 6, 6, 5,
 5, 6, 5, 5, 5, 6, 5, 6, 5, 5,
 6, 5, 6, 11, 19, 31, 41, 48, 57, 58,
 61, 61, 61, 61, 61, 61, 61, 61, 61, 61,
 61, 61, 61, 61, 61, 62, 61, 61, 61, 63,
 62, 61, 57, 50, 41, 29, 21, 26, 47, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 59, 45, 28, 13, 6, 5,
 6, 6, 5, 6, 5, 5, 6, 5, 6, 6,
 6, 6, 6, 5, 5, 6, 5, 6, 5, 5,
 6, 5, 6, 6, 6, 5, 6, 5, 5, 6,
 6, 5, 6, 6, 6, 5, 6, 5, 6, 6,
 17, 29, 39, 54, 56, 58, 58, 61, 61, 61,
 62, 61, 61, 62, 61, 61, 63, 63, 61, 61,
 62, 62, 61, 62, 61, 61, 61, 61, 62, 62,
 61, 63, 61, 63, 63, 61, 63, 61, 62, 54,
 52, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 54, 38, 24, 8, 5, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 6,
 5, 6, 5, 5, 6, 6, 6, 6, 5, 6,
 6, 5, 6, 5, 5, 5, 6, 5, 6, 6,
 5, 5, 6, 5, 5, 5, 6, 13, 31, 41,
 57, 61, 61, 61, 61, 62, 62, 62, 61, 61,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 63, 63, 63, 61, 63, 63, 62, 63, 61,
 62, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 48, 32, 15, 6, 5, 5, 6, 6, 5, 6,
 5, 5, 6, 6, 6, 5, 6, 6, 5, 5,
 6, 5, 6, 6, 5, 5, 5, 6, 6, 5,
 5, 6, 5, 6, 6, 6, 5, 6, 5, 5,
 6, 6, 5, 6, 6, 19, 36, 52, 51, 58,
 61, 61, 61, 61, 61, 61, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 63, 63, 61, 63, 63,
 61, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 57, 41, 26,
 11, 5, 6, 6, 5, 6, 6, 6, 5, 6,
 6, 6, 6, 6, 5, 5, 6, 5, 5, 6,
 6, 5, 6, 5, 5, 6, 6, 6, 5, 5,
 6, 6, 5, 6, 5, 5, 5, 6, 5, 6,
 6, 6, 6, 18, 41, 55, 58, 61, 61, 61,
 61, 61, 61, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 40, 16,
 25, 61, 63, 62, 18, 32, 54, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 48, 32, 18, 6, 5,
 5, 6, 5, 5, 6, 5, 6, 5, 6, 5,
 5, 6, 5, 6, 6, 6, 6, 6, 6, 5,
 6, 6, 5, 6, 6, 5, 5, 5, 6, 6,
 5, 5, 6, 5, 6, 6, 6, 6, 5, 6,
 5, 17, 36, 46, 56, 58, 61, 63, 61, 63,
 63, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 40, 1,
 1, 0, 27, 62, 63, 41, 6, 6, 18, 38,
 59, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 50, 36, 24, 8, 5, 6, 6, 5,
 6, 6, 6, 6, 6, 6, 6, 5, 6, 6,
 6, 6, 5, 6, 5, 5, 5, 5, 5, 5,
 6, 5, 5, 6, 5, 5, 6, 6, 6, 5,
 5, 6, 5, 6, 5, 5, 6, 5, 6, 13,
 31, 54, 58, 61, 62, 61, 61, 61, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 27,
 0, 0, 1, 3, 58, 61, 62, 17, 6, 6,
 5, 6, 23, 39, 59, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 50,
 38, 24, 13, 6, 5, 5, 6, 5, 5, 6,
 5, 6, 5, 5, 6, 5, 5, 6, 5, 5,
 6, 5, 6, 5, 6, 6, 6, 6, 6, 6,
 5, 6, 6, 5, 6, 6, 5, 5, 6, 6,
 5, 6, 6, 5, 6, 6, 6, 5, 23, 44,
 49, 58, 61, 61, 63, 63, 63, 63, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 46, 0, 0, 0, 0, 25, 62, 63, 48, 5,
 5, 6, 6, 5, 6, 6, 18, 35, 50, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 59, 47, 35, 23, 10,
 6, 5, 6, 6, 5, 6, 6, 5, 6, 6,
 6, 6, 5, 6, 6, 5, 6, 6, 6, 6,
 6, 5, 6, 5, 6, 5, 5, 5, 5, 5,
 5, 6, 5, 6, 5, 5, 6, 6, 5, 6,
 5, 5, 6, 6, 6, 5, 11, 31, 54, 58,
 61, 61, 63, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 12, 0, 0, 0, 2, 58, 62, 63,
 24, 5, 5, 6, 5, 5, 6, 5, 6, 5,
 11, 26, 38, 52, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 48, 38, 28, 15, 10, 5, 5, 6,
 6, 6, 5, 5, 6, 5, 6, 6, 5, 6,
 5, 5, 6, 5, 6, 6, 5, 5, 5, 6,
 5, 6, 5, 6, 5, 6, 6, 6, 6, 6,
 6, 5, 6, 5, 6, 6, 6, 5, 6, 5,
 6, 6, 6, 5, 6, 14, 41, 46, 58, 61,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 40, 0, 0, 0, 0, 22, 62,
 61, 54, 8, 6, 6, 6, 6, 5, 6, 5,
 6, 5, 5, 6, 5, 10, 21, 32, 44, 54,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 54, 44, 35,
 26, 15, 6, 6, 6, 5, 6, 5, 6, 6,
 6, 5, 5, 6, 6, 6, 6, 6, 5, 6,
 5, 6, 6, 6, 6, 5, 5, 6, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 5, 6, 5,
 5, 6, 5, 6, 5, 5, 6, 6, 5, 6,
 5, 5, 6, 6, 23, 48, 58, 61, 61, 61,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 7, 0, 0, 0, 2,
 51, 63, 62, 29, 5, 5, 6, 6, 5, 6,
 6, 6, 6, 5, 6, 6, 6, 6, 5, 6,
 6, 10, 18, 26, 35, 41, 48, 54, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 59,
 55, 48, 42, 36, 28, 21, 14, 6, 5, 5,
 5, 6, 5, 5, 6, 6, 6, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 5, 5, 6, 5,
 6, 5, 6, 5, 6, 6, 6, 5, 5, 5,
 6, 5, 6, 5, 6, 6, 5, 6, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 6, 5, 6,
 6, 5, 6, 31, 37, 56, 58, 61, 63, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 59, 59, 54, 54, 54, 54,
 54, 55, 59, 59, 62, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 57, 37, 0, 0, 0,
 0, 25, 61, 61, 57, 10, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 6, 5, 5, 6,
 5, 5, 6, 5, 6, 5, 5, 5, 6, 6,
 10, 14, 18, 23, 26, 28, 29, 31, 32, 32,
 32, 32, 29, 29, 26, 24, 21, 18, 14, 10,
 6, 6, 5, 6, 5, 6, 6, 5, 5, 6,
 6, 6, 6, 6, 6, 5, 6, 5, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 6, 6, 6,
 6, 5, 6, 5, 6, 5, 5, 5, 6, 6,
 6, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 6, 6, 5, 6, 5, 6,
 5, 11, 31, 54, 61, 62, 62, 61, 61, 63,
 63, 63, 63, 63, 62, 57, 48, 42, 35, 29,
 24, 18, 14, 11, 8, 6, 5, 6, 6, 6,
 6, 6, 5, 5, 10, 8, 11, 15, 21, 26,
 32, 41, 48, 57, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 62, 4, 0,
 0, 0, 2, 51, 61, 61, 35, 5, 6, 5,
 5, 6, 5, 6, 5, 5, 5, 6, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 6, 5, 6,
 6, 5, 6, 5, 5, 6, 6, 5, 6, 6,
 6, 6, 6, 6, 6, 6, 6, 5, 6, 6,
 6, 5, 6, 5, 6, 5, 6, 6, 6, 5,
 6, 5, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 5, 5,
 5, 6, 5, 6, 5, 6, 6, 6, 5, 5,
 5, 5, 5, 6, 6, 5, 6, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 11, 35, 43, 58, 63, 63, 63, 63, 63, 62,
 54, 45, 35, 26, 18, 8, 6, 6, 5, 6,
 6, 6, 5, 5, 5, 6, 6, 5, 5, 5,
 5, 5, 6, 6, 5, 5, 5, 6, 5, 6,
 6, 5, 5, 6, 6, 10, 21, 32, 44, 55,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 33,
 0, 0, 0, 0, 20, 61, 63, 58, 14, 5,
 6, 6, 6, 6, 5, 6, 6, 6, 6, 5,
 6, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 6, 5, 6, 6, 6, 6, 5, 5, 6, 5,
 5, 5, 5, 6, 5, 5, 5, 5, 6, 5,
 5, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 6, 5, 6, 6, 6, 6, 5,
 6, 6, 6, 5, 5, 6, 5, 6, 5, 6,
 6, 6, 5, 6, 5, 6, 5, 5, 5, 6,
 6, 6, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 6, 6, 5, 6, 6, 6, 5, 6, 11,
 36, 53, 61, 61, 61, 61, 57, 42, 32, 21,
 10, 6, 6, 5, 6, 6, 6, 5, 5, 6,
 6, 6, 5, 6, 6, 6, 6, 5, 6, 6,
 6, 6, 6, 6, 5, 6, 6, 6, 6, 6,
 6, 5, 6, 6, 5, 5, 6, 6, 6, 5,
 6, 15, 28, 42, 59, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 3, 0, 0, 1, 0, 51, 62, 61, 44,
 5, 6, 5, 6, 6, 5, 6, 5, 6, 6,
 5, 6, 6, 6, 6, 6, 6, 5, 6, 5,
 5, 6, 5, 5, 6, 6, 6, 6, 6, 6,
 6, 6, 6, 5, 6, 6, 6, 6, 6, 6,
 6, 6, 6, 6, 6, 6, 6, 6, 5, 6,
 5, 6, 5, 6, 6, 5, 5, 6, 5, 6,
 5, 5, 6, 6, 6, 5, 6, 5, 6, 5,
 5, 5, 6, 5, 6, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 5, 6, 5, 14, 36,
 43, 58, 62, 48, 36, 24, 11, 6, 5, 6,
 6, 5, 5, 6, 5, 5, 5, 6, 6, 5,
 5, 5, 6, 5, 6, 5, 5, 6, 5, 6,
 5, 6, 5, 6, 6, 5, 5, 6, 5, 5,
 5, 6, 5, 5, 6, 6, 5, 6, 5, 6,
 5, 5, 6, 6, 5, 6, 19, 36, 54, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 30, 0, 0, 0, 0, 16, 62, 61,
 56, 19, 5, 6, 5, 5, 6, 5, 6, 5,
 5, 6, 5, 5, 5, 6, 5, 5, 6, 5,
 6, 6, 6, 6, 6, 5, 5, 6, 5, 5,
 6, 5, 6, 5, 6, 6, 5, 6, 5, 5,
 6, 5, 6, 5, 5, 5, 6, 5, 5, 6,
 5, 6, 6, 6, 5, 5, 6, 6, 5, 6,
 5, 6, 6, 5, 5, 5, 6, 5, 6, 5,
 6, 6, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 6, 5, 6, 6, 5, 6, 6, 6, 5,
 6, 6, 6, 5, 6, 6, 5, 14, 36, 51,
 48, 35, 21, 8, 6, 5, 6, 5, 5, 6,
 6, 5, 6, 6, 6, 6, 6, 6, 6, 5,
 6, 6, 6, 6, 6, 5, 6, 6, 6, 6,
 5, 6, 5, 6, 5, 5, 6, 6, 5, 6,
 6, 6, 6, 6, 6, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 5, 6, 6, 5, 5, 6,
 18, 36, 55, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 2, 0, 0, 0, 1, 46,
 62, 61, 48, 6, 6, 6, 5, 6, 5, 6,
 6, 6, 6, 6, 6, 5, 6, 6, 6, 6,
 5, 6, 5, 5, 6, 6, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 6, 6, 5, 6, 6, 6,
 6, 5, 5, 6, 6, 6, 5, 6, 6, 5,
 6, 5, 5, 6, 6, 6, 5, 6, 5, 6,
 5, 5, 6, 5, 5, 6, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 5, 5,
 6, 6, 5, 5, 6, 5, 8, 28, 32, 19,
 6, 5, 5, 5, 5, 6, 5, 6, 6, 5,
 5, 6, 5, 6, 5, 5, 6, 5, 5, 6,
 5, 6, 5, 5, 6, 6, 5, 6, 5, 5,
 6, 5, 6, 6, 6, 6, 5, 6, 6, 5,
 6, 5, 5, 6, 5, 6, 6, 5, 6, 6,
 6, 5, 6, 6, 6, 5, 5, 6, 6, 5,
 6, 5, 6, 6, 24, 45, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 25, 0, 0, 0, 0,
 16, 62, 61, 58, 26, 5, 5, 6, 5, 6,
 5, 6, 5, 5, 5, 5, 6, 5, 6, 5,
 5, 6, 5, 6, 6, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 6, 6, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 5, 5, 6, 6, 5, 5, 5, 6, 5, 5,
 6, 5, 6, 6, 6, 5, 5, 6, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 6, 6, 5,
 6, 6, 5, 6, 6, 6, 6, 5, 6, 6,
 5, 6, 6, 5, 6, 6, 6, 6, 5, 6,
 6, 6, 6, 6, 6, 6, 6, 6, 6, 5,
 6, 6, 6, 6, 5, 6, 6, 5, 6, 6,
 6, 6, 5, 6, 6, 5, 5, 6, 5, 6,
 6, 6, 6, 6, 5, 6, 5, 6, 5, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 11, 14,
 15, 19, 23, 24, 24, 24, 24, 24, 21, 18,
 14, 10, 8, 5, 6, 6, 5, 14, 35, 59,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 63, 62, 62, 62, 0, 0, 0,
 0, 0, 46, 62, 61, 54, 6, 6, 6, 5,
 6, 5, 6, 6, 6, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 5, 6, 5, 5,
 6, 6, 6, 5, 6, 5, 6, 5, 5, 5,
 6, 6, 6, 6, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 5, 6, 6, 6, 5, 6, 6,
 5, 6, 5, 5, 5, 6, 5, 6, 5, 5,
 6, 6, 5, 6, 5, 6, 5, 6, 5, 5,
 6, 5, 5, 6, 6, 5, 5, 6, 6, 5,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 5, 5, 5, 6,
 5, 6, 5, 5, 6, 5, 6, 6, 5, 6,
 5, 5, 6, 5, 6, 6, 6, 5, 6, 5,
 6, 5, 5, 5, 6, 5, 6, 6, 6, 6,
 5, 6, 14, 24, 32, 36, 48, 54, 57, 62,
 58, 61, 61, 61, 61, 61, 61, 61, 63, 63,
 61, 63, 61, 59, 54, 48, 44, 32, 28, 15,
 11, 29, 55, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 25, 0,
 0, 0, 0, 12, 61, 63, 56, 31, 5, 5,
 6, 5, 6, 5, 5, 5, 5, 6, 5, 6,
 5, 5, 6, 5, 6, 5, 5, 6, 5, 6,
 6, 5, 5, 5, 6, 5, 6, 5, 6, 6,
 6, 5, 5, 5, 5, 5, 6, 5, 6, 5,
 6, 5, 5, 6, 6, 5, 5, 5, 6, 5,
 5, 5, 6, 6, 6, 5, 6, 5, 6, 6,
 6, 5, 6, 6, 6, 5, 6, 6, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 6,
 5, 6, 6, 5, 6, 6, 6, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 6, 6,
 6, 6, 5, 6, 6, 6, 6, 5, 5, 6,
 5, 6, 6, 5, 6, 5, 5, 5, 6, 5,
 6, 5, 6, 6, 6, 5, 6, 6, 15, 28,
 36, 52, 56, 61, 61, 61, 58, 61, 61, 61,
 63, 61, 61, 61, 62, 61, 61, 61, 61, 61,
 61, 63, 63, 62, 61, 61, 62, 62, 61, 62,
 61, 62, 54, 42, 50, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 61, 63, 62, 62, 51,
 0, 0, 0, 0, 1, 43, 62, 61, 53, 11,
 5, 6, 5, 6, 6, 6, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 5, 6, 6, 6, 5, 6, 5, 6, 5, 5,
 5, 6, 6, 6, 6, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 5, 6, 6, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 6,
 5, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 5, 6, 6, 5, 6, 5, 6, 5, 5, 6,
 6, 5, 5, 5, 6, 5, 6, 5, 6, 5,
 5, 6, 6, 5, 6, 5, 5, 6, 6, 5,
 6, 5, 5, 6, 5, 6, 6, 6, 5, 6,
 5, 6, 5, 5, 6, 17, 29, 41, 51, 58,
 58, 62, 62, 61, 61, 61, 61, 63, 61, 61,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 63, 63, 63, 63, 63, 61, 61, 63, 61,
 63, 61, 63, 63, 63, 61, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 16, 0, 0, 0, 0, 9, 61, 61, 56,
 36, 6, 5, 6, 5, 5, 6, 5, 6, 5,
 6, 5, 5, 6, 5, 6, 5, 5, 6, 5,
 6, 6, 5, 5, 5, 6, 5, 6, 5, 6,
 6, 6, 5, 5, 5, 5, 5, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 6, 6, 5, 6, 6, 5, 6,
 6, 5, 6, 6, 6, 5, 6, 6, 5, 6,
 5, 6, 5, 6, 6, 5, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 5, 6, 6, 5,
 5, 6, 6, 6, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 5, 6, 5, 6, 6, 5, 5,
 6, 5, 6, 6, 5, 6, 5, 5, 5, 6,
 5, 6, 6, 23, 36, 54, 62, 61, 61, 62,
 62, 61, 61, 61, 62, 63, 63, 63, 61, 63,
 63, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 51, 0, 0, 0, 1, 1, 40, 62,
 61, 56, 17, 5, 6, 6, 6, 5, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 5, 6, 6, 6, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 6, 6, 6, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 6, 5, 5, 6, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 6, 5, 5, 5, 6, 5, 6, 5, 6,
 5, 5, 6, 6, 5, 6, 5, 5, 6, 6,
 5, 6, 5, 5, 6, 5, 6, 6, 6, 6,
 10, 26, 44, 51, 61, 61, 61, 61, 61, 63,
 61, 63, 61, 63, 63, 63, 63, 63, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 16, 0, 0, 0, 0, 9,
 63, 61, 56, 44, 5, 6, 5, 6, 6, 5,
 6, 5, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 5, 5, 5, 5, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 5, 5, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 5, 6, 6, 5, 6,
 6, 6, 5, 6, 6, 5, 6, 6, 5, 6,
 6, 5, 6, 6, 5, 5, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 5, 6, 5, 6, 6, 5,
 5, 6, 5, 6, 6, 5, 6, 5, 6, 26,
 41, 53, 58, 61, 61, 61, 61, 61, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 46, 0, 0, 0, 0,
 0, 37, 62, 61, 58, 23, 6, 5, 6, 5,
 6, 5, 6, 6, 6, 5, 6, 6, 5, 5,
 6, 6, 5, 6, 6, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 6, 6, 6, 5, 6,
 5, 6, 5, 6, 5, 5, 6, 6, 5, 6,
 5, 6, 6, 6, 5, 6, 6, 6, 5, 6,
 5, 5, 6, 6, 5, 6, 5, 6, 6, 5,
 6, 5, 6, 5, 6, 5, 5, 6, 5, 6,
 6, 5, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 5, 5, 6, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 17, 36, 49,
 56, 61, 61, 61, 63, 61, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 57, 16, 0, 0,
 0, 0, 9, 62, 61, 53, 48, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 6,
 5, 6, 6, 5, 5, 6, 6, 6, 6, 5,
 5, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 6, 6, 5, 6, 6, 5, 5, 6, 5, 6,
 6, 5, 5, 6, 6, 6, 5, 6, 5, 6,
 6, 5, 5, 6, 5, 6, 5, 6, 5, 6,
 6, 6, 5, 6, 6, 6, 5, 6, 5, 5,
 6, 5, 6, 5, 6, 5, 6, 6, 5, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 8, 29, 50, 58, 61,
 63, 61, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 43, 0,
 0, 0, 0, 0, 34, 62, 61, 58, 26, 6,
 6, 5, 6, 5, 6, 6, 5, 5, 6, 6,
 5, 6, 5, 6, 6, 6, 5, 6, 5, 5,
 6, 6, 5, 6, 6, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 5, 6, 6, 5, 6,
 6, 5, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 5, 6, 6, 5, 6, 5, 6, 6, 6,
 5, 6, 5, 6, 5, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 6, 5, 6, 6,
 5, 5, 6, 6, 5, 6, 6, 5, 6, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 6, 6, 17, 39, 46, 56, 61, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 57,
 9, 0, 0, 0, 0, 4, 61, 61, 61, 40,
 6, 6, 5, 6, 6, 5, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 6,
 5, 6, 6, 5, 6, 5, 6, 6, 5, 5,
 6, 6, 5, 6, 6, 6, 5, 6, 6, 6,
 5, 6, 5, 6, 6, 6, 5, 6, 6, 6,
 5, 6, 5, 6, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 5, 6, 5, 6, 6, 6, 5, 5, 6, 5,
 5, 6, 5, 6, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 6, 6, 6,
 5, 5, 6, 26, 48, 58, 61, 63, 61, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 37, 0, 0, 0, 1, 0, 34, 62, 62,
 63, 35, 5, 6, 5, 5, 6, 6, 5, 6,
 5, 6, 6, 6, 5, 6, 6, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 6, 6, 5, 6,
 6, 5, 5, 6, 6, 5, 6, 5, 6, 5,
 5, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 5, 5, 6, 5, 6, 5, 5, 6, 5, 6,
 6, 6, 5, 6, 5, 5, 6, 6, 6, 6,
 6, 6, 6, 5, 6, 5, 6, 5, 6, 6,
 6, 5, 5, 6, 6, 5, 6, 5, 6, 5,
 5, 11, 31, 40, 56, 58, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 7, 0, 0, 0, 0, 3, 61,
 63, 58, 43, 11, 6, 6, 5, 6, 6, 5,
 6, 5, 6, 5, 6, 5, 5, 6, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 5, 6, 6, 6,
 5, 6, 6, 5, 6, 6, 5, 6, 6, 5,
 5, 6, 5, 6, 6, 5, 6, 5, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 6, 5, 5,
 5, 6, 5, 6, 5, 6, 6, 5, 5, 5,
 5, 5, 5, 5, 6, 5, 6, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 14, 36, 53, 61, 63, 61, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 34, 0, 0, 0, 0, 0,
 30, 62, 63, 61, 39, 6, 5, 6, 5, 6,
 6, 6, 5, 5, 6, 6, 5, 6, 6, 5,
 6, 5, 6, 5, 6, 6, 5, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 5, 6, 6, 5, 6, 5, 5, 6, 6, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 6, 5,
 6, 5, 5, 6, 5, 6, 5, 5, 6, 6,
 6, 6, 5, 6, 6, 6, 5, 6, 6, 6,
 6, 6, 6, 6, 5, 6, 5, 6, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 5, 17,
 41, 46, 58, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 4, 0, 0, 0,
 0, 3, 58, 63, 61, 46, 17, 5, 6, 5,
 6, 5, 6, 6, 5, 6, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 6, 5, 6, 5,
 6, 5, 6, 5, 5, 6, 5, 6, 5, 5,
 6, 5, 6, 6, 6, 5, 6, 6, 6, 5,
 5, 6, 6, 6, 5, 5, 5, 6, 5, 5,
 6, 5, 5, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 19, 42,
 58, 61, 61, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 33, 0, 0,
 0, 0, 1, 27, 62, 63, 61, 45, 6, 6,
 5, 5, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 5, 6, 6, 5,
 6, 5, 6, 5, 6, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 5, 5, 6, 6, 5,
 5, 6, 5, 6, 6, 5, 6, 5, 6, 6,
 5, 6, 6, 5, 5, 6, 5, 6, 5, 6,
 6, 6, 5, 5, 6, 6, 6, 6, 6, 6,
 6, 5, 6, 6, 6, 5, 6, 5, 6, 6,
 6, 5, 5, 6, 6, 6, 6, 19, 30, 53,
 58, 61, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 57, 3,
 0, 0, 0, 0, 3, 58, 61, 61, 43, 19,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 5, 5,
 6, 6, 5, 6, 5, 5, 6, 6, 5, 5,
 6, 6, 5, 6, 6, 6, 5, 6, 5, 6,
 5, 5, 6, 6, 6, 5, 5, 6, 5, 5,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 5, 6, 6, 5, 6, 5, 23, 48, 62, 62,
 62, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 30, 0, 0, 0, 0, 0, 27, 62, 61, 61,
 52, 6, 5, 6, 6, 6, 5, 6, 6, 6,
 5, 6, 5, 6, 5, 5, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 5, 6, 6,
 5, 5, 6, 6, 6, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 6, 6, 5, 5, 6, 6, 6, 5, 6,
 6, 5, 6, 6, 6, 6, 6, 5, 6, 6,
 6, 5, 6, 5, 6, 23, 33, 53, 58, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 57, 2, 0, 0, 0, 0, 2, 58, 63,
 58, 46, 26, 5, 5, 6, 6, 5, 5, 5,
 6, 6, 5, 6, 6, 5, 6, 5, 5, 5,
 6, 5, 6, 5, 6, 5, 5, 5, 6, 5,
 5, 6, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 6, 6, 5, 5, 5, 6, 6, 5, 6,
 6, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 6, 6, 5, 5, 6, 5,
 6, 5, 6, 5, 5, 5, 5, 5, 6, 5,
 5, 5, 6, 6, 26, 48, 61, 62, 63, 61,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 25, 0, 0, 0, 0, 0, 25,
 62, 61, 61, 49, 8, 6, 5, 6, 6, 6,
 5, 5, 6, 5, 5, 6, 5, 6, 6, 6,
 5, 6, 5, 6, 5, 6, 6, 6, 5, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 5, 6,
 5, 5, 5, 6, 6, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 6, 6, 6, 5, 6, 5,
 6, 5, 6, 5, 5, 5, 6, 6, 6, 6,
 6, 6, 5, 6, 6, 6, 6, 6, 6, 5,
 6, 6, 6, 23, 30, 53, 58, 63, 63, 63,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 1, 0, 0, 0, 0,
 1, 53, 61, 63, 43, 35, 6, 5, 5, 5,
 5, 6, 6, 5, 6, 6, 5, 6, 5, 5,
 5, 6, 5, 6, 5, 6, 5, 5, 5, 6,
 5, 5, 6, 5, 6, 6, 5, 6, 6, 5,
 6, 6, 6, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 5, 6, 5, 5, 6, 5, 6, 6,
 6, 6, 6, 6, 6, 6, 6, 5, 5, 5,
 5, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 24, 52, 61, 62, 61, 61, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 62, 22, 0, 0, 0,
 0, 0, 22, 62, 62, 61, 51, 11, 6, 6,
 6, 5, 5, 6, 5, 5, 6, 5, 6, 6,
 6, 5, 6, 5, 6, 5, 6, 6, 6, 5,
 6, 6, 5, 6, 5, 5, 6, 6, 6, 5,
 6, 6, 5, 5, 6, 5, 6, 6, 6, 6,
 6, 6, 6, 5, 6, 6, 6, 5, 6, 5,
 5, 5, 5, 6, 5, 5, 5, 6, 6, 6,
 6, 6, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 23, 27, 51, 58, 61, 63, 63, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 1, 0,
 0, 0, 0, 2, 51, 63, 61, 46, 36, 6,
 5, 6, 6, 6, 6, 6, 6, 6, 6, 5,
 5, 6, 6, 5, 6, 6, 5, 5, 5, 6,
 5, 6, 5, 6, 6, 6, 6, 5, 6, 5,
 6, 5, 6, 6, 6, 5, 6, 5, 5, 5,
 5, 5, 6, 5, 6, 5, 6, 5, 6, 6,
 6, 6, 6, 6, 6, 6, 6, 6, 5, 5,
 5, 6, 5, 6, 5, 6, 6, 6, 5, 6,
 23, 52, 61, 63, 61, 61, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 16,
 0, 0, 0, 0, 1, 20, 62, 61, 61, 53,
 19, 6, 5, 5, 5, 5, 5, 5, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 6, 6, 6,
 6, 6, 5, 6, 5, 5, 5, 6, 5, 6,
 5, 6, 5, 5, 6, 5, 6, 6, 6, 6,
 6, 6, 6, 5, 6, 6, 5, 6, 5, 6,
 5, 6, 5, 5, 5, 6, 5, 5, 6, 6,
 6, 6, 6, 5, 6, 5, 6, 5, 6, 26,
 22, 49, 56, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 57, 0, 0, 0, 0, 0, 1, 51, 61, 61,
 51, 25, 6, 6, 6, 6, 6, 5, 6, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 5, 6,
 5, 6, 5, 6, 6, 6, 6, 6, 5, 6,
 5, 6, 6, 6, 6, 5, 6, 5, 5, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 6, 6,
 6, 5, 6, 6, 6, 5, 6, 6, 6, 5,
 5, 5, 6, 5, 6, 6, 6, 6, 26, 40,
 61, 63, 61, 61, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 62, 62, 16, 0, 0, 0, 0, 0, 16, 62,
 62, 62, 60, 23, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 6, 6, 6, 5, 6, 6, 6,
 5, 6, 6, 5, 6, 5, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 5, 6, 6, 6, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 5, 6, 5, 6, 5, 6, 5, 5, 5, 6,
 6, 6, 5, 6, 5, 6, 6, 26, 25, 51,
 61, 63, 63, 63, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 57, 0, 0, 0, 0, 0, 1,
 46, 63, 63, 56, 27, 6, 6, 5, 6, 5,
 6, 6, 5, 6, 5, 5, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 6, 6, 6, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 5, 5, 5,
 6, 5, 6, 5, 6, 5, 6, 6, 6, 5,
 6, 6, 5, 6, 5, 6, 5, 6, 6, 6,
 5, 5, 5, 6, 6, 10, 31, 43, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 7, 0, 0, 0, 0,
 1, 16, 62, 63, 62, 61, 31, 6, 5, 6,
 5, 6, 5, 6, 6, 6, 6, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 5, 5, 6,
 5, 6, 5, 6, 6, 5, 6, 6, 6, 6,
 6, 5, 6, 6, 6, 6, 5, 6, 5, 6,
 5, 5, 6, 5, 6, 5, 6, 5, 5, 5,
 6, 6, 6, 5, 11, 3, 40, 53, 58, 61,
 63, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 62, 50, 0, 0, 0,
 0, 0, 0, 46, 63, 61, 56, 30, 8, 6,
 6, 6, 5, 6, 5, 5, 5, 6, 5, 6,
 6, 6, 6, 6, 6, 5, 6, 6, 6, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 5, 5,
 6, 6, 6, 5, 5, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 6, 5, 6, 5, 6, 6,
 6, 5, 6, 23, 44, 59, 60, 63, 61, 61,
 61, 63, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 62, 62, 62, 58, 7, 0,
 0, 0, 0, 0, 12, 62, 61, 63, 61, 36,
 6, 5, 6, 5, 6, 6, 6, 6, 5, 6,
 5, 5, 5, 5, 6, 5, 6, 6, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 6, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 5, 6, 5, 6, 5, 6, 5, 5,
 5, 6, 28, 12, 43, 53, 61, 63, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 37,
 0, 0, 0, 0, 0, 0, 43, 62, 63, 51,
 33, 11, 6, 6, 5, 6, 5, 6, 5, 6,
 6, 6, 6, 6, 6, 5, 6, 5, 5, 6,
 5, 6, 5, 6, 5, 6, 6, 5, 6, 5,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 6, 5, 6, 6, 5, 6, 5, 6, 6, 6,
 19, 41, 43, 61, 63, 61, 61, 61, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 7, 0, 0, 0, 0, 0, 12, 62, 61,
 61, 61, 41, 6, 5, 6, 6, 6, 5, 6,
 5, 6, 5, 5, 6, 5, 6, 6, 6, 6,
 6, 6, 6, 6, 6, 5, 6, 5, 5, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 5, 6, 6, 5, 5, 6, 6, 5, 11, 0,
 44, 34, 46, 58, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 34, 0, 0, 0, 0, 0, 0, 43,
 63, 61, 58, 33, 17, 6, 5, 6, 5, 6,
 5, 6, 6, 6, 6, 5, 6, 5, 5, 5,
 6, 5, 5, 5, 6, 5, 6, 5, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 6, 5,
 6, 5, 6, 5, 6, 6, 11, 28, 45, 54,
 56, 61, 61, 61, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 3, 0, 0, 0, 0, 0,
 9, 62, 61, 61, 61, 37, 6, 5, 5, 6,
 6, 5, 6, 5, 6, 5, 6, 6, 6, 6,
 5, 6, 6, 6, 5, 6, 5, 6, 5, 5,
 6, 5, 6, 5, 6, 5, 6, 5, 5, 6,
 6, 5, 6, 6, 14, 0, 41, 30, 43, 49,
 63, 61, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 30, 0, 0, 0, 0,
 0, 0, 40, 61, 62, 58, 52, 7, 19, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 5, 5,
 5, 6, 5, 5, 5, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 5, 6, 5, 6, 6,
 6, 11, 26, 36, 37, 54, 56, 61, 61, 61,
 61, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 57, 3, 0, 0,
 0, 0, 0, 7, 62, 62, 61, 62, 59, 46,
 37, 25, 31, 23, 14, 6, 6, 6, 6, 6,
 6, 5, 6, 6, 6, 5, 6, 5, 6, 5,
 5, 6, 5, 6, 6, 5, 6, 6, 23, 0,
 35, 22, 37, 43, 46, 56, 63, 61, 63, 63,
 63, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 61, 62, 57, 27, 0,
 0, 0, 0, 0, 0, 37, 63, 61, 63, 63,
 63, 60, 51, 43, 43, 37, 34, 20, 35, 0,
 28, 23, 19, 14, 11, 11, 11, 11, 11, 11,
 17, 19, 23, 28, 31, 36, 25, 30, 40, 54,
 53, 61, 63, 61, 61, 63, 61, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 1, 0, 0, 0, 0, 0, 7, 62, 63, 63,
 63, 63, 61, 61, 61, 61, 63, 62, 61, 59,
 59, 43, 37, 37, 37, 37, 37, 34, 34, 37,
 34, 37, 37, 37, 40, 43, 49, 56, 63, 63,
 63, 61, 63, 63, 61, 63, 63, 61, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 62,
 57, 25, 0, 0, 0, 0, 0, 0, 34, 63,
 63, 63, 63, 63, 63, 61, 63, 63, 63, 63,
 61, 63, 63, 61, 61, 61, 61, 61, 61, 61,
 61, 61, 61, 61, 61, 61, 61, 63, 63, 63,
 61, 63, 63, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 0, 0, 0, 0, 0, 0, 4,
 62, 63, 63, 63, 63, 63, 63, 62, 63, 61,
 61, 61, 63, 63, 63, 63, 63, 61, 63, 63,
 61, 63, 63, 61, 63, 61, 63, 63, 63, 63,
 61, 63, 63, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 62, 57, 16, 0, 0, 0, 0, 0,
 0, 30, 63, 63, 63, 63, 63, 63, 61, 63,
 62, 63, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 63, 62, 51, 1, 0, 0, 0,
 0, 1, 3, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 57, 16, 0, 0,
 0, 0, 0, 0, 27, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 51, 0,
 0, 0, 0, 0, 1, 3, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 57,
 16, 0, 0, 0, 0, 0, 0, 27, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 61, 63, 62,
 62, 43, 0, 0, 0, 0, 0, 0, 3, 58,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 9, 0, 0, 0, 0, 0, 0,
 25, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 40, 0, 0, 0, 0, 0,
 0, 2, 51, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 7, 0, 0, 0,
 0, 0, 0, 25, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 34, 0, 0,
 0, 0, 0, 0, 1, 51, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 57, 4,
 0, 0, 0, 0, 0, 0, 22, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 33, 0, 0, 0, 0, 0, 0, 1, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 57, 3, 0, 0, 0, 0, 0, 0, 16,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 30, 0, 0, 0, 0, 0, 1,
 1, 51, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 56,
 43, 37, 33, 30, 30, 30, 33, 37, 43, 53,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 51, 34,
 30, 33, 43, 61, 63, 63, 63, 63, 44, 35,
 38, 39, 42, 42, 45, 45, 45, 48, 48, 48,
 48, 47, 45, 44, 41, 36, 50, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 36, 36, 38, 41,
 42, 44, 45, 45, 48, 48, 48, 48, 48, 45,
 45, 44, 42, 39, 36, 38, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 2, 0, 0, 0, 0,
 0, 0, 16, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 58, 56, 53, 51, 46, 43, 43, 40,
 37, 34, 34, 33, 33, 33, 33, 33, 33, 33,
 33, 33, 37, 40, 43, 51, 58, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 40, 22, 4,
 0, 1, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 12, 27, 43, 61, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 56, 56, 51, 49,
 46, 43, 40, 40, 37, 34, 34, 33, 33, 33,
 33, 33, 33, 33, 33, 33, 34, 37, 40, 46,
 51, 58, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 51, 16, 1,
 9, 16, 12, 3, 3, 33, 63, 63, 63, 10,
 5, 6, 6, 6, 5, 6, 5, 5, 5, 5,
 5, 6, 5, 5, 5, 6, 6, 26, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 45, 5, 6, 5,
 6, 5, 5, 6, 5, 5, 5, 5, 5, 5,
 6, 5, 6, 6, 5, 6, 5, 59, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 27, 0, 0, 0,
 0, 0, 0, 0, 46, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 16,
 9, 4, 3, 2, 1, 0, 0, 1, 0, 0,
 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 0, 0, 1, 0, 0, 1, 4, 16,
 30, 46, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 56, 25, 3, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 1, 0, 3, 12, 46, 62,
 63, 61, 20, 9, 7, 3, 2, 1, 1, 0,
 0, 0, 1, 0, 0, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
 0, 0, 1, 3, 12, 22, 33, 46, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 43, 2, 20,
 51, 62, 62, 62, 62, 37, 3, 20, 62, 63,
 6, 6, 6, 5, 5, 6, 5, 6, 6, 6,
 6, 6, 5, 6, 6, 6, 5, 5, 6, 54,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 48, 6, 5,
 6, 5, 6, 6, 5, 6, 6, 6, 6, 6,
 6, 5, 6, 5, 5, 6, 5, 6, 59, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 57, 57, 2, 0,
 0, 0, 0, 0, 0, 16, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 51,
 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 3, 25, 51, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 33, 2, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 25,
 63, 62, 58, 0, 0, 0, 0, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
 12, 30, 51, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 51, 3, 30,
 62, 16, 7, 7, 12, 33, 62, 51, 7, 25,
 63, 45, 35, 26, 14, 6, 6, 5, 6, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 5, 6,
 26, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 62, 62, 41,
 31, 24, 13, 5, 6, 5, 6, 5, 6, 5,
 6, 6, 6, 6, 6, 6, 21, 32, 42, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 22,
 0, 0, 0, 0, 0, 0, 0, 43, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 62,
 58, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 1, 22, 58, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 58, 16, 0, 0, 0, 0,
 0, 0, 0, 0, 9, 30, 43, 57, 51, 40,
 25, 4, 0, 0, 0, 0, 0, 0, 0, 0,
 9, 62, 62, 58, 3, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 9, 33, 62, 61, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 16, 16,
 62, 62, 7, 25, 51, 33, 1, 37, 62, 46,
 2, 51, 61, 62, 61, 61, 50, 26, 6, 5,
 6, 5, 5, 5, 6, 5, 6, 6, 5, 6,
 5, 6, 48, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 63,
 61, 61, 61, 62, 48, 24, 6, 5, 6, 5,
 6, 5, 5, 5, 6, 32, 55, 63, 63, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 57, 1, 0, 0, 0, 0, 0, 0, 12, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 43, 33, 22, 3, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 7,
 30, 57, 43, 57, 40, 27, 9, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 3,
 46, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 58, 9, 0, 0, 0, 0,
 0, 0, 0, 3, 43, 62, 62, 62, 62, 62,
 62, 62, 57, 30, 1, 0, 0, 0, 0, 0,
 0, 2, 61, 62, 62, 57, 57, 43, 27, 2,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 16, 34, 43, 57, 43, 57, 43,
 34, 27, 16, 3, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 2, 27, 58,
 63, 63, 63, 63, 63, 63, 63, 62, 58, 2,
 51, 63, 62, 7, 30, 62, 62, 16, 22, 62,
 62, 16, 25, 63, 61, 62, 63, 61, 63, 36,
 6, 6, 6, 6, 5, 6, 5, 6, 6, 6,
 6, 5, 5, 14, 59, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 62, 61, 63, 61, 63, 62, 31, 5, 6,
 6, 6, 6, 6, 6, 38, 61, 61, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 34, 27, 27, 30, 27, 27, 30, 30,
 58, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 62, 62, 62, 57, 7, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 57, 57, 62, 62, 62, 62, 62, 62, 46, 16,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 2, 46, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 58, 9, 0, 0, 0, 0,
 0, 0, 0, 7, 57, 62, 62, 62, 62, 62,
 62, 62, 62, 62, 62, 51, 2, 0, 0, 0,
 0, 1, 0, 51, 62, 62, 62, 62, 62, 62,
 51, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 25, 57, 62, 62, 62, 62, 57,
 62, 62, 62, 62, 62, 57, 27, 9, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 1, 0,
 3, 37, 62, 63, 63, 63, 63, 61, 62, 40,
 3, 62, 63, 62, 7, 33, 62, 58, 7, 34,
 62, 62, 34, 12, 63, 63, 61, 61, 61, 62,
 56, 14, 5, 6, 5, 6, 6, 6, 5, 6,
 5, 5, 6, 6, 5, 28, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 61, 58, 57, 6,
 6, 5, 5, 6, 5, 11, 61, 61, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 62, 62, 62, 62, 62, 62,
 62, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 62, 63, 61, 62, 57, 30,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 62, 62, 62, 62, 62, 62, 62, 62, 57,
 57, 22, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 3, 53, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 25, 1, 0, 0, 0,
 0, 0, 0, 1, 51, 62, 62, 62, 62, 62,
 63, 63, 63, 63, 62, 62, 57, 57, 2, 0,
 0, 0, 0, 0, 43, 63, 63, 62, 62, 62,
 62, 57, 16, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 43, 62, 62, 62, 62, 62,
 62, 62, 62, 62, 62, 62, 62, 62, 57, 43,
 16, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 16, 56, 63, 63, 63, 63, 62,
 37, 9, 62, 62, 62, 9, 3, 7, 2, 22,
 62, 63, 62, 40, 4, 63, 63, 61, 63, 61,
 62, 61, 31, 5, 6, 5, 5, 6, 6, 5,
 6, 6, 5, 6, 6, 6, 5, 42, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 63, 61, 61, 61, 61,
 18, 6, 6, 5, 6, 5, 28, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 62,
 62, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 46, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 57, 62, 62, 62, 63, 63, 63, 62,
 62, 62, 62, 16, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 1, 16, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 46, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 61, 63, 62, 62, 62, 40,
 1, 0, 0, 0, 0, 34, 62, 63, 61, 62,
 63, 62, 62, 30, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 57, 62, 62, 62, 62,
 63, 62, 63, 63, 63, 63, 62, 62, 62, 62,
 62, 62, 40, 4, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 1, 0, 7, 51, 62, 63, 63,
 62, 40, 7, 62, 63, 62, 7, 25, 43, 2,
 43, 62, 63, 62, 37, 9, 63, 63, 63, 63,
 63, 61, 62, 36, 6, 5, 6, 6, 5, 5,
 6, 6, 5, 6, 5, 6, 5, 6, 8, 52,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 61, 28, 6, 5, 6, 5, 6, 36, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 57, 57, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 3, 62, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 57, 4, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 1, 49, 63, 63,
 63, 63, 63, 63, 63, 62, 16, 0, 0, 0,
 0, 0, 0, 0, 1, 46, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 16, 0, 0, 0, 0, 30, 63, 63, 63,
 63, 63, 62, 57, 34, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 51, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 62, 62, 57, 16, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 2, 46, 63,
 62, 62, 51, 1, 53, 62, 62, 9, 33, 62,
 30, 7, 61, 63, 62, 22, 22, 63, 63, 63,
 63, 63, 61, 61, 41, 6, 5, 5, 6, 6,
 5, 5, 6, 5, 6, 5, 6, 5, 6, 5,
 15, 59, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 61, 36, 6, 6, 6, 5, 5, 45, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 2, 62, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 34, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 27, 62,
 63, 63, 63, 63, 63, 63, 51, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 57, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 3, 0, 0, 0, 25, 62, 63,
 63, 63, 63, 63, 62, 43, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 57, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 22, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 3,
 46, 62, 62, 62, 9, 27, 62, 62, 7, 33,
 62, 62, 7, 30, 62, 58, 2, 43, 63, 63,
 63, 63, 63, 63, 61, 39, 5, 6, 6, 5,
 5, 6, 6, 6, 6, 6, 6, 5, 6, 5,
 6, 6, 26, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 42, 6, 5, 5, 6, 6, 52,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 1, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 7,
 63, 63, 63, 63, 63, 63, 57, 34, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 27, 0, 0, 0, 22, 63,
 63, 63, 63, 62, 62, 62, 50, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 51, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 62, 57, 16,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 4, 53, 61, 62, 43, 2, 43, 62, 16,
 34, 62, 62, 43, 7, 51, 12, 16, 62, 63,
 63, 63, 63, 62, 61, 61, 44, 6, 5, 6,
 6, 5, 5, 5, 5, 5, 6, 6, 6, 6,
 5, 6, 5, 6, 35, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 63, 47, 6, 6, 5, 6, 6,
 57, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 1, 3, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 9,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 1, 62, 63, 63, 63, 63, 63, 62, 16, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 57, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 62, 1, 0, 0, 16,
 62, 63, 63, 63, 62, 62, 62, 43, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 57,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 16, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 12, 62, 62, 62, 30, 3, 34,
 62, 62, 62, 62, 62, 51, 12, 7, 62, 62,
 63, 63, 63, 63, 61, 63, 61, 41, 5, 6,
 5, 5, 6, 6, 6, 6, 6, 5, 6, 5,
 5, 6, 5, 6, 5, 5, 42, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 58, 50, 6, 5, 6, 5,
 6, 59, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 62, 57, 2, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 2, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 25, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 51, 63, 63, 63, 63, 62, 57, 9,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 43,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 16, 0, 1,
 16, 63, 63, 63, 63, 63, 62, 57, 50, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 51, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 57, 57, 2, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 27, 62, 62, 62, 34,
 3, 7, 25, 34, 33, 16, 2, 16, 58, 62,
 61, 63, 63, 63, 63, 62, 61, 61, 44, 6,
 6, 6, 6, 28, 31, 6, 5, 6, 5, 6,
 6, 5, 6, 5, 6, 6, 6, 6, 50, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 54, 6, 5, 6,
 5, 10, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 48, 26, 29, 60, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 2, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 3, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 30, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 1, 57, 61, 63, 63, 63, 63, 62,
 3, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 16, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 62, 63, 62, 62, 27,
 30, 57, 61, 63, 63, 63, 63, 62, 62, 43,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 57, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 34, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 1, 51, 62, 62,
 62, 58, 34, 16, 12, 16, 27, 46, 62, 62,
 63, 63, 63, 63, 63, 63, 61, 63, 61, 41,
 5, 5, 5, 6, 36, 51, 28, 6, 5, 6,
 6, 5, 6, 6, 6, 6, 6, 5, 6, 13,
 59, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 57, 6, 6,
 6, 6, 11, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 59, 13, 5, 6, 48,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 57, 57, 1, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 2, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 51, 62, 63, 63, 63, 62,
 57, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 46, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 62, 62, 62, 62, 63, 63, 63, 63, 62, 57,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 51, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 7, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 16, 63,
 63, 62, 62, 62, 62, 62, 62, 62, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 62, 61, 61,
 44, 6, 6, 6, 6, 39, 61, 58, 24, 6,
 5, 6, 5, 5, 6, 5, 5, 6, 5, 6,
 5, 18, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 61, 59, 6,
 5, 5, 6, 13, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 24, 6, 5, 6,
 48, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 1,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 3,
 62, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 25, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 62, 63, 63, 63, 63,
 63, 62, 3, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 4, 58, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 62, 61, 61, 63, 63, 63, 63, 63, 63, 62,
 62, 43, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 57, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 34, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
 46, 62, 62, 63, 63, 63, 62, 62, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 61,
 61, 41, 5, 5, 6, 6, 38, 61, 63, 51,
 17, 6, 5, 6, 6, 5, 6, 6, 5, 6,
 6, 6, 6, 26, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 53,
 6, 6, 6, 5, 14, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 29, 5, 5, 6,
 5, 48, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 57, 57,
 2, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 2, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 57, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 12, 62, 63, 63, 63,
 63, 62, 57, 7, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 9, 58, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 51, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 57, 57, 2,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 22, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 61, 44, 6, 5, 6, 6, 41, 61, 62,
 61, 54, 11, 5, 5, 6, 5, 6, 6, 5,
 5, 6, 5, 6, 6, 35, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 61, 8, 6, 6, 6, 15, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 61, 32, 6, 6, 5,
 6, 5, 48, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 3, 62, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 7, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 37, 62, 63, 63,
 63, 63, 63, 62, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 7, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 43, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 57, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 16, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 2, 62, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 41, 5, 6, 5, 5, 38, 62,
 63, 62, 58, 48, 6, 6, 5, 6, 6, 5,
 6, 6, 5, 6, 6, 5, 5, 42, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 10, 5, 5, 5, 18, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 29, 6, 6, 5,
 6, 6, 6, 48, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 50, 2, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 2, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 50, 1, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 4, 62, 63, 63,
 63, 63, 63, 62, 57, 50, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 2,
 34, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 50, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 51, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 57, 50, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 37, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 44, 6, 6, 6, 6, 36,
 63, 61, 61, 61, 61, 41, 6, 5, 5, 6,
 5, 6, 6, 5, 5, 6, 6, 6, 6, 48,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 63, 61, 11, 6, 6, 6, 17, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 55, 21, 5, 5, 6,
 5, 5, 6, 6, 48, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 2, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 3, 62, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 22, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 2, 43, 62, 63,
 63, 63, 63, 63, 62, 62, 57, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 1, 0, 12, 46, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 43, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 57, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 62, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 16, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 41, 5, 6, 5, 5,
 41, 63, 63, 61, 61, 61, 53, 29, 6, 6,
 6, 6, 5, 5, 6, 6, 6, 5, 5, 6,
 13, 54, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 62, 62, 10, 5, 6, 5, 15, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 54, 41, 32, 28, 26, 26, 28,
 35, 45, 59, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 39, 10, 6, 6, 6,
 6, 6, 6, 5, 5, 48, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 50, 2, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 50, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 34, 62, 63,
 63, 63, 63, 63, 62, 62, 57, 57, 16, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 16, 49, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 50, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 4, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 4, 61, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 61, 61, 44, 5, 6, 6,
 5, 38, 63, 63, 63, 61, 62, 63, 62, 19,
 5, 5, 6, 6, 5, 6, 5, 6, 6, 5,
 5, 6, 17, 59, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 58, 11, 5, 6, 6, 18,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 55, 35, 14, 5, 6, 5, 5, 5, 6,
 6, 5, 6, 8, 26, 48, 63, 63, 63, 63,
 63, 63, 63, 63, 50, 19, 6, 5, 6, 5,
 5, 6, 5, 6, 6, 5, 18, 29, 29, 29,
 29, 29, 29, 29, 31, 59, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 2, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 3, 62, 62, 63, 63,
 63, 63, 63, 63, 61, 62, 43, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 3, 50, 62, 62,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 57,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 22, 51,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 43, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 57,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 63, 62, 62, 16, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 63, 61, 42, 6, 6,
 5, 6, 41, 63, 63, 63, 63, 63, 61, 62,
 46, 13, 6, 6, 5, 6, 5, 6, 6, 5,
 6, 6, 5, 5, 24, 62, 63, 63, 63, 63,
 63, 63, 63, 61, 61, 62, 10, 6, 6, 5,
 18, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 59, 28, 6, 5, 5, 6, 6, 6, 6, 6,
 6, 5, 6, 5, 5, 5, 5, 26, 59, 63,
 63, 63, 63, 48, 24, 6, 6, 5, 6, 5,
 6, 6, 5, 6, 6, 5, 6, 6, 6, 6,
 6, 6, 6, 6, 6, 5, 42, 63, 63, 63,
 63, 63, 63, 62, 62, 50, 2, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 62, 63, 63,
 63, 63, 63, 63, 61, 57, 25, 0, 0, 0,
 0, 0, 0, 0, 0, 3, 16, 62, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 57, 42, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 2, 25, 56, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 50, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 51, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 57, 42, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 43,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 61, 42, 5,
 6, 5, 5, 38, 63, 63, 63, 62, 61, 63,
 62, 61, 48, 6, 6, 5, 6, 5, 6, 6,
 5, 6, 6, 6, 5, 6, 29, 62, 63, 63,
 63, 63, 63, 63, 62, 63, 58, 10, 5, 6,
 5, 17, 63, 63, 63, 63, 63, 63, 63, 63,
 45, 13, 6, 6, 6, 5, 5, 6, 5, 6,
 6, 6, 6, 6, 6, 6, 6, 5, 5, 14,
 54, 63, 62, 21, 6, 5, 5, 6, 5, 6,
 5, 6, 6, 5, 6, 6, 5, 5, 5, 5,
 5, 5, 5, 5, 5, 6, 6, 38, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 2, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 16, 34,
 40, 40, 40, 34, 27, 12, 1, 0, 0, 0,
 0, 0, 0, 1, 39, 27, 57, 57, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 57, 9, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 3, 34, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 57,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 57, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 61, 30, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 34, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 41,
 6, 5, 6, 6, 41, 61, 63, 63, 61, 63,
 61, 63, 63, 58, 36, 5, 6, 6, 6, 5,
 5, 6, 5, 6, 5, 6, 5, 6, 39, 63,
 63, 63, 63, 63, 63, 63, 61, 62, 11, 6,
 5, 6, 15, 62, 63, 63, 63, 63, 63, 63,
 35, 5, 5, 6, 5, 5, 6, 6, 18, 44,
 54, 57, 50, 28, 6, 5, 6, 5, 6, 6,
 5, 11, 55, 63, 6, 5, 6, 6, 6, 6,
 5, 6, 5, 5, 6, 5, 5, 6, 6, 6,
 6, 6, 6, 6, 6, 6, 6, 5, 52, 63,
 63, 63, 63, 63, 63, 62, 62, 50, 2, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 57, 57, 62, 62, 62,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 62, 57, 50, 7, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 12, 53, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 57, 57,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 51, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 62, 50, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 27, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 61,
 44, 6, 5, 6, 5, 39, 63, 63, 63, 63,
 62, 62, 62, 61, 61, 61, 31, 5, 5, 6,
 6, 5, 6, 5, 6, 6, 6, 5, 6, 6,
 45, 63, 63, 63, 63, 63, 62, 63, 62, 10,
 6, 6, 6, 18, 63, 63, 63, 63, 63, 63,
 32, 6, 6, 5, 6, 6, 5, 6, 36, 62,
 61, 63, 63, 61, 62, 36, 5, 6, 5, 6,
 6, 6, 6, 21, 62, 32, 17, 17, 15, 6,
 6, 6, 6, 6, 5, 6, 6, 5, 6, 5,
 11, 17, 17, 17, 17, 17, 15, 17, 28, 61,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 2,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 2, 16, 33, 51,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 57, 7, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 1, 0, 3, 43,
 62, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 62, 43, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 57, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 37,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 25, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 42, 5, 6, 5, 6, 38, 63, 63, 63,
 63, 63, 61, 61, 62, 61, 61, 51, 21, 6,
 5, 6, 6, 6, 6, 6, 5, 5, 6, 5,
 5, 10, 52, 63, 63, 63, 63, 63, 62, 58,
 11, 6, 5, 5, 18, 62, 63, 63, 63, 63,
 41, 6, 6, 5, 6, 6, 5, 6, 36, 63,
 61, 61, 61, 61, 61, 61, 58, 14, 5, 6,
 6, 5, 5, 5, 6, 45, 61, 61, 62, 58,
 42, 5, 5, 5, 5, 6, 5, 5, 6, 5,
 6, 50, 62, 62, 62, 62, 62, 61, 61, 63,
 62, 63, 63, 63, 63, 63, 63, 62, 62, 50,
 2, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 2, 16, 49, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 50, 16,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 37, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 57, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 51, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 57,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 25, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 61, 44, 5, 6, 6, 6, 38, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 62, 63, 57,
 14, 5, 5, 5, 6, 5, 6, 6, 6, 6,
 6, 6, 5, 13, 55, 63, 63, 63, 61, 62,
 62, 10, 6, 6, 5, 18, 63, 63, 63, 63,
 50, 6, 5, 6, 5, 5, 6, 5, 21, 61,
 61, 63, 62, 62, 63, 63, 63, 61, 28, 5,
 5, 6, 6, 6, 5, 5, 19, 62, 61, 61,
 61, 48, 6, 6, 6, 5, 6, 6, 5, 6,
 5, 6, 54, 61, 61, 61, 61, 61, 61, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 2, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 16, 40, 57, 57, 43, 57, 34, 27,
 16, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 0, 1, 25, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 30, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 37, 62, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 57, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 43, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 27, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 42, 6, 6, 5, 5, 41, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 56, 48, 6, 6, 6, 5, 6, 6, 5, 5,
 6, 5, 5, 6, 6, 18, 62, 63, 63, 61,
 61, 58, 11, 6, 5, 6, 17, 62, 63, 63,
 63, 18, 6, 6, 5, 6, 6, 6, 6, 44,
 61, 63, 63, 63, 63, 63, 63, 63, 61, 31,
 6, 6, 6, 6, 5, 6, 6, 5, 55, 61,
 61, 58, 48, 5, 6, 5, 6, 5, 5, 6,
 6, 6, 6, 57, 61, 61, 63, 63, 63, 63,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 57, 57, 2, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 57, 62, 62, 57, 62, 57, 57,
 57, 57, 57, 39, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 9, 51, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 57, 57, 50, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 1, 46, 63, 63, 63, 63,
 62, 62, 62, 57, 50, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 51, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 27, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 61, 63, 42, 5, 6, 6, 5, 36,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 61, 61, 61, 42, 5, 6, 5, 5, 6, 6,
 5, 6, 6, 5, 5, 6, 5, 26, 62, 63,
 63, 62, 62, 10, 6, 5, 5, 18, 63, 63,
 62, 44, 5, 6, 6, 5, 6, 5, 5, 6,
 57, 63, 63, 63, 63, 63, 63, 63, 62, 61,
 24, 5, 5, 5, 6, 5, 6, 6, 6, 42,
 63, 61, 61, 50, 5, 6, 5, 6, 6, 5,
 5, 5, 5, 6, 54, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 57, 2, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 1, 57, 62, 62, 62, 62, 62,
 62, 62, 62, 57, 57, 57, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 7, 58,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 57, 33, 3, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 4, 62, 61, 63,
 63, 62, 62, 62, 57, 43, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 57, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 37, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 34, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 63, 58, 41, 6, 6, 5, 6,
 41, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 61, 56, 31, 5, 6, 6, 6,
 5, 6, 6, 5, 6, 6, 6, 6, 5, 32,
 63, 63, 61, 58, 11, 5, 6, 6, 17, 63,
 63, 61, 18, 6, 5, 5, 6, 5, 6, 6,
 6, 31, 50, 55, 57, 57, 57, 57, 54, 45,
 28, 6, 6, 6, 6, 6, 6, 6, 5, 5,
 35, 63, 63, 58, 45, 6, 6, 6, 5, 5,
 6, 6, 6, 6, 6, 54, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 50, 2, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 3, 62, 62, 63, 62, 63,
 63, 62, 62, 62, 57, 57, 57, 50, 3, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 9, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 62, 57, 57, 57, 42,
 3, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 22, 62,
 63, 63, 63, 62, 62, 57, 50, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 57, 50, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 43, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 42, 5, 6, 5,
 5, 38, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 61, 61, 58, 23, 5, 5,
 6, 5, 5, 6, 5, 6, 5, 6, 6, 6,
 5, 41, 62, 62, 62, 11, 5, 6, 5, 17,
 63, 62, 50, 6, 6, 6, 5, 6, 5, 6,
 5, 5, 6, 6, 6, 6, 6, 6, 6, 5,
 5, 5, 6, 5, 6, 5, 5, 5, 6, 6,
 5, 31, 63, 61, 61, 48, 6, 5, 6, 5,
 6, 5, 5, 5, 6, 6, 57, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 2, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 3, 57, 62, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 62, 62, 57,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 1, 1, 30, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 62, 57, 25, 1, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 1,
 51, 62, 63, 63, 63, 62, 62, 57, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 57,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 25, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 57, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 41, 6, 6,
 6, 6, 41, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 61, 61, 61, 51, 14,
 6, 5, 6, 6, 6, 6, 5, 6, 5, 6,
 5, 6, 6, 47, 61, 58, 10, 6, 5, 6,
 18, 62, 61, 32, 5, 6, 5, 6, 5, 6,
 5, 6, 6, 6, 5, 5, 5, 5, 5, 5,
 6, 6, 6, 5, 6, 5, 6, 6, 6, 6,
 5, 6, 32, 63, 63, 58, 48, 5, 6, 5,
 6, 5, 6, 6, 6, 5, 5, 54, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 57, 50, 2, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 2, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 57, 25, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 2, 58, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 62, 57, 57, 57, 50, 16, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 25, 63, 63, 63, 62, 57, 57, 50, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 51, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 16, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 2, 62,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 61, 42, 5,
 5, 6, 5, 36, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 61,
 52, 6, 6, 5, 5, 6, 6, 5, 6, 5,
 6, 5, 6, 6, 10, 50, 62, 8, 6, 5,
 5, 18, 62, 63, 17, 5, 6, 6, 6, 5,
 6, 5, 6, 5, 6, 6, 6, 6, 6, 6,
 5, 6, 5, 6, 5, 6, 5, 6, 5, 6,
 6, 5, 10, 50, 63, 61, 61, 50, 6, 6,
 5, 6, 5, 5, 5, 6, 6, 6, 57, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 2, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 2, 62, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 57, 1, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 33, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 62, 62, 57, 25, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 4, 62, 63, 63, 62, 62, 62, 40,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 57, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 7, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 16,
 62, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 42,
 6, 6, 5, 6, 41, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 58, 42, 6, 6, 6, 5, 5, 6, 6,
 6, 5, 6, 5, 5, 6, 11, 48, 6, 5,
 6, 6, 17, 61, 51, 6, 6, 5, 5, 5,
 6, 6, 6, 5, 14, 35, 35, 36, 35, 36,
 35, 36, 35, 36, 35, 36, 35, 36, 35, 36,
 36, 35, 41, 54, 63, 63, 63, 58, 45, 6,
 6, 5, 6, 6, 6, 6, 6, 6, 5, 54,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 57, 50, 2, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 2, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 16, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 57, 57, 50,
 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 51, 63, 63, 62, 62, 57,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 51, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 50, 1, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 33, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 63,
 39, 5, 6, 5, 5, 38, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 63, 61, 61, 61, 32, 6, 6, 6, 5, 5,
 5, 6, 5, 6, 6, 5, 5, 6, 6, 6,
 5, 6, 5, 17, 62, 52, 6, 6, 6, 6,
 5, 5, 5, 6, 5, 35, 58, 61, 61, 63,
 61, 63, 61, 61, 61, 58, 61, 58, 58, 58,
 62, 61, 61, 63, 61, 63, 62, 61, 61, 48,
 6, 6, 5, 6, 5, 5, 5, 5, 6, 6,
 57, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 2,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 3,
 62, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 33, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 2, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 34, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 34, 62, 63, 63, 62,
 62, 43, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 57, 61, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 51, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 57, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 39, 6, 6, 6, 6, 41, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 63, 61, 61, 61, 51, 23, 5, 5, 6,
 6, 6, 6, 6, 6, 5, 6, 6, 5, 6,
 5, 6, 5, 6, 18, 61, 44, 5, 5, 5,
 5, 6, 6, 6, 6, 6, 35, 61, 62, 61,
 62, 61, 61, 61, 61, 61, 61, 61, 61, 61,
 63, 61, 61, 61, 63, 62, 63, 61, 63, 58,
 48, 5, 6, 5, 5, 6, 6, 6, 6, 6,
 5, 54, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 57, 50,
 2, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 2, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 50, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 51,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 62, 57, 57, 42, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 25, 63, 63, 62,
 57, 57, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 51, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 57, 42,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 12, 62, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 63, 38, 5, 6, 5, 5, 36, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 61, 61, 56, 17, 5,
 5, 5, 5, 5, 6, 6, 5, 6, 6, 6,
 6, 5, 6, 5, 5, 18, 61, 44, 6, 6,
 6, 5, 5, 5, 5, 6, 5, 31, 63, 63,
 61, 63, 61, 63, 63, 61, 63, 61, 63, 63,
 63, 61, 61, 63, 63, 63, 63, 63, 62, 61,
 61, 50, 6, 5, 6, 6, 5, 5, 5, 5,
 6, 6, 57, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 2, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 3, 62, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 51, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 46, 62, 56, 51, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 16, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 1, 22, 62, 63,
 62, 62, 62, 43, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 57, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 2, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 37, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 36, 6, 5, 6, 6, 35, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 61, 58, 50,
 10, 6, 6, 6, 6, 5, 5, 6, 5, 6,
 5, 5, 6, 6, 6, 6, 15, 58, 39, 5,
 5, 5, 6, 6, 6, 6, 5, 6, 24, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 61, 58, 45, 6, 5, 6, 5, 6, 6, 6,
 6, 6, 5, 54, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 57, 50, 2, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 2, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 57, 57, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 43, 40, 1, 0, 25, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 57, 50, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 20, 63,
 63, 62, 57, 57, 50, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 51, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 3, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 35, 6, 5, 6, 6, 32,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 61,
 61, 45, 6, 5, 5, 6, 6, 5, 6, 5,
 6, 6, 5, 5, 6, 6, 6, 18, 61, 45,
 6, 6, 5, 5, 5, 5, 6, 5, 5, 11,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 48, 6, 5, 6, 5, 6, 5,
 5, 5, 6, 6, 57, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 2, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 3, 62, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 51, 30, 0, 0, 3, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 62, 62, 57, 16, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 22,
 62, 63, 63, 62, 62, 43, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 57, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 16, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 1, 34, 57, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 61, 32, 5, 6, 5, 6,
 32, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 61, 53, 35, 6, 6, 5, 5, 6, 5,
 6, 6, 5, 6, 6, 5, 5, 5, 17, 58,
 45, 6, 5, 6, 6, 6, 6, 6, 6, 6,
 5, 45, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 58, 48, 6, 6, 5, 6, 5,
 6, 6, 6, 6, 5, 54, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 57, 50, 2, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 62,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 57, 34, 0, 0, 0, 34, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 62, 57, 42,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 27, 63, 63, 62, 57, 57, 50, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 57, 57, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 7, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 31, 6, 6, 5,
 6, 28, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 61, 58, 26, 6, 6, 5, 6,
 5, 5, 6, 5, 5, 6, 6, 6, 5, 18,
 61, 57, 6, 6, 5, 5, 5, 5, 6, 5,
 6, 5, 24, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 61, 61, 48, 5, 6, 5, 6,
 5, 6, 5, 5, 6, 6, 54, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 2, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 2, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 43, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 1, 62, 37, 0, 0, 0, 7,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 43, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 1, 37, 62, 63, 62, 62, 62, 50, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 57,
 61, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 22, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 1, 50, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 26, 5, 5,
 6, 5, 26, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 51, 17, 5, 6,
 5, 6, 6, 5, 6, 6, 6, 6, 5, 6,
 17, 61, 51, 14, 6, 5, 6, 6, 6, 5,
 6, 6, 6, 6, 47, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 61, 58, 48, 5, 6, 6,
 5, 6, 5, 6, 6, 6, 5, 50, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 57, 50, 2, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 62, 43, 0, 0, 0,
 0, 33, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 50, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 51, 63, 63, 62, 62, 57, 50, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 46, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 50, 1, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 27, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 61, 61, 23, 6,
 6, 6, 5, 19, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 61, 54, 10,
 6, 5, 5, 6, 5, 5, 5, 5, 6, 5,
 6, 18, 61, 61, 31, 6, 5, 5, 5, 6,
 5, 5, 6, 6, 5, 15, 59, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 59, 35, 54, 63, 61, 61, 50, 6, 5,
 6, 5, 6, 5, 5, 5, 6, 6, 45, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 57, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 16, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 33, 57, 57, 0, 0,
 0, 0, 3, 58, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 51, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 9, 62, 62, 63, 62, 62, 62, 43,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 40, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 58, 4, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 57, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 63, 61, 15,
 6, 5, 5, 6, 13, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 53,
 45, 8, 5, 6, 5, 6, 6, 6, 6, 6,
 6, 6, 15, 63, 58, 45, 5, 6, 6, 6,
 5, 6, 6, 5, 5, 6, 6, 21, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 24, 5, 13, 62, 61, 58, 45, 6,
 5, 6, 6, 5, 6, 6, 6, 6, 5, 36,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 57, 50, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 43,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 57, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 62, 62, 57, 0,
 0, 0, 0, 0, 16, 61, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 50, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 33, 62, 63, 63, 62, 62, 57,
 50, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 34, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 57, 16, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 61, 61,
 8, 6, 6, 5, 6, 10, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 61,
 61, 58, 36, 5, 6, 5, 5, 5, 5, 5,
 5, 5, 6, 15, 61, 61, 58, 17, 5, 5,
 6, 5, 5, 6, 6, 5, 5, 6, 5, 18,
 54, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 32, 6, 5, 8, 59, 61, 61, 48,
 6, 5, 6, 5, 6, 5, 5, 6, 6, 5,
 24, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 57, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 30, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 30, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 25, 62, 62, 62,
 3, 0, 0, 0, 0, 0, 27, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 3, 57, 62, 63, 63, 63, 62,
 62, 34, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 16, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 22, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 50, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 63,
 54, 5, 6, 5, 6, 5, 5, 50, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 49, 28, 6, 6, 6, 6, 6,
 6, 6, 6, 6, 18, 61, 61, 58, 44, 5,
 6, 5, 6, 6, 6, 5, 6, 6, 5, 6,
 6, 6, 32, 55, 63, 63, 63, 63, 63, 63,
 63, 52, 23, 5, 5, 6, 32, 61, 63, 58,
 48, 6, 6, 5, 6, 5, 6, 6, 6, 5,
 6, 6, 54, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 57, 50,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 9, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 2, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 4, 62, 63, 62,
 57, 16, 0, 0, 0, 0, 0, 0, 34, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 3, 0, 0, 0, 0,
 0, 0, 0, 0, 34, 62, 63, 63, 63, 62,
 62, 57, 42, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 3, 61, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 57, 16, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 62, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 63, 42, 5, 6, 6, 6, 6, 6, 36, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 61, 53, 17, 5, 5, 5,
 5, 5, 5, 6, 6, 17, 61, 61, 61, 58,
 23, 6, 5, 5, 5, 6, 5, 6, 6, 5,
 5, 6, 6, 6, 6, 18, 29, 36, 38, 38,
 32, 18, 5, 6, 6, 5, 15, 62, 63, 61,
 61, 53, 6, 5, 6, 6, 5, 5, 5, 6,
 5, 6, 5, 17, 59, 63, 63, 63, 63, 63,
 59, 55, 63, 63, 63, 63, 63, 63, 62, 62,
 34, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 40, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 51, 7, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 3, 57, 62, 62,
 62, 62, 27, 0, 0, 0, 0, 0, 0, 0,
 33, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 25, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 57, 62, 63, 63, 63,
 63, 62, 62, 16, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 27, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 43, 4, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 39, 57, 57, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 58, 17, 6, 6, 5, 5, 6, 5, 13,
 59, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 60, 40, 10, 6,
 6, 6, 6, 6, 5, 5, 15, 63, 61, 61,
 61, 43, 11, 6, 6, 6, 5, 6, 6, 5,
 6, 6, 6, 5, 5, 5, 5, 6, 5, 6,
 6, 5, 6, 6, 6, 5, 8, 48, 63, 62,
 63, 61, 53, 11, 5, 6, 5, 6, 6, 6,
 6, 6, 5, 6, 5, 13, 35, 50, 54, 48,
 32, 10, 13, 62, 63, 63, 63, 63, 63, 62,
 57, 16, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 43, 63, 63, 63, 63,
 63, 63, 61, 62, 54, 7, 1, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 1, 43, 62, 62,
 62, 62, 62, 57, 0, 0, 0, 0, 0, 0,
 0, 0, 22, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 50, 0, 0, 0, 0,
 0, 0, 0, 0, 9, 62, 62, 63, 63, 63,
 63, 62, 62, 57, 4, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 27, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 43, 16, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 4, 51, 62, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 48, 18, 5, 5, 6, 6, 5, 6, 5,
 5, 14, 42, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 62, 63, 44,
 5, 5, 5, 5, 6, 6, 5, 14, 61, 63,
 62, 62, 61, 48, 6, 5, 6, 5, 5, 6,
 5, 6, 5, 6, 6, 6, 6, 6, 6, 5,
 5, 6, 5, 5, 5, 6, 6, 44, 62, 61,
 63, 63, 62, 61, 28, 6, 5, 6, 5, 5,
 5, 5, 6, 5, 6, 5, 5, 6, 6, 5,
 6, 6, 6, 5, 54, 63, 63, 63, 63, 63,
 51, 16, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 1, 16, 40, 51,
 56, 56, 51, 34, 12, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 16, 50, 62, 62,
 63, 62, 62, 62, 57, 1, 0, 0, 0, 0,
 0, 0, 1, 0, 7, 40, 62, 63, 63, 63,
 63, 63, 63, 61, 58, 22, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 57, 62, 62, 63, 63,
 63, 63, 63, 51, 16, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
 7, 30, 51, 58, 63, 63, 63, 58, 51, 40,
 25, 4, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 32, 16, 50, 57, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 59, 39,
 28, 15, 5, 6, 6, 6, 6, 5, 6, 5,
 6, 6, 5, 6, 8, 21, 31, 38, 54, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 58,
 53, 28, 6, 6, 6, 6, 5, 6, 15, 62,
 63, 63, 63, 61, 53, 48, 10, 5, 6, 6,
 6, 6, 5, 6, 6, 6, 5, 6, 5, 5,
 6, 6, 6, 6, 6, 6, 6, 42, 62, 61,
 63, 63, 63, 61, 58, 48, 6, 6, 5, 6,
 6, 6, 6, 6, 6, 6, 6, 6, 5, 5,
 6, 6, 5, 6, 38, 63, 62, 51, 33, 16,
 7, 2, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 2, 25, 62, 62, 62,
 63, 63, 63, 61, 62, 57, 27, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 7, 27, 40,
 51, 51, 51, 40, 22, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 16, 57, 62, 62, 62, 62,
 43, 30, 22, 9, 2, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 2, 4, 2, 2, 0,
 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 2, 27, 57, 62, 62, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 31,
 6, 6, 6, 5, 6, 5, 5, 6, 5, 6,
 5, 6, 6, 5, 5, 6, 5, 6, 5, 21,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 61, 61, 60, 17, 5, 5, 6, 5, 6, 11,
 61, 63, 63, 62, 61, 61, 61, 54, 21, 5,
 5, 5, 6, 5, 5, 5, 6, 5, 6, 6,
 5, 6, 5, 5, 6, 5, 14, 45, 61, 61,
 63, 63, 63, 63, 61, 61, 56, 32, 6, 5,
 6, 5, 5, 5, 5, 6, 5, 6, 6, 6,
 5, 6, 6, 11, 48, 63, 63, 62, 12, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 39, 16, 57, 57, 62, 62,
 63, 63, 63, 63, 63, 62, 62, 57, 16, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 1,
 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 4, 50, 57, 62, 62, 63, 61,
 51, 1, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 3,
 39, 50, 57, 57, 62, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 31, 5, 5, 5, 6, 5, 6, 6, 5, 6,
 6, 6, 5, 5, 6, 6, 5, 6, 5, 6,
 18, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 63, 61, 61, 58, 48, 6, 6, 6, 6, 5,
 15, 62, 63, 63, 63, 63, 61, 61, 58, 53,
 41, 17, 6, 6, 6, 6, 6, 6, 6, 6,
 5, 6, 5, 6, 6, 6, 31, 62, 61, 61,
 63, 63, 63, 63, 63, 61, 61, 61, 49, 28,
 6, 5, 6, 6, 6, 6, 5, 6, 5, 6,
 5, 6, 10, 32, 62, 63, 62, 62, 57, 7,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 3, 3, 39, 30, 57, 57, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 57,
 57, 16, 2, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 16, 33, 57, 62, 62, 63, 63, 62,
 62, 51, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 4, 16, 30, 50,
 57, 57, 57, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 52, 32, 35, 35, 39, 39, 41, 41, 41,
 44, 41, 44, 44, 42, 41, 41, 36, 36, 35,
 32, 45, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 61, 61, 35, 6, 5, 6,
 24, 54, 63, 63, 63, 63, 63, 61, 61, 61,
 61, 58, 62, 45, 28, 13, 6, 5, 5, 5,
 6, 5, 6, 6, 17, 36, 57, 58, 61, 63,
 63, 63, 63, 63, 63, 63, 63, 61, 61, 61,
 56, 45, 19, 6, 5, 5, 6, 5, 6, 5,
 8, 24, 41, 58, 61, 62, 61, 63, 62, 62,
 43, 27, 30, 50, 27, 42, 50, 50, 50, 50,
 50, 50, 50, 34, 50, 30, 33, 30, 27, 22,
 25, 25, 22, 25, 22, 27, 30, 50, 33, 50,
 50, 57, 57, 62, 57, 57, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 62, 62, 57, 62, 37, 16, 7, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 16, 39, 50, 57, 57, 57, 62, 62, 63, 63,
 62, 62, 62, 27, 30, 30, 50, 27, 42, 50,
 50, 50, 50, 50, 50, 50, 33, 50, 30, 30,
 27, 16, 16, 16, 16, 16, 16, 16, 16, 16,
 16, 22, 27, 33, 50, 57, 57, 57, 57, 57,
 57, 62, 62, 62, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 61, 61, 58, 61, 61, 61,
 61, 61, 61, 61, 61, 61, 62, 61, 61, 63,
 63, 63, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 61, 61, 58, 39, 45,
 59, 61, 63, 62, 63, 63, 63, 63, 63, 63,
 63, 61, 62, 61, 58, 58, 56, 54, 48, 41,
 39, 36, 41, 48, 57, 61, 61, 61, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 61, 61, 58, 58, 49, 45, 41, 36, 39, 44,
 52, 58, 61, 61, 62, 62, 61, 63, 63, 62,
 62, 57, 57, 57, 57, 57, 57, 57, 57, 57,
 57, 57, 57, 57, 57, 57, 62, 57, 57, 62,
 62, 57, 62, 62, 57, 62, 57, 62, 57, 62,
 62, 62, 62, 62, 62, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 62, 62, 62, 62, 62, 62, 57, 57,
 40, 33, 27, 25, 25, 25, 27, 27, 50, 50,
 57, 62, 57, 62, 62, 62, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 57, 57, 57, 57, 57,
 57, 57, 57, 57, 57, 57, 57, 62, 62, 57,
 62, 62, 62, 62, 57, 62, 57, 62, 62, 62,
 62, 62, 62, 62, 62, 57, 62, 62, 62, 62,
 62, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 61, 61, 61, 63, 61, 61, 61,
 61, 62, 61, 61, 61, 63, 61, 62, 62, 61,
 62, 61, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 61, 63, 61,
 61, 61, 61, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 61, 62, 63, 62, 61, 61, 61,
 61, 61, 61, 58, 61, 62, 63, 61, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 61, 61, 63, 61, 61, 58, 61, 61,
 61, 62, 62, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 62, 62, 57, 62, 57,
 62, 57, 62, 62, 62, 62, 62, 62, 62, 62,
 62, 62, 62, 62, 62, 62, 62, 62, 62, 62,
 62, 62, 63, 62, 62, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 62, 62, 62,
 62, 62, 62, 62, 62, 62, 62, 62, 57, 62,
 62, 57, 62, 62, 62, 62, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 62, 62, 62, 62, 62,
 57, 62, 57, 62, 57, 62, 62, 62, 62, 62,
 62, 62, 63, 63, 62, 62, 62, 62, 62, 62,
 62, 62, 62, 62, 62, 62, 62, 62, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 63,
 63, 61, 63, 63, 61, 63, 63, 63, 63, 63,
 61, 61, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 61, 61,
 63, 63, 62, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 63, 63, 61, 61, 61,
 61, 61, 61, 61, 62, 61, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 61, 63, 61, 61, 61, 61,
 61, 61, 61, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 62, 62, 62,
 62, 62, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 62, 63, 63, 63, 63, 62, 62, 62,
 62, 62, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 62, 62, 62, 62, 62, 62, 62, 62, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 63, 63, 63, 63, 62, 62, 62, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 61, 63, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 61,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 61, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 62, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 56, 27, 27, 27, 27, 27, 27, 27, 27, 27,
 27, 43, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 7, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 7, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 37, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 34, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 61, 62, 62, 4, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 7, 61, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 34, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 33, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 3, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 4, 58,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 30,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
 30, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 2, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 3, 58, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 27, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 30, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 1, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 2, 56, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 25, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 27, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 57, 57, 1, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 56, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 62, 16, 1,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 25,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 50,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 1, 53, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 16, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 22, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 50, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 1, 51, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 62, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 20, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 57, 50, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 51, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 62, 62, 62, 9, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 16, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 57, 57, 50, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
 46, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 62,
 7, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 16, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 57, 50, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 46, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 3, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 12, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 62, 57, 50, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 43, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 57, 1, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 1, 9, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 57, 50, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 1, 43,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 62, 57, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 9, 62, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 62, 57,
 25, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 40, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 62,
 62, 57, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 7, 62, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 57, 16, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 34, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 57, 1, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 1, 4, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 16, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 34, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 57, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 4,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 57, 16,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 30, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 61, 63, 62, 62,
 57, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 1, 4, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 57, 16, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 27, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 62, 57, 57, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 1, 3, 62, 61, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 62, 57, 57, 7, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 27, 62, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 62, 62, 37, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 2, 58,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 57, 57, 7, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
 25, 61, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 62, 37,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 2, 51, 62, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 57,
 57, 3, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 25, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 62, 33, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 1, 51, 62, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 62, 57, 57, 3, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 22, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 30, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 51, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 62, 57, 50, 2, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 16,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 62, 62, 25, 0,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
 1, 51, 62, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 62, 57, 50,
 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 16, 61, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 62,
 62, 16, 1, 0, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 46, 62, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 62, 57, 50, 1, 0, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 25, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 62, 62, 16, 0, 0, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 16, 62, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 62, 57, 50, 1, 0, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 20, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 16, 0, 0,
 0, 0, 0, 0, 0, 0, 0, 1, 40, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 62, 62, 57, 50, 1,
 0, 0, 0, 0, 0, 0, 0, 0, 20, 62,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 43, 1, 0, 0, 0, 0, 0, 1, 30, 57,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
 57, 57, 50, 16, 2, 0, 4, 25, 57, 62,
 62, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63, 63,
 63, 63, 63, 63, 63, 63, 63, 63, 63,
};
static const char _pulse_off_header_data[] = {
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 75, 73, 72, 70, 70,
 72, 73, 75, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 74, 71, 68, 67, 66, 66,
 67, 68, 71, 74, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 74, 69, 67, 64, 64, 64, 64,
 64, 64, 67, 69, 74, 76, 76, 76, 76, 76,
 76, 76, 75, 71, 67, 64, 64, 64, 64, 64,
 64, 64, 64, 67, 71, 75, 76, 76, 76, 76,
 76, 76, 73, 68, 64, 64, 64, 64, 64, 64,
 64, 64, 64, 64, 68, 73, 76, 76, 76, 76,
 76, 76, 72, 67, 64, 64, 64, 64, 64, 64,
 64, 64, 64, 64, 67, 72, 76, 76, 76, 76,
 76, 76, 70, 66, 64, 64, 64, 64, 64, 64,
 64, 64, 64, 64, 66, 70, 76, 76, 76, 76,
 76, 76, 70, 66, 64, 64, 64, 64, 64, 64,
 64, 64, 64, 64, 66, 70, 76, 76, 76, 76,
 76, 76, 72, 67, 64, 64, 64, 64, 64, 64,
 64, 64, 64, 64, 67, 72, 76, 76, 76, 76,
 76, 76, 73, 68, 64, 64, 64, 64, 64, 64,
 64, 64, 64, 64, 68, 73, 76, 76, 76, 76,
 76, 76, 75, 71, 67, 64, 64, 64, 64, 64,
 64, 64, 64, 67, 71, 75, 76, 76, 76, 76,
 76, 76, 76, 74, 69, 67, 64, 64, 64, 64,
 64, 64, 67, 69, 74, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 74, 71, 68, 67, 65, 65,
 67, 68, 71, 74, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 75, 73, 72, 70, 70,
 72, 73, 75, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76, 76,
 76, 76, 76, 76, 76, 76, 76, 76, 76,
};
static const char _pulse_on_header_data[] = {
 95, 95, 95, 95, 95, 94, 93, 91, 89, 88, 88,
 89, 91, 93, 94, 95, 95, 95, 95, 95, 95,
 95, 95, 95, 93, 90, 86, 85, 83, 81, 81,
 83, 85, 86, 90, 93, 95, 95, 95, 95, 95,
 95, 94, 92, 87, 84, 80, 80, 80, 80, 80,
 80, 80, 80, 84, 87, 92, 94, 95, 95, 95,
 95, 92, 86, 82, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 82, 86, 92, 95, 95, 95,
 93, 87, 82, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 82, 87, 93, 95, 94,
 90, 84, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 84, 90, 94, 93,
 86, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 86, 93, 91,
 85, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 85, 91, 89,
 83, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 83, 89, 88,
 82, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 80, 88, 88,
 80, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 81, 88, 89,
 83, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 83, 89, 91,
 85, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 85, 91, 93,
 86, 80, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 80, 86, 93, 94,
 89, 84, 80, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 80, 84, 89, 94, 94,
 93, 87, 82, 80, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 80, 82, 87, 93, 94, 94,
 94, 92, 86, 82, 80, 80, 80, 80, 80, 80,
 80, 80, 80, 80, 82, 86, 92, 95, 95, 95,
 95, 94, 92, 87, 84, 80, 80, 80, 80, 80,
 80, 80, 80, 84, 87, 92, 94, 95, 95, 95,
 94, 94, 94, 93, 89, 86, 85, 83, 82, 80,
 83, 85, 86, 89, 93, 94, 95, 95, 95, 95,
 95, 95, 95, 94, 94, 93, 91, 89, 89, 88,
 89, 91, 93, 94, 94, 95, 95, 95, 95,
};
