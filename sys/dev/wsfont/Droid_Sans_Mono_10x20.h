/*	$NetBSD: Droid_Sans_Mono_10x20.h,v 1.1 2021/11/20 00:08:23 rin Exp $	*/

/*
   Copyright 2010 Ascender Corporation

   Licensed under the Apache License, Version 2.0 (the "License");
   you may not use this file except in compliance with the License.
   You may obtain a copy of the License at

       http://www.apache.org/licenses/LICENSE-2.0

   Unless required by applicable law or agreed to in writing, software
   distributed under the License is distributed on an "AS IS" BASIS,
   WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
   See the License for the specific language governing permissions and
   limitations under the License.
*/

static u_char Droid_Sans_Mono_10x20_data[];

static struct wsdisplay_font Droid_Sans_Mono_10x20 = {
	"Droid Sans Mono",			/* typeface name */
	32,				/* firstchar */
	256 - 32,			/* numchar */
	WSDISPLAY_FONTENC_ISO,		/* encoding */
	10,				/* width */
	20,				/* height */
	10,				/* stride */
	WSDISPLAY_FONTORDER_L2R,	/* bit order */
	WSDISPLAY_FONTORDER_L2R,	/* byte order */
	Droid_Sans_Mono_10x20_data		/* data */
};

static u_char Droid_Sans_Mono_10x20_data[] = {
	/* 32 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 33 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x0a, 0xff, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Xa     */
0x00, 0x00, 0x00, 0x00, 0xfc, 0x9b, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xe3, 0x81, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xd6, 0x74, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc9, 0x67, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xbc, 0x5a, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0xaf, 0x4e, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x18, 0x09, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x1a, 0xfb, 0xb2, 0x00, 0x00, 0x00, 0x00, /*     Xa     */
0x00, 0x00, 0x00, 0x12, 0xe8, 0x99, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 34 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xbb, 0xff, 0x09, 0x6f, 0xff, 0x55, 0x00, 0x00, /*   aX +X-   */
0x00, 0x00, 0xa7, 0xf5, 0x00, 0x5b, 0xff, 0x41, 0x00, 0x00, /*   aX -X-   */
0x00, 0x00, 0x93, 0xe1, 0x00, 0x47, 0xff, 0x2d, 0x00, 0x00, /*   oX -X.   */
0x00, 0x00, 0x7e, 0xcd, 0x00, 0x32, 0xff, 0x19, 0x00, 0x00, /*   +O .X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 35 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x80, 0xa4, 0x00, 0x0e, 0xfd, 0x14, 0x00, /*    oa  X   */
0x00, 0x00, 0x00, 0xb6, 0x6d, 0x00, 0x45, 0xdb, 0x00, 0x00, /*    a+ -O   */
0x00, 0x00, 0x00, 0xec, 0x37, 0x00, 0x7c, 0xa3, 0x00, 0x00, /*    X. +a   */
0x0c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x40, /*  XXXXXXXX- */
0x02, 0x2c, 0x6d, 0xdc, 0x2c, 0x2c, 0xe7, 0x5e, 0x2c, 0x0b, /*  .+O..X-.  */
0x00, 0x00, 0x78, 0xab, 0x00, 0x0d, 0xfe, 0x13, 0x00, 0x00, /*   +a  X    */
0x00, 0x00, 0xa5, 0x7e, 0x00, 0x39, 0xe6, 0x00, 0x00, 0x00, /*   a+ .X    */
0xa4, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xb0, 0x00, /* aXXXXXXXa  */
0x1c, 0x31, 0xfe, 0x48, 0x2c, 0xab, 0x9e, 0x2c, 0x1e, 0x00, /*  .X-.ao.   */
0x00, 0x2a, 0xf7, 0x03, 0x00, 0xc3, 0x62, 0x00, 0x00, 0x00, /*  .X  O+    */
0x00, 0x53, 0xcf, 0x00, 0x00, 0xee, 0x37, 0x00, 0x00, 0x00, /*  -O  X.    */
0x00, 0x7c, 0xa5, 0x00, 0x1a, 0xff, 0x0d, 0x00, 0x00, 0x00, /*  +a  X     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 36 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xb8, 0x58, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0xb8, 0x58, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x49, 0xcb, 0xfd, 0xfc, 0xde, 0x87, 0x00, 0x00, /*   -OXXOo   */
0x00, 0x2a, 0xfa, 0x8b, 0xc8, 0x7b, 0x63, 0x65, 0x00, 0x00, /*  .XoO+++   */
0x00, 0x64, 0xf9, 0x00, 0xb8, 0x58, 0x00, 0x00, 0x00, 0x00, /*  +X a-     */
0x00, 0x3b, 0xff, 0x59, 0xb8, 0x58, 0x00, 0x00, 0x00, 0x00, /*  .X-a-     */
0x00, 0x00, 0x7e, 0xfa, 0xfd, 0x99, 0x13, 0x00, 0x00, 0x00, /*   +XXo     */
0x00, 0x00, 0x00, 0x19, 0xd1, 0xf5, 0xf3, 0x55, 0x00, 0x00, /*     OXX-   */
0x00, 0x00, 0x00, 0x00, 0xb8, 0x5b, 0x96, 0xf4, 0x08, 0x00, /*     a-oX   */
0x00, 0x00, 0x00, 0x00, 0xb8, 0x58, 0x46, 0xff, 0x1a, 0x00, /*     a--X   */
0x00, 0x74, 0x81, 0x49, 0xc6, 0x93, 0xce, 0xce, 0x00, 0x00, /*  +o-OoOO   */
0x00, 0x51, 0xcb, 0xef, 0xff, 0xe4, 0x95, 0x16, 0x00, 0x00, /*  -OXXXo    */
0x00, 0x00, 0x00, 0x00, 0xb8, 0x58, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0xb8, 0x58, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 37 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x38, 0xd4, 0xed, 0x9e, 0x03, 0x00, 0x35, 0xf3, 0x12, 0x00, /* .OXo  .X   */
0xd0, 0x6f, 0x08, 0xd6, 0x60, 0x00, 0xaf, 0x8d, 0x00, 0x00, /* O+ O+ ao   */
0xf6, 0x36, 0x00, 0xa6, 0x8a, 0x2a, 0xf7, 0x1a, 0x00, 0x00, /* X. ao.X    */
0xcc, 0x70, 0x08, 0xd6, 0x61, 0xa2, 0x99, 0x00, 0x00, 0x00, /* O+ O+ao    */
0x34, 0xd3, 0xed, 0xa3, 0x25, 0xf8, 0x23, 0x00, 0x00, 0x00, /* .OXa.X.    */
0x00, 0x00, 0x00, 0x00, 0x96, 0xa6, 0x00, 0x00, 0x00, 0x00, /*     oa     */
0x00, 0x00, 0x00, 0x17, 0xf6, 0x2d, 0x00, 0x00, 0x00, 0x00, /*     X.     */
0x00, 0x00, 0x00, 0x89, 0xb3, 0x33, 0xd2, 0xed, 0xa3, 0x05, /*    oa.OXa  */
0x00, 0x00, 0x10, 0xf1, 0x39, 0xc8, 0x77, 0x07, 0xcf, 0x67, /*    X.O+ O+ */
0x00, 0x00, 0x7c, 0xbf, 0x00, 0xee, 0x3e, 0x00, 0x9e, 0x92, /*   +a X. oo */
0x00, 0x0a, 0xeb, 0x46, 0x00, 0xc4, 0x78, 0x07, 0xd0, 0x6a, /*   X- O+ O+ */
0x00, 0x6f, 0xcc, 0x00, 0x00, 0x2f, 0xd0, 0xee, 0xa8, 0x07, /*  +O  .OXa  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 38 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x64, 0xdb, 0xf6, 0xce, 0x3e, 0x00, 0x00, 0x00, /*   +OXO.    */
0x00, 0x34, 0xfe, 0x81, 0x3a, 0xb4, 0xeb, 0x06, 0x00, 0x00, /*  .Xo.aX    */
0x00, 0x6a, 0xf9, 0x00, 0x00, 0x3f, 0xff, 0x24, 0x00, 0x00, /*  +X  .X.   */
0x00, 0x4a, 0xff, 0x2e, 0x00, 0x91, 0xe8, 0x07, 0x00, 0x00, /*  -X. oX    */
0x00, 0x03, 0xd5, 0xc5, 0xa1, 0xf8, 0x46, 0x00, 0x00, 0x00, /*   OOaX-    */
0x00, 0x00, 0x78, 0xff, 0xea, 0x2f, 0x00, 0x5f, 0xfd, 0x0d, /*   +XX. -X  */
0x00, 0x85, 0xfc, 0xad, 0xfe, 0x50, 0x00, 0x8c, 0xd3, 0x00, /*  oXaX- oO  */
0x39, 0xff, 0x6f, 0x00, 0x9d, 0xf1, 0x27, 0xcc, 0x95, 0x00, /* .X+ oX.Oo  */
0x78, 0xfe, 0x08, 0x00, 0x08, 0xcf, 0xda, 0xfe, 0x36, 0x00, /* +X   OOX.  */
0x69, 0xff, 0x1c, 0x00, 0x00, 0x2a, 0xfe, 0xe5, 0x00, 0x00, /* +X   .XX   */
0x1f, 0xf5, 0xc1, 0x3f, 0x52, 0xcd, 0xe5, 0xfd, 0x6e, 0x00, /*  XO.-OXX+  */
0x00, 0x41, 0xca, 0xf6, 0xe7, 0x96, 0x15, 0x7d, 0xfa, 0x3a, /*  -OXXo +X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 39 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x16, 0xff, 0xb0, 0x00, 0x00, 0x00, 0x00, /*     Xa     */
0x00, 0x00, 0x00, 0x03, 0xfd, 0x9b, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xec, 0x86, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xd7, 0x72, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 40 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x03, 0xad, 0xc6, 0x0a, 0x00, 0x00, /*      aO    */
0x00, 0x00, 0x00, 0x00, 0x9b, 0xd7, 0x11, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x46, 0xfe, 0x3d, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0xd4, 0xaa, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x2f, 0xff, 0x4d, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .X-      */
0x00, 0x00, 0x78, 0xfb, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, /*   +X       */
0x00, 0x00, 0x96, 0xe2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX       */
0x00, 0x00, 0xa9, 0xce, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   aO       */
0x00, 0x00, 0x97, 0xe2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX       */
0x00, 0x00, 0x7a, 0xfa, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, /*   +X       */
0x00, 0x00, 0x33, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .X-      */
0x00, 0x00, 0x00, 0xd9, 0xa7, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0x4c, 0xfe, 0x39, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x00, 0xa1, 0xd4, 0x0f, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x00, 0x00, 0x04, 0xaf, 0xc2, 0x09, 0x00, 0x00, /*      aO    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 41 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3e, 0xf2, 0x50, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .X-      */
0x00, 0x00, 0x00, 0x4e, 0xf7, 0x3e, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x00, 0xa0, 0xda, 0x07, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x00, 0x00, 0x16, 0xf8, 0x70, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xb2, 0xca, 0x00, 0x00, 0x00, /*      aO    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0xff, 0x14, 0x00, 0x00, /*      +X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xff, 0x31, 0x00, 0x00, /*      -X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xff, 0x45, 0x00, 0x00, /*      .X-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xff, 0x32, 0x00, 0x00, /*      -X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x65, 0xff, 0x15, 0x00, 0x00, /*      +X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xb0, 0xcf, 0x00, 0x00, 0x00, /*      aO    */
0x00, 0x00, 0x00, 0x00, 0x13, 0xf7, 0x76, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x9b, 0xdf, 0x09, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x49, 0xf8, 0x43, 0x00, 0x00, 0x00, 0x00, /*    -X-     */
0x00, 0x00, 0x3b, 0xf1, 0x53, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .X-      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 42 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xf5, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x6b, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x9d, 0x86, 0x40, 0xc0, 0x66, 0x5d, 0xa1, 0x57, 0x00, /*  oo-O+-a-  */
0x00, 0x93, 0xb4, 0xcc, 0xff, 0xef, 0xbf, 0xac, 0x52, 0x00, /*  oaOXXaa-  */
0x00, 0x00, 0x00, 0x8f, 0xc5, 0xf3, 0x2e, 0x00, 0x00, 0x00, /*    oOX.    */
0x00, 0x00, 0x53, 0xff, 0x34, 0xa4, 0xdb, 0x0f, 0x00, 0x00, /*   -X.aO    */
0x00, 0x00, 0x70, 0xaf, 0x00, 0x25, 0xca, 0x30, 0x00, 0x00, /*   +a .O.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 43 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x23, 0x2c, 0x2c, 0xd1, 0x7b, 0x2c, 0x2c, 0x11, 0x00, /*  ...O+..   */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0x25, 0x12, 0x00, 0x00, 0x00, 0x00, /*     .      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 44 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xca, 0xf8, 0x0a, 0x00, 0x00, 0x00, /*     OX     */
0x00, 0x00, 0x00, 0x04, 0xf7, 0xb0, 0x00, 0x00, 0x00, 0x00, /*     Xa     */
0x00, 0x00, 0x00, 0x35, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, /*    .X-     */
0x00, 0x00, 0x00, 0x72, 0xd7, 0x01, 0x00, 0x00, 0x00, 0x00, /*    +O      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 45 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xc4, 0xff, 0xff, 0xff, 0xff, 0x60, 0x00, 0x00, /*   OXXXX+   */
0x00, 0x00, 0x3d, 0x50, 0x50, 0x50, 0x50, 0x1e, 0x00, 0x00, /*   .----    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 46 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x35, 0xf1, 0xc3, 0x00, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x00, 0x36, 0xf1, 0xc3, 0x00, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 47 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xa9, 0xbb, 0x00, 0x00, /*       aa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x16, 0xf9, 0x53, 0x00, 0x00, /*       X-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xe6, 0x04, 0x00, 0x00, /*      +X    */
0x00, 0x00, 0x00, 0x00, 0x02, 0xdf, 0x82, 0x00, 0x00, 0x00, /*      Oo    */
0x00, 0x00, 0x00, 0x00, 0x4a, 0xfc, 0x1d, 0x00, 0x00, 0x00, /*     -X     */
0x00, 0x00, 0x00, 0x00, 0xb2, 0xb1, 0x00, 0x00, 0x00, 0x00, /*     aa     */
0x00, 0x00, 0x00, 0x1d, 0xfc, 0x49, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x83, 0xdf, 0x02, 0x00, 0x00, 0x00, 0x00, /*    oO      */
0x00, 0x00, 0x04, 0xe6, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, /*    X+      */
0x00, 0x00, 0x54, 0xf9, 0x16, 0x00, 0x00, 0x00, 0x00, 0x00, /*   -X       */
0x00, 0x00, 0xbc, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   aa       */
0x00, 0x24, 0xfe, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 48 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x24, 0xba, 0xf6, 0xe6, 0x7e, 0x02, 0x00, 0x00, /*   .aXX+    */
0x00, 0x08, 0xdd, 0xbe, 0x3e, 0x5f, 0xf3, 0x76, 0x00, 0x00, /*   Oa.-X+   */
0x00, 0x5e, 0xfa, 0x17, 0x00, 0x00, 0x7b, 0xed, 0x04, 0x00, /*  -X   +X   */
0x00, 0xa0, 0xc9, 0x00, 0x00, 0x00, 0x2f, 0xff, 0x38, 0x00, /*  aO   .X.  */
0x00, 0xc4, 0xa7, 0x00, 0x00, 0x00, 0x0d, 0xff, 0x5e, 0x00, /*  Oa    X-  */
0x00, 0xd3, 0x9a, 0x00, 0x00, 0x00, 0x00, 0xfe, 0x6e, 0x00, /*  Oo    X+  */
0x00, 0xd3, 0x9b, 0x00, 0x00, 0x00, 0x00, 0xff, 0x6e, 0x00, /*  Oo    X+  */
0x00, 0xc3, 0xa7, 0x00, 0x00, 0x00, 0x0d, 0xff, 0x5f, 0x00, /*  Oa    X-  */
0x00, 0x9d, 0xc9, 0x00, 0x00, 0x00, 0x30, 0xff, 0x3a, 0x00, /*  oO   .X.  */
0x00, 0x58, 0xfa, 0x17, 0x00, 0x00, 0x79, 0xf1, 0x06, 0x00, /*  -X   +X   */
0x00, 0x05, 0xd8, 0xbe, 0x3d, 0x5e, 0xf2, 0x7f, 0x00, 0x00, /*   Oa.-X+   */
0x00, 0x00, 0x20, 0xb8, 0xf6, 0xe8, 0x84, 0x03, 0x00, 0x00, /*   .aXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 49 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x27, 0xcc, 0xec, 0x00, 0x00, 0x00, 0x00, /*    .OX     */
0x00, 0x00, 0x65, 0xf2, 0xc5, 0xec, 0x00, 0x00, 0x00, 0x00, /*   +XOX     */
0x00, 0x0d, 0xc2, 0x46, 0x6c, 0xec, 0x00, 0x00, 0x00, 0x00, /*   O-+X     */
0x00, 0x00, 0x00, 0x00, 0x71, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x73, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x74, 0xec, 0x00, 0x00, 0x00, 0x00, /*     +X     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 50 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x04, 0x71, 0xd4, 0xf8, 0xdc, 0x76, 0x02, 0x00, 0x00, /*   +OXO+    */
0x00, 0x65, 0xe9, 0x70, 0x39, 0x72, 0xfc, 0x6e, 0x00, 0x00, /*  +X+.+X+   */
0x00, 0x01, 0x14, 0x00, 0x00, 0x00, 0xab, 0xc9, 0x00, 0x00, /*       aO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x92, 0xdd, 0x00, 0x00, /*       oO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc5, 0xae, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0xff, 0x46, 0x00, 0x00, /*      -X-   */
0x00, 0x00, 0x00, 0x00, 0x18, 0xe5, 0xa0, 0x00, 0x00, 0x00, /*      Xa    */
0x00, 0x00, 0x00, 0x09, 0xc8, 0xcd, 0x0a, 0x00, 0x00, 0x00, /*     OO     */
0x00, 0x00, 0x02, 0xad, 0xe2, 0x1a, 0x00, 0x00, 0x00, 0x00, /*    aX      */
0x00, 0x00, 0x8e, 0xee, 0x2a, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX.      */
0x00, 0x6b, 0xff, 0x6d, 0x30, 0x30, 0x30, 0x30, 0x11, 0x00, /*  +X+....   */
0x00, 0xc4, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x5c, 0x00, /*  OXXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 51 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x25, 0x9f, 0xe5, 0xf8, 0xdc, 0x7e, 0x04, 0x00, 0x00, /*  .oXXO+    */
0x00, 0xa6, 0xc4, 0x5d, 0x3a, 0x70, 0xfa, 0x83, 0x00, 0x00, /*  aO-.+Xo   */
0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xa5, 0xd2, 0x00, 0x00, /*       aO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xb4, 0xc3, 0x00, 0x00, /*       aO   */
0x00, 0x00, 0x00, 0x00, 0x17, 0x78, 0xf5, 0x44, 0x00, 0x00, /*      +X-   */
0x00, 0x00, 0x3c, 0xff, 0xff, 0xe0, 0x49, 0x00, 0x00, 0x00, /*   .XXX-    */
0x00, 0x00, 0x0b, 0x30, 0x43, 0x7f, 0xf4, 0x7d, 0x00, 0x00, /*    .-+X+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xfd, 0x17, 0x00, /*       +X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44, 0xff, 0x38, 0x00, /*       -X.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7c, 0xfe, 0x18, 0x00, /*       +X   */
0x00, 0xbc, 0x68, 0x40, 0x3f, 0x7e, 0xf7, 0x9c, 0x00, 0x00, /*  a+-.+Xo   */
0x00, 0x87, 0xd7, 0xf3, 0xf1, 0xce, 0x69, 0x04, 0x00, 0x00, /*  oOXXO+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 52 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0xa7, 0xff, 0x24, 0x00, 0x00, /*      aX.   */
0x00, 0x00, 0x00, 0x00, 0x4c, 0xed, 0xff, 0x24, 0x00, 0x00, /*     -XX.   */
0x00, 0x00, 0x00, 0x0d, 0xe3, 0x84, 0xff, 0x24, 0x00, 0x00, /*     XoX.   */
0x00, 0x00, 0x00, 0x96, 0xc5, 0x37, 0xff, 0x24, 0x00, 0x00, /*    oO.X.   */
0x00, 0x00, 0x3c, 0xf7, 0x29, 0x3a, 0xff, 0x24, 0x00, 0x00, /*   .X..X.   */
0x00, 0x07, 0xd8, 0x7c, 0x00, 0x3c, 0xff, 0x24, 0x00, 0x00, /*   O+ .X.   */
0x00, 0x85, 0xd2, 0x05, 0x00, 0x3c, 0xff, 0x24, 0x00, 0x00, /*  oO  .X.   */
0x2e, 0xf7, 0x35, 0x00, 0x00, 0x3c, 0xff, 0x24, 0x00, 0x00, /* .X.  .X.   */
0x83, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xcc, 0x00, /* oXXXXXXXO  */
0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0xff, 0x4d, 0x26, 0x00, /*  ....+X-.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x3c, 0xff, 0x24, 0x00, 0x00, /*      .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x3c, 0xff, 0x24, 0x00, 0x00, /*      .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 53 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x05, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, 0x00, /*   XXXXX+   */
0x00, 0x18, 0xff, 0x5d, 0x30, 0x30, 0x30, 0x13, 0x00, 0x00, /*   X-...    */
0x00, 0x2a, 0xff, 0x26, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X.       */
0x00, 0x3c, 0xff, 0x13, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X        */
0x00, 0x4e, 0xfd, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X        */
0x00, 0x5f, 0xfe, 0xe5, 0xf8, 0xdd, 0x89, 0x0d, 0x00, 0x00, /*  -XXXOo    */
0x00, 0x07, 0x56, 0x3b, 0x3c, 0x75, 0xf2, 0xbc, 0x00, 0x00, /*   -..+Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6e, 0xff, 0x25, 0x00, /*       +X.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0xff, 0x39, 0x00, /*       -X.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x75, 0xfd, 0x14, 0x00, /*       +X   */
0x00, 0x89, 0x75, 0x45, 0x3b, 0x76, 0xf4, 0x97, 0x00, 0x00, /*  o+-.+Xo   */
0x00, 0x54, 0xcb, 0xf0, 0xf2, 0xce, 0x68, 0x03, 0x00, 0x00, /*  -OXXO+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 54 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x40, 0xb8, 0xef, 0xfb, 0x7e, 0x00, 0x00, /*    -aXX+   */
0x00, 0x00, 0x57, 0xfc, 0x9b, 0x50, 0x3b, 0x2d, 0x00, 0x00, /*   -Xo-..   */
0x00, 0x0e, 0xed, 0x6a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X+       */
0x00, 0x5d, 0xed, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X        */
0x00, 0x98, 0xbb, 0x78, 0xe8, 0xf6, 0xb6, 0x1f, 0x00, 0x00, /*  oa+XXa    */
0x00, 0xba, 0xef, 0xb4, 0x37, 0x3d, 0xd0, 0xca, 0x01, 0x00, /*  aXa..OO   */
0x00, 0xc7, 0xdf, 0x07, 0x00, 0x00, 0x35, 0xff, 0x37, 0x00, /*  OO   .X.  */
0x00, 0xc3, 0xa9, 0x00, 0x00, 0x00, 0x04, 0xfd, 0x5b, 0x00, /*  Oa    X-  */
0x00, 0xa4, 0xc1, 0x00, 0x00, 0x00, 0x0b, 0xff, 0x4e, 0x00, /*  aO    X-  */
0x00, 0x5f, 0xfc, 0x20, 0x00, 0x00, 0x4c, 0xfe, 0x23, 0x00, /*  -X.  -X.  */
0x00, 0x06, 0xd4, 0xd4, 0x4c, 0x53, 0xe3, 0xa6, 0x00, 0x00, /*   OO--Xa   */
0x00, 0x00, 0x1a, 0xac, 0xf4, 0xef, 0x9d, 0x0c, 0x00, 0x00, /*    aXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 55 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xe0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x78, 0x00, /*  XXXXXXX+  */
0x00, 0x2a, 0x30, 0x30, 0x30, 0x30, 0x4f, 0xff, 0x46, 0x00, /*  .....-X-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x85, 0xdf, 0x02, 0x00, /*       oO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xe8, 0x7c, 0x00, 0x00, /*       X+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x56, 0xfc, 0x1a, 0x00, 0x00, /*      -X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xbe, 0xb1, 0x00, 0x00, 0x00, /*      aa    */
0x00, 0x00, 0x00, 0x00, 0x27, 0xff, 0x4c, 0x00, 0x00, 0x00, /*     .X-    */
0x00, 0x00, 0x00, 0x00, 0x8f, 0xe3, 0x03, 0x00, 0x00, 0x00, /*     oX     */
0x00, 0x00, 0x00, 0x09, 0xee, 0x81, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x60, 0xfd, 0x1f, 0x00, 0x00, 0x00, 0x00, /*    +X      */
0x00, 0x00, 0x00, 0xc8, 0xb7, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x2f, 0xff, 0x52, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .X-      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 56 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x37, 0xc0, 0xf2, 0xe5, 0x94, 0x0d, 0x00, 0x00, /*   .OXXo    */
0x00, 0x19, 0xf0, 0xab, 0x3c, 0x55, 0xe5, 0xa4, 0x00, 0x00, /*   Xa.-Xa   */
0x00, 0x57, 0xff, 0x0e, 0x00, 0x00, 0x72, 0xf2, 0x00, 0x00, /*  -X   +X   */
0x00, 0x4b, 0xff, 0x1d, 0x00, 0x00, 0x87, 0xe4, 0x00, 0x00, /*  -X   oX   */
0x00, 0x05, 0xd3, 0xc1, 0x1d, 0x52, 0xf5, 0x67, 0x00, 0x00, /*   OO -X+   */
0x00, 0x00, 0x1a, 0xe0, 0xfc, 0xff, 0x68, 0x00, 0x00, 0x00, /*    XXX+    */
0x00, 0x04, 0xa5, 0xc9, 0x34, 0x96, 0xe9, 0x3b, 0x00, 0x00, /*   aO.oX.   */
0x00, 0x71, 0xeb, 0x10, 0x00, 0x00, 0x78, 0xee, 0x12, 0x00, /*  +X   +X   */
0x00, 0xba, 0xa8, 0x00, 0x00, 0x00, 0x0d, 0xff, 0x54, 0x00, /*  aa    X-  */
0x00, 0xac, 0xbd, 0x00, 0x00, 0x00, 0x2c, 0xff, 0x42, 0x00, /*  aa   .X-  */
0x00, 0x50, 0xff, 0x83, 0x3a, 0x4f, 0xd1, 0xd3, 0x07, 0x00, /*  -Xo.-OO   */
0x00, 0x00, 0x5a, 0xcd, 0xf4, 0xe6, 0xa1, 0x1a, 0x00, 0x00, /*   -OXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 57 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3b, 0xc9, 0xf8, 0xe1, 0x72, 0x00, 0x00, 0x00, /*   .OXX+    */
0x00, 0x19, 0xf4, 0xa6, 0x40, 0x73, 0xfb, 0x70, 0x00, 0x00, /*   Xa-+X+   */
0x00, 0x87, 0xe1, 0x03, 0x00, 0x00, 0x81, 0xef, 0x08, 0x00, /*  oX   oX   */
0x00, 0xb4, 0xa6, 0x00, 0x00, 0x00, 0x26, 0xff, 0x3e, 0x00, /*  aa   .X.  */
0x00, 0xc0, 0x9d, 0x00, 0x00, 0x00, 0x0e, 0xff, 0x5d, 0x00, /*  Oo    X-  */
0x00, 0x9d, 0xce, 0x00, 0x00, 0x00, 0x4c, 0xff, 0x63, 0x00, /*  oO   -X+  */
0x00, 0x35, 0xff, 0x87, 0x2d, 0x57, 0xd6, 0xff, 0x56, 0x00, /*  .Xo.-OX-  */
0x00, 0x00, 0x51, 0xd2, 0xf7, 0xcd, 0x53, 0xff, 0x33, 0x00, /*   -OXO-X.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x55, 0xf2, 0x07, 0x00, /*       -X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc3, 0x97, 0x00, 0x00, /*       Oo   */
0x00, 0x00, 0x41, 0x2b, 0x50, 0xc7, 0xdc, 0x14, 0x00, 0x00, /*   -.-OO    */
0x00, 0x00, 0xe0, 0xfb, 0xe1, 0x94, 0x15, 0x00, 0x00, 0x00, /*   XXXo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 58 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x0d, 0xe0, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x0d, 0xe1, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x0d, 0xe0, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x0d, 0xe1, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 59 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x07, 0xdb, 0x99, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x07, 0xdb, 0x99, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x1e, 0xff, 0x8a, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x50, 0xff, 0x3d, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x82, 0xdf, 0x01, 0x00, 0x00, 0x00, 0x00, /*    oO      */
0x00, 0x00, 0x00, 0xb3, 0x7b, 0x00, 0x00, 0x00, 0x00, 0x00, /*    a+      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 60 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x16, 0x8b, 0x5d, 0x00, /*        o-  */
0x00, 0x00, 0x00, 0x00, 0x16, 0x8b, 0xf4, 0xb2, 0x24, 0x00, /*      oXa.  */
0x00, 0x00, 0x16, 0x8b, 0xf3, 0xae, 0x30, 0x00, 0x00, 0x00, /*    oXa.    */
0x00, 0x7b, 0xf3, 0xaa, 0x2d, 0x00, 0x00, 0x00, 0x00, 0x00, /*  +Xa.      */
0x00, 0x7e, 0xf4, 0xa9, 0x2c, 0x00, 0x00, 0x00, 0x00, 0x00, /*  +Xa.      */
0x00, 0x00, 0x18, 0x8f, 0xf4, 0xad, 0x30, 0x00, 0x00, 0x00, /*    oXa.    */
0x00, 0x00, 0x00, 0x00, 0x17, 0x8e, 0xf5, 0xb1, 0x24, 0x00, /*      oXa.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0x8d, 0x5d, 0x00, /*        o-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 61 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x23, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0x11, 0x00, /*  .......   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x23, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0x11, 0x00, /*  .......   */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 62 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xa5, 0x57, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  a-        */
0x00, 0x5d, 0xe0, 0xd5, 0x57, 0x02, 0x00, 0x00, 0x00, 0x00, /*  -XO-      */
0x00, 0x00, 0x05, 0x64, 0xdd, 0xd5, 0x57, 0x02, 0x00, 0x00, /*    +OO-    */
0x00, 0x00, 0x00, 0x00, 0x04, 0x61, 0xdb, 0xd5, 0x32, 0x00, /*      +OO.  */
0x00, 0x00, 0x00, 0x00, 0x04, 0x60, 0xdb, 0xd8, 0x34, 0x00, /*      +OO.  */
0x00, 0x00, 0x05, 0x63, 0xdd, 0xd7, 0x5b, 0x02, 0x00, 0x00, /*    +OO-    */
0x00, 0x5d, 0xe0, 0xd6, 0x5a, 0x02, 0x00, 0x00, 0x00, 0x00, /*  -XO-      */
0x00, 0xa6, 0x59, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  a-        */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 63 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3c, 0xa7, 0xdf, 0xf7, 0xe1, 0x98, 0x15, 0x00, 0x00, /*  .aOXXo    */
0x00, 0x5a, 0xb2, 0x5e, 0x3a, 0x54, 0xd9, 0xca, 0x03, 0x00, /*  -a-.-OO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xff, 0x2d, 0x00, /*       .X.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xff, 0x3a, 0x00, /*       .X.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0xf1, 0x0b, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xfb, 0x55, 0x00, 0x00, /*      +X-   */
0x00, 0x00, 0x00, 0x00, 0x8b, 0xf6, 0x4f, 0x00, 0x00, 0x00, /*     oX-    */
0x00, 0x00, 0x00, 0x29, 0xff, 0x49, 0x00, 0x00, 0x00, 0x00, /*    .X-     */
0x00, 0x00, 0x00, 0x56, 0xed, 0x00, 0x00, 0x00, 0x00, 0x00, /*    -X      */
0x00, 0x00, 0x00, 0x05, 0x1d, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x92, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, /*    oX.     */
0x00, 0x00, 0x00, 0x7a, 0xf1, 0x29, 0x00, 0x00, 0x00, 0x00, /*    +X.     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 64 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2a, 0xaf, 0xee, 0xf4, 0xb9, 0x2e, 0x00, 0x00, /*   .aXXa.   */
0x00, 0x33, 0xed, 0x74, 0x18, 0x12, 0x70, 0xec, 0x28, 0x00, /*  .X+  +X.  */
0x02, 0xd3, 0x65, 0x00, 0x00, 0x00, 0x00, 0x84, 0xb4, 0x00, /*  O+    oa  */
0x42, 0xdd, 0x02, 0x54, 0xe3, 0xf6, 0xcc, 0x2c, 0xf7, 0x12, /* -O -XXO.X  */
0x86, 0x93, 0x18, 0xf7, 0x4e, 0x39, 0xff, 0x15, 0xda, 0x41, /* oo X-.X O- */
0xad, 0x6a, 0x70, 0xcd, 0x00, 0x31, 0xff, 0x09, 0xbe, 0x55, /* a++O .X a- */
0xbb, 0x5b, 0x91, 0xab, 0x00, 0x40, 0xfc, 0x00, 0xba, 0x4f, /* a-oa -X a- */
0xb6, 0x61, 0x8a, 0xb0, 0x00, 0x5e, 0xf6, 0x00, 0xcc, 0x37, /* a+oa -X O. */
0x9b, 0x81, 0x51, 0xe9, 0x1e, 0xb7, 0xeb, 0x34, 0xe8, 0x05, /* oo-X aX.X  */
0x5f, 0xc8, 0x03, 0xa3, 0xf3, 0x8f, 0x60, 0xf3, 0x6b, 0x00, /* -O aXo+X+  */
0x0d, 0xeb, 0x4e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  X-        */
0x00, 0x4e, 0xf0, 0x6f, 0x19, 0x0d, 0x2f, 0x79, 0x00, 0x00, /*  -X+  .+   */
0x00, 0x00, 0x39, 0xb6, 0xef, 0xf6, 0xd6, 0x7f, 0x00, 0x00, /*   .aXXO+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 65 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xff, 0xb7, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 66 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xf0, 0xff, 0xff, 0xfe, 0xf0, 0xc3, 0x4e, 0x00, 0x00, /*  XXXXXO-   */
0x00, 0xf0, 0xa3, 0x40, 0x42, 0x5a, 0xc1, 0xfb, 0x32, 0x00, /*  Xa---OX.  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x0e, 0xfd, 0x79, 0x00, /*  Xo    X+  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x03, 0xf9, 0x7a, 0x00, /*  Xo    X+  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x16, 0x89, 0xed, 0x1d, 0x00, /*  Xo   oX   */
0x00, 0xf0, 0xff, 0xff, 0xff, 0xff, 0xcb, 0x27, 0x00, 0x00, /*  XXXXXO.   */
0x00, 0xf0, 0xa3, 0x40, 0x40, 0x56, 0xb5, 0xe7, 0x30, 0x00, /*  Xa---aX.  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x04, 0xdb, 0xb5, 0x00, /*  Xo    Oa  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xb2, 0xd9, 0x00, /*  Xo    aO  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x05, 0xdf, 0xb6, 0x00, /*  Xo    Oa  */
0x00, 0xf0, 0xa3, 0x40, 0x40, 0x53, 0xb5, 0xff, 0x45, 0x00, /*  Xa---aX-  */
0x00, 0xf0, 0xff, 0xff, 0xff, 0xf3, 0xc8, 0x4c, 0x00, 0x00, /*  XXXXXO-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 67 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x46, 0xb9, 0xee, 0xf7, 0xdd, 0x97, 0x0d, /*    -aXXOo  */
0x00, 0x00, 0x72, 0xff, 0xc0, 0x61, 0x52, 0x7d, 0xab, 0x00, /*   +XO+-+a  */
0x00, 0x30, 0xfc, 0xa5, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .Xa       */
0x00, 0x9c, 0xf8, 0x1b, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0xda, 0xbd, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xf4, 0x9c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Xo        */
0x00, 0xf5, 0x92, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Xo        */
0x00, 0xde, 0xae, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xa7, 0xed, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aX        */
0x00, 0x45, 0xff, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -Xo       */
0x00, 0x00, 0x9a, 0xff, 0xae, 0x5c, 0x4f, 0x6e, 0x7f, 0x00, /*   oXa--++  */
0x00, 0x00, 0x01, 0x66, 0xcc, 0xf5, 0xf6, 0xdc, 0x80, 0x00, /*    +OXXOo  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 68 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xf0, 0xff, 0xff, 0xef, 0xbb, 0x4c, 0x00, 0x00, 0x00, /*  XXXXa-    */
0x00, 0xf0, 0xa3, 0x41, 0x5a, 0xb0, 0xff, 0x7c, 0x00, 0x00, /*  Xa--aX+   */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x87, 0xfe, 0x36, 0x00, /*  Xo   oX.  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x08, 0xef, 0x9f, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xb5, 0xd9, 0x00, /*  Xo    aO  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0x9a, 0xf1, 0x00, /*  Xo    oX  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0x9d, 0xed, 0x00, /*  Xo    oX  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xbb, 0xd2, 0x00, /*  Xo    aO  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x0f, 0xf5, 0x95, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x01, 0x9f, 0xfb, 0x2b, 0x00, /*  Xo   oX.  */
0x00, 0xf0, 0xa3, 0x45, 0x66, 0xc5, 0xfe, 0x69, 0x00, 0x00, /*  Xa-+OX+   */
0x00, 0xf0, 0xff, 0xfc, 0xe8, 0xae, 0x3b, 0x00, 0x00, 0x00, /*  XXXXa.    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 69 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, /*  -XXXXXX   */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x45, 0x00, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 70 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x18, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7c, 0x00, /*   XXXXXX+  */
0x00, 0x18, 0xff, 0x8a, 0x48, 0x48, 0x48, 0x48, 0x22, 0x00, /*   Xo----.  */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x30, 0x00, /*   XXXXXX.  */
0x00, 0x18, 0xff, 0x8a, 0x48, 0x48, 0x48, 0x48, 0x0d, 0x00, /*   Xo----   */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x18, 0xff, 0x5c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 71 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x05, 0x78, 0xd7, 0xf8, 0xe6, 0xab, 0x20, 0x00, /*    +OXXa.  */
0x00, 0x00, 0xaf, 0xf8, 0x87, 0x50, 0x6d, 0xc1, 0x0f, 0x00, /*   aXo-+O   */
0x00, 0x5a, 0xff, 0x5a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0xbe, 0xde, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xf4, 0x9b, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Xo        */
0x0d, 0xff, 0x81, 0x00, 0x00, 0xc0, 0xff, 0xff, 0x8c, 0x00, /*  Xo  OXXo  */
0x0d, 0xff, 0x78, 0x00, 0x00, 0x36, 0x48, 0xeb, 0x8c, 0x00, /*  X+  .-Xo  */
0x01, 0xf6, 0x8f, 0x00, 0x00, 0x00, 0x00, 0xe4, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xc6, 0xc5, 0x00, 0x00, 0x00, 0x00, 0xe4, 0x8c, 0x00, /*  OO    Xo  */
0x00, 0x6d, 0xff, 0x3c, 0x00, 0x00, 0x00, 0xe4, 0x8c, 0x00, /*  +X.   Xo  */
0x00, 0x06, 0xcc, 0xef, 0x78, 0x4d, 0x68, 0xf3, 0x8c, 0x00, /*   OX+-+Xo  */
0x00, 0x00, 0x11, 0x97, 0xe9, 0xf8, 0xe1, 0xac, 0x3c, 0x00, /*    oXXXa.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 72 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8c, 0x00, /*  XXXXXXXo  */
0x00, 0xf0, 0xa6, 0x48, 0x48, 0x48, 0x48, 0xee, 0x8c, 0x00, /*  Xa----Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xe8, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 73 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x05, 0x22, 0x35, 0xf3, 0xa4, 0x2e, 0x17, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x05, 0x21, 0x34, 0xf3, 0xa3, 0x2d, 0x16, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 74 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xcc, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xd9, 0xa0, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x29, 0xfc, 0x72, 0x00, 0x00, /*      .X+   */
0x00, 0x94, 0x64, 0x4f, 0x74, 0xe6, 0xdf, 0x0f, 0x00, 0x00, /*  o+-+XO    */
0x00, 0xa1, 0xe9, 0xfa, 0xea, 0xa1, 0x1a, 0x00, 0x00, 0x00, /*  aXXXa     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 75 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x00, 0x04, 0xc4, 0xcc, 0x07, /*  -X    OO  */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x00, 0x89, 0xed, 0x20, 0x00, /*  -X   oX.  */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x4a, 0xfc, 0x49, 0x00, 0x00, /*  -X  -X-   */
0x00, 0x58, 0xff, 0x1c, 0x1c, 0xec, 0x80, 0x00, 0x00, 0x00, /*  -X  Xo    */
0x00, 0x58, 0xff, 0x1f, 0xc5, 0xb7, 0x02, 0x00, 0x00, 0x00, /*  -X Oa     */
0x00, 0x58, 0xff, 0x96, 0xff, 0x5b, 0x00, 0x00, 0x00, 0x00, /*  -XoX-     */
0x00, 0x58, 0xff, 0xcf, 0xb4, 0xe3, 0x0d, 0x00, 0x00, 0x00, /*  -XOaX     */
0x00, 0x58, 0xff, 0x22, 0x19, 0xf1, 0x8f, 0x00, 0x00, 0x00, /*  -X. Xo    */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x6d, 0xfc, 0x32, 0x00, 0x00, /*  -X  +X.   */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x03, 0xcd, 0xcb, 0x02, 0x00, /*  -X   OO   */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x00, 0x35, 0xfd, 0x6c, 0x00, /*  -X   .X+  */
0x00, 0x58, 0xff, 0x1c, 0x00, 0x00, 0x00, 0x96, 0xf1, 0x1a, /*  -X    oX  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 76 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X-       */
0x00, 0x2c, 0xff, 0x7b, 0x48, 0x48, 0x48, 0x48, 0x12, 0x00, /*  .X+----   */
0x00, 0x2c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x40, 0x00, /*  .XXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 77 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x1c, 0xff, 0xe8, 0x00, 0x00, 0x00, 0x5a, 0xff, 0xb8, 0x00, /*  XX   -Xa  */
0x1c, 0xf9, 0xf9, 0x1b, 0x00, 0x00, 0x8c, 0xff, 0xb8, 0x00, /*  XX   oXa  */
0x1c, 0xf2, 0xcc, 0x4d, 0x00, 0x00, 0xbf, 0xda, 0xb8, 0x00, /*  XO-  aOa  */
0x1c, 0xfe, 0x9a, 0x7f, 0x00, 0x01, 0xef, 0xac, 0xb8, 0x00, /*  Xo+  Xaa  */
0x1c, 0xff, 0x6d, 0xb1, 0x00, 0x24, 0xfb, 0x80, 0xb8, 0x00, /*  X+a .Xoa  */
0x1c, 0xff, 0x3d, 0xe3, 0x00, 0x56, 0xcd, 0x78, 0xb8, 0x00, /*  X.X -O+a  */
0x1c, 0xff, 0x13, 0xf5, 0x16, 0x89, 0x94, 0x78, 0xb8, 0x00, /*  X X oo+a  */
0x1c, 0xff, 0x10, 0xc5, 0x48, 0xbb, 0x5b, 0x78, 0xb8, 0x00, /*  X O-a-+a  */
0x1c, 0xff, 0x10, 0x90, 0x7a, 0xed, 0x22, 0x78, 0xb8, 0x00, /*  X o+X.+a  */
0x1c, 0xff, 0x10, 0x5c, 0xcd, 0xe9, 0x00, 0x78, 0xb8, 0x00, /*  X -OX +a  */
0x1c, 0xff, 0x10, 0x27, 0xff, 0xb0, 0x00, 0x78, 0xb8, 0x00, /*  X .Xa +a  */
0x1c, 0xff, 0x10, 0x01, 0xf0, 0x78, 0x00, 0x78, 0xb8, 0x00, /*  X  X+ +a  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 78 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xf0, 0xe9, 0x08, 0x00, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  XX    Oo  */
0x00, 0xf0, 0xff, 0x65, 0x00, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  XX+   Oo  */
0x00, 0xf0, 0xba, 0xd7, 0x01, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  XaO   Oo  */
0x00, 0xf0, 0x64, 0xef, 0x4d, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  X+X-  Oo  */
0x00, 0xf0, 0x62, 0x88, 0xc0, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  X+oO  Oo  */
0x00, 0xf0, 0x67, 0x1a, 0xf9, 0x34, 0x00, 0xd4, 0x88, 0x00, /*  X+ X. Oo  */
0x00, 0xf0, 0x68, 0x00, 0xa0, 0xa8, 0x00, 0xd4, 0x88, 0x00, /*  X+ aa Oo  */
0x00, 0xf0, 0x68, 0x00, 0x2d, 0xfb, 0x1f, 0xd0, 0x88, 0x00, /*  X+ .X Oo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0xb9, 0x90, 0xc8, 0x88, 0x00, /*  X+  aoOo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0x45, 0xf3, 0xce, 0x88, 0x00, /*  X+  -XOo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0x00, 0xd1, 0xff, 0x88, 0x00, /*  X+   OXo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0x00, 0x5e, 0xff, 0x88, 0x00, /*  X+   -Xo  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 79 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xf0, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf7, 0xec, 0x9c, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 80 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xa0, 0xff, 0xff, 0xfc, 0xe1, 0xa7, 0x27, 0x00, 0x00, /*  aXXXXa.   */
0x00, 0xa0, 0xdf, 0x40, 0x45, 0x6d, 0xe2, 0xe7, 0x13, 0x00, /*  aO--+XX   */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x34, 0xff, 0x62, 0x00, /*  aO   .X+  */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x02, 0xfc, 0x83, 0x00, /*  aO    Xo  */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x21, 0xff, 0x6a, 0x00, /*  aO   .X+  */
0x00, 0xa0, 0xd4, 0x00, 0x0a, 0x33, 0xc2, 0xf0, 0x16, 0x00, /*  aO  .OX   */
0x00, 0xa0, 0xff, 0xff, 0xff, 0xff, 0xca, 0x34, 0x00, 0x00, /*  aXXXXO.   */
0x00, 0xa0, 0xdf, 0x40, 0x38, 0x17, 0x00, 0x00, 0x00, 0x00, /*  aO-.      */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 81 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xee, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdb, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xab, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5c, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xc7, 0x02, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf8, 0xfc, 0xeb, 0x0d, 0x00, 0x00, /*   -OXXX    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0xff, 0x68, 0x00, 0x00, /*      -X+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xa3, 0xfd, 0x6f, 0x00, /*       aX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xa0, 0x67, 0x00, /*        a+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 82 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x8c, 0xff, 0xff, 0xfb, 0xe1, 0x95, 0x12, 0x00, 0x00, /*  oXXXXo    */
0x00, 0x8c, 0xf1, 0x40, 0x4a, 0x7b, 0xf1, 0xc7, 0x01, 0x00, /*  oX--+XO   */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x00, 0x6e, 0xff, 0x30, 0x00, /*  oX   +X.  */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x00, 0x3d, 0xff, 0x49, 0x00, /*  oX   .X-  */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x00, 0x5d, 0xff, 0x28, 0x00, /*  oX   -X.  */
0x00, 0x8c, 0xec, 0x00, 0x09, 0x3f, 0xde, 0xb5, 0x00, 0x00, /*  oX  .Oa   */
0x00, 0x8c, 0xff, 0xff, 0xff, 0xff, 0x95, 0x0b, 0x00, 0x00, /*  oXXXXo    */
0x00, 0x8c, 0xf1, 0x40, 0x53, 0xfc, 0x75, 0x00, 0x00, 0x00, /*  oX--X+    */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x94, 0xf3, 0x1b, 0x00, 0x00, /*  oX  oX    */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x12, 0xed, 0xa8, 0x00, 0x00, /*  oX   Xa   */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x00, 0x6d, 0xff, 0x41, 0x00, /*  oX   +X-  */
0x00, 0x8c, 0xec, 0x00, 0x00, 0x00, 0x04, 0xd5, 0xd5, 0x05, /*  oX    OO  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 83 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4e, 0xc4, 0xee, 0xf4, 0xdb, 0x9d, 0x15, 0x00, /*   -OXXOo   */
0x00, 0x4c, 0xfe, 0x9c, 0x54, 0x58, 0x81, 0xba, 0x04, 0x00, /*  -Xo--oa   */
0x00, 0xa7, 0xc4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xac, 0xc3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0x5d, 0xff, 0x7c, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X+       */
0x00, 0x01, 0x7f, 0xfa, 0xeb, 0x8c, 0x21, 0x00, 0x00, 0x00, /*   +XXo.    */
0x00, 0x00, 0x00, 0x1c, 0x88, 0xeb, 0xfb, 0x78, 0x00, 0x00, /*     oXX+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x0a, 0x95, 0xff, 0x38, 0x00, /*       oX.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xf9, 0x74, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1a, 0xff, 0x63, 0x00, /*        X+  */
0x00, 0xb2, 0x7f, 0x56, 0x47, 0x66, 0xd5, 0xe3, 0x10, 0x00, /*  a+--+OX   */
0x00, 0x88, 0xd7, 0xf1, 0xf8, 0xdc, 0x96, 0x1b, 0x00, 0x00, /*  oOXXOo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 84 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x34, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc8, 0x00, /* .XXXXXXXO  */
0x0e, 0x48, 0x48, 0x48, 0xf4, 0xa9, 0x48, 0x48, 0x38, 0x00, /*  ---Xa--.  */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 85 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x03, 0xfc, 0x6e, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x03, 0xff, 0x72, 0x00, 0x00, 0x00, 0x00, 0xd6, 0x9e, 0x00, /*  X+    Oo  */
0x00, 0xf5, 0x89, 0x00, 0x00, 0x00, 0x00, 0xef, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0xc5, 0xd4, 0x01, 0x00, 0x00, 0x3d, 0xff, 0x55, 0x00, /*  OO   .X-  */
0x00, 0x56, 0xff, 0xb4, 0x58, 0x6b, 0xe7, 0xd5, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x60, 0xd5, 0xfa, 0xee, 0xa9, 0x1d, 0x00, 0x00, /*   +OXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 86 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x94, 0xed, 0x03, 0x00, 0x00, 0x00, 0x00, 0x5a, 0xff, 0x2e, /* oX     -X. */
0x43, 0xff, 0x3d, 0x00, 0x00, 0x00, 0x00, 0xa6, 0xdd, 0x00, /* -X.    aO  */
0x04, 0xed, 0x88, 0x00, 0x00, 0x00, 0x03, 0xed, 0x8c, 0x00, /*  Xo    Xo  */
0x00, 0xa1, 0xd4, 0x00, 0x00, 0x00, 0x3d, 0xff, 0x3a, 0x00, /*  aO   .X.  */
0x00, 0x50, 0xff, 0x1f, 0x00, 0x00, 0x88, 0xe7, 0x02, 0x00, /*  -X   oX   */
0x00, 0x09, 0xf5, 0x6b, 0x00, 0x00, 0xd4, 0x98, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x00, 0xae, 0xb6, 0x00, 0x1f, 0xff, 0x46, 0x00, 0x00, /*   aa  X-   */
0x00, 0x00, 0x5d, 0xf7, 0x0a, 0x6a, 0xf0, 0x05, 0x00, 0x00, /*   -X +X    */
0x00, 0x00, 0x11, 0xfb, 0x49, 0xb2, 0xa4, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x00, 0xbb, 0x8c, 0xf2, 0x52, 0x00, 0x00, 0x00, /*    aoX-    */
0x00, 0x00, 0x00, 0x6a, 0xeb, 0xf6, 0x0b, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0x1a, 0xfe, 0xb0, 0x00, 0x00, 0x00, 0x00, /*     Xa     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 87 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0xec, 0x67, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc9, 0x87, /* X+      Oo */
0xca, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x68, /* Oo      X+ */
0xa8, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xfa, 0x49, /* aa      X- */
0x86, 0xc8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x16, 0xff, 0x29, /* oO      X. */
0x64, 0xe8, 0x00, 0x09, 0xf8, 0xa6, 0x00, 0x30, 0xff, 0x0b, /* +X  Xa .X  */
0x42, 0xff, 0x08, 0x47, 0xd8, 0xea, 0x01, 0x49, 0xeb, 0x00, /* -X -OX -X  */
0x20, 0xff, 0x22, 0x8b, 0x88, 0xe1, 0x31, 0x64, 0xcb, 0x00, /* .X.ooX.+O  */
0x03, 0xfa, 0x3b, 0xd0, 0x48, 0xa3, 0x77, 0x7f, 0xac, 0x00, /*  X.O-a++a  */
0x00, 0xdc, 0x65, 0xf8, 0x0b, 0x5b, 0xbc, 0x9a, 0x8d, 0x00, /*  O+X -aoo  */
0x00, 0xba, 0xb2, 0xc1, 0x00, 0x14, 0xf4, 0xba, 0x6d, 0x00, /*  aaO  Xa+  */
0x00, 0x98, 0xf4, 0x7d, 0x00, 0x00, 0xc9, 0xf6, 0x4e, 0x00, /*  oX+  OX-  */
0x00, 0x75, 0xff, 0x39, 0x00, 0x00, 0x80, 0xff, 0x2f, 0x00, /*  +X.  oX.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 88 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x1a, 0xf4, 0x7f, 0x00, 0x00, 0x00, 0x05, 0xda, 0x9d, 0x00, /*  X+    Oo  */
0x00, 0x7b, 0xf4, 0x1a, 0x00, 0x00, 0x72, 0xf1, 0x17, 0x00, /*  +X   +X   */
0x00, 0x08, 0xdf, 0x9f, 0x00, 0x14, 0xef, 0x74, 0x00, 0x00, /*   Oo  X+   */
0x00, 0x00, 0x55, 0xfd, 0x30, 0x95, 0xda, 0x06, 0x00, 0x00, /*   -X.oO    */
0x00, 0x00, 0x00, 0xc1, 0xd0, 0xfb, 0x4c, 0x00, 0x00, 0x00, /*    OOX-    */
0x00, 0x00, 0x00, 0x39, 0xff, 0xc6, 0x00, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x00, 0x7b, 0xf9, 0xf5, 0x1b, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x17, 0xf3, 0x5f, 0xd9, 0xa1, 0x00, 0x00, 0x00, /*    X-Oa    */
0x00, 0x00, 0x9b, 0xcd, 0x01, 0x56, 0xfe, 0x33, 0x00, 0x00, /*   oO -X.   */
0x00, 0x2e, 0xfd, 0x42, 0x00, 0x01, 0xcc, 0xc1, 0x00, 0x00, /*  .X-  OO   */
0x00, 0xbb, 0xb6, 0x00, 0x00, 0x00, 0x45, 0xff, 0x53, 0x00, /*  aa   -X-  */
0x4c, 0xfd, 0x2c, 0x00, 0x00, 0x00, 0x00, 0xbc, 0xdc, 0x06, /* -X.    aO  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 89 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x77, 0xf9, 0x1e, 0x00, 0x00, 0x00, 0x00, 0x7e, 0xf5, 0x19, /* +X     +X  */
0x08, 0xe3, 0x9a, 0x00, 0x00, 0x00, 0x11, 0xf0, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0x61, 0xfa, 0x21, 0x00, 0x00, 0x86, 0xea, 0x0d, 0x00, /*  +X.  oX   */
0x00, 0x02, 0xd3, 0x9d, 0x00, 0x15, 0xf3, 0x6d, 0x00, 0x00, /*   Oo  X+   */
0x00, 0x00, 0x4b, 0xfb, 0x23, 0x8d, 0xdd, 0x05, 0x00, 0x00, /*   -X.oO    */
0x00, 0x00, 0x00, 0xc0, 0xb5, 0xf6, 0x57, 0x00, 0x00, 0x00, /*    OaX-    */
0x00, 0x00, 0x00, 0x36, 0xff, 0xcc, 0x01, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 90 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x08, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xa0, 0x00, /*  XXXXXXXa  */
0x02, 0x48, 0x48, 0x48, 0x48, 0x48, 0x72, 0xff, 0x5e, 0x00, /*  -----+X-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xc7, 0xba, 0x00, 0x00, /*       Oa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xf4, 0x21, 0x00, 0x00, /*      +X.   */
0x00, 0x00, 0x00, 0x00, 0x20, 0xf4, 0x70, 0x00, 0x00, 0x00, /*     .X+    */
0x00, 0x00, 0x00, 0x00, 0xb9, 0xc9, 0x02, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x00, 0x60, 0xfa, 0x2c, 0x00, 0x00, 0x00, 0x00, /*    +X.     */
0x00, 0x00, 0x17, 0xed, 0x82, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Xo      */
0x00, 0x00, 0xab, 0xd6, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, /*   aO       */
0x00, 0x50, 0xfe, 0x3a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x0e, 0xe6, 0xc2, 0x48, 0x48, 0x48, 0x48, 0x48, 0x38, 0x00, /*  XO-----.  */
0x34, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc8, 0x00, /* .XXXXXXXO  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 91 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0xc8, 0xff, 0xff, 0xff, 0x58, 0x00, 0x00, /*    OXXX-   */
0x00, 0x00, 0x00, 0xc8, 0xb3, 0x2c, 0x2c, 0x0f, 0x00, 0x00, /*    Oa..    */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xa4, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0xc8, 0xb3, 0x2c, 0x2c, 0x0f, 0x00, 0x00, /*    Oa..    */
0x00, 0x00, 0x00, 0xc8, 0xff, 0xff, 0xff, 0x58, 0x00, 0x00, /*    OXXX-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 92 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x25, 0xfe, 0x3f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X.       */
0x00, 0x00, 0xbc, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   aa       */
0x00, 0x00, 0x54, 0xf9, 0x16, 0x00, 0x00, 0x00, 0x00, 0x00, /*   -X       */
0x00, 0x00, 0x04, 0xe6, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, /*    X+      */
0x00, 0x00, 0x00, 0x83, 0xdf, 0x02, 0x00, 0x00, 0x00, 0x00, /*    oO      */
0x00, 0x00, 0x00, 0x1d, 0xfc, 0x49, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0xb2, 0xb1, 0x00, 0x00, 0x00, 0x00, /*     aa     */
0x00, 0x00, 0x00, 0x00, 0x4a, 0xfc, 0x1d, 0x00, 0x00, 0x00, /*     -X     */
0x00, 0x00, 0x00, 0x00, 0x02, 0xdf, 0x82, 0x00, 0x00, 0x00, /*      Oo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xe5, 0x04, 0x00, 0x00, /*      +X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x16, 0xfa, 0x53, 0x00, 0x00, /*       X-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xa8, 0xbb, 0x00, 0x00, /*       aa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 93 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xbc, 0xff, 0xff, 0xff, 0x64, 0x00, 0x00, 0x00, /*   aXXX+    */
0x00, 0x00, 0x20, 0x2c, 0x32, 0xff, 0x64, 0x00, 0x00, 0x00, /*   ...X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0x64, 0x00, 0x00, 0x00, /*      X+    */
0x00, 0x00, 0x20, 0x2c, 0x32, 0xff, 0x64, 0x00, 0x00, 0x00, /*   ...X+    */
0x00, 0x00, 0xbc, 0xff, 0xff, 0xff, 0x64, 0x00, 0x00, 0x00, /*   aXXX+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 94 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x16, 0xf6, 0x40, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x86, 0xdf, 0xc8, 0x00, 0x00, 0x00, 0x00, /*    oOO     */
0x00, 0x00, 0x0e, 0xee, 0x29, 0xdc, 0x52, 0x00, 0x00, 0x00, /*    X.O-    */
0x00, 0x00, 0x78, 0xaf, 0x00, 0x5b, 0xd7, 0x03, 0x00, 0x00, /*   +a -O    */
0x00, 0x08, 0xe8, 0x3b, 0x00, 0x02, 0xd3, 0x64, 0x00, 0x00, /*   X.  O+   */
0x00, 0x6a, 0xc8, 0x00, 0x00, 0x00, 0x50, 0xe4, 0x09, 0x00, /*  +O   -X   */
0x04, 0xdf, 0x55, 0x00, 0x00, 0x00, 0x00, 0xca, 0x77, 0x00, /*  O-    O+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 95 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, /*          . */
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x03, /* XXXXXXXXX  */
0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x11, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 96 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x85, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, /*    oX.     */
0x00, 0x00, 0x00, 0x08, 0xd6, 0xab, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0x22, 0xe8, 0x31, 0x00, 0x00, 0x00, /*     .X.    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 97 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 98 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa1, 0x82, 0xe8, 0xf6, 0xb3, 0x1b, 0x00, 0x00, /*  OaoXXa    */
0x00, 0xc4, 0xf2, 0xad, 0x44, 0x52, 0xe0, 0xc7, 0x00, 0x00, /*  OXa--XO   */
0x00, 0xc4, 0xe8, 0x04, 0x00, 0x00, 0x48, 0xff, 0x3b, 0x00, /*  OX   -X.  */
0x00, 0xc4, 0xb6, 0x00, 0x00, 0x00, 0x08, 0xff, 0x6a, 0x00, /*  Oa    X+  */
0x00, 0xc4, 0xaa, 0x00, 0x00, 0x00, 0x00, 0xf6, 0x80, 0x00, /*  Oa    Xo  */
0x00, 0xc4, 0xb8, 0x00, 0x00, 0x00, 0x08, 0xff, 0x68, 0x00, /*  Oa    X+  */
0x00, 0xc4, 0xec, 0x07, 0x00, 0x00, 0x49, 0xff, 0x39, 0x00, /*  OX   -X.  */
0x00, 0xc4, 0xf0, 0xb4, 0x44, 0x51, 0xe1, 0xc4, 0x00, 0x00, /*  OXa--XO   */
0x00, 0xc4, 0x66, 0x83, 0xe9, 0xf6, 0xb2, 0x1a, 0x00, 0x00, /*  O+oXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 99 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x0a, 0x88, 0xdd, 0xf9, 0xed, 0xc2, 0x1d, 0x00, /*    oOXXO   */
0x00, 0x03, 0xc1, 0xef, 0x71, 0x3c, 0x4c, 0x88, 0x02, 0x00, /*   OX+.-o   */
0x00, 0x50, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0x90, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0xa3, 0xd7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0x94, 0xee, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0x56, 0xff, 0x43, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0x05, 0xca, 0xec, 0x6a, 0x3a, 0x48, 0x86, 0x19, 0x00, /*   OX+.-o   */
0x00, 0x00, 0x0e, 0x91, 0xe2, 0xfb, 0xeb, 0xb8, 0x13, 0x00, /*    oXXXa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 100 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0b, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x52, 0xd9, 0xf8, 0xcd, 0x40, 0xfe, 0x60, 0x00, /*   -OXO-X+  */
0x00, 0x2e, 0xfd, 0xa5, 0x40, 0x5e, 0xde, 0xfd, 0x60, 0x00, /*  .Xa--OX+  */
0x00, 0x9e, 0xe2, 0x02, 0x00, 0x00, 0x58, 0xff, 0x60, 0x00, /*  oX   -X+  */
0x00, 0xce, 0xa3, 0x00, 0x00, 0x00, 0x1d, 0xff, 0x60, 0x00, /*  Oa    X+  */
0x00, 0xe4, 0x91, 0x00, 0x00, 0x00, 0x0d, 0xff, 0x60, 0x00, /*  Xo    X+  */
0x00, 0xcf, 0xa2, 0x00, 0x00, 0x00, 0x20, 0xff, 0x60, 0x00, /*  Oa   .X+  */
0x00, 0xa0, 0xe0, 0x02, 0x00, 0x00, 0x58, 0xff, 0x60, 0x00, /*  aX   -X+  */
0x00, 0x30, 0xfd, 0xa3, 0x3f, 0x5a, 0xd6, 0xfc, 0x60, 0x00, /*  .Xa.-OX+  */
0x00, 0x00, 0x55, 0xda, 0xf9, 0xcd, 0x3a, 0xd9, 0x60, 0x00, /*   -OXO.O+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 101 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2e, 0xb9, 0xf5, 0xf0, 0xa4, 0x14, 0x00, 0x00, /*   .aXXa    */
0x00, 0x22, 0xf1, 0xb2, 0x43, 0x4f, 0xd8, 0xc2, 0x00, 0x00, /*  .Xa--OO   */
0x00, 0x9b, 0xe4, 0x07, 0x00, 0x00, 0x3b, 0xff, 0x44, 0x00, /*  oX   .X-  */
0x00, 0xdc, 0xa3, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x75, 0x00, /*  Oa    X+  */
0x00, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8f, 0x00, /*  XXXXXXXo  */
0x00, 0xde, 0xa9, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1b, 0x00, /*  Oa.....   */
0x00, 0x9c, 0xd2, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x20, 0xed, 0xb0, 0x49, 0x39, 0x57, 0xa2, 0x13, 0x00, /*  .Xa-.-a   */
0x00, 0x00, 0x25, 0xaa, 0xee, 0xf8, 0xde, 0x9a, 0x0a, 0x00, /*   .aXXOo   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 102 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x45, 0xce, 0xf5, 0xf1, 0x7d, 0x00, /*     -OXX+  */
0x00, 0x00, 0x00, 0x0d, 0xee, 0xad, 0x3b, 0x48, 0x29, 0x00, /*     Xa.-.  */
0x00, 0x00, 0x00, 0x38, 0xff, 0x30, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x4e, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0xa7, 0xec, 0xff, 0xff, 0xff, 0xff, 0xff, 0x28, 0x00, /*  aXXXXXX.  */
0x00, 0x19, 0x20, 0x62, 0xff, 0x3c, 0x20, 0x20, 0x05, 0x00, /*   .+X...   */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x4c, 0xff, 0x20, 0x00, 0x00, 0x00, 0x00, /*    -X.     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 103 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xcd, 0xf7, 0xff, 0xff, 0xff, 0xbe, 0x00, /*   -OXXXXa  */
0x00, 0x26, 0xf9, 0x7a, 0x13, 0x45, 0xf7, 0x79, 0x00, 0x00, /*  .X+ -X+   */
0x00, 0x6f, 0xf2, 0x01, 0x00, 0x00, 0xaf, 0xb6, 0x00, 0x00, /*  +X   aa   */
0x00, 0x7b, 0xed, 0x00, 0x00, 0x00, 0xaa, 0xb5, 0x00, 0x00, /*  +X   aa   */
0x00, 0x32, 0xfd, 0x68, 0x07, 0x35, 0xf2, 0x67, 0x00, 0x00, /*  .X+ .X+   */
0x00, 0x00, 0x6d, 0xff, 0xf9, 0xde, 0x79, 0x01, 0x00, 0x00, /*   +XXO+    */
0x00, 0x00, 0xcc, 0x79, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   O+       */
0x00, 0x08, 0xfc, 0x5b, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X-       */
0x00, 0x02, 0xb2, 0xff, 0xff, 0xff, 0xec, 0xa6, 0x0e, 0x00, /*   aXXXXa   */
0x01, 0xba, 0xb2, 0x3d, 0x30, 0x32, 0x4b, 0xe4, 0x88, 0x00, /*  aa...-Xo  */
0x27, 0xff, 0x30, 0x00, 0x00, 0x00, 0x00, 0xbc, 0xa5, 0x00, /* .X.    aa  */
0x0a, 0xf2, 0xa5, 0x34, 0x25, 0x3b, 0x8d, 0xfe, 0x53, 0x00, /*  Xa...oX-  */
0x00, 0x39, 0xbb, 0xec, 0xfc, 0xed, 0xbd, 0x51, 0x00, 0x00, /*  .aXXXa-   */
	/* 104 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc0, 0xa7, 0x7b, 0xe4, 0xf5, 0xc9, 0x3c, 0x00, 0x00, /*  Oa+XXO.   */
0x00, 0xc0, 0xf0, 0xc8, 0x4c, 0x42, 0xc4, 0xec, 0x0e, 0x00, /*  OXO--OX   */
0x00, 0xc0, 0xf6, 0x14, 0x00, 0x00, 0x30, 0xff, 0x42, 0x00, /*  OX   .X-  */
0x00, 0xc0, 0xc3, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5a, 0x00, /*  OO    X-  */
0x00, 0xc0, 0xae, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 105 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xad, 0x93, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0xae, 0x8d, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xdc, 0xff, 0xff, 0xa8, 0x00, 0x00, 0x00, 0x00, /*   OXXa     */
0x00, 0x00, 0x01, 0x11, 0xcb, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x05, 0x14, 0xcb, 0xb1, 0x13, 0x05, 0x00, 0x00, /*     Oa     */
0x00, 0x71, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x65, 0x00, /*  +XXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 106 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0xcd, 0x70, 0x00, 0x00, 0x00, /*      O+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xcd, 0x70, 0x00, 0x00, 0x00, /*      O+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x07, 0xfb, 0xff, 0xff, 0xff, 0xac, 0x00, 0x00, 0x00, /*   XXXXa    */
0x00, 0x00, 0x00, 0x09, 0x16, 0xc7, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xc0, 0xab, 0x00, 0x00, 0x00, /*      Oa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0xd7, 0x93, 0x00, 0x00, 0x00, /*      Oo    */
0x00, 0x5a, 0x3c, 0x39, 0x8d, 0xfe, 0x42, 0x00, 0x00, 0x00, /*  -..oX-    */
0x00, 0xc6, 0xf4, 0xf6, 0xd0, 0x58, 0x00, 0x00, 0x00, 0x00, /*  OXXO-     */
	/* 107 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x50, 0xff, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X        */
0x00, 0x50, 0xff, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X        */
0x00, 0x50, 0xff, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X        */
0x00, 0x50, 0xff, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X        */
0x00, 0x50, 0xff, 0x18, 0x00, 0x00, 0x58, 0xfb, 0x63, 0x00, /*  -X   -X+  */
0x00, 0x50, 0xff, 0x18, 0x00, 0x4f, 0xfa, 0x68, 0x00, 0x00, /*  -X  -X+   */
0x00, 0x50, 0xff, 0x11, 0x46, 0xf8, 0x6d, 0x00, 0x00, 0x00, /*  -X -X+    */
0x00, 0x50, 0xff, 0x3b, 0xf6, 0x72, 0x00, 0x00, 0x00, 0x00, /*  -X.X+     */
0x00, 0x50, 0xfd, 0xe7, 0xfc, 0x77, 0x00, 0x00, 0x00, 0x00, /*  -XXX+     */
0x00, 0x50, 0xff, 0x50, 0x67, 0xfd, 0x48, 0x00, 0x00, 0x00, /*  -X-+X-    */
0x00, 0x50, 0xff, 0x18, 0x00, 0x99, 0xef, 0x24, 0x00, 0x00, /*  -X  oX.   */
0x00, 0x50, 0xff, 0x18, 0x00, 0x05, 0xc4, 0xd5, 0x0c, 0x00, /*  -X   OO   */
0x00, 0x50, 0xff, 0x18, 0x00, 0x00, 0x17, 0xe3, 0xae, 0x01, /*  -X    Xa  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 108 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xec, 0xff, 0xff, 0x98, 0x00, 0x00, 0x00, 0x00, /*   XXXo     */
0x00, 0x00, 0x01, 0x12, 0xdc, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x00, 0x00, 0xd8, 0x98, 0x00, 0x00, 0x00, 0x00, /*     Oo     */
0x00, 0x00, 0x06, 0x15, 0xdc, 0xa3, 0x12, 0x04, 0x00, 0x00, /*     Oa     */
0x00, 0x85, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x55, 0x00, /*  oXXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 109 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x48, 0xca, 0x6f, 0xf4, 0xa6, 0x2a, 0xdd, 0xe2, 0x39, 0x00, /* -O+Xa.OX.  */
0x48, 0xf6, 0x8e, 0x5c, 0xff, 0xcd, 0x49, 0xbc, 0xb8, 0x00, /* -Xo-XO-aa  */
0x48, 0xff, 0x1a, 0x00, 0xe1, 0x96, 0x00, 0x69, 0xde, 0x00, /* -X  Xo +O  */
0x48, 0xff, 0x02, 0x00, 0xd0, 0x78, 0x00, 0x5c, 0xe7, 0x00, /* -X  O+ -X  */
0x48, 0xfc, 0x00, 0x00, 0xd0, 0x70, 0x00, 0x5c, 0xe8, 0x00, /* -X  O+ -X  */
0x48, 0xfc, 0x00, 0x00, 0xd0, 0x70, 0x00, 0x5c, 0xe8, 0x00, /* -X  O+ -X  */
0x48, 0xfc, 0x00, 0x00, 0xd0, 0x70, 0x00, 0x5c, 0xe8, 0x00, /* -X  O+ -X  */
0x48, 0xfc, 0x00, 0x00, 0xd0, 0x70, 0x00, 0x5c, 0xe8, 0x00, /* -X  O+ -X  */
0x48, 0xfc, 0x00, 0x00, 0xd0, 0x70, 0x00, 0x5c, 0xe8, 0x00, /* -X  O+ -X  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 110 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0x7b, 0x79, 0xe3, 0xf5, 0xc9, 0x3c, 0x00, 0x00, /*  O++XXO.   */
0x00, 0xc0, 0xec, 0xc8, 0x4c, 0x42, 0xc4, 0xec, 0x0e, 0x00, /*  OXO--OX   */
0x00, 0xc0, 0xf6, 0x14, 0x00, 0x00, 0x30, 0xff, 0x42, 0x00, /*  OX   .X-  */
0x00, 0xc0, 0xc3, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5a, 0x00, /*  OO    X-  */
0x00, 0xc0, 0xae, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 111 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x45, 0xc8, 0xf7, 0xea, 0x96, 0x0d, 0x00, 0x00, /*   -OXXo    */
0x00, 0x42, 0xfc, 0x9b, 0x40, 0x55, 0xdb, 0xc2, 0x03, 0x00, /*  -Xo--OO   */
0x00, 0xc4, 0xc2, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x54, 0x00, /*  OO   .X-  */
0x06, 0xfc, 0x79, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x14, 0xff, 0x66, 0x00, 0x00, 0x00, 0x00, 0xcf, 0xab, 0x00, /*  X+    Oa  */
0x05, 0xfb, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x00, 0xbe, 0xc4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x57, 0x00, /*  aO   .X-  */
0x00, 0x3a, 0xfa, 0x9c, 0x40, 0x54, 0xdb, 0xca, 0x04, 0x00, /*  .Xo--OO   */
0x00, 0x00, 0x3f, 0xc6, 0xf8, 0xeb, 0x9b, 0x11, 0x00, 0x00, /*   .OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 112 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc4, 0x77, 0x7e, 0xe7, 0xf6, 0xb3, 0x1b, 0x00, 0x00, /*  O++XXa    */
0x00, 0xc4, 0xed, 0xac, 0x43, 0x52, 0xe0, 0xc7, 0x00, 0x00, /*  OXa--XO   */
0x00, 0xc4, 0xea, 0x07, 0x00, 0x00, 0x48, 0xff, 0x3b, 0x00, /*  OX   -X.  */
0x00, 0xc4, 0xba, 0x00, 0x00, 0x00, 0x08, 0xff, 0x6a, 0x00, /*  Oa    X+  */
0x00, 0xc4, 0xa9, 0x00, 0x00, 0x00, 0x00, 0xf6, 0x80, 0x00, /*  Oa    Xo  */
0x00, 0xc4, 0xb8, 0x00, 0x00, 0x00, 0x08, 0xff, 0x68, 0x00, /*  Oa    X+  */
0x00, 0xc4, 0xec, 0x07, 0x00, 0x00, 0x49, 0xff, 0x39, 0x00, /*  OX   -X.  */
0x00, 0xc4, 0xf3, 0xb4, 0x44, 0x51, 0xe1, 0xc4, 0x00, 0x00, /*  OXa--XO   */
0x00, 0xc4, 0xa0, 0x83, 0xe9, 0xf6, 0xb2, 0x1a, 0x00, 0x00, /*  OaoXXa    */
0x00, 0xc4, 0xa7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
	/* 113 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x52, 0xd9, 0xf8, 0xcc, 0x37, 0xda, 0x60, 0x00, /*   -OXO.O+  */
0x00, 0x2e, 0xfd, 0xa5, 0x40, 0x5e, 0xda, 0xfc, 0x60, 0x00, /*  .Xa--OX+  */
0x00, 0x9e, 0xe2, 0x02, 0x00, 0x00, 0x58, 0xff, 0x60, 0x00, /*  oX   -X+  */
0x00, 0xce, 0xa3, 0x00, 0x00, 0x00, 0x1d, 0xff, 0x60, 0x00, /*  Oa    X+  */
0x00, 0xe4, 0x91, 0x00, 0x00, 0x00, 0x0d, 0xff, 0x60, 0x00, /*  Xo    X+  */
0x00, 0xcf, 0xa2, 0x00, 0x00, 0x00, 0x20, 0xff, 0x60, 0x00, /*  Oa   .X+  */
0x00, 0xa0, 0xe0, 0x02, 0x00, 0x00, 0x58, 0xff, 0x60, 0x00, /*  aX   -X+  */
0x00, 0x30, 0xfd, 0xa3, 0x3f, 0x5a, 0xd6, 0xfd, 0x60, 0x00, /*  .Xa.-OX+  */
0x00, 0x00, 0x55, 0xda, 0xf9, 0xcd, 0x3e, 0xff, 0x60, 0x00, /*   -OXO.X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0b, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0x60, 0x00, /*        X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0x60, 0x00, /*        X+  */
	/* 114 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xf0, 0x43, 0x61, 0xdc, 0xf9, 0xdb, 0x21, 0x00, /*   X-+OXO.  */
0x00, 0x00, 0xf0, 0xb1, 0xba, 0x4c, 0x3d, 0x79, 0x02, 0x00, /*   Xaa-.+   */
0x00, 0x00, 0xf0, 0xd9, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, /*   XO       */
0x00, 0x00, 0xf0, 0x91, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   Xo       */
0x00, 0x00, 0xf0, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X+       */
0x00, 0x00, 0xf0, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X+       */
0x00, 0x00, 0xf0, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X+       */
0x00, 0x00, 0xf0, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X+       */
0x00, 0x00, 0xf0, 0x7c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   X+       */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 115 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x42, 0xc3, 0xf0, 0xf3, 0xd3, 0x73, 0x00, 0x00, /*   -OXXO+   */
0x00, 0x18, 0xf7, 0x92, 0x39, 0x42, 0x74, 0x61, 0x00, 0x00, /*   Xo.-++   */
0x00, 0x3b, 0xff, 0x2d, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .X.       */
0x00, 0x07, 0xd9, 0xe7, 0x78, 0x19, 0x00, 0x00, 0x00, 0x00, /*   OX+      */
0x00, 0x00, 0x0e, 0x81, 0xe8, 0xfb, 0xa2, 0x14, 0x00, 0x00, /*    oXXa    */
0x00, 0x00, 0x00, 0x00, 0x05, 0x5c, 0xe8, 0xbd, 0x00, 0x00, /*      -Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xf6, 0x00, 0x00, /*       +X   */
0x00, 0x50, 0x8a, 0x4d, 0x36, 0x51, 0xd5, 0xb7, 0x00, 0x00, /*  -o-.-Oa   */
0x00, 0x36, 0xc0, 0xeb, 0xfa, 0xe3, 0x9a, 0x14, 0x00, 0x00, /*  .OXXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 116 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x13, 0x2d, 0x00, 0x00, 0x00, 0x00, 0x00, /*     .      */
0x00, 0x00, 0x00, 0x6f, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, /*    +o      */
0x00, 0x00, 0x00, 0xb5, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, /*    ao      */
0x00, 0xae, 0xec, 0xff, 0xff, 0xff, 0xff, 0xff, 0x04, 0x00, /*  aXXXXXX   */
0x00, 0x1d, 0x20, 0xd9, 0xa5, 0x20, 0x20, 0x20, 0x00, 0x00, /*   .Oa...   */
0x00, 0x00, 0x00, 0xd4, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oo      */
0x00, 0x00, 0x00, 0xd4, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oo      */
0x00, 0x00, 0x00, 0xd4, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oo      */
0x00, 0x00, 0x00, 0xd4, 0x98, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oo      */
0x00, 0x00, 0x00, 0xc9, 0xa2, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Oa      */
0x00, 0x00, 0x00, 0x92, 0xef, 0x51, 0x34, 0x44, 0x00, 0x00, /*    oX-.-   */
0x00, 0x00, 0x00, 0x12, 0xa9, 0xee, 0xf0, 0xc9, 0x00, 0x00, /*     aXXO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 117 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xbf, 0xad, 0x00, 0x00, 0x00, 0x27, 0xff, 0x5c, 0x00, /*  aa   .X-  */
0x00, 0xa7, 0xcb, 0x00, 0x00, 0x00, 0x65, 0xff, 0x5c, 0x00, /*  aO   +X-  */
0x00, 0x5f, 0xff, 0x7d, 0x3a, 0x66, 0xdc, 0xfd, 0x5c, 0x00, /*  -X+.+OX-  */
0x00, 0x01, 0x7f, 0xe2, 0xf8, 0xc9, 0x36, 0xdd, 0x5c, 0x00, /*   +XXO.O-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 118 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x2e, 0xff, 0x48, 0x00, 0x00, 0x00, 0x00, 0xb5, 0xc5, 0x00, /* .X-    aO  */
0x00, 0xd2, 0xa2, 0x00, 0x00, 0x00, 0x13, 0xfa, 0x69, 0x00, /*  Oa    X+  */
0x00, 0x75, 0xf2, 0x09, 0x00, 0x00, 0x67, 0xf9, 0x12, 0x00, /*  +X   +X   */
0x00, 0x1b, 0xfd, 0x56, 0x00, 0x00, 0xc0, 0xb0, 0x00, 0x00, /*   X-  Oa   */
0x00, 0x00, 0xbc, 0xb0, 0x00, 0x1b, 0xfd, 0x53, 0x00, 0x00, /*   aa  X-   */
0x00, 0x00, 0x60, 0xf9, 0x10, 0x70, 0xef, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0x0d, 0xf6, 0x5e, 0xc1, 0x9a, 0x00, 0x00, 0x00, /*    X-Oo    */
0x00, 0x00, 0x00, 0xa7, 0xb7, 0xfc, 0x3e, 0x00, 0x00, 0x00, /*    aaX.    */
0x00, 0x00, 0x00, 0x4a, 0xff, 0xe0, 0x01, 0x00, 0x00, 0x00, /*    -XX     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 119 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0xee, 0x51, 0x00, 0x0e, 0xfd, 0xae, 0x00, 0x00, 0xaf, 0x00, /* X-  Xa  a  */
0xbe, 0x7e, 0x00, 0x44, 0xe7, 0xe5, 0x00, 0x00, 0xdd, 0x00, /* a+ -XX  O  */
0x8c, 0xaa, 0x00, 0x7c, 0x91, 0xf8, 0x1b, 0x0c, 0xfe, 0x00, /* oa +oX  X  */
0x5a, 0xd6, 0x00, 0xb4, 0x5d, 0xcb, 0x51, 0x39, 0xf2, 0x00, /* -O a-O-.X  */
0x28, 0xfb, 0x05, 0xea, 0x2b, 0x96, 0x86, 0x65, 0xc1, 0x00, /* .X X.oo+O  */
0x02, 0xf4, 0x41, 0xf1, 0x02, 0x61, 0xb5, 0x8f, 0x8f, 0x00, /*  X-X +aoo  */
0x00, 0xc5, 0x93, 0xbb, 0x00, 0x2b, 0xe2, 0xb4, 0x5d, 0x00, /*  Ooa .Xa-  */
0x00, 0x93, 0xe5, 0x83, 0x00, 0x02, 0xf2, 0xe6, 0x2b, 0x00, /*  oXo  XX.  */
0x00, 0x61, 0xff, 0x4b, 0x00, 0x00, 0xbf, 0xf5, 0x03, 0x00, /*  +X-  aX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 120 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x01, 0xb9, 0xd5, 0x07, 0x00, 0x00, 0x43, 0xfe, 0x56, 0x00, /*  aO   -X-  */
0x00, 0x1a, 0xed, 0x8a, 0x00, 0x0e, 0xe1, 0xa2, 0x00, 0x00, /*   Xo  Xa   */
0x00, 0x00, 0x55, 0xfd, 0x39, 0x9f, 0xe0, 0x0e, 0x00, 0x00, /*   -X.oX    */
0x00, 0x00, 0x00, 0xa3, 0xe9, 0xfd, 0x3e, 0x00, 0x00, 0x00, /*    aXX.    */
0x00, 0x00, 0x00, 0x33, 0xff, 0xca, 0x00, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x03, 0xc7, 0xcc, 0xf9, 0x61, 0x00, 0x00, 0x00, /*    OOX+    */
0x00, 0x00, 0x7f, 0xf2, 0x1e, 0x79, 0xf2, 0x21, 0x00, 0x00, /*   +X +X.   */
0x00, 0x37, 0xfb, 0x63, 0x00, 0x03, 0xc9, 0xc4, 0x03, 0x00, /*  .X+  OO   */
0x0b, 0xda, 0xb6, 0x00, 0x00, 0x00, 0x28, 0xf7, 0x7a, 0x00, /*  Oa   .X+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 121 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x2a, 0xff, 0x4c, 0x00, 0x00, 0x00, 0x00, 0xb5, 0xc4, 0x00, /* .X-    aO  */
0x00, 0xc4, 0xaf, 0x00, 0x00, 0x00, 0x13, 0xfa, 0x67, 0x00, /*  Oa    X+  */
0x00, 0x5e, 0xfb, 0x17, 0x00, 0x00, 0x69, 0xf8, 0x10, 0x00, /*  -X   +X   */
0x00, 0x09, 0xee, 0x74, 0x00, 0x00, 0xc3, 0xab, 0x00, 0x00, /*   X+  Oa   */
0x00, 0x00, 0x92, 0xd7, 0x00, 0x1e, 0xfe, 0x4d, 0x00, 0x00, /*   oO  X-   */
0x00, 0x00, 0x2d, 0xff, 0x38, 0x75, 0xea, 0x04, 0x00, 0x00, /*   .X.+X    */
0x00, 0x00, 0x00, 0xc7, 0x90, 0xc9, 0x91, 0x00, 0x00, 0x00, /*    OoOo    */
0x00, 0x00, 0x00, 0x61, 0xdf, 0xfd, 0x33, 0x00, 0x00, 0x00, /*    +OX.    */
0x00, 0x00, 0x00, 0x0a, 0xf0, 0xd5, 0x00, 0x00, 0x00, 0x00, /*     XO     */
0x00, 0x00, 0x00, 0x06, 0xef, 0x78, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x5a, 0xf9, 0x18, 0x00, 0x00, 0x00, 0x00, /*    -X      */
0x0e, 0x36, 0x51, 0xe6, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .-Xo      */
0x30, 0xf0, 0xef, 0x9c, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, /* .XXo       */
	/* 122 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x50, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x04, 0x00, /*  -XXXXXX   */
0x00, 0x0a, 0x20, 0x20, 0x20, 0x21, 0xc7, 0xc5, 0x00, 0x00, /*   ....OO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x75, 0xec, 0x1c, 0x00, 0x00, /*      +X    */
0x00, 0x00, 0x00, 0x00, 0x3a, 0xf9, 0x49, 0x00, 0x00, 0x00, /*     .X-    */
0x00, 0x00, 0x00, 0x13, 0xe3, 0x85, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x01, 0xb6, 0xc0, 0x03, 0x00, 0x00, 0x00, 0x00, /*    aO      */
0x00, 0x00, 0x79, 0xe8, 0x19, 0x00, 0x00, 0x00, 0x00, 0x00, /*   +X       */
0x00, 0x3d, 0xfb, 0x63, 0x20, 0x20, 0x20, 0x20, 0x05, 0x00, /*  .X+....   */
0x00, 0x94, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x28, 0x00, /*  oXXXXXX.  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 123 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x6d, 0xd3, 0xc9, 0x00, 0x00, /*      +OO   */
0x00, 0x00, 0x00, 0x00, 0x56, 0xfe, 0x73, 0x2d, 0x00, 0x00, /*     -X+.   */
0x00, 0x00, 0x00, 0x00, 0x91, 0xda, 0x00, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x00, 0xa3, 0xcd, 0x00, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x10, 0x56, 0xf3, 0x88, 0x00, 0x00, 0x00, 0x00, /*    -Xo     */
0x00, 0x3c, 0xff, 0xff, 0x8f, 0x02, 0x00, 0x00, 0x00, 0x00, /*  .XXo      */
0x00, 0x0b, 0x3d, 0x80, 0xfb, 0x6b, 0x00, 0x00, 0x00, 0x00, /*   .oX+     */
0x00, 0x00, 0x00, 0x00, 0xa9, 0xc9, 0x00, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x00, 0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x00, 0x92, 0xd9, 0x00, 0x00, 0x00, 0x00, /*     oO     */
0x00, 0x00, 0x00, 0x00, 0x5a, 0xfd, 0x70, 0x2c, 0x00, 0x00, /*     -X+.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xd5, 0xca, 0x00, 0x00, /*      +OO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 124 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
	/* 125 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x37, 0xea, 0xb6, 0x32, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .Xa.      */
0x00, 0x0a, 0x41, 0xb7, 0xea, 0x06, 0x00, 0x00, 0x00, 0x00, /*   -aX      */
0x00, 0x00, 0x00, 0x3e, 0xff, 0x2d, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x38, 0xff, 0x34, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x38, 0xff, 0x34, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x31, 0xff, 0x3f, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x09, 0xe4, 0xbe, 0x2f, 0x07, 0x00, 0x00, /*     Xa.    */
0x00, 0x00, 0x00, 0x00, 0x24, 0xd2, 0xff, 0xd8, 0x00, 0x00, /*     .OXO   */
0x00, 0x00, 0x00, 0x03, 0xcb, 0xd7, 0x5a, 0x2d, 0x00, 0x00, /*     OO-.   */
0x00, 0x00, 0x00, 0x2e, 0xff, 0x45, 0x00, 0x00, 0x00, 0x00, /*    .X-     */
0x00, 0x00, 0x00, 0x38, 0xff, 0x34, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x38, 0xff, 0x34, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x00, 0x00, 0x3e, 0xff, 0x2e, 0x00, 0x00, 0x00, 0x00, /*    .X.     */
0x00, 0x0a, 0x3d, 0xb2, 0xed, 0x07, 0x00, 0x00, 0x00, 0x00, /*   .aX      */
0x00, 0x37, 0xeb, 0xb8, 0x35, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .Xa.      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 126 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3b, 0xdc, 0xe4, 0x6a, 0x00, 0x00, 0x08, 0x45, 0x00, /*  .OX+   -  */
0x00, 0xc6, 0x60, 0x5f, 0xea, 0xb6, 0x40, 0xac, 0x63, 0x00, /*  O+-Xa-a+  */
0x00, 0x4c, 0x00, 0x00, 0x17, 0xa9, 0xf3, 0xac, 0x09, 0x00, /*  -   aXa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 127 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 128 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 129 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 130 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 131 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 132 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 133 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 134 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 135 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 136 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 137 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 138 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 139 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 140 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 141 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 142 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 143 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 144 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 145 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 146 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 147 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 148 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 149 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 150 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 151 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 152 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 153 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 154 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 155 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 156 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 157 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 158 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 159 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0x54, 0x00, 0x00, 0x00, 0x00, 0xbc, 0x14, 0x00, /*  +-    a   */
0x00, 0x7c, 0xdf, 0xd0, 0xd0, 0xd0, 0xd0, 0xf3, 0x14, 0x00, /*  +OOOOOX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 160 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 161 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x0d, 0xe0, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x0d, 0xe1, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xb2, 0x49, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0xbe, 0x55, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0xc9, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xd5, 0x6c, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xe0, 0x77, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x00, 0xec, 0x83, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf7, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x03, 0xff, 0x9a, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x0e, 0xff, 0xa6, 0x00, 0x00, 0x00, 0x00, /*     Xa     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 162 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x44, 0xd2, 0x02, 0x00, 0x00, 0x00, /*     -O     */
0x00, 0x00, 0x0b, 0x8f, 0xe8, 0xff, 0xfc, 0xd2, 0x1e, 0x00, /*    oXXXO   */
0x00, 0x01, 0xc6, 0xef, 0x71, 0x3c, 0x49, 0x7e, 0x01, 0x00, /*   OX+.-+   */
0x00, 0x4f, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0x89, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0xa0, 0xd7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0x89, 0xee, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0x50, 0xff, 0x43, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0x01, 0xc5, 0xec, 0x6a, 0x39, 0x46, 0x7d, 0x17, 0x00, /*   OX+.-+   */
0x00, 0x00, 0x0a, 0x89, 0xe1, 0xff, 0xf0, 0xbf, 0x14, 0x00, /*    oXXXa   */
0x00, 0x00, 0x00, 0x00, 0x44, 0xd0, 0x00, 0x00, 0x00, 0x00, /*     -O     */
0x00, 0x00, 0x00, 0x00, 0x44, 0xd0, 0x00, 0x00, 0x00, 0x00, /*     -O     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 163 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x51, 0xd0, 0xf6, 0xe6, 0xac, 0x1a, 0x00, /*    -OXXa   */
0x00, 0x00, 0x32, 0xfc, 0x98, 0x3a, 0x4f, 0x95, 0x05, 0x00, /*   .Xo.-o   */
0x00, 0x00, 0x75, 0xf9, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, /*   +X       */
0x00, 0x00, 0x80, 0xec, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX       */
0x00, 0x00, 0x80, 0xec, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX       */
0x0c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x00, 0x00, /*  XXXXXX    */
0x01, 0x20, 0x90, 0xee, 0x20, 0x20, 0x1c, 0x00, 0x00, 0x00, /*  .oX..     */
0x00, 0x00, 0x80, 0xec, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX       */
0x00, 0x00, 0x88, 0xe4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   oX       */
0x00, 0x00, 0xb7, 0xb7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   aa       */
0x01, 0x6c, 0xfb, 0x61, 0x30, 0x30, 0x30, 0x30, 0x20, 0x00, /*  +X+.....  */
0x10, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xac, 0x00, /*  XXXXXXXa  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 164 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x0f, 0x2a, 0x00, 0x00, 0x00, 0x00, 0x3b, 0x00, 0x00, /*   .    .   */
0x00, 0x5a, 0xe9, 0xa7, 0xf1, 0xdd, 0xa7, 0xe3, 0x0f, 0x00, /*  -XaXOaX   */
0x00, 0x00, 0xc9, 0xbc, 0x3d, 0x5b, 0xed, 0x65, 0x00, 0x00, /*   Oa.-X+   */
0x00, 0x10, 0xfc, 0x11, 0x00, 0x00, 0x6c, 0xaf, 0x00, 0x00, /*   X   +a   */
0x00, 0x11, 0xfc, 0x10, 0x00, 0x00, 0x6a, 0xb1, 0x00, 0x00, /*   X   +a   */
0x00, 0x00, 0xca, 0xba, 0x3c, 0x5a, 0xeb, 0x66, 0x00, 0x00, /*   Oa.-X+   */
0x00, 0x56, 0xe8, 0xa8, 0xf2, 0xdf, 0xaa, 0xe1, 0x0d, 0x00, /*  -XaXOaX   */
0x00, 0x0e, 0x26, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, /*   .    .   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 165 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x28, 0xfd, 0x56, 0x00, 0x00, 0x00, 0x00, 0xc1, 0xbb, 0x00, /* .X-    Oa  */
0x00, 0xa6, 0xcd, 0x00, 0x00, 0x00, 0x38, 0xff, 0x3b, 0x00, /*  aO   .X.  */
0x00, 0x29, 0xfd, 0x44, 0x00, 0x00, 0xb1, 0xb9, 0x00, 0x00, /*  .X-  aa   */
0x00, 0x00, 0xa9, 0xba, 0x00, 0x2a, 0xfe, 0x39, 0x00, 0x00, /*   aa .X.   */
0x00, 0x00, 0x2c, 0xfd, 0x32, 0xa1, 0xb8, 0x00, 0x00, 0x00, /*   .X.aa    */
0x00, 0x00, 0x00, 0xab, 0xbf, 0xfa, 0x38, 0x00, 0x00, 0x00, /*    aaX.    */
0x00, 0x40, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd8, 0x00, 0x00, /*  -XXXXXO   */
0x00, 0x05, 0x14, 0x14, 0xe9, 0x86, 0x14, 0x10, 0x00, 0x00, /*     Xo     */
0x00, 0x05, 0x14, 0x14, 0xe9, 0x86, 0x14, 0x10, 0x00, 0x00, /*     Xo     */
0x00, 0x40, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd8, 0x00, 0x00, /*  -XXXXXO   */
0x00, 0x00, 0x00, 0x00, 0xe8, 0x7c, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x00, 0xe8, 0x7c, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 166 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
	/* 167 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x22, 0xb2, 0xef, 0xf2, 0xc7, 0x42, 0x00, 0x00, /*   .aXXO-   */
0x00, 0x00, 0xc8, 0xb6, 0x2e, 0x32, 0x71, 0x2a, 0x00, 0x00, /*   Oa..+.   */
0x00, 0x00, 0xea, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   Xo       */
0x00, 0x00, 0x79, 0xfe, 0xa6, 0x29, 0x00, 0x00, 0x00, 0x00, /*   +Xa.     */
0x00, 0x00, 0x3c, 0xe8, 0xc6, 0xfd, 0x98, 0x06, 0x00, 0x00, /*   .XOXo    */
0x00, 0x00, 0xd3, 0x63, 0x00, 0x40, 0xf1, 0x75, 0x00, 0x00, /*   O+ -X+   */
0x00, 0x00, 0xed, 0x57, 0x00, 0x00, 0x98, 0xab, 0x00, 0x00, /*   X-  oa   */
0x00, 0x00, 0xa5, 0xe8, 0x50, 0x06, 0xcd, 0x80, 0x00, 0x00, /*   aX- Oo   */
0x00, 0x00, 0x0b, 0x93, 0xf9, 0xec, 0xda, 0x0b, 0x00, 0x00, /*    oXXO    */
0x00, 0x00, 0x00, 0x00, 0x1c, 0x9a, 0xff, 0x60, 0x00, 0x00, /*      oX+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc3, 0xa8, 0x00, 0x00, /*       Oa   */
0x00, 0x11, 0x89, 0x3f, 0x26, 0x4e, 0xee, 0x6f, 0x00, 0x00, /*   o..-X+   */
0x00, 0x0c, 0xb2, 0xea, 0xf9, 0xdd, 0x7d, 0x02, 0x00, 0x00, /*   aXXO+    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 168 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x42, 0xda, 0x03, 0x4f, 0xcf, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x42, 0xda, 0x03, 0x50, 0xcf, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 169 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x63, 0xcc, 0xdb, 0xdd, 0xae, 0x2b, 0x00, 0x00, /*   +OOOa.   */
0x00, 0x8b, 0xa6, 0x18, 0x00, 0x01, 0x42, 0xd4, 0x32, 0x00, /*  oa   -O.  */
0x36, 0xbf, 0x02, 0x00, 0x00, 0x00, 0x00, 0x2c, 0xca, 0x00, /* .a     .O  */
0x9b, 0x48, 0x0f, 0x99, 0xe6, 0xf4, 0xbc, 0x06, 0xad, 0x36, /* o- oXXa a. */
0xd2, 0x0b, 0xa8, 0xc8, 0x2f, 0x1e, 0x47, 0x00, 0x6e, 0x6f, /* O aO. - ++ */
0xdb, 0x03, 0xf7, 0x45, 0x00, 0x00, 0x00, 0x00, 0x53, 0x87, /* O X-    -o */
0xdb, 0x02, 0xf7, 0x43, 0x00, 0x00, 0x00, 0x00, 0x54, 0x87, /* O X-    -o */
0xd2, 0x0b, 0xad, 0xc2, 0x2c, 0x1a, 0x3e, 0x00, 0x6e, 0x6f, /* O aO. . ++ */
0x9c, 0x48, 0x13, 0xa1, 0xe9, 0xf4, 0x9f, 0x00, 0xad, 0x37, /* o- aXXo a. */
0x38, 0xbd, 0x01, 0x00, 0x00, 0x00, 0x00, 0x2c, 0xcc, 0x00, /* .a     .O  */
0x00, 0x8e, 0xa3, 0x17, 0x00, 0x00, 0x41, 0xd5, 0x35, 0x00, /*  oa   -O.  */
0x00, 0x01, 0x66, 0xcd, 0xdb, 0xdd, 0xaf, 0x2c, 0x00, 0x00, /*   +OOOa.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 170 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3b, 0xd3, 0xe8, 0xe2, 0x58, 0x00, 0x00, 0x00, /*   .OXX-    */
0x00, 0x00, 0x0f, 0x1e, 0x00, 0x5b, 0xf1, 0x02, 0x00, 0x00, /*      -X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x14, 0xff, 0x18, 0x00, 0x00, /*       X    */
0x00, 0x00, 0x28, 0xb3, 0xe0, 0xe6, 0xff, 0x1c, 0x00, 0x00, /*   .aXXX    */
0x00, 0x00, 0xb9, 0x9c, 0x07, 0x1b, 0xff, 0x1c, 0x00, 0x00, /*   ao  X    */
0x00, 0x00, 0xca, 0x76, 0x03, 0x93, 0xff, 0x1c, 0x00, 0x00, /*   O+ oX    */
0x00, 0x00, 0x59, 0xee, 0xdf, 0x67, 0xe0, 0x1c, 0x00, 0x00, /*   -XO+X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 171 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x63, 0x8a, 0x00, 0x3a, 0xb2, 0x00, 0x00, /*    +o .a   */
0x00, 0x00, 0x25, 0xf4, 0x51, 0x0e, 0xdf, 0x7d, 0x00, 0x00, /*   .X- O+   */
0x00, 0x04, 0xca, 0xaa, 0x00, 0xa4, 0xd3, 0x05, 0x00, 0x00, /*   Oa aO    */
0x00, 0x58, 0xff, 0x2d, 0x2c, 0xff, 0x5d, 0x00, 0x00, 0x00, /*  -X..X-    */
0x00, 0x06, 0xcd, 0xaa, 0x00, 0xa7, 0xd2, 0x05, 0x00, 0x00, /*   Oa aO    */
0x00, 0x00, 0x27, 0xf4, 0x50, 0x0f, 0xe0, 0x7d, 0x00, 0x00, /*   .X- X+   */
0x00, 0x00, 0x00, 0x63, 0x8b, 0x00, 0x3b, 0xb2, 0x00, 0x00, /*    +o .a   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 172 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x23, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0xce, 0x68, 0x00, /*  ......O+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc4, 0x68, 0x00, /*        O+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc4, 0x68, 0x00, /*        O+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 173 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xc4, 0xff, 0xff, 0xff, 0xff, 0x60, 0x00, 0x00, /*   OXXXX+   */
0x00, 0x00, 0x3d, 0x50, 0x50, 0x50, 0x50, 0x1e, 0x00, 0x00, /*   .----    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 174 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x63, 0xcc, 0xdb, 0xdd, 0xae, 0x2b, 0x00, 0x00, /*   +OOOa.   */
0x00, 0x8b, 0xa6, 0x18, 0x00, 0x01, 0x42, 0xd4, 0x32, 0x00, /*  oa   -O.  */
0x36, 0xbf, 0x02, 0x00, 0x00, 0x00, 0x00, 0x2c, 0xca, 0x00, /* .a     .O  */
0x9b, 0x48, 0x48, 0xff, 0xfc, 0xdf, 0x61, 0x00, 0xad, 0x36, /* o--XXO+ a. */
0xd2, 0x0b, 0x48, 0xf4, 0x12, 0x68, 0xfa, 0x07, 0x6e, 0x6f, /* O -X +X ++ */
0xdb, 0x00, 0x48, 0xf4, 0x12, 0x70, 0xf2, 0x06, 0x53, 0x87, /* O -X +X -o */
0xdb, 0x00, 0x48, 0xff, 0xff, 0xfa, 0x43, 0x00, 0x54, 0x87, /* O -XXX- -o */
0xd2, 0x0b, 0x48, 0xf4, 0x0f, 0xd9, 0x81, 0x00, 0x6e, 0x6f, /* O -X Oo ++ */
0x9c, 0x48, 0x48, 0xf4, 0x00, 0x27, 0xef, 0x4f, 0xad, 0x37, /* o--X .X-a. */
0x38, 0xbd, 0x01, 0x00, 0x00, 0x00, 0x00, 0x2c, 0xcc, 0x00, /* .a     .O  */
0x00, 0x8e, 0xa3, 0x17, 0x00, 0x00, 0x41, 0xd5, 0x35, 0x00, /*  oa   -O.  */
0x00, 0x01, 0x66, 0xcd, 0xdb, 0xdd, 0xaf, 0x2c, 0x00, 0x00, /*   +OOOa.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 175 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, /*            */
0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x28, /*          . */
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xc4, /* XXXXXXXXXO */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 176 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x78, 0xe9, 0xcf, 0x2d, 0x00, 0x00, 0x00, /*    +XO.    */
0x00, 0x00, 0x45, 0xcd, 0x11, 0x48, 0xd8, 0x04, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x94, 0x61, 0x00, 0x00, 0xc6, 0x2e, 0x00, 0x00, /*   o+  O.   */
0x00, 0x00, 0x94, 0x5e, 0x00, 0x00, 0xc3, 0x2f, 0x00, 0x00, /*   o-  O.   */
0x00, 0x00, 0x47, 0xcb, 0x10, 0x45, 0xda, 0x05, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x00, 0x7a, 0xe9, 0xd1, 0x30, 0x00, 0x00, 0x00, /*    +XO.    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 177 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x23, 0x2c, 0x2c, 0xd1, 0x7b, 0x2c, 0x2c, 0x11, 0x00, /*  ...O+..   */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0xc8, 0x60, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x23, 0x2c, 0x2c, 0x51, 0x3e, 0x2c, 0x2c, 0x11, 0x00, /*  ...-...   */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 178 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x0b, 0xa4, 0xe6, 0xcf, 0x21, 0x00, 0x00, 0x00, /*    aXO.    */
0x00, 0x00, 0x00, 0x47, 0x01, 0x96, 0x8f, 0x00, 0x00, 0x00, /*    - oo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x9b, 0x8e, 0x00, 0x00, 0x00, /*      oo    */
0x00, 0x00, 0x00, 0x00, 0x26, 0xef, 0x2a, 0x00, 0x00, 0x00, /*     .X.    */
0x00, 0x00, 0x00, 0x0d, 0xd4, 0x69, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x02, 0xb3, 0x8e, 0x00, 0x00, 0x00, 0x00, 0x00, /*    ao      */
0x00, 0x00, 0x44, 0xff, 0xe9, 0xe8, 0xcb, 0x00, 0x00, 0x00, /*   -XXXO    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 179 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x15, 0xb9, 0xec, 0xbf, 0x0d, 0x00, 0x00, 0x00, /*    aXa     */
0x00, 0x00, 0x02, 0x34, 0x05, 0xe2, 0x5a, 0x00, 0x00, 0x00, /*    . X-    */
0x00, 0x00, 0x00, 0x00, 0x12, 0xe6, 0x37, 0x00, 0x00, 0x00, /*      X.    */
0x00, 0x00, 0x00, 0x41, 0xf1, 0xba, 0x0a, 0x00, 0x00, 0x00, /*    -Xa     */
0x00, 0x00, 0x00, 0x00, 0x02, 0xb8, 0x81, 0x00, 0x00, 0x00, /*      ao    */
0x00, 0x00, 0x18, 0x0f, 0x02, 0xbc, 0x81, 0x00, 0x00, 0x00, /*      ao    */
0x00, 0x00, 0x38, 0xe0, 0xea, 0xbf, 0x16, 0x00, 0x00, 0x00, /*   .XXa     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 180 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x9a, 0xf9, 0x28, 0x00, 0x00, 0x00, /*     oX.    */
0x00, 0x00, 0x00, 0x19, 0xf7, 0x7b, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x95, 0xa7, 0x01, 0x00, 0x00, 0x00, 0x00, /*    oa      */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 181 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x3c, 0xff, 0x34, 0x00, /*  oO   .X.  */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x3c, 0xff, 0x34, 0x00, /*  oO   .X.  */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x3c, 0xff, 0x34, 0x00, /*  oO   .X.  */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x3c, 0xff, 0x34, 0x00, /*  oO   .X.  */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x3d, 0xff, 0x34, 0x00, /*  oO   .X.  */
0x00, 0x98, 0xd5, 0x00, 0x00, 0x00, 0x51, 0xff, 0x34, 0x00, /*  oO   -X.  */
0x00, 0x98, 0xed, 0x03, 0x00, 0x00, 0x8a, 0xff, 0x34, 0x00, /*  oX   oX.  */
0x00, 0x98, 0xff, 0x91, 0x3b, 0x6e, 0xe4, 0xff, 0x34, 0x00, /*  oXo.+XX.  */
0x00, 0x98, 0xdf, 0xc3, 0xf7, 0xc7, 0x32, 0xfe, 0x34, 0x00, /*  oOOXO.X.  */
0x00, 0x98, 0xd0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x98, 0xd3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x98, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
	/* 182 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x2b, 0xba, 0xf4, 0xff, 0xff, 0xff, 0xff, 0x70, 0x00, /*  .aXXXXX+  */
0x09, 0xe5, 0xff, 0xff, 0xff, 0xe6, 0x30, 0x9b, 0x70, 0x00, /*  XXXXX.o+  */
0x4f, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x84, 0x70, 0x00, /* -XXXXX o+  */
0x74, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x84, 0x70, 0x00, /* +XXXXX o+  */
0x6e, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x84, 0x70, 0x00, /* +XXXXX o+  */
0x4e, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x84, 0x70, 0x00, /* -XXXXX o+  */
0x07, 0xe4, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x84, 0x70, 0x00, /*  XXXXX o+  */
0x00, 0x2b, 0xbe, 0xf1, 0xec, 0xe0, 0x00, 0x84, 0x70, 0x00, /*  .aXXX o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x10, 0xe0, 0x00, 0x84, 0x70, 0x00, /*      X o+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 183 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x0d, 0xe0, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x0d, 0xe1, 0x8e, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 184 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0xbb, 0x39, 0x00, 0x00, 0x00, 0x00, /*     a.     */
0x00, 0x00, 0x00, 0x0a, 0xb2, 0xd7, 0x10, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x00, 0x00, 0x06, 0xec, 0x36, 0x00, 0x00, 0x00, /*      X.    */
0x00, 0x00, 0x00, 0x90, 0xe4, 0xa1, 0x04, 0x00, 0x00, 0x00, /*    oXa     */
	/* 185 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x38, 0xe0, 0xa4, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x04, 0xbc, 0xa1, 0xa4, 0x00, 0x00, 0x00, 0x00, /*    aaa     */
0x00, 0x00, 0x00, 0x00, 0x7e, 0xa4, 0x00, 0x00, 0x00, 0x00, /*     +a     */
0x00, 0x00, 0x00, 0x00, 0x80, 0xa4, 0x00, 0x00, 0x00, 0x00, /*     oa     */
0x00, 0x00, 0x00, 0x00, 0x80, 0xa4, 0x00, 0x00, 0x00, 0x00, /*     oa     */
0x00, 0x00, 0x00, 0x00, 0x80, 0xa4, 0x00, 0x00, 0x00, 0x00, /*     oa     */
0x00, 0x00, 0x00, 0x00, 0x80, 0xa4, 0x00, 0x00, 0x00, 0x00, /*     oa     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 186 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x02, 0x8b, 0xe4, 0xd5, 0x3c, 0x00, 0x00, 0x00, /*    oXO.    */
0x00, 0x00, 0x5d, 0xcd, 0x09, 0x3f, 0xe9, 0x0a, 0x00, 0x00, /*   -O .X    */
0x00, 0x00, 0xad, 0x76, 0x00, 0x00, 0xdf, 0x47, 0x00, 0x00, /*   a+  O-   */
0x00, 0x00, 0xc4, 0x64, 0x00, 0x00, 0xcd, 0x5f, 0x00, 0x00, /*   O+  O-   */
0x00, 0x00, 0xac, 0x78, 0x00, 0x00, 0xe1, 0x47, 0x00, 0x00, /*   a+  X-   */
0x00, 0x00, 0x5a, 0xcf, 0x09, 0x41, 0xeb, 0x0b, 0x00, 0x00, /*   -O -X    */
0x00, 0x00, 0x02, 0x88, 0xe5, 0xd5, 0x40, 0x00, 0x00, 0x00, /*    oXO-    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 187 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x31, 0xb7, 0x04, 0x16, 0xc3, 0x15, 0x00, 0x00, 0x00, /*  .a  O     */
0x00, 0x09, 0xdc, 0x85, 0x00, 0xb8, 0xb2, 0x00, 0x00, 0x00, /*   Oo aa    */
0x00, 0x00, 0x42, 0xfc, 0x3d, 0x1f, 0xf3, 0x67, 0x00, 0x00, /*   -X. X+   */
0x00, 0x00, 0x00, 0xc5, 0xc4, 0x00, 0x96, 0xec, 0x03, 0x00, /*    OO oX   */
0x00, 0x00, 0x41, 0xfc, 0x41, 0x1f, 0xf3, 0x6c, 0x00, 0x00, /*   -X- X+   */
0x00, 0x09, 0xdc, 0x87, 0x00, 0xb8, 0xb4, 0x00, 0x00, 0x00, /*   Oo aa    */
0x00, 0x31, 0xb8, 0x05, 0x16, 0xc4, 0x16, 0x00, 0x00, 0x00, /*  .a  O     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 188 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x15, 0xb7, 0xf0, 0x00, 0x00, 0x00, 0x35, 0xf3, 0x12, 0x00, /*  aX   .X   */
0x8b, 0x8a, 0xf0, 0x00, 0x00, 0x00, 0xaf, 0x8d, 0x00, 0x00, /* ooX   ao   */
0x00, 0x32, 0xf0, 0x00, 0x00, 0x2a, 0xf7, 0x1a, 0x00, 0x00, /*  .X  .X    */
0x00, 0x34, 0xf0, 0x00, 0x00, 0xa2, 0x99, 0x00, 0x00, 0x00, /*  .X  ao    */
0x00, 0x34, 0xf0, 0x00, 0x20, 0xf8, 0x23, 0x00, 0x00, 0x00, /*  .X .X.    */
0x00, 0x34, 0xf0, 0x00, 0x96, 0xa6, 0x00, 0xab, 0xcc, 0x00, /*  .X oa aO  */
0x00, 0x34, 0xf0, 0x17, 0xf6, 0x2d, 0x62, 0xd8, 0xcc, 0x00, /*  .X X.+OO  */
0x00, 0x00, 0x00, 0x89, 0xb3, 0x24, 0xd5, 0x62, 0xcc, 0x00, /*    oa.O+O  */
0x00, 0x00, 0x10, 0xf1, 0x3e, 0xc6, 0x3e, 0x54, 0xcc, 0x00, /*    X.O.-O  */
0x00, 0x00, 0x7c, 0xbf, 0x38, 0xe8, 0xe8, 0xef, 0xfb, 0x69, /*   +a.XXXX+ */
0x00, 0x0a, 0xeb, 0x46, 0x00, 0x00, 0x00, 0x54, 0xcc, 0x00, /*   X-   -O  */
0x00, 0x6f, 0xcc, 0x00, 0x00, 0x00, 0x00, 0x54, 0xcc, 0x00, /*  +O    -O  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 189 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x23, 0xcc, 0xcc, 0x00, 0x00, 0x00, 0xb9, 0x82, 0x00, 0x00, /* .OO   ao   */
0xa6, 0x93, 0xcc, 0x00, 0x00, 0x33, 0xf4, 0x14, 0x00, 0x00, /* aoO  .X    */
0x00, 0x56, 0xcc, 0x00, 0x00, 0xad, 0x8f, 0x00, 0x00, 0x00, /*  -O  ao    */
0x00, 0x58, 0xcc, 0x00, 0x28, 0xf7, 0x1c, 0x00, 0x00, 0x00, /*  -O .X     */
0x00, 0x58, 0xcc, 0x00, 0xa0, 0x9c, 0x00, 0x00, 0x00, 0x00, /*  -O ao     */
0x00, 0x58, 0xcc, 0x1e, 0xf7, 0x52, 0xc6, 0xe9, 0xa8, 0x02, /*  -O X-OXa  */
0x00, 0x58, 0xcc, 0x93, 0xa8, 0x12, 0x36, 0x04, 0xdd, 0x43, /*  -Ooa . O- */
0x00, 0x00, 0x16, 0xf5, 0x30, 0x00, 0x00, 0x00, 0xe6, 0x42, /*    X.   X- */
0x00, 0x00, 0x87, 0xb5, 0x00, 0x00, 0x00, 0x67, 0xd4, 0x04, /*   oa   +O  */
0x00, 0x0f, 0xf0, 0x3b, 0x00, 0x00, 0x35, 0xea, 0x2a, 0x00, /*   X.  .X.  */
0x00, 0x7a, 0xc2, 0x00, 0x00, 0x1b, 0xe1, 0x47, 0x00, 0x00, /*  +O   X-   */
0x09, 0xe9, 0x48, 0x00, 0x00, 0x90, 0xfa, 0xe8, 0xe8, 0x86, /*  X-  oXXXo */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 190 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x66, 0xdf, 0xe9, 0x58, 0x00, 0x00, 0x00, 0xc8, 0x72, 0x00, /* +OX-   O+  */
0x29, 0x0c, 0x6b, 0xd6, 0x00, 0x00, 0x43, 0xed, 0x0c, 0x00, /* . +O  -X   */
0x00, 0x01, 0x7e, 0xb0, 0x00, 0x00, 0xbd, 0x7f, 0x00, 0x00, /*   +a  a+   */
0x00, 0xb9, 0xf3, 0x49, 0x00, 0x36, 0xf3, 0x12, 0x00, 0x00, /*  aX- .X    */
0x00, 0x00, 0x3e, 0xf5, 0x08, 0xb0, 0x8c, 0x00, 0x00, 0x00, /*   .X ao    */
0x28, 0x00, 0x43, 0xf8, 0x30, 0xf7, 0x19, 0x84, 0xf4, 0x00, /* . -X.X oX  */
0xa6, 0xe9, 0xe4, 0x63, 0xa3, 0x98, 0x3c, 0xd5, 0xf4, 0x00, /* aXX+ao.OX  */
0x00, 0x00, 0x00, 0x20, 0xf8, 0x32, 0xd5, 0x4f, 0xf4, 0x00, /*    .X.O-X  */
0x00, 0x00, 0x00, 0x97, 0xa5, 0xa5, 0x63, 0x2c, 0xf4, 0x00, /*    oaa+.X  */
0x00, 0x00, 0x18, 0xf6, 0x41, 0xe8, 0xe8, 0xec, 0xfe, 0x8d, /*    X-XXXXo */
0x00, 0x00, 0x8a, 0xb2, 0x00, 0x00, 0x00, 0x2c, 0xf4, 0x00, /*   oa   .X  */
0x00, 0x10, 0xf2, 0x38, 0x00, 0x00, 0x00, 0x2c, 0xf4, 0x00, /*   X.   .X  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 191 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x85, 0xee, 0x20, 0x00, 0x00, 0x00, /*     oX.    */
0x00, 0x00, 0x00, 0x00, 0x9e, 0xfe, 0x2b, 0x00, 0x00, 0x00, /*     oX.    */
0x00, 0x00, 0x00, 0x00, 0x06, 0x1c, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x55, 0xee, 0x00, 0x00, 0x00, 0x00, /*     -X     */
0x00, 0x00, 0x00, 0x01, 0xae, 0xc2, 0x00, 0x00, 0x00, 0x00, /*     aO     */
0x00, 0x00, 0x06, 0xa6, 0xf2, 0x34, 0x00, 0x00, 0x00, 0x00, /*    aX.     */
0x00, 0x03, 0xb6, 0xe6, 0x31, 0x00, 0x00, 0x00, 0x00, 0x00, /*   aX.      */
0x00, 0x65, 0xf6, 0x27, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  +X.       */
0x00, 0xa3, 0xb9, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aa        */
0x00, 0x97, 0xcd, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x3c, 0xfc, 0x97, 0x3d, 0x45, 0x77, 0xc6, 0x09, 0x00, /*  .Xo.-+O   */
0x00, 0x00, 0x49, 0xc5, 0xf0, 0xee, 0xc7, 0x73, 0x0c, 0x00, /*   -OXXO+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 192 */
0x00, 0x00, 0x28, 0xf9, 0x99, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .Xo      */
0x00, 0x00, 0x00, 0x7b, 0xf7, 0x18, 0x00, 0x00, 0x00, 0x00, /*    +X      */
0x00, 0x00, 0x00, 0x01, 0xa6, 0x94, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xff, 0xb7, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 193 */
0x00, 0x00, 0x00, 0x00, 0x00, 0xcd, 0xe2, 0x0a, 0x00, 0x00, /*      OX    */
0x00, 0x00, 0x00, 0x00, 0x44, 0xfe, 0x49, 0x00, 0x00, 0x00, /*     -X-    */
0x00, 0x00, 0x00, 0x00, 0xc9, 0x74, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xff, 0xb7, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 194 */
0x00, 0x00, 0x00, 0x39, 0xff, 0xd2, 0x02, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x09, 0xd5, 0xa9, 0xe6, 0x7a, 0x00, 0x00, 0x00, /*    OaX+    */
0x00, 0x00, 0x92, 0xac, 0x04, 0x2d, 0xe3, 0x33, 0x00, 0x00, /*   oa .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xff, 0xb7, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 195 */
0x00, 0x00, 0x4a, 0xe9, 0x71, 0x00, 0x52, 0x85, 0x00, 0x00, /*   -X+ -o   */
0x00, 0x00, 0xc5, 0x5a, 0xca, 0x7e, 0xae, 0x53, 0x00, 0x00, /*   O-O+a-   */
0x00, 0x00, 0xd3, 0x00, 0x10, 0xc2, 0xc2, 0x07, 0x00, 0x00, /*   O  OO    */
0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xff, 0xb7, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 196 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x42, 0xda, 0x03, 0x4f, 0xcf, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x42, 0xda, 0x03, 0x50, 0xcf, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xff, 0xb7, 0x00, 0x00, 0x00, 0x00, /*    .Xa     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 197 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x60, 0xd5, 0xc4, 0x17, 0x00, 0x00, 0x00, /*    +OO     */
0x00, 0x00, 0x00, 0xde, 0x0f, 0x7e, 0x7a, 0x00, 0x00, 0x00, /*    O ++    */
0x00, 0x00, 0x00, 0xd8, 0x07, 0x7d, 0x79, 0x00, 0x00, 0x00, /*    O ++    */
0x00, 0x00, 0x00, 0x83, 0xff, 0xff, 0x16, 0x00, 0x00, 0x00, /*    oXX     */
0x00, 0x00, 0x00, 0x71, 0xf7, 0xf9, 0x0e, 0x00, 0x00, 0x00, /*    +XX     */
0x00, 0x00, 0x00, 0xc1, 0x9b, 0xf7, 0x59, 0x00, 0x00, 0x00, /*    OoX-    */
0x00, 0x00, 0x14, 0xfc, 0x51, 0xbb, 0xa9, 0x00, 0x00, 0x00, /*    X-aa    */
0x00, 0x00, 0x62, 0xf9, 0x0d, 0x70, 0xf3, 0x07, 0x00, 0x00, /*   +X +X    */
0x00, 0x00, 0xb2, 0xbb, 0x00, 0x23, 0xff, 0x4b, 0x00, 0x00, /*   aa .X-   */
0x00, 0x0b, 0xf7, 0x71, 0x00, 0x00, 0xd6, 0x9b, 0x00, 0x00, /*   X+  Oo   */
0x00, 0x53, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe9, 0x02, 0x00, /*  -XXXXXX   */
0x00, 0xa3, 0xd7, 0x48, 0x48, 0x48, 0x67, 0xff, 0x3d, 0x00, /*  aO---+X.  */
0x04, 0xee, 0x84, 0x00, 0x00, 0x00, 0x01, 0xe8, 0x8d, 0x00, /*  Xo    Xo  */
0x44, 0xff, 0x35, 0x00, 0x00, 0x00, 0x00, 0x9c, 0xde, 0x00, /* -X.    oO  */
0x94, 0xe6, 0x01, 0x00, 0x00, 0x00, 0x00, 0x4f, 0xff, 0x2f, /* oX     -X. */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 198 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x79, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x74, /*   +XXXXXX+ */
0x00, 0x00, 0xb1, 0x9c, 0xbd, 0xcf, 0x48, 0x48, 0x48, 0x20, /*   aoaO---. */
0x00, 0x00, 0xe8, 0x49, 0xa4, 0xbc, 0x00, 0x00, 0x00, 0x00, /*   X-aa     */
0x00, 0x22, 0xff, 0x16, 0xa4, 0xbc, 0x00, 0x00, 0x00, 0x00, /*  .X aa     */
0x00, 0x5a, 0xe3, 0x00, 0xa4, 0xbc, 0x00, 0x00, 0x00, 0x00, /*  -X aa     */
0x00, 0x92, 0xb0, 0x00, 0xa4, 0xff, 0xff, 0xff, 0xff, 0x28, /*  oa aXXXX. */
0x00, 0xcb, 0x7d, 0x00, 0xa4, 0xcf, 0x48, 0x48, 0x48, 0x0b, /*  O+ aO---  */
0x08, 0xfa, 0xff, 0xff, 0xff, 0xbc, 0x00, 0x00, 0x00, 0x00, /*  XXXXa     */
0x3b, 0xfe, 0x4d, 0x48, 0xbd, 0xbc, 0x00, 0x00, 0x00, 0x00, /* .X--aa     */
0x74, 0xd8, 0x00, 0x00, 0xa4, 0xbc, 0x00, 0x00, 0x00, 0x00, /* +O  aa     */
0xac, 0xa5, 0x00, 0x00, 0xa4, 0xcf, 0x48, 0x48, 0x48, 0x20, /* aa  aO---. */
0xe4, 0x71, 0x00, 0x00, 0xa4, 0xff, 0xff, 0xff, 0xff, 0x74, /* X+  aXXXX+ */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 199 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x46, 0xb9, 0xee, 0xf7, 0xdd, 0x97, 0x0d, /*    -aXXOo  */
0x00, 0x00, 0x72, 0xff, 0xc0, 0x61, 0x52, 0x7d, 0xab, 0x00, /*   +XO+-+a  */
0x00, 0x30, 0xfc, 0xa5, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .Xa       */
0x00, 0x9c, 0xf8, 0x1b, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0xda, 0xbd, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xf4, 0x9c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Xo        */
0x00, 0xf5, 0x92, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Xo        */
0x00, 0xde, 0xae, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xa7, 0xed, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aX        */
0x00, 0x45, 0xff, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -Xo       */
0x00, 0x00, 0x9a, 0xff, 0xae, 0x5c, 0x4f, 0x6e, 0x7f, 0x00, /*   oXa--++  */
0x00, 0x00, 0x01, 0x66, 0xcc, 0xf5, 0xf6, 0xdc, 0x80, 0x00, /*    +OXXOo  */
0x00, 0x00, 0x00, 0x00, 0x1f, 0xd3, 0x01, 0x00, 0x00, 0x00, /*      O     */
0x00, 0x00, 0x00, 0x00, 0x40, 0xdb, 0x89, 0x00, 0x00, 0x00, /*     -Oo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x52, 0xd6, 0x00, 0x00, 0x00, /*      -O    */
0x00, 0x00, 0x00, 0x06, 0xdd, 0xdd, 0x58, 0x00, 0x00, 0x00, /*     OO-    */
	/* 200 */
0x00, 0x00, 0x22, 0xf7, 0xa1, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .Xa      */
0x00, 0x00, 0x00, 0x73, 0xfa, 0x1d, 0x00, 0x00, 0x00, 0x00, /*    +X      */
0x00, 0x00, 0x00, 0x00, 0x9f, 0x9c, 0x00, 0x00, 0x00, 0x00, /*     oo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, /*  -XXXXXX   */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x45, 0x00, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 201 */
0x00, 0x00, 0x00, 0x00, 0x1d, 0xfb, 0xa1, 0x00, 0x00, 0x00, /*      Xa    */
0x00, 0x00, 0x00, 0x00, 0x90, 0xe7, 0x14, 0x00, 0x00, 0x00, /*     oX     */
0x00, 0x00, 0x00, 0x1b, 0xed, 0x34, 0x00, 0x00, 0x00, 0x00, /*     X.     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, /*  -XXXXXX   */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x45, 0x00, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 202 */
0x00, 0x00, 0x00, 0x0a, 0xe6, 0xfa, 0x23, 0x00, 0x00, 0x00, /*     XX.    */
0x00, 0x00, 0x00, 0x97, 0xd5, 0xba, 0xc0, 0x02, 0x00, 0x00, /*    oOaO    */
0x00, 0x00, 0x4b, 0xda, 0x1d, 0x0c, 0xc1, 0x76, 0x00, 0x00, /*   -O  O+   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, /*  -XXXXXX   */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x45, 0x00, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 203 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x18, 0xe3, 0x24, 0x24, 0xe3, 0x18, 0x00, 0x00, /*    X..X    */
0x00, 0x00, 0x18, 0xe3, 0x24, 0x24, 0xe3, 0x17, 0x00, 0x00, /*    X..X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0x00, 0x00, /*  -XXXXXX   */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x45, 0x00, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X.       */
0x00, 0x4c, 0xff, 0x64, 0x48, 0x48, 0x48, 0x48, 0x14, 0x00, /*  -X+----   */
0x00, 0x4c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, 0x00, /*  -XXXXXX-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 204 */
0x00, 0x00, 0x5d, 0xff, 0x5d, 0x00, 0x00, 0x00, 0x00, 0x00, /*   -X-      */
0x00, 0x00, 0x00, 0xb6, 0xd2, 0x01, 0x00, 0x00, 0x00, 0x00, /*    aO      */
0x00, 0x00, 0x00, 0x0f, 0xd4, 0x58, 0x00, 0x00, 0x00, 0x00, /*     O-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x05, 0x22, 0x35, 0xf3, 0xa4, 0x2e, 0x17, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x05, 0x21, 0x34, 0xf3, 0xa3, 0x2d, 0x16, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 205 */
0x00, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xf4, 0x1d, 0x00, 0x00, /*      aX    */
0x00, 0x00, 0x00, 0x00, 0x23, 0xfc, 0x6b, 0x00, 0x00, 0x00, /*     .X+    */
0x00, 0x00, 0x00, 0x00, 0xa5, 0x98, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x05, 0x22, 0x35, 0xf3, 0xa4, 0x2e, 0x17, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x05, 0x21, 0x34, 0xf3, 0xa3, 0x2d, 0x16, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 206 */
0x00, 0x00, 0x00, 0x39, 0xff, 0xd2, 0x02, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x09, 0xd5, 0xa9, 0xe6, 0x7a, 0x00, 0x00, 0x00, /*    OaX+    */
0x00, 0x00, 0x92, 0xac, 0x04, 0x2d, 0xe3, 0x33, 0x00, 0x00, /*   oa .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x05, 0x22, 0x35, 0xf3, 0xa4, 0x2e, 0x17, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x05, 0x21, 0x34, 0xf3, 0xa3, 0x2d, 0x16, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 207 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3e, 0xdc, 0x04, 0x4c, 0xd2, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x3f, 0xdc, 0x04, 0x4d, 0xd3, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x05, 0x22, 0x35, 0xf3, 0xa4, 0x2e, 0x17, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x05, 0x21, 0x34, 0xf3, 0xa3, 0x2d, 0x16, 0x00, 0x00, /*   ..Xa.    */
0x00, 0x3c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd4, 0x00, 0x00, /*  .XXXXXO   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 208 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xf0, 0xff, 0xff, 0xef, 0xbb, 0x4c, 0x00, 0x00, 0x00, /*  XXXXa-    */
0x00, 0xf0, 0xa3, 0x41, 0x5a, 0xb0, 0xff, 0x7c, 0x00, 0x00, /*  Xa--aX+   */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x87, 0xfe, 0x36, 0x00, /*  Xo   oX.  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x08, 0xef, 0x9f, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xb5, 0xd9, 0x00, /*  Xo    aO  */
0xff, 0xff, 0xff, 0xff, 0xff, 0x7c, 0x00, 0x9a, 0xf1, 0x00, /* XXXXX+ oX  */
0x48, 0xf4, 0xa6, 0x48, 0x48, 0x22, 0x00, 0x9d, 0xed, 0x00, /* -Xa--. oX  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x00, 0xbb, 0xd2, 0x00, /*  Xo    aO  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x00, 0x0f, 0xf5, 0x95, 0x00, /*  Xo    Xo  */
0x00, 0xf0, 0x84, 0x00, 0x00, 0x01, 0x9f, 0xfb, 0x2b, 0x00, /*  Xo   oX.  */
0x00, 0xf0, 0xa3, 0x45, 0x66, 0xc5, 0xfe, 0x69, 0x00, 0x00, /*  Xa-+OX+   */
0x00, 0xf0, 0xff, 0xfc, 0xe8, 0xae, 0x3b, 0x00, 0x00, 0x00, /*  XXXXa.    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 209 */
0x00, 0x00, 0x40, 0xe9, 0x7c, 0x00, 0x46, 0x91, 0x00, 0x00, /*   -X+ -o   */
0x00, 0x00, 0xb9, 0x61, 0xc2, 0x88, 0xa5, 0x5f, 0x00, 0x00, /*   a+Ooa-   */
0x00, 0x00, 0xd4, 0x00, 0x0c, 0xba, 0xca, 0x0c, 0x00, 0x00, /*   O  aO    */
0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xf0, 0xe9, 0x08, 0x00, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  XX    Oo  */
0x00, 0xf0, 0xff, 0x65, 0x00, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  XX+   Oo  */
0x00, 0xf0, 0xba, 0xd7, 0x01, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  XaO   Oo  */
0x00, 0xf0, 0x64, 0xef, 0x4d, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  X+X-  Oo  */
0x00, 0xf0, 0x62, 0x88, 0xc0, 0x00, 0x00, 0xd4, 0x88, 0x00, /*  X+oO  Oo  */
0x00, 0xf0, 0x67, 0x1a, 0xf9, 0x34, 0x00, 0xd4, 0x88, 0x00, /*  X+ X. Oo  */
0x00, 0xf0, 0x68, 0x00, 0xa0, 0xa8, 0x00, 0xd4, 0x88, 0x00, /*  X+ aa Oo  */
0x00, 0xf0, 0x68, 0x00, 0x2d, 0xfb, 0x1f, 0xd0, 0x88, 0x00, /*  X+ .X Oo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0xb9, 0x90, 0xc8, 0x88, 0x00, /*  X+  aoOo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0x45, 0xf3, 0xce, 0x88, 0x00, /*  X+  -XOo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0x00, 0xd1, 0xff, 0x88, 0x00, /*  X+   OXo  */
0x00, 0xf0, 0x68, 0x00, 0x00, 0x00, 0x5e, 0xff, 0x88, 0x00, /*  X+   -Xo  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 210 */
0x00, 0x00, 0x2d, 0xfb, 0x91, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .Xo      */
0x00, 0x00, 0x00, 0x83, 0xf3, 0x13, 0x00, 0x00, 0x00, 0x00, /*    oX      */
0x00, 0x00, 0x00, 0x02, 0xad, 0x8c, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xf0, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf7, 0xec, 0x9c, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 211 */
0x00, 0x00, 0x00, 0x00, 0x04, 0xe1, 0xd2, 0x02, 0x00, 0x00, /*      XO    */
0x00, 0x00, 0x00, 0x00, 0x5c, 0xfa, 0x35, 0x00, 0x00, 0x00, /*     -X.    */
0x00, 0x00, 0x00, 0x02, 0xdd, 0x5d, 0x00, 0x00, 0x00, 0x00, /*     O-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xf0, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf7, 0xec, 0x9c, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 212 */
0x00, 0x00, 0x00, 0x39, 0xff, 0xd2, 0x02, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x09, 0xd5, 0xa9, 0xe6, 0x7a, 0x00, 0x00, 0x00, /*    OaX+    */
0x00, 0x00, 0x92, 0xac, 0x04, 0x2d, 0xe3, 0x33, 0x00, 0x00, /*   oa .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xf0, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf7, 0xec, 0x9c, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 213 */
0x00, 0x00, 0x3a, 0xe8, 0x82, 0x00, 0x3e, 0x99, 0x00, 0x00, /*   .Xo .o   */
0x00, 0x00, 0xb1, 0x67, 0xbd, 0x8e, 0x9e, 0x67, 0x00, 0x00, /*   a+aoo+   */
0x00, 0x00, 0xd3, 0x01, 0x0a, 0xb4, 0xce, 0x0f, 0x00, 0x00, /*   O  aO    */
0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xf0, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf7, 0xec, 0x9c, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 214 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3e, 0xdc, 0x04, 0x4c, 0xd2, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x3f, 0xdc, 0x04, 0x4d, 0xd3, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xec, 0x9d, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x45, 0xfd, 0xbc, 0x54, 0x67, 0xe5, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0x36, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xd6, 0xb0, 0x00, /*  X+    Oa  */
0x42, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x52, 0xff, 0x37, 0x00, 0x00, 0x00, 0x00, 0x98, 0xf1, 0x00, /* -X.    oX  */
0x52, 0xff, 0x38, 0x00, 0x00, 0x00, 0x00, 0x99, 0xf0, 0x00, /* -X.    oX  */
0x41, 0xff, 0x4b, 0x00, 0x00, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-    aO  */
0x18, 0xff, 0x79, 0x00, 0x00, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  X+    Oa  */
0x00, 0xcb, 0xd8, 0x05, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OO   .X-  */
0x00, 0x45, 0xfd, 0xb9, 0x53, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x4b, 0xca, 0xf7, 0xec, 0x9c, 0x12, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 215 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x1f, 0x86, 0x01, 0x00, 0x00, 0x22, 0x85, 0x01, 0x00, /*   o   .o   */
0x00, 0x24, 0xe4, 0x9b, 0x01, 0x24, 0xe3, 0x9a, 0x01, 0x00, /*  .Xo .Xo   */
0x00, 0x00, 0x24, 0xe4, 0xa6, 0xe5, 0x9a, 0x01, 0x00, 0x00, /*   .XaXo    */
0x00, 0x00, 0x00, 0x48, 0xff, 0xd8, 0x02, 0x00, 0x00, 0x00, /*    -XO     */
0x00, 0x00, 0x22, 0xe2, 0xa5, 0xe4, 0x98, 0x01, 0x00, 0x00, /*   .XaXo    */
0x00, 0x20, 0xe1, 0x98, 0x01, 0x24, 0xe2, 0x97, 0x01, 0x00, /*  .Xo .Xo   */
0x00, 0x1c, 0x7f, 0x01, 0x00, 0x00, 0x21, 0x82, 0x01, 0x00, /*   +   .o   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 216 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x1a, 0x00, /*            */
0x00, 0x00, 0x4a, 0xc9, 0xf6, 0xe4, 0x95, 0x98, 0xd0, 0x00, /*   -OXXooO  */
0x00, 0x45, 0xfd, 0xbc, 0x55, 0x6d, 0xea, 0xff, 0x49, 0x00, /*  -Xa-+XX-  */
0x00, 0xcc, 0xd8, 0x06, 0x00, 0x00, 0xc3, 0xff, 0x5d, 0x00, /*  OO   OX-  */
0x19, 0xff, 0x7a, 0x00, 0x00, 0x5d, 0xf4, 0xe2, 0xb1, 0x00, /*  X+  -XXa  */
0x42, 0xff, 0x4a, 0x00, 0x0e, 0xe7, 0x78, 0xa9, 0xde, 0x00, /* -X-  X+aO  */
0x52, 0xff, 0x38, 0x00, 0x90, 0xd8, 0x06, 0x99, 0xf2, 0x00, /* -X. oO oX  */
0x53, 0xff, 0x39, 0x2d, 0xfb, 0x45, 0x00, 0x99, 0xf0, 0x00, /* -X..X- oX  */
0x41, 0xff, 0x4b, 0xc2, 0xac, 0x00, 0x00, 0xaa, 0xdd, 0x00, /* -X-Oa  aO  */
0x16, 0xff, 0xca, 0xf5, 0x1d, 0x00, 0x00, 0xd5, 0xb0, 0x00, /*  XOX   Oa  */
0x00, 0xc6, 0xff, 0x79, 0x00, 0x00, 0x34, 0xff, 0x5d, 0x00, /*  OX+  .X-  */
0x00, 0x9c, 0xff, 0xb9, 0x57, 0x66, 0xe4, 0xca, 0x03, 0x00, /*  oXa-+XO   */
0x27, 0xfc, 0x7c, 0xc5, 0xf3, 0xec, 0x9c, 0x12, 0x00, 0x00, /* .X+OXXo    */
0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .         */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 217 */
0x00, 0x00, 0x1d, 0xf4, 0xa9, 0x00, 0x00, 0x00, 0x00, 0x00, /*    Xa      */
0x00, 0x00, 0x00, 0x6b, 0xfc, 0x23, 0x00, 0x00, 0x00, 0x00, /*    +X.     */
0x00, 0x00, 0x00, 0x00, 0x97, 0xa4, 0x00, 0x00, 0x00, 0x00, /*     oa     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x03, 0xfc, 0x6e, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x03, 0xff, 0x72, 0x00, 0x00, 0x00, 0x00, 0xd6, 0x9e, 0x00, /*  X+    Oo  */
0x00, 0xf5, 0x89, 0x00, 0x00, 0x00, 0x00, 0xef, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0xc5, 0xd4, 0x01, 0x00, 0x00, 0x3d, 0xff, 0x55, 0x00, /*  OO   .X-  */
0x00, 0x56, 0xff, 0xb4, 0x58, 0x6b, 0xe7, 0xd5, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x60, 0xd5, 0xfa, 0xee, 0xa9, 0x1d, 0x00, 0x00, /*   +OXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 218 */
0x00, 0x00, 0x00, 0x00, 0x0f, 0xf2, 0xb9, 0x00, 0x00, 0x00, /*      Xa    */
0x00, 0x00, 0x00, 0x00, 0x78, 0xf2, 0x21, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x0d, 0xea, 0x45, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x03, 0xfc, 0x6e, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x03, 0xff, 0x72, 0x00, 0x00, 0x00, 0x00, 0xd6, 0x9e, 0x00, /*  X+    Oo  */
0x00, 0xf5, 0x89, 0x00, 0x00, 0x00, 0x00, 0xef, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0xc5, 0xd4, 0x01, 0x00, 0x00, 0x3d, 0xff, 0x55, 0x00, /*  OO   .X-  */
0x00, 0x56, 0xff, 0xb4, 0x58, 0x6b, 0xe7, 0xd5, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x60, 0xd5, 0xfa, 0xee, 0xa9, 0x1d, 0x00, 0x00, /*   +OXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 219 */
0x00, 0x00, 0x00, 0x39, 0xff, 0xd2, 0x02, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x09, 0xd5, 0xa9, 0xe6, 0x7a, 0x00, 0x00, 0x00, /*    OaX+    */
0x00, 0x00, 0x92, 0xac, 0x04, 0x2d, 0xe3, 0x33, 0x00, 0x00, /*   oa .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x03, 0xfc, 0x6e, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x03, 0xff, 0x72, 0x00, 0x00, 0x00, 0x00, 0xd6, 0x9e, 0x00, /*  X+    Oo  */
0x00, 0xf5, 0x89, 0x00, 0x00, 0x00, 0x00, 0xef, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0xc5, 0xd4, 0x01, 0x00, 0x00, 0x3d, 0xff, 0x55, 0x00, /*  OO   .X-  */
0x00, 0x56, 0xff, 0xb4, 0x58, 0x6b, 0xe7, 0xd5, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x60, 0xd5, 0xfa, 0xee, 0xa9, 0x1d, 0x00, 0x00, /*   +OXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 220 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3e, 0xdc, 0x04, 0x4c, 0xd2, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x3f, 0xdc, 0x04, 0x4d, 0xd3, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x03, 0xfc, 0x6e, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x04, 0xff, 0x70, 0x00, 0x00, 0x00, 0x00, 0xd4, 0xa0, 0x00, /*  X+    Oa  */
0x03, 0xff, 0x72, 0x00, 0x00, 0x00, 0x00, 0xd6, 0x9e, 0x00, /*  X+    Oo  */
0x00, 0xf5, 0x89, 0x00, 0x00, 0x00, 0x00, 0xef, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0xc5, 0xd4, 0x01, 0x00, 0x00, 0x3d, 0xff, 0x55, 0x00, /*  OO   .X-  */
0x00, 0x56, 0xff, 0xb4, 0x58, 0x6b, 0xe7, 0xd5, 0x03, 0x00, /*  -Xa-+XO   */
0x00, 0x00, 0x60, 0xd5, 0xfa, 0xee, 0xa9, 0x1d, 0x00, 0x00, /*   +OXXa    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 221 */
0x00, 0x00, 0x00, 0x00, 0x0f, 0xf2, 0xb9, 0x00, 0x00, 0x00, /*      Xa    */
0x00, 0x00, 0x00, 0x00, 0x78, 0xf2, 0x21, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x0d, 0xea, 0x45, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x77, 0xf9, 0x1e, 0x00, 0x00, 0x00, 0x00, 0x7e, 0xf5, 0x19, /* +X     +X  */
0x08, 0xe3, 0x9a, 0x00, 0x00, 0x00, 0x11, 0xf0, 0x83, 0x00, /*  Xo    Xo  */
0x00, 0x61, 0xfa, 0x21, 0x00, 0x00, 0x86, 0xea, 0x0d, 0x00, /*  +X.  oX   */
0x00, 0x02, 0xd3, 0x9d, 0x00, 0x15, 0xf3, 0x6d, 0x00, 0x00, /*   Oo  X+   */
0x00, 0x00, 0x4b, 0xfb, 0x23, 0x8d, 0xdd, 0x05, 0x00, 0x00, /*   -X.oO    */
0x00, 0x00, 0x00, 0xc0, 0xb5, 0xf6, 0x57, 0x00, 0x00, 0x00, /*    OaX-    */
0x00, 0x00, 0x00, 0x36, 0xff, 0xcc, 0x01, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0xf0, 0x88, 0x00, 0x00, 0x00, 0x00, /*     Xo     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 222 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xff, 0xff, 0xfc, 0xe1, 0xaa, 0x2b, 0x00, 0x00, /*  aXXXXa.   */
0x00, 0xa0, 0xdf, 0x40, 0x45, 0x6a, 0xde, 0xea, 0x17, 0x00, /*  aO--+OX   */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x65, 0x00, /*  aO   .X+  */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x02, 0xfc, 0x84, 0x00, /*  aO    Xo  */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x34, 0xff, 0x61, 0x00, /*  aO   .X+  */
0x00, 0xa0, 0xdf, 0x40, 0x49, 0x70, 0xe2, 0xdc, 0x0b, 0x00, /*  aO--+XO   */
0x00, 0xa0, 0xff, 0xff, 0xf8, 0xd9, 0x90, 0x15, 0x00, 0x00, /*  aXXXOo    */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0xa0, 0xd4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 223 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x72, 0xd9, 0xf7, 0xe3, 0x8f, 0x08, 0x00, 0x00, /*   +OXXo    */
0x00, 0x5a, 0xff, 0x7a, 0x38, 0x5d, 0xf2, 0x8c, 0x00, 0x00, /*  -X+.-Xo   */
0x00, 0xa3, 0xc8, 0x00, 0x00, 0x00, 0xaf, 0xc5, 0x00, 0x00, /*  aO   aO   */
0x00, 0xb7, 0xb4, 0x00, 0x00, 0x1e, 0xed, 0x8c, 0x00, 0x00, /*  aa   Xo   */
0x00, 0xb8, 0xb4, 0x00, 0x14, 0xd8, 0xc4, 0x0b, 0x00, 0x00, /*  aa  OO    */
0x00, 0xb8, 0xb4, 0x00, 0x88, 0xe4, 0x0d, 0x00, 0x00, 0x00, /*  aa oX     */
0x00, 0xb8, 0xb4, 0x00, 0x8c, 0xed, 0x20, 0x00, 0x00, 0x00, /*  aa oX.    */
0x00, 0xb8, 0xb4, 0x00, 0x19, 0xd9, 0xef, 0x4f, 0x00, 0x00, /*  aa  OX-   */
0x00, 0xb8, 0xb4, 0x00, 0x00, 0x0d, 0xa6, 0xfe, 0x5a, 0x00, /*  aa   aX-  */
0x00, 0xb8, 0xb4, 0x00, 0x00, 0x00, 0x00, 0xaf, 0xdd, 0x00, /*  aa    aO  */
0x00, 0xb8, 0xb4, 0x00, 0x00, 0x00, 0x00, 0x77, 0xf3, 0x00, /*  aa    +X  */
0x00, 0xb8, 0xb4, 0x32, 0x83, 0x40, 0x48, 0xd9, 0xb6, 0x00, /*  aa.o--Oa  */
0x00, 0xb8, 0xb4, 0x20, 0xc1, 0xf2, 0xee, 0xaf, 0x1b, 0x00, /*  aa.OXXa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 224 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x34, 0xfd, 0x89, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .Xo      */
0x00, 0x00, 0x00, 0x8b, 0xef, 0x0f, 0x00, 0x00, 0x00, 0x00, /*    oX      */
0x00, 0x00, 0x00, 0x03, 0xb4, 0x84, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 225 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x07, 0xe9, 0xc9, 0x00, 0x00, 0x00, /*      XO    */
0x00, 0x00, 0x00, 0x00, 0x68, 0xf7, 0x2c, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x06, 0xe4, 0x52, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 226 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x2c, 0xfd, 0xde, 0x06, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x04, 0xca, 0xb1, 0xde, 0x8a, 0x00, 0x00, 0x00, /*    OaOo    */
0x00, 0x00, 0x82, 0xb8, 0x08, 0x24, 0xdf, 0x40, 0x00, 0x00, /*   oa .O-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 227 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, /*            */
0x00, 0x00, 0x37, 0xe7, 0x86, 0x00, 0x3a, 0x9d, 0x00, 0x00, /*   .Xo .o   */
0x00, 0x00, 0xad, 0x69, 0xba, 0x91, 0x9b, 0x6b, 0x00, 0x00, /*   a+aoo+   */
0x00, 0x00, 0xd2, 0x02, 0x09, 0xb2, 0xd1, 0x11, 0x00, 0x00, /*   O  aO    */
0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 228 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2e, 0xe2, 0x0f, 0x3b, 0xde, 0x06, 0x00, 0x00, /*   .X .O    */
0x00, 0x00, 0x2e, 0xe2, 0x0e, 0x3b, 0xde, 0x05, 0x00, 0x00, /*   .X .O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 229 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x63, 0xd4, 0xc2, 0x15, 0x00, 0x00, 0x00, /*    +OO     */
0x00, 0x00, 0x00, 0xe1, 0x0d, 0x82, 0x76, 0x00, 0x00, 0x00, /*    X o+    */
0x00, 0x00, 0x00, 0xd9, 0x06, 0x81, 0x75, 0x00, 0x00, 0x00, /*    O o+    */
0x00, 0x00, 0x00, 0x66, 0xd3, 0xc3, 0x14, 0x00, 0x00, 0x00, /*    +OO     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x16, 0x8e, 0xd8, 0xf6, 0xe6, 0xa8, 0x1a, 0x00, 0x00, /*   oOXXa    */
0x00, 0x0c, 0xa9, 0x5f, 0x3a, 0x5e, 0xef, 0xb3, 0x00, 0x00, /*   a-.-Xa   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0xf1, 0x00, 0x00, /*       oX   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62, 0xff, 0x04, 0x00, /*       +X   */
0x00, 0x04, 0x6c, 0xc1, 0xe3, 0xf7, 0xfd, 0xff, 0x04, 0x00, /*   +OXXXX   */
0x00, 0x94, 0xef, 0x5d, 0x1f, 0x07, 0x66, 0xff, 0x04, 0x00, /*  oX-  +X   */
0x00, 0xe2, 0x96, 0x00, 0x00, 0x00, 0x96, 0xff, 0x04, 0x00, /*  Xo   oX   */
0x00, 0xbd, 0xd8, 0x38, 0x2e, 0x7a, 0xe8, 0xff, 0x04, 0x00, /*  aO..+XX   */
0x00, 0x25, 0xbd, 0xf5, 0xef, 0xa1, 0x2b, 0xff, 0x04, 0x00, /*  .aXXa.X   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 230 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x03, 0x90, 0xe7, 0xed, 0x62, 0x5e, 0xed, 0xd5, 0x24, 0x00, /*  oXX+-XO.  */
0x00, 0x8c, 0x49, 0x7a, 0xf4, 0xea, 0x51, 0xbd, 0xb5, 0x00, /*  o-+XX-aa  */
0x00, 0x00, 0x00, 0x05, 0xfb, 0xa2, 0x00, 0x47, 0xfc, 0x12, /*     Xa -X  */
0x00, 0x00, 0x00, 0x00, 0xed, 0x78, 0x00, 0x25, 0xff, 0x31, /*     X+ .X. */
0x04, 0x8d, 0xdf, 0xf9, 0xff, 0xff, 0xff, 0xff, 0xff, 0x43, /*  oOXXXXXX- */
0x68, 0xf6, 0x4d, 0x0c, 0xf1, 0x8c, 0x30, 0x30, 0x30, 0x0c, /* +X- Xo...  */
0x9a, 0xbd, 0x00, 0x10, 0xff, 0xa4, 0x00, 0x00, 0x00, 0x00, /* oa  Xa     */
0x7d, 0xef, 0x43, 0xa3, 0xa4, 0xf7, 0x81, 0x54, 0x97, 0x0d, /* +X-aaXo-o  */
0x13, 0xc1, 0xf4, 0xa2, 0x06, 0x56, 0xe1, 0xf3, 0xb0, 0x07, /*  OXa -XXa  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 231 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x0a, 0x88, 0xdd, 0xf9, 0xed, 0xc2, 0x1d, 0x00, /*    oOXXO   */
0x00, 0x03, 0xc1, 0xef, 0x71, 0x3c, 0x4c, 0x88, 0x02, 0x00, /*   OX+.-o   */
0x00, 0x50, 0xff, 0x4a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0x90, 0xf0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0xa3, 0xd7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  aO        */
0x00, 0x94, 0xee, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oX        */
0x00, 0x56, 0xff, 0x43, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  -X-       */
0x00, 0x05, 0xca, 0xec, 0x6a, 0x3a, 0x48, 0x86, 0x19, 0x00, /*   OX+.-o   */
0x00, 0x00, 0x0e, 0x91, 0xe2, 0xfb, 0xeb, 0xb8, 0x13, 0x00, /*    oXXXa   */
0x00, 0x00, 0x00, 0x00, 0x57, 0x9d, 0x00, 0x00, 0x00, 0x00, /*     -o     */
0x00, 0x00, 0x00, 0x00, 0x68, 0xe8, 0x53, 0x00, 0x00, 0x00, /*     +X-    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x8e, 0x9a, 0x00, 0x00, 0x00, /*      oo    */
0x00, 0x00, 0x00, 0x39, 0xdf, 0xd1, 0x30, 0x00, 0x00, 0x00, /*    .OO.    */
	/* 232 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x04, 0xd8, 0xda, 0x02, 0x00, 0x00, 0x00, 0x00, /*    OO      */
0x00, 0x00, 0x00, 0x3b, 0xfb, 0x53, 0x00, 0x00, 0x00, 0x00, /*    .X-     */
0x00, 0x00, 0x00, 0x00, 0x64, 0xd7, 0x00, 0x00, 0x00, 0x00, /*     +O     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2e, 0xb9, 0xf5, 0xf0, 0xa4, 0x14, 0x00, 0x00, /*   .aXXa    */
0x00, 0x22, 0xf1, 0xb2, 0x43, 0x4f, 0xd8, 0xc2, 0x00, 0x00, /*  .Xa--OO   */
0x00, 0x9b, 0xe4, 0x07, 0x00, 0x00, 0x3b, 0xff, 0x44, 0x00, /*  oX   .X-  */
0x00, 0xdc, 0xa3, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x75, 0x00, /*  Oa    X+  */
0x00, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8f, 0x00, /*  XXXXXXXo  */
0x00, 0xde, 0xa9, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1b, 0x00, /*  Oa.....   */
0x00, 0x9c, 0xd2, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x20, 0xed, 0xb0, 0x49, 0x39, 0x57, 0xa2, 0x13, 0x00, /*  .Xa-.-a   */
0x00, 0x00, 0x25, 0xaa, 0xee, 0xf8, 0xde, 0x9a, 0x0a, 0x00, /*   .aXXOo   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 233 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x09, 0xec, 0xc5, 0x00, 0x00, 0x00, /*      XO    */
0x00, 0x00, 0x00, 0x00, 0x6c, 0xf6, 0x29, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x08, 0xe6, 0x4f, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2e, 0xb9, 0xf5, 0xf0, 0xa4, 0x14, 0x00, 0x00, /*   .aXXa    */
0x00, 0x22, 0xf1, 0xb2, 0x43, 0x4f, 0xd8, 0xc2, 0x00, 0x00, /*  .Xa--OO   */
0x00, 0x9b, 0xe4, 0x07, 0x00, 0x00, 0x3b, 0xff, 0x44, 0x00, /*  oX   .X-  */
0x00, 0xdc, 0xa3, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x75, 0x00, /*  Oa    X+  */
0x00, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8f, 0x00, /*  XXXXXXXo  */
0x00, 0xde, 0xa9, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1b, 0x00, /*  Oa.....   */
0x00, 0x9c, 0xd2, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x20, 0xed, 0xb0, 0x49, 0x39, 0x57, 0xa2, 0x13, 0x00, /*  .Xa-.-a   */
0x00, 0x00, 0x25, 0xaa, 0xee, 0xf8, 0xde, 0x9a, 0x0a, 0x00, /*   .aXXOo   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 234 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x20, 0xf9, 0xe8, 0x0c, 0x00, 0x00, 0x00, /*    .XX     */
0x00, 0x00, 0x01, 0xbc, 0xba, 0xd5, 0x9a, 0x00, 0x00, 0x00, /*    aaOo    */
0x00, 0x00, 0x72, 0xc3, 0x0d, 0x1c, 0xd8, 0x4e, 0x00, 0x00, /*   +O  O-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2e, 0xb9, 0xf5, 0xf0, 0xa4, 0x14, 0x00, 0x00, /*   .aXXa    */
0x00, 0x22, 0xf1, 0xb2, 0x43, 0x4f, 0xd8, 0xc2, 0x00, 0x00, /*  .Xa--OO   */
0x00, 0x9b, 0xe4, 0x07, 0x00, 0x00, 0x3b, 0xff, 0x44, 0x00, /*  oX   .X-  */
0x00, 0xdc, 0xa3, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x75, 0x00, /*  Oa    X+  */
0x00, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8f, 0x00, /*  XXXXXXXo  */
0x00, 0xde, 0xa9, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1b, 0x00, /*  Oa.....   */
0x00, 0x9c, 0xd2, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x20, 0xed, 0xb0, 0x49, 0x39, 0x57, 0xa2, 0x13, 0x00, /*  .Xa-.-a   */
0x00, 0x00, 0x25, 0xaa, 0xee, 0xf8, 0xde, 0x9a, 0x0a, 0x00, /*   .aXXOo   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 235 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x24, 0xe3, 0x18, 0x31, 0xe1, 0x0c, 0x00, 0x00, /*   .X .X    */
0x00, 0x00, 0x24, 0xe3, 0x17, 0x31, 0xe2, 0x0c, 0x00, 0x00, /*   .X .X    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x2e, 0xb9, 0xf5, 0xf0, 0xa4, 0x14, 0x00, 0x00, /*   .aXXa    */
0x00, 0x22, 0xf1, 0xb2, 0x43, 0x4f, 0xd8, 0xc2, 0x00, 0x00, /*  .Xa--OO   */
0x00, 0x9b, 0xe4, 0x07, 0x00, 0x00, 0x3b, 0xff, 0x44, 0x00, /*  oX   .X-  */
0x00, 0xdc, 0xa3, 0x00, 0x00, 0x00, 0x07, 0xfe, 0x75, 0x00, /*  Oa    X+  */
0x00, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8f, 0x00, /*  XXXXXXXo  */
0x00, 0xde, 0xa9, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1b, 0x00, /*  Oa.....   */
0x00, 0x9c, 0xd2, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  oO        */
0x00, 0x20, 0xed, 0xb0, 0x49, 0x39, 0x57, 0xa2, 0x13, 0x00, /*  .Xa-.-a   */
0x00, 0x00, 0x25, 0xaa, 0xee, 0xf8, 0xde, 0x9a, 0x0a, 0x00, /*   .aXXOo   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 236 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x34, 0xfd, 0x89, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .Xo      */
0x00, 0x00, 0x00, 0x8b, 0xef, 0x0f, 0x00, 0x00, 0x00, 0x00, /*    oX      */
0x00, 0x00, 0x00, 0x03, 0xb4, 0x84, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xdc, 0xff, 0xff, 0xa8, 0x00, 0x00, 0x00, 0x00, /*   OXXa     */
0x00, 0x00, 0x01, 0x11, 0xcb, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x05, 0x14, 0xcb, 0xb1, 0x13, 0x05, 0x00, 0x00, /*     Oa     */
0x00, 0x71, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x65, 0x00, /*  +XXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 237 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0xb6, 0xef, 0x16, 0x00, 0x00, /*      aX    */
0x00, 0x00, 0x00, 0x00, 0x2d, 0xfe, 0x5f, 0x00, 0x00, 0x00, /*     .X-    */
0x00, 0x00, 0x00, 0x00, 0xb1, 0x8c, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xdc, 0xff, 0xff, 0xa8, 0x00, 0x00, 0x00, 0x00, /*   OXXa     */
0x00, 0x00, 0x01, 0x11, 0xcb, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x05, 0x14, 0xcb, 0xb1, 0x13, 0x05, 0x00, 0x00, /*     Oa     */
0x00, 0x71, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x65, 0x00, /*  +XXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 238 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x39, 0xff, 0xd2, 0x02, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x09, 0xd5, 0xa9, 0xe6, 0x7a, 0x00, 0x00, 0x00, /*    OaX+    */
0x00, 0x00, 0x92, 0xac, 0x04, 0x2d, 0xe3, 0x33, 0x00, 0x00, /*   oa .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xdc, 0xff, 0xff, 0xa8, 0x00, 0x00, 0x00, 0x00, /*   OXXa     */
0x00, 0x00, 0x01, 0x11, 0xcb, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x05, 0x14, 0xcb, 0xb1, 0x13, 0x05, 0x00, 0x00, /*     Oa     */
0x00, 0x71, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x65, 0x00, /*  +XXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 239 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x42, 0xda, 0x03, 0x4f, 0xcf, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x42, 0xda, 0x03, 0x50, 0xcf, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0xdc, 0xff, 0xff, 0xa8, 0x00, 0x00, 0x00, 0x00, /*   OXXa     */
0x00, 0x00, 0x01, 0x11, 0xcb, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x00, 0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, /*     Oa     */
0x00, 0x00, 0x05, 0x14, 0xcb, 0xb1, 0x13, 0x05, 0x00, 0x00, /*     Oa     */
0x00, 0x71, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x65, 0x00, /*  +XXXXXX+  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 240 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x01, 0xb9, 0x5e, 0x08, 0x8e, 0x6c, 0x00, 0x00, /*    a- o+   */
0x00, 0x00, 0x01, 0x6d, 0xf7, 0xec, 0xcb, 0x2a, 0x00, 0x00, /*    +XXO.   */
0x00, 0x00, 0x0b, 0x90, 0xf9, 0xf6, 0x97, 0x00, 0x00, 0x00, /*    oXXo    */
0x00, 0x00, 0x30, 0xc2, 0x2f, 0x4d, 0xfd, 0x52, 0x00, 0x00, /*   .O.-X-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x95, 0xd4, 0x00, 0x00, /*       oO   */
0x00, 0x00, 0x5a, 0xd5, 0xf8, 0xd9, 0x8e, 0xff, 0x2a, 0x00, /*   -OXOoX.  */
0x00, 0x41, 0xff, 0x9f, 0x40, 0x55, 0xdb, 0xff, 0x65, 0x00, /*  -Xo--OX+  */
0x00, 0xb6, 0xd7, 0x01, 0x00, 0x00, 0x30, 0xff, 0x7d, 0x00, /*  aO   .X+  */
0x00, 0xde, 0x9f, 0x00, 0x00, 0x00, 0x00, 0xf5, 0x80, 0x00, /*  Oo    Xo  */
0x00, 0xe6, 0x9d, 0x00, 0x00, 0x00, 0x04, 0xfd, 0x61, 0x00, /*  Xo    X+  */
0x00, 0xb4, 0xd4, 0x01, 0x00, 0x00, 0x41, 0xfd, 0x26, 0x00, /*  aO   -X.  */
0x00, 0x3b, 0xfb, 0x9d, 0x3f, 0x54, 0xde, 0xa2, 0x00, 0x00, /*  .Xo.-Oa   */
0x00, 0x00, 0x43, 0xc8, 0xf9, 0xea, 0x92, 0x09, 0x00, 0x00, /*   -OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 241 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, /*            */
0x00, 0x00, 0x3d, 0xe8, 0x7f, 0x00, 0x42, 0x95, 0x00, 0x00, /*   .X+ -o   */
0x00, 0x00, 0xb5, 0x64, 0xbf, 0x8b, 0xa1, 0x63, 0x00, 0x00, /*   a+aoa+   */
0x00, 0x00, 0xd3, 0x00, 0x0b, 0xb7, 0xcc, 0x0d, 0x00, 0x00, /*   O  aO    */
0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0x7b, 0x79, 0xe3, 0xf5, 0xc9, 0x3c, 0x00, 0x00, /*  O++XXO.   */
0x00, 0xc0, 0xec, 0xc8, 0x4c, 0x42, 0xc4, 0xec, 0x0e, 0x00, /*  OXO--OX   */
0x00, 0xc0, 0xf6, 0x14, 0x00, 0x00, 0x30, 0xff, 0x42, 0x00, /*  OX   .X-  */
0x00, 0xc0, 0xc3, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5a, 0x00, /*  OO    X-  */
0x00, 0xc0, 0xae, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 242 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x02, 0xd2, 0xe0, 0x04, 0x00, 0x00, 0x00, 0x00, /*    OX      */
0x00, 0x00, 0x00, 0x35, 0xf9, 0x5b, 0x00, 0x00, 0x00, 0x00, /*    .X-     */
0x00, 0x00, 0x00, 0x00, 0x5d, 0xdd, 0x02, 0x00, 0x00, 0x00, /*     -O     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x45, 0xc8, 0xf7, 0xea, 0x96, 0x0d, 0x00, 0x00, /*   -OXXo    */
0x00, 0x42, 0xfc, 0x9b, 0x40, 0x55, 0xdb, 0xc2, 0x03, 0x00, /*  -Xo--OO   */
0x00, 0xc4, 0xc2, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x54, 0x00, /*  OO   .X-  */
0x06, 0xfc, 0x79, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x14, 0xff, 0x66, 0x00, 0x00, 0x00, 0x00, 0xcf, 0xab, 0x00, /*  X+    Oa  */
0x05, 0xfb, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x00, 0xbe, 0xc4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x57, 0x00, /*  aO   .X-  */
0x00, 0x3a, 0xfa, 0x9c, 0x40, 0x54, 0xdb, 0xca, 0x04, 0x00, /*  .Xo--OO   */
0x00, 0x00, 0x3f, 0xc6, 0xf8, 0xeb, 0x9b, 0x11, 0x00, 0x00, /*   .OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 243 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x0b, 0xee, 0xc1, 0x00, 0x00, 0x00, /*      XO    */
0x00, 0x00, 0x00, 0x00, 0x70, 0xf5, 0x26, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x09, 0xe7, 0x4c, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x45, 0xc8, 0xf7, 0xea, 0x96, 0x0d, 0x00, 0x00, /*   -OXXo    */
0x00, 0x42, 0xfc, 0x9b, 0x40, 0x55, 0xdb, 0xc2, 0x03, 0x00, /*  -Xo--OO   */
0x00, 0xc4, 0xc2, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x54, 0x00, /*  OO   .X-  */
0x06, 0xfc, 0x79, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x14, 0xff, 0x66, 0x00, 0x00, 0x00, 0x00, 0xcf, 0xab, 0x00, /*  X+    Oa  */
0x05, 0xfb, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x00, 0xbe, 0xc4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x57, 0x00, /*  aO   .X-  */
0x00, 0x3a, 0xfa, 0x9c, 0x40, 0x54, 0xdb, 0xca, 0x04, 0x00, /*  .Xo--OO   */
0x00, 0x00, 0x3f, 0xc6, 0xf8, 0xeb, 0x9b, 0x11, 0x00, 0x00, /*   .OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 244 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x45, 0xff, 0xc7, 0x01, 0x00, 0x00, 0x00, /*    -XO     */
0x00, 0x00, 0x0d, 0xdd, 0xa4, 0xec, 0x6e, 0x00, 0x00, 0x00, /*    OaX+    */
0x00, 0x00, 0x9e, 0xa2, 0x02, 0x35, 0xe5, 0x2a, 0x00, 0x00, /*   oa .X.   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x45, 0xc8, 0xf7, 0xea, 0x96, 0x0d, 0x00, 0x00, /*   -OXXo    */
0x00, 0x42, 0xfc, 0x9b, 0x40, 0x55, 0xdb, 0xc2, 0x03, 0x00, /*  -Xo--OO   */
0x00, 0xc4, 0xc2, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x54, 0x00, /*  OO   .X-  */
0x06, 0xfc, 0x79, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x14, 0xff, 0x66, 0x00, 0x00, 0x00, 0x00, 0xcf, 0xab, 0x00, /*  X+    Oa  */
0x05, 0xfb, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x00, 0xbe, 0xc4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x57, 0x00, /*  aO   .X-  */
0x00, 0x3a, 0xfa, 0x9c, 0x40, 0x54, 0xdb, 0xca, 0x04, 0x00, /*  .Xo--OO   */
0x00, 0x00, 0x3f, 0xc6, 0xf8, 0xeb, 0x9b, 0x11, 0x00, 0x00, /*   .OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 245 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, /*            */
0x00, 0x00, 0x46, 0xe9, 0x75, 0x00, 0x4e, 0x89, 0x00, 0x00, /*   -X+ -o   */
0x00, 0x00, 0xc1, 0x5c, 0xc7, 0x81, 0xab, 0x57, 0x00, 0x00, /*   O-Ooa-   */
0x00, 0x00, 0xd3, 0x00, 0x0f, 0xbf, 0xc5, 0x09, 0x00, 0x00, /*   O  aO    */
0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x45, 0xc8, 0xf7, 0xea, 0x96, 0x0d, 0x00, 0x00, /*   -OXXo    */
0x00, 0x42, 0xfc, 0x9b, 0x40, 0x55, 0xdb, 0xc2, 0x03, 0x00, /*  -Xo--OO   */
0x00, 0xc4, 0xc2, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x54, 0x00, /*  OO   .X-  */
0x06, 0xfc, 0x79, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x14, 0xff, 0x66, 0x00, 0x00, 0x00, 0x00, 0xcf, 0xab, 0x00, /*  X+    Oa  */
0x05, 0xfb, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x00, 0xbe, 0xc4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x57, 0x00, /*  aO   .X-  */
0x00, 0x3a, 0xfa, 0x9c, 0x40, 0x54, 0xdb, 0xca, 0x04, 0x00, /*  .Xo--OO   */
0x00, 0x00, 0x3f, 0xc6, 0xf8, 0xeb, 0x9b, 0x11, 0x00, 0x00, /*   .OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 246 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x4f, 0xcf, 0x00, 0x5e, 0xc1, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x50, 0xcf, 0x00, 0x5e, 0xc1, 0x00, 0x00, 0x00, /*   -O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x45, 0xc8, 0xf7, 0xea, 0x96, 0x0d, 0x00, 0x00, /*   -OXXo    */
0x00, 0x42, 0xfc, 0x9b, 0x40, 0x55, 0xdb, 0xc2, 0x03, 0x00, /*  -Xo--OO   */
0x00, 0xc4, 0xc2, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x54, 0x00, /*  OO   .X-  */
0x06, 0xfc, 0x79, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x14, 0xff, 0x66, 0x00, 0x00, 0x00, 0x00, 0xcf, 0xab, 0x00, /*  X+    Oa  */
0x05, 0xfb, 0x7a, 0x00, 0x00, 0x00, 0x00, 0xe3, 0x97, 0x00, /*  X+    Xo  */
0x00, 0xbe, 0xc4, 0x00, 0x00, 0x00, 0x2d, 0xff, 0x57, 0x00, /*  aO   .X-  */
0x00, 0x3a, 0xfa, 0x9c, 0x40, 0x54, 0xdb, 0xca, 0x04, 0x00, /*  .Xo--OO   */
0x00, 0x00, 0x3f, 0xc6, 0xf8, 0xeb, 0x9b, 0x11, 0x00, 0x00, /*   .OXXo    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 247 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x07, 0xdf, 0x7d, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x02, 0xab, 0x5a, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xd0, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x68, 0x00, /*  OXXXXXX+  */
0x00, 0x23, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0x2c, 0x11, 0x00, /*  .......   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x02, 0xab, 0x5a, 0x00, 0x00, 0x00, 0x00, /*     a-     */
0x00, 0x00, 0x00, 0x07, 0xdf, 0x7d, 0x00, 0x00, 0x00, 0x00, /*     O+     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 248 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, /*        -   */
0x00, 0x00, 0x4a, 0xca, 0xf8, 0xe9, 0xb8, 0xf3, 0x16, 0x00, /*   -OXXaX   */
0x00, 0x47, 0xfd, 0x91, 0x3e, 0x6e, 0xff, 0xd5, 0x05, 0x00, /*  -Xo.+XO   */
0x00, 0xc7, 0xba, 0x00, 0x00, 0xae, 0xd1, 0xff, 0x59, 0x00, /*  Oa  aOX-  */
0x06, 0xfc, 0x77, 0x00, 0x4a, 0xf9, 0x26, 0xe0, 0x99, 0x00, /*  X+ -X.Xo  */
0x14, 0xff, 0x65, 0x08, 0xdd, 0x83, 0x00, 0xce, 0xab, 0x00, /*  X+ Oo Oa  */
0x05, 0xfb, 0x76, 0x83, 0xde, 0x09, 0x00, 0xe1, 0x99, 0x00, /*  X+oO  Xo  */
0x00, 0xc1, 0xd2, 0xf9, 0x4b, 0x00, 0x26, 0xff, 0x5c, 0x00, /*  OOX- .X-  */
0x00, 0x43, 0xff, 0xe1, 0x3b, 0x4f, 0xd3, 0xd2, 0x07, 0x00, /*  -XX.-OO   */
0x00, 0x6c, 0xec, 0xc6, 0xf7, 0xec, 0xa0, 0x15, 0x00, 0x00, /*  +XOXXa    */
0x00, 0x10, 0x3a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .        */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 249 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x28, 0xf9, 0x99, 0x00, 0x00, 0x00, 0x00, 0x00, /*   .Xo      */
0x00, 0x00, 0x00, 0x7b, 0xf7, 0x18, 0x00, 0x00, 0x00, 0x00, /*    +X      */
0x00, 0x00, 0x00, 0x01, 0xa6, 0x94, 0x00, 0x00, 0x00, 0x00, /*     ao     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xbf, 0xad, 0x00, 0x00, 0x00, 0x27, 0xff, 0x5c, 0x00, /*  aa   .X-  */
0x00, 0xa7, 0xcb, 0x00, 0x00, 0x00, 0x65, 0xff, 0x5c, 0x00, /*  aO   +X-  */
0x00, 0x5f, 0xff, 0x7d, 0x3a, 0x66, 0xdc, 0xfd, 0x5c, 0x00, /*  -X+.+OX-  */
0x00, 0x01, 0x7f, 0xe2, 0xf8, 0xc9, 0x36, 0xdd, 0x5c, 0x00, /*   +XXO.O-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 250 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x09, 0xec, 0xc5, 0x00, 0x00, 0x00, /*      XO    */
0x00, 0x00, 0x00, 0x00, 0x6c, 0xf6, 0x29, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x08, 0xe6, 0x4f, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xbf, 0xad, 0x00, 0x00, 0x00, 0x27, 0xff, 0x5c, 0x00, /*  aa   .X-  */
0x00, 0xa7, 0xcb, 0x00, 0x00, 0x00, 0x65, 0xff, 0x5c, 0x00, /*  aO   +X-  */
0x00, 0x5f, 0xff, 0x7d, 0x3a, 0x66, 0xdc, 0xfd, 0x5c, 0x00, /*  -X+.+OX-  */
0x00, 0x01, 0x7f, 0xe2, 0xf8, 0xc9, 0x36, 0xdd, 0x5c, 0x00, /*   +XXO.O-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 251 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x2c, 0xfd, 0xde, 0x06, 0x00, 0x00, 0x00, /*    .XO     */
0x00, 0x00, 0x04, 0xca, 0xb1, 0xde, 0x8a, 0x00, 0x00, 0x00, /*    OaOo    */
0x00, 0x00, 0x82, 0xb8, 0x08, 0x24, 0xdf, 0x40, 0x00, 0x00, /*   oa .O-   */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xbf, 0xad, 0x00, 0x00, 0x00, 0x27, 0xff, 0x5c, 0x00, /*  aa   .X-  */
0x00, 0xa7, 0xcb, 0x00, 0x00, 0x00, 0x65, 0xff, 0x5c, 0x00, /*  aO   +X-  */
0x00, 0x5f, 0xff, 0x7d, 0x3a, 0x66, 0xdc, 0xfd, 0x5c, 0x00, /*  -X+.+OX-  */
0x00, 0x01, 0x7f, 0xe2, 0xf8, 0xc9, 0x36, 0xdd, 0x5c, 0x00, /*   +XXO.O-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 252 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x3e, 0xdc, 0x04, 0x4c, 0xd2, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x3f, 0xdc, 0x04, 0x4d, 0xd3, 0x00, 0x00, 0x00, /*   .O -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x10, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xc0, 0xac, 0x00, 0x00, 0x00, 0x11, 0xff, 0x5c, 0x00, /*  Oa    X-  */
0x00, 0xbf, 0xad, 0x00, 0x00, 0x00, 0x27, 0xff, 0x5c, 0x00, /*  aa   .X-  */
0x00, 0xa7, 0xcb, 0x00, 0x00, 0x00, 0x65, 0xff, 0x5c, 0x00, /*  aO   +X-  */
0x00, 0x5f, 0xff, 0x7d, 0x3a, 0x66, 0xdc, 0xfd, 0x5c, 0x00, /*  -X+.+OX-  */
0x00, 0x01, 0x7f, 0xe2, 0xf8, 0xc9, 0x36, 0xdd, 0x5c, 0x00, /*   +XXO.O-  */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
	/* 253 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x0f, 0xf2, 0xb9, 0x00, 0x00, 0x00, /*      Xa    */
0x00, 0x00, 0x00, 0x00, 0x78, 0xf2, 0x21, 0x00, 0x00, 0x00, /*     +X.    */
0x00, 0x00, 0x00, 0x0d, 0xea, 0x45, 0x00, 0x00, 0x00, 0x00, /*     X-     */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x2a, 0xff, 0x4c, 0x00, 0x00, 0x00, 0x00, 0xb5, 0xc4, 0x00, /* .X-    aO  */
0x00, 0xc4, 0xaf, 0x00, 0x00, 0x00, 0x13, 0xfa, 0x67, 0x00, /*  Oa    X+  */
0x00, 0x5e, 0xfb, 0x17, 0x00, 0x00, 0x69, 0xf8, 0x10, 0x00, /*  -X   +X   */
0x00, 0x09, 0xee, 0x74, 0x00, 0x00, 0xc3, 0xab, 0x00, 0x00, /*   X+  Oa   */
0x00, 0x00, 0x92, 0xd7, 0x00, 0x1e, 0xfe, 0x4d, 0x00, 0x00, /*   oO  X-   */
0x00, 0x00, 0x2d, 0xff, 0x38, 0x75, 0xea, 0x04, 0x00, 0x00, /*   .X.+X    */
0x00, 0x00, 0x00, 0xc7, 0x90, 0xc9, 0x91, 0x00, 0x00, 0x00, /*    OoOo    */
0x00, 0x00, 0x00, 0x61, 0xdf, 0xfd, 0x33, 0x00, 0x00, 0x00, /*    +OX.    */
0x00, 0x00, 0x00, 0x0a, 0xf0, 0xd5, 0x00, 0x00, 0x00, 0x00, /*     XO     */
0x00, 0x00, 0x00, 0x06, 0xef, 0x78, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x5a, 0xf9, 0x18, 0x00, 0x00, 0x00, 0x00, /*    -X      */
0x0e, 0x36, 0x51, 0xe6, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .-Xo      */
0x30, 0xf0, 0xef, 0x9c, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, /* .XXo       */
	/* 254 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa3, 0x7e, 0xe7, 0xf6, 0xb3, 0x1b, 0x00, 0x00, /*  Oa+XXa    */
0x00, 0xc4, 0xf0, 0xac, 0x43, 0x52, 0xe0, 0xc7, 0x00, 0x00, /*  OXa--XO   */
0x00, 0xc4, 0xea, 0x07, 0x00, 0x00, 0x48, 0xff, 0x3b, 0x00, /*  OX   -X.  */
0x00, 0xc4, 0xba, 0x00, 0x00, 0x00, 0x08, 0xff, 0x6a, 0x00, /*  Oa    X+  */
0x00, 0xc4, 0xa9, 0x00, 0x00, 0x00, 0x00, 0xf6, 0x80, 0x00, /*  Oa    Xo  */
0x00, 0xc4, 0xb8, 0x00, 0x00, 0x00, 0x08, 0xff, 0x68, 0x00, /*  Oa    X+  */
0x00, 0xc4, 0xec, 0x07, 0x00, 0x00, 0x49, 0xff, 0x39, 0x00, /*  OX   -X.  */
0x00, 0xc4, 0xf3, 0xb4, 0x44, 0x51, 0xe1, 0xc4, 0x00, 0x00, /*  OXa--XO   */
0x00, 0xc4, 0xa0, 0x83, 0xe9, 0xf6, 0xb2, 0x1a, 0x00, 0x00, /*  OaoXXa    */
0x00, 0xc4, 0xa7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
0x00, 0xc4, 0xa8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*  Oa        */
	/* 255 */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x00, 0x00, 0x34, 0xe1, 0x0a, 0x42, 0xda, 0x03, 0x00, 0x00, /*   .X -O    */
0x00, 0x00, 0x35, 0xe1, 0x09, 0x42, 0xda, 0x03, 0x00, 0x00, /*   .X -O    */
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*            */
0x2a, 0xff, 0x4c, 0x00, 0x00, 0x00, 0x00, 0xb5, 0xc4, 0x00, /* .X-    aO  */
0x00, 0xc4, 0xaf, 0x00, 0x00, 0x00, 0x13, 0xfa, 0x67, 0x00, /*  Oa    X+  */
0x00, 0x5e, 0xfb, 0x17, 0x00, 0x00, 0x69, 0xf8, 0x10, 0x00, /*  -X   +X   */
0x00, 0x09, 0xee, 0x74, 0x00, 0x00, 0xc3, 0xab, 0x00, 0x00, /*   X+  Oa   */
0x00, 0x00, 0x92, 0xd7, 0x00, 0x1e, 0xfe, 0x4d, 0x00, 0x00, /*   oO  X-   */
0x00, 0x00, 0x2d, 0xff, 0x38, 0x75, 0xea, 0x04, 0x00, 0x00, /*   .X.+X    */
0x00, 0x00, 0x00, 0xc7, 0x90, 0xc9, 0x91, 0x00, 0x00, 0x00, /*    OoOo    */
0x00, 0x00, 0x00, 0x61, 0xdf, 0xfd, 0x33, 0x00, 0x00, 0x00, /*    +OX.    */
0x00, 0x00, 0x00, 0x0a, 0xf0, 0xd5, 0x00, 0x00, 0x00, 0x00, /*     XO     */
0x00, 0x00, 0x00, 0x06, 0xef, 0x78, 0x00, 0x00, 0x00, 0x00, /*     X+     */
0x00, 0x00, 0x00, 0x5a, 0xf9, 0x18, 0x00, 0x00, 0x00, 0x00, /*    -X      */
0x0e, 0x36, 0x51, 0xe6, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, /*  .-Xo      */
0x30, 0xf0, 0xef, 0x9c, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, /* .XXo       */
};
