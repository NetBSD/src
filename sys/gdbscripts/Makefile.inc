#	$NetBSD: Makefile.inc,v 1.6.18.1 2020/04/13 08:05:03 martin Exp $

SYS_GDBINIT=	bdump cpus devs kernhist lwps module msgbuf pgrpdump procs vchain vdump
