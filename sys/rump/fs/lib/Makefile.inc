#	$NetBSD: Makefile.inc,v 1.4.22.4 2010/03/11 15:04:35 yamt Exp $
#

RUMPTOP=	${.CURDIR}/../../..

.include "${RUMPTOP}/Makefile.rump"
