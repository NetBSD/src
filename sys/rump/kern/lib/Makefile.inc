#	$NetBSD: Makefile.inc,v 1.1.6.2 2010/08/17 06:47:59 uebayasi Exp $
#

RUMPTOP=	${.CURDIR}/../../..

.include "${RUMPTOP}/Makefile.rump"
