/*	$NetBSD: assym.h,v 1.2.8.2 2009/05/04 08:14:30 yamt Exp $	*/

/* XXX: this file should be autogenerated */

#ifdef __hppa__
#define U_PCB 0
#define PCB_ONFAULT 272
#define L_ADDR 24
#endif
