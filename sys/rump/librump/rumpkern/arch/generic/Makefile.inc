#	$NetBSD: Makefile.inc,v 1.2.18.1 2019/06/10 22:09:54 christos Exp $
#

SRCS+=	rump_generic_cpu.c rump_generic_kobj.c rump_generic_pmap.c
SRCS+=	rump_generic_abi.c
SRCS+=	rump_generic_directmap.c
