/* $NetBSD: rump_syscalls.h,v 1.5.2.5 2008/11/20 20:45:39 christos Exp $ */

/*
 * System call protos in rump namespace.
 *
 * DO NOT EDIT-- this file is automatically generated.
 * created from	NetBSD: syscalls.master,v 1.216 2008/11/19 18:36:07 ad Exp
 */

ssize_t rump_sys_read(int, void *, size_t, int *);
ssize_t rump_sys_write(int, const void *, size_t, int *);
int rump_sys_open(const char *, int, mode_t, int *);
int rump_sys_close(int, int *);
