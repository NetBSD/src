#	$NetBSD: Makefile.inc,v 1.4.2.1 2009/05/13 17:22:57 jym Exp $
#
#CPPFLAGS+=	-DRUMP_WITHOUT_THREADS
