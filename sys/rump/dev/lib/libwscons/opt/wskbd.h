#define NWSKBD 1
