#define NWSMOUSE 1
