#define WSKBDDEVCF_CONSOLE 0
#define WSKBDDEVCF_CONSOLE_DEFAULT -1
#define WSKBDDEVCF_MUX 1
#define WSKBDDEVCF_MUX_DEFAULT 1
#define WSKBDDEVCF_NLOCS 2
#define WSMOUSEDEVCF_MUX 0
#define WSMOUSEDEVCF_MUX_DEFAULT 0
#define WSMOUSEDEVCF_NLOCS 1
