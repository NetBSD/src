#define UHIDBUSCF_REPORTID 0
#define UHIDBUSCF_REPORTID_DEFAULT -1
#define UHIDBUSCF_NLOCS 1
