/*
 * debuggers.h
 * Automatically generated by config program (not yet!)
 */
#include <kgdb/kgdb.h>

struct kgdb_allow kgdballow[] = {
	{ { 255, 255, 255, 0 }, { 192, 76, 135, 0 } },
};
int kgdbcount = sizeof(kgdballow)/sizeof(kgdballow[0]);
