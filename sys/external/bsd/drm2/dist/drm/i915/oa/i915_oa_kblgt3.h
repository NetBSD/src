/*	$NetBSD: i915_oa_kblgt3.h,v 1.2 2021/12/18 23:45:31 riastradh Exp $	*/

/* SPDX-License-Identifier: MIT */
/*
 * Copyright © 2018-2019 Intel Corporation
 *
 * Autogenerated file by GPU Top : https://github.com/rib/gputop
 * DO NOT EDIT manually!
 */

#ifndef __I915_OA_KBLGT3_H__
#define __I915_OA_KBLGT3_H__

struct drm_i915_private;

void i915_perf_load_test_config_kblgt3(struct drm_i915_private *dev_priv);

#endif
