/*	$NetBSD: i915_oa_sklgt4.h,v 1.2 2021/12/18 23:45:31 riastradh Exp $	*/

/* SPDX-License-Identifier: MIT */
/*
 * Copyright © 2018-2019 Intel Corporation
 *
 * Autogenerated file by GPU Top : https://github.com/rib/gputop
 * DO NOT EDIT manually!
 */

#ifndef __I915_OA_SKLGT4_H__
#define __I915_OA_SKLGT4_H__

struct drm_i915_private;

void i915_perf_load_test_config_sklgt4(struct drm_i915_private *dev_priv);

#endif
