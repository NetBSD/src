/*	$NetBSD: efi_stub.S,v 1.1.1.1.4.2 2014/05/18 17:46:03 rmind Exp $	*/

/* This stub is a stub to make the build happy */
