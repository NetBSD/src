/*	$NetBSD: efi_stub.S,v 1.1.1.1.6.2 2019/06/10 22:08:36 christos Exp $	*/

/* This stub is a stub to make the build happy */
