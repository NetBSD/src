/*	$NetBSD: efi_stub.S,v 1.1.1.1.2.2 2018/09/06 06:56:40 pgoyette Exp $	*/

/* This stub is a stub to make the build happy */
