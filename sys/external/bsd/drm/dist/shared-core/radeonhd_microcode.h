/*
 * Copyright 2010 Advanced Micro Devices, Inc.
 * All Rights Reserved.
 *
 * Permission is hereby granted, free of charge, to any person obtaining a
 * copy of this software and associated documentation files (the "Software"),
 * to deal in the Software without restriction, including without limitation
 * the rights to use, copy, modify, merge, publish, distribute, sublicense,
 * and/or sell copies of the Software, and to permit persons to whom the
 * Software is furnished to do so, subject to the following conditions:
 *
 * The above copyright notice and this permission notice (including the next
 * paragraph) shall be included in all copies or substantial portions of the
 * Software.
 *
 * THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
 * IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
 * FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT.  IN NO EVENT SHALL
 * IN NO EVENT SHALL THE COPYRIGHT OWNER(S) AND/OR ITS SUPPLIERS BE
 * LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION
 * OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION
 * WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.
 *
 */

#define EVERGREEN_PFP_UCODE_SIZE 1120
#define EVERGREEN_PM4_UCODE_SIZE 1376

static const u32 CEDAR_me_microcode[]={
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xD440007F,
0x1C8C0002,
0x98C0000B,
0x7C410000,
0xC80C000E,
0x98C00003,
0x043C0005,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F4,
0xCC000047,
0x80000000,
0xD0400060,
0xC80C0010,
0x98C00003,
0x043C0023,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F3,
0xCC000049,
0x80000000,
0xD0400060,
0xCC000046,
0x8400002D,
0xCC00004B,
0xCC412264,
0xCC412265,
0xCC412266,
0x80000000,
0xCC41A2DD,
0xCC400046,
0x8400002D,
0xCC00004B,
0x04142264,
0x04182265,
0x041C2266,
0xD8174100,
0xD81B4100,
0xD81F4100,
0x80000000,
0xCC41A2DD,
0xC03A0004,
0x0434226B,
0x0430225C,
0x7F7B4007,
0xCC350000,
0xC83C0004,
0x88000000,
0xCFF10000,
0x7C40C000,
0x94C0FFCA,
0xCC00001F,
0x80000000,
0xCC000041,
0x7C40C000,
0xC0160004,
0x1CD0FFFF,
0x7D150007,
0xCC110000,
0x18D8003E,
0x14DC001F,
0xC8200004,
0x95C00006,
0x7C424000,
0xCC00004D,
0x7E568007,
0xCC290000,
0xC8240004,
0x7E260006,
0x95800006,
0x7C42C000,
0xCC00004D,
0x7ED70007,
0xCC310000,
0xC82C0004,
0x7E2E0007,
0xCC00004D,
0x1D10FFFF,
0x80000000,
0xCE110000,
0x7C40C000,
0x80000000,
0xCC400040,
0xCD41225D,
0xCC400045,
0xCC00004A,
0xCD01225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC412257,
0x7C418000,
0xCC400045,
0xCC40004A,
0xCC41225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0xCC000045,
0x80000064,
0xCC00004A,
0x040CA1FD,
0xC0120001,
0xCC000045,
0xCC00004A,
0x7CD0C007,
0xCC41225C,
0xCC41A1FC,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC41225D,
0xCC000045,
0xCC00004A,
0x084C0001,
0x7C410000,
0x7C414000,
0x1D58FFFF,
0x195C03F0,
0x15600015,
0xCD81A102,
0xCDC12256,
0xCE01225C,
0x94C00005,
0x21240020,
0xCE41A1FC,
0x8000007D,
0x08CC0001,
0xCD01A1FC,
0xCC01A102,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C408000,
0x7C40C000,
0xC02A0002,
0x7C410000,
0x7D290007,
0x1C940001,
0x1C980006,
0x1C9C0300,
0x15DC0008,
0x7C420000,
0x7C424000,
0x9540000F,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0xCCC12169,
0xCD01216A,
0xCE81216B,
0x29B40002,
0xCC01216C,
0x9740000E,
0x29B40000,
0x800000BD,
0xC834000E,
0x29B40002,
0x97400009,
0x29B40000,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0x800000BD,
0xC834000E,
0x97400004,
0x7E028000,
0x800000BD,
0xC834000E,
0x29B40004,
0x9740FF49,
0x00000000,
0xCE01216D,
0xCE41216E,
0xC8280003,
0xC834000E,
0x9B400004,
0xC83C000E,
0x8400034E,
0xCC00004D,
0x29F40000,
0x97400007,
0x0430A2B6,
0x840000DF,
0xCE81A2B7,
0xCF81A2C4,
0x80000000,
0xCFC1A2D1,
0x29F40001,
0x97400007,
0x0430A2BA,
0x840000DF,
0xCE81A2BB,
0xCF81A2C5,
0x80000000,
0xCFC1A2D2,
0x29F40002,
0x97400007,
0x0430A2BE,
0x840000DF,
0xCE81A2BF,
0xCF81A2C6,
0x80000000,
0xCFC1A2D3,
0x0430A2C2,
0x840000DF,
0xCE81A2C3,
0xCF81A2C7,
0x80000000,
0xCFC1A2D4,
0xC02E0004,
0x7F2F0007,
0xCC310000,
0xC82C0004,
0xC0300006,
0x7EF34023,
0xC0300020,
0x7F6B8020,
0x88000000,
0x7FB3C024,
0xCC000042,
0x80000000,
0xCC40001F,
0x7C40C000,
0x7C410000,
0x1914003D,
0x99400013,
0x0414002E,
0x840004C5,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004C5,
0x0418002D,
0xCD41A2A4,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xCCC12100,
0xCD012101,
0xCCC12102,
0xCD012103,
0x800004C2,
0xCD81A2A4,
0x1D181000,
0x95800005,
0xC81C0013,
0x29E40040,
0x9640FFFF,
0xC81C0013,
0xCCC12175,
0xCD012176,
0xC8200014,
0x96000000,
0xC8200014,
0x16280001,
0x9A800004,
0xCC00004F,
0x800004C2,
0xCC00007F,
0x80000109,
0xCCC12175,
0x7C40C000,
0x7C410000,
0xCC000045,
0xCC00004A,
0x40D40003,
0xCD41225C,
0xCD01A1FC,
0xC01A0001,
0x041CA1FD,
0x7DD9C007,
0x7C420000,
0x08CC0001,
0x06240001,
0x06280002,
0xCE1D0000,
0xCE5D0000,
0x98C0FFFA,
0xCE9D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00001,
0x14CC0001,
0x7C414000,
0x95000006,
0x7C418000,
0xCD41216D,
0xCD81216E,
0x80000137,
0xC81C0003,
0xC0220004,
0x7E160007,
0xCC210000,
0xC81C0004,
0x7C424000,
0x98C00004,
0x7C428000,
0x80000000,
0xCDE50000,
0xCE412169,
0xCE81216A,
0xCDC1216B,
0x80000000,
0xCC01216C,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0x7C41C000,
0x18A41FE8,
0x2A68003C,
0x9680000A,
0x7C020000,
0x7C420000,
0x3A300003,
0xCC000058,
0x9B000003,
0x42200005,
0x04200040,
0x80000153,
0x7C024000,
0x7E024000,
0x9A400000,
0x0A640001,
0x1CEC0010,
0x9AC0000A,
0xCC00004D,
0xC02A0004,
0xC82C0020,
0x7E928007,
0xCC000041,
0xCC290000,
0xCEC0001E,
0x80000163,
0xC8300004,
0xCD01216D,
0xCD41216E,
0xC8300003,
0x7F1F0006,
0x1CF40007,
0x13780001,
0x9740002A,
0x07B80168,
0x9F800000,
0x00000000,
0x80000178,
0x7F1B800E,
0x8000017C,
0x7F1B800F,
0x80000180,
0x7F1B800C,
0x80000184,
0x7F1B800D,
0x80000188,
0x7F1B8011,
0x8000018C,
0x7F1B8010,
0x80000191,
0x14A40008,
0x9B800019,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800015,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800011,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B80000D,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800009,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800005,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x14A40008,
0x1E6400FF,
0x2A68003C,
0x9A80FE6D,
0x14EC0008,
0x7C434000,
0x7C438000,
0x7C43C000,
0x96C00007,
0xCC00004D,
0xCF412169,
0xCF81216A,
0xCFC1216B,
0x80000000,
0xCC01216C,
0x80000000,
0xCFF50000,
0xCC000059,
0x840004C5,
0x2A68003C,
0x9A800004,
0xC8280017,
0x80000000,
0xD440007F,
0x9680FFAB,
0x7E024000,
0x8400028C,
0xC00E0002,
0xCC000041,
0x800001AF,
0xCCC1304A,
0x94000000,
0xC83C001C,
0x7C40C000,
0x7C410000,
0xC01E0001,
0x15240012,
0xC0220002,
0x96400005,
0xC0260004,
0xC027FFFB,
0x7D250006,
0xC0260000,
0x7DD28006,
0x7E12C006,
0x7D250007,
0x7C414000,
0x7C418000,
0xCCC12169,
0x9A80000C,
0xCD01216A,
0xCD41216B,
0x96C0FE3C,
0xCD81216C,
0x840004C5,
0xCC00007F,
0xC830001A,
0x97000000,
0xC830001A,
0x80000001,
0x7C408000,
0x840004C5,
0xCC00007F,
0xC8140015,
0xC8180016,
0xCD41216B,
0x96C0FE2E,
0xCD81216C,
0x800001C6,
0xCC00007F,
0xCC0003E5,
0xC82C0020,
0xC00E2024,
0x04103000,
0x20CC226B,
0x04143001,
0xCC000041,
0xD0110000,
0xCCD50000,
0xCEC0001E,
0xC80C0009,
0x98C00000,
0xC80C0009,
0x7C410000,
0x7C414000,
0xCC400043,
0xCC400044,
0xC00E8000,
0x7C424000,
0x7C428000,
0x16AC001F,
0x96C0FE15,
0xC035F000,
0xCE4003E1,
0x1E780003,
0x127C0008,
0x7FF7C006,
0x7FFBC007,
0x16780018,
0xCFC003E2,
0xCF8003E3,
0x12B00002,
0x7F3F0000,
0xCF0003E4,
0x80000451,
0x7C80C000,
0x7C40C000,
0x18D001E8,
0x11280001,
0x95000010,
0x06A801FF,
0x9E800000,
0x00000000,
0x80000217,
0xC0120800,
0x80000225,
0xC8140011,
0x8000022C,
0xC8140012,
0x80000233,
0xCCC1A2A4,
0x8000023C,
0x1CE8003F,
0x80000264,
0x7CC1800B,
0x1CD0003F,
0x29280006,
0x292C0016,
0x7EAE8007,
0xC81C0013,
0x9A80003D,
0x0414002E,
0x80000000,
0xCCC1A2A4,
0xC0120800,
0x7C414000,
0x7D0CC007,
0xC0120008,
0x15580003,
0x155C000C,
0x7C420000,
0x7DD1C006,
0x12200014,
0x7E1E4007,
0x7E4E8007,
0xCE81A2A4,
0x80000000,
0xCD81A1FE,
0xC8140011,
0x04102118,
0x95400000,
0xC8140011,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xC8140012,
0x04102106,
0x95400000,
0xC8140012,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xCCC1A2A4,
0x04100001,
0xCD000019,
0x840004C5,
0xCC00007F,
0xC810001B,
0x99000000,
0xC810001B,
0x80000001,
0x7C408000,
0x2AA00004,
0x2AA40014,
0x7E260007,
0x0414002E,
0x96000008,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004C5,
0x040C002D,
0xCD41A2A4,
0x04102100,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xD4510000,
0x800004C2,
0xCCC1A2A4,
0x840004C5,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004C5,
0x0418002D,
0x8400025A,
0xC81C0013,
0x80000001,
0x7C408000,
0x95C00000,
0xC81C0013,
0xCD41A2A4,
0xCC012100,
0xCC012101,
0xCD812102,
0xCD812103,
0xCD81A2A4,
0x88000000,
0xCC00004D,
0x1D980001,
0x7C410000,
0x7C414000,
0x99800009,
0x7C420000,
0xC83C0032,
0x11980010,
0xC81C000B,
0x3BFC0001,
0x97C0FFFF,
0xC83C0032,
0x80000276,
0xC83C0033,
0x11980010,
0xC81C000A,
0x3BFC0001,
0x97C0FFFF,
0xC83C0033,
0x1568001D,
0x7D594007,
0x9A800004,
0x11E4000A,
0x7E260007,
0xCDC00066,
0xCD012158,
0xCD412159,
0xCE01215A,
0xCCC1A2A4,
0x9A800242,
0x05100004,
0x042C0001,
0x12F0001D,
0x7D714007,
0x12E00010,
0x2220000C,
0xCD012158,
0xCD412159,
0xCE01215A,
0x800004C2,
0xCCC1A2A4,
0x043C0005,
0xCFC1A2A4,
0xC0360002,
0x88000000,
0xCF412010,
0x7C40C000,
0x14D0001D,
0x99000008,
0x14D4001C,
0x9540FD6B,
0xC0260004,
0x22642154,
0xCC250000,
0x80000000,
0xC8280004,
0x800004C2,
0xCD400061,
0x840004C5,
0x1C740001,
0x1C780002,
0x9B400003,
0xC80C0029,
0x8400034D,
0xC814002B,
0x9B800003,
0x04100010,
0x84000364,
0xCCC1A250,
0xCD01A050,
0x840002FE,
0x04180400,
0x840004C5,
0xCC000063,
0xC83C002D,
0x8400030C,
0xC8100029,
0xC81C002F,
0x1DDC0001,
0xC8240027,
0x95C00009,
0xC8340031,
0xC8380030,
0xC83C002D,
0x53740020,
0x7FB78027,
0x47B80550,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240027,
0xC8280023,
0x3AA80002,
0x9A80FFFF,
0xC8280023,
0xC0300001,
0xC8280024,
0x9A800000,
0xC8280024,
0xCF00005B,
0x50D80008,
0x14DC0018,
0x21DC8000,
0xCD812180,
0xCDC12181,
0x51200008,
0x15240018,
0xCE012182,
0xCE412183,
0xCD412184,
0x7C408000,
0xA0000000,
0xCC80004D,
0x840004C5,
0x1C740001,
0x1C780002,
0x9B400003,
0xC80C002A,
0x8400034D,
0xC814002C,
0x9B800003,
0x04100010,
0x84000364,
0xCCC1A260,
0xCD01A060,
0x840002FE,
0x04180980,
0x840004C5,
0xCC000064,
0xC83C002E,
0x8400030C,
0xC810002A,
0xC81C002F,
0x1DDC0001,
0xC8240028,
0x95C00009,
0xC8340031,
0xC8380030,
0xC83C002E,
0x53740020,
0x7FB78027,
0x47B80554,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240028,
0xC8280025,
0xC8280023,
0x3AA80002,
0x9A80FFFF,
0xC8280023,
0x9A800000,
0xC8280025,
0x800002C6,
0xC0300002,
0x0598C000,
0x10DC0008,
0x14E00018,
0xCDD90000,
0xC81C0022,
0xC8240022,
0x1DDC0FFF,
0xCDD90001,
0x7E624007,
0xCE590002,
0xD8185103,
0xD8185104,
0x88000000,
0xD8185107,
0x1BF800F0,
0xC0360800,
0x97800003,
0xC0300080,
0x88000000,
0xC02A0004,
0xCF41217C,
0xCF01217D,
0xCD01217E,
0x22A8217F,
0x04240008,
0x9A400000,
0x0A640001,
0xCC290000,
0xC8200004,
0x1638001F,
0x9B80FFFB,
0x04240008,
0x88000000,
0x00000000,
0xC80C0024,
0x94C00024,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0024,
0x80000331,
0xC80C0025,
0x94C0001B,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0025,
0x840004C5,
0xCC00007F,
0xC83C03FB,
0x9BC00000,
0xC83C03FB,
0xD04003FC,
0xC03E0004,
0xD20121F8,
0x23FC21F9,
0x840004C5,
0xCC3D0000,
0xC8380004,
0x1BB4003E,
0x1FB00004,
0x7F02C00B,
0x1EE80004,
0x7EB64007,
0x9A40FFF6,
0xC03E0004,
0xD00003FC,
0x7C410000,
0x80000001,
0x7C408000,
0x8400034D,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC83C000E,
0x97C00003,
0xD30003E6,
0x88000000,
0x043C0026,
0xCFC1A2A4,
0xC83C03E6,
0x0BFC0001,
0xCFC003E6,
0x9BC0FFFB,
0xCC00004D,
0x043C0005,
0xCFC1A2A4,
0xCC01A1F4,
0x840004C5,
0xCC000047,
0x88000000,
0xCC00007F,
0x84000364,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x043C0022,
0xCFC1A2A4,
0x840004C5,
0xCC000048,
0x88000000,
0xCC00007F,
0x8400036F,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x043C0023,
0xCFC1A2A4,
0xCC01A1F3,
0x840004C5,
0xCC000049,
0x88000000,
0xCC00007F,
0x80000000,
0x7C40C000,
0x80000000,
0x7C40C000,
0xC0120001,
0x7C514007,
0x80000000,
0xD4550000,
0xCC400065,
0xC838002D,
0xC83C002E,
0xC035E000,
0xC0320004,
0x7FB78006,
0x7FF7C006,
0x23B81000,
0x23FC1000,
0xCF812154,
0xCFC12155,
0xCC312155,
0xC82C0004,
0xC81C0025,
0xC8240024,
0x7DE5C007,
0x99C0FFFE,
0xC81C0025,
0x80000001,
0x7C408000,
0x7C40C000,
0x7C410000,
0x19280030,
0x96800008,
0xC8280027,
0xC8240028,
0x9A400000,
0xC8240027,
0x9A400000,
0xC8240028,
0xCC0003E0,
0x7C414000,
0x7C418000,
0x151C001F,
0xCCC000C7,
0xCD0000C8,
0x95C00003,
0xC01C8000,
0xCDC12010,
0xE1830000,
0x055C2000,
0xCC00004D,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000C9,
0xCD0000CA,
0xE1830000,
0x055CA000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CB,
0xCD0000CC,
0xE1830000,
0x055CE940,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CD,
0xCD0000CE,
0xE1830000,
0x055CE880,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CF,
0xCD0000D0,
0xE1830000,
0x055CC000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D1,
0xCD0000D2,
0xE1830000,
0x055CF000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D3,
0xCD0000D4,
0xE1830000,
0x055CF3FC,
0x80000000,
0xDC1F4100,
0xD4432000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443A000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E940,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E880,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F3FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CA000,
0xCC43A000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CC000,
0xCC43C000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0xC8130002,
0x94C00003,
0xC8170002,
0xC81B0002,
0x041CF3FC,
0xCC03F3FC,
0xD81FC100,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC01E0010,
0xC80C0029,
0x50D00008,
0x10540002,
0x80000428,
0x7D158020,
0xC01E0020,
0xC80C002A,
0x50D00008,
0x08540400,
0x11540002,
0x7D518020,
0xCDC00062,
0xD45A0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00003,
0x11280001,
0x9500000A,
0x06A80432,
0x9E800000,
0x7C418000,
0x80000440,
0x7C41C000,
0x80000446,
0x7C41C000,
0x8000044C,
0x7C41C000,
0x7C418000,
0x7C41C000,
0x14D40010,
0x0554A000,
0x80000000,
0xCD950000,
0xC0220004,
0x0598A000,
0x7DA18007,
0xCC190000,
0x8000043C,
0xC8180004,
0xC0220004,
0xCD8125D6,
0x222025D7,
0xCC210000,
0x8000043C,
0xC8180004,
0xCD81216D,
0xCDC1216E,
0x8000043C,
0xC8180003,
0x7C40C000,
0xC81003E1,
0xC81403E4,
0xC81803E2,
0xC81C03E3,
0xCD812169,
0xCDC1216A,
0xCCC1216B,
0xCC01216C,
0x04200004,
0x7DA18000,
0x7D96400C,
0x9640FBA4,
0xCD8003E2,
0x1D280003,
0xC02DF000,
0x11180008,
0x7DAD8006,
0x7DA98007,
0x80000000,
0xCD8003E2,
0x7C40C000,
0x80000000,
0xCC4C03E0,
0x1C8CFFFF,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC8140023,
0x31580004,
0x9580FFFF,
0xC8140023,
0xCC00005B,
0xCC412180,
0x204C8000,
0xCCC12181,
0x14D0001F,
0xCC412182,
0xCC412183,
0x9500FB88,
0xCC412184,
0xC8140023,
0x9940FFFF,
0xC8140023,
0x80000001,
0x7C408000,
0xC0160004,
0x21542140,
0xCC550000,
0xC8180004,
0x80000000,
0xCC0003E0,
0x7C40C000,
0x18D00038,
0xC0160080,
0x95000003,
0xC02A0004,
0x7CD4C007,
0xCCC1217C,
0xCC41217D,
0xCC41217E,
0x7C418000,
0x14FC001F,
0x1D98FFFF,
0x39B00003,
0x22A0217F,
0x9B000003,
0x419C0005,
0x041C0040,
0x99C00000,
0x09DC0001,
0xCC210000,
0xC8240004,
0x166C001F,
0x419C0005,
0x9AC0FFFA,
0xCC80004D,
0x9BC0FB62,
0x00000000,
0x80000000,
0xCC0003E0,
0x7C40C000,
0x7C410000,
0x1518001F,
0x51140020,
0x9980000B,
0x191C0031,
0xCD000062,
0x7D4D4027,
0xD4560000,
0x95C0FB55,
0xC8200026,
0x9A000000,
0xC8200026,
0x80000001,
0x7C408000,
0xE03A0000,
0xC0260004,
0xCCC12169,
0x7D250007,
0xCD01216A,
0x0BB80002,
0xCC41216B,
0x9B80FFFE,
0xCC41216C,
0x99C0FD0C,
0xCC00007F,
0x80000001,
0x7C408000,
0xC00E0100,
0xCC000041,
0xCCC1304A,
0xC83C007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00010468,
0x00100003,
0x00120005,
0x0015001A,
0x00160022,
0x00170035,
0x0021003A,
0x00240057,
0x00250057,
0x00270061,
0x00280054,
0x00290062,
0x002A005F,
0x002B0062,
0x002D0069,
0x002E006C,
0x002F0077,
0x00300079,
0x003200EA,
0x0034008E,
0x00350062,
0x003900EC,
0x003A0114,
0x003B0129,
0x003C0141,
0x003D01B1,
0x003F00E9,
0x0041046D,
0x0042047F,
0x00430485,
0x004401D6,
0x00450141,
0x004601FA,
0x004701FA,
0x004801FA,
0x004A0291,
0x004B0376,
0x004C029D,
0x004D02D4,
0x004E0320,
0x004F0329,
0x0051036A,
0x00520348,
0x0053035F,
0x00540378,
0x0057037A,
0x00600392,
0x006103AA,
0x0062037E,
0x006303B4,
0x006403BE,
0x006503C8,
0x006603D2,
0x006703DC,
0x006803E6,
0x006903EA,
0x006A041C,
0x006B03EE,
0x006C03F2,
0x006D03F6,
0x006E03FA,
0x006F03FE,
0x007003F6,
0x00710422,
0x00720410,
0x00730402,
0x00740409,
0x0075042D,
0x007A04A2,
0x007C0450,
0x007D0465,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
0x000F04BE,
};

static const u32 CEDAR_pfp_microcode[]={
0x7C408000,
0xA0000000,
0x04280001,
0x80000000,
0xE0030000,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x104C0001,
0x98C00005,
0x1C900002,
0xCC400029,
0x80000337,
0xCC40002A,
0x99000005,
0x00000000,
0xCC40002B,
0x80000337,
0xCC40002C,
0xCC40002D,
0x80000337,
0xCC40002E,
0x1C8C0002,
0xCC800040,
0x98C00004,
0xCC400040,
0x80000337,
0xCC000052,
0x80000337,
0xCC000054,
0x80000000,
0xCC4003FD,
0xC810002E,
0xC80C002D,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0C00043,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1000043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC000040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x45180008,
0xC99E0000,
0xC82403FD,
0x7DE68011,
0x96800003,
0x7E5EC001,
0x7C02C006,
0xCEC3A29E,
0x55140020,
0xCC00006C,
0xCD00006D,
0xCD40006D,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1400043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC800040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC8180015,
0x1D980001,
0x7C424000,
0x958002C0,
0x7C428000,
0xC81C0020,
0xC037C000,
0x7C40C000,
0x7C410000,
0x7CB48006,
0xC0360003,
0x1AB801E8,
0x97800007,
0xD04003E0,
0x8400033A,
0xCC00007F,
0xC83803E0,
0x9B800000,
0xC83803E0,
0x99C00000,
0xC81C0020,
0x7CB48007,
0x10D40002,
0x7D654000,
0xCD400043,
0xCE800043,
0xCD000043,
0xCC800040,
0xCE400040,
0xCE800040,
0xCCC00040,
0xE03A0000,
0x9780FF6E,
0xCD000040,
0x7C40C000,
0x80000088,
0x7C410000,
0x1C8C0002,
0xC810001C,
0x98C00009,
0xC820001F,
0x99000004,
0xC81C0006,
0x8400033D,
0xCC000052,
0xC8180015,
0x80000074,
0x1D980002,
0xC810001E,
0x9900FFFC,
0xC81C0008,
0x8400033D,
0xCC000054,
0xC8180015,
0x80000074,
0x1D980002,
0x1C8C0002,
0xC810001D,
0x98C0000F,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x8400033D,
0xCC000053,
0xC8180015,
0x94C00003,
0x189401E8,
0x05540006,
0x20100001,
0x7D150003,
0x80000074,
0x7D918006,
0x9940FFF8,
0xC820001F,
0x8400033D,
0xC81C0007,
0x800000B3,
0xCC00006E,
0xC00E8080,
0xCC000067,
0x04D08080,
0xCC000068,
0xCD0003F1,
0xCD0003F2,
0xCD0003F3,
0xCD0003F4,
0xCD0003F6,
0xCD0003F7,
0xCD0003F8,
0x80000005,
0xCD0003F9,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0x800000D8,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0x800000E8,
0xCC000040,
0xC820001F,
0x800000E7,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xC80C0029,
0xC810002A,
0xCC800040,
0xCC400040,
0x51100020,
0x7CD0C027,
0x10500002,
0x7D0D0020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0400043,
0xCC000040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x1C8C0002,
0xC810001D,
0x98C00012,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x8400033D,
0xCC000053,
0xC80C002F,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7CC4C000,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x9940FFF5,
0xC820001F,
0x8400033D,
0xC81C0007,
0x80000109,
0xCC00006E,
0x7C40C000,
0xC8100047,
0x9900000B,
0xC8140044,
0x99400004,
0xC8180009,
0xCD800040,
0xCC000040,
0x80000133,
0xCC800040,
0x7C40C000,
0xC8100047,
0x9500FFF7,
0xC8140045,
0x99400004,
0xC818000A,
0xCD800040,
0xCC000040,
0x80000133,
0xD8000840,
0x7C40C000,
0xC8100047,
0x9900FFFC,
0x00000000,
0xCC800040,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC8100046,
0xD8000740,
0xCD000040,
0x8400014A,
0xCD000040,
0xC80C0043,
0x94C0000A,
0xC8140048,
0x80000143,
0x04100003,
0xC8100046,
0xD80007C0,
0xCD000040,
0x8400014A,
0xCD000040,
0xC8140048,
0x9D400000,
0xCC00006A,
0xC8280016,
0x1EA80001,
0x9A800003,
0xC0290001,
0x88000000,
0xC02C0156,
0xCE80005C,
0xD80008C0,
0xCEC00040,
0x88000000,
0xCC000040,
0x1C8C0002,
0xC810001E,
0xC820001F,
0x94C00008,
0xC814001C,
0x9900000A,
0xC81C0008,
0x8400033D,
0xCC000054,
0x80000165,
0xCC800040,
0x99400004,
0xC81C0006,
0x8400033D,
0xCC000052,
0xCC800040,
0x80000000,
0xD4400040,
0xCC400027,
0xCC400028,
0x80000337,
0xCC00006B,
0xC0320003,
0xC037FFFF,
0x80000170,
0x7CB08007,
0x7C434000,
0xC8200028,
0xC81C0027,
0xC8180026,
0xCF43A29E,
0x7C414000,
0x52200020,
0x7DE1C027,
0x7D58C003,
0x7CDCC020,
0x54D00020,
0x80000185,
0xCC800040,
0x7C418000,
0xCC800040,
0x80000182,
0xCD800040,
0xC019FFFF,
0xCC800040,
0xCD83A29E,
0x7C40C000,
0x7C410000,
0x7C414000,
0xCCC3A1FA,
0xCD03A1F9,
0xCD43A29D,
0xCCC00040,
0xCD000040,
0xCD400040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00001,
0xCCC3A29F,
0x95000003,
0xD0400026,
0xD0800026,
0xCC800040,
0x80000000,
0xCCC00040,
0x7C40C000,
0xCC800040,
0xCCC3A2A2,
0x80000000,
0xCCC00040,
0x7C40C000,
0x14D4001F,
0xCC800040,
0x95400003,
0x7C410000,
0xCCC00059,
0x1518001F,
0xCCC00040,
0x95800003,
0xCD000040,
0xCD00005A,
0x80000337,
0xCC00007F,
0xC820001F,
0x7C410000,
0xD8200244,
0xCE200044,
0x7C414000,
0x7C418000,
0xCDA00049,
0xCD200041,
0xCD600041,
0xCDA00041,
0x15100008,
0x11540018,
0x7D53C007,
0xCFC0002F,
0x06200001,
0xCE000058,
0x80000337,
0xCC00007F,
0xC820001F,
0xCA0C0017,
0x94C00005,
0x7C410000,
0xD82002C6,
0x800001AF,
0xCE200046,
0xCC000048,
0x800001C5,
0x00000000,
0xC820001F,
0x7C418000,
0x0A200001,
0xCA14001A,
0xCA180017,
0x7D598007,
0x95800005,
0xCE000058,
0xCCA00046,
0x80000000,
0xCD600046,
0xCCA00044,
0x80000000,
0xCD600044,
0x80000337,
0xCC40006A,
0xCC800040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0x7C438000,
0x7C43C000,
0x041C0002,
0xCF800042,
0xCFC00042,
0xCDC00042,
0x041C0020,
0xCCC00042,
0xCD000042,
0xCDC00042,
0x041C0007,
0x04200001,
0x7C024000,
0xC8140003,
0xC8180003,
0x51980020,
0x7D594027,
0xC8280003,
0xC82C0003,
0xC8300003,
0xC8340003,
0x52EC0020,
0x7EAE8027,
0x53740020,
0x7F370027,
0x7F2B4021,
0x7E764020,
0x56A8003F,
0x5730003F,
0x7EB28006,
0x7E2A0006,
0x99C0FFF2,
0x09DC0001,
0x9680FFE1,
0x53F40020,
0x7F7B4027,
0x7D654020,
0x55580020,
0xCC00005B,
0xCD760000,
0xCDB60000,
0xC8200041,
0x9A000000,
0xC8200041,
0x80000001,
0x7C408000,
0x7C40C000,
0x7C410000,
0xCCC003FE,
0xCD0003FF,
0xCCC00042,
0xCD000042,
0x1514001F,
0x191800F0,
0x275C0001,
0x7D760006,
0x99800005,
0x7D5E4006,
0xCC000042,
0x80000337,
0xCC00004D,
0x15980001,
0x152C0008,
0x99800031,
0x1EEC0001,
0x96000004,
0x1530000C,
0x80000337,
0xCC000042,
0x04140020,
0xCD400042,
0x1F300001,
0x20280001,
0x04380020,
0x043C0007,
0xC8140003,
0xC8180003,
0xC81C0003,
0xC8200003,
0x7D5D400D,
0x7DA1C00D,
0x7D5D4007,
0x1610001F,
0x159C001F,
0x7D1D0006,
0x7D174006,
0x7E928006,
0x9B400012,
0x0BB80004,
0x9BC0FFF2,
0x0BFC0001,
0xC80C03FE,
0x9A800009,
0xC81003FF,
0x9B0000FD,
0xCC00004D,
0x04140020,
0xCCC00042,
0xCD000042,
0x80000224,
0xCD400042,
0x96C000F6,
0xCC00004D,
0x80000337,
0xCC00004E,
0x9AC00003,
0xCC00004D,
0xCC00004E,
0x9780FDB8,
0xE3830000,
0x80000000,
0xDC0301FF,
0x96400004,
0xCC00004E,
0x80000337,
0xCC000042,
0xD2000042,
0xC8080003,
0xC80C0003,
0xC8100003,
0xC8140003,
0xC8180003,
0xC81C0003,
0xC8240003,
0xC8280003,
0x15FC001F,
0x16B0001F,
0x7FF3C006,
0x14F0001F,
0x7FF3C006,
0x1570001F,
0x7FF3C006,
0x7D888001,
0x97C0000D,
0x7DCCC001,
0x7E510001,
0x7E954001,
0x7C90800C,
0x7CD4C00C,
0x9AC00003,
0x7C8F4006,
0x24B40001,
0x9B4000CD,
0xCC00004D,
0x80000337,
0xCC00004E,
0xC80C03FE,
0xC81003FF,
0xCCC00042,
0x80000250,
0xCD000042,
0x7C40C000,
0x7C410000,
0x1914003B,
0xCC00005B,
0x95400013,
0xC8140040,
0x31580002,
0x9580FFFF,
0xC8140040,
0xCC000063,
0x211C8000,
0xCCC12185,
0xCDC12186,
0x1514001F,
0xCC412187,
0xCC412188,
0x9540FD7D,
0xCC412189,
0xC8140040,
0x9940FFFF,
0xC8140040,
0x80000001,
0x7C408000,
0xCC800040,
0xCCC00040,
0xCD000040,
0x80000000,
0xD4400040,
0xD08003E0,
0xCC800040,
0x8400033A,
0xCC400040,
0xC80C03E0,
0x98C00000,
0xC80C03E0,
0x7C408000,
0xA0000000,
0x7E828006,
0x7C40C000,
0x840002A2,
0x14D0001F,
0x9900FD64,
0xD04003E0,
0x8400033A,
0xCC00007F,
0x80000294,
0xC80C03E0,
0xCC800040,
0xCCC00040,
0x88000000,
0xD4400040,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7C40C000,
0xCCC00021,
0xCCC00040,
0xD4400040,
0xC037FFFF,
0xD00003FB,
0xD00003FC,
0x80000000,
0xCF4003FD,
0x7C40C000,
0x14DC001D,
0x99C00007,
0xCC800040,
0x18DC003C,
0x99C0007F,
0xCCC00040,
0x80000337,
0xCC00006A,
0x18D8003C,
0xCD800066,
0xCC00006A,
0x80000337,
0xCCC00040,
0x7C40C000,
0x50500020,
0x8400033A,
0xCC00005D,
0x7CD0C027,
0xC820001F,
0xC8D60000,
0x99400008,
0x7C438000,
0xE3830000,
0xCFA0004F,
0x8400033A,
0xCC00005E,
0x80000000,
0xD440007F,
0x80000337,
0xCC00005E,
0x8400033A,
0xCC00005D,
0xC820001F,
0x7C40C000,
0xC036FF00,
0xC8100021,
0xC0303FFF,
0x7CF54006,
0x7D518006,
0x7D81800A,
0x99800008,
0x7CF38006,
0xE3830000,
0xCFA0004F,
0x8400033A,
0xCC00005E,
0x80000000,
0xD440007F,
0x80000337,
0xCC00005E,
0x8400033A,
0x7C40C000,
0x14DC0008,
0x95C00019,
0x1CDC0010,
0x7C410000,
0x99C00004,
0x50540020,
0x800002F2,
0xC91D0000,
0x7D150027,
0xC91E0000,
0x7C420000,
0x7C424000,
0x7C418000,
0x7DE5C006,
0x7DE28011,
0x9A80FD09,
0x41AC0005,
0x9AC00000,
0x0AEC0001,
0x1CDC0010,
0x99C00004,
0x00000000,
0x800002F5,
0xC91D0000,
0x800002F5,
0xC91E0000,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00006,
0x29100006,
0x99000007,
0xC814001C,
0x99400005,
0xCC000052,
0xC81C0006,
0x8400033D,
0xC820001F,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0x1518001F,
0xCD00005B,
0x99800004,
0x51140020,
0x80000000,
0xD44D0000,
0x7D4D4027,
0x191C0031,
0xD4560000,
0x95C0FCD1,
0xC8200041,
0x9A000000,
0xC8200041,
0x80000001,
0x7C408000,
0x80000000,
0xD440007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0xCDC00040,
0x88000000,
0xCC000040,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00020003,
0x00030306,
0x0004030E,
0x000501AB,
0x000600D6,
0x000700E5,
0x000800F8,
0x000900DE,
0x000A00D3,
0x000B00E2,
0x000C011A,
0x000D0124,
0x000E0138,
0x000F0142,
0x00100335,
0x0011000A,
0x00120018,
0x00130020,
0x00160022,
0x00240031,
0x0025004C,
0x00260167,
0x001701C7,
0x001801D5,
0x002202C1,
0x002302D2,
0x0027017C,
0x001F01DA,
0x0020020A,
0x0028019E,
0x0029016B,
0x002A0190,
0x002B0180,
0x002F0199,
0x003201BD,
0x00340316,
0x0035016F,
0x003901D7,
0x003C02E6,
0x003E0335,
0x003F01AB,
0x00410273,
0x0042028F,
0x00430299,
0x004402A6,
0x004A02B3,
0x00550309,
0x00560311,
0x00600072,
0x00610097,
0x006200C1,
0x006300AA,
0x006400AA,
0x006500AA,
0x006600AA,
0x006700AA,
0x006800CE,
0x006900D9,
0x006A012E,
0x006B00FB,
0x006C00FB,
0x006D00FB,
0x006E00FB,
0x006F00FB,
0x00700100,
0x007300E8,
0x007400E8,
0x00750155,
0x007B0324,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
};

static const u32 CEDAR_rlc_microcode[]={
0x20380010,
0x23B80000,
0xCF800012,
0xCC000085,
0x04180001,
0xCD80000E,
0xCD800083,
0xCC000082,
0xCD800081,
0xCC00000B,
0x8000004A,
0x00000000,
0xCC00000E,
0xCC00000E,
0xC8100082,
0x202801C3,
0x201C0000,
0xC8100082,
0xC8080085,
0x7F8B8007,
0xC8080081,
0x94800030,
0x00000000,
0x80000054,
0x00000000,
0xC9CC0083,
0x94C00017,
0x00000000,
0x84000097,
0x200C0001,
0x840000AA,
0x20380000,
0x97800011,
0x200C000D,
0xC0302009,
0xCCF10000,
0xC030200A,
0xC0341818,
0x13740008,
0x23741818,
0xCB0D0000,
0x7CF4C006,
0xC808001A,
0x98800006,
0x201C0001,
0x94C0FFFB,
0x00000000,
0x80000041,
0x7DC1C006,
0x840000BD,
0x11B8001F,
0x840000AA,
0x20380001,
0x84000097,
0x200C0000,
0xC03001C0,
0xCB390000,
0x20380000,
0x95C0FFD3,
0xCF800003,
0x7DC1C006,
0x840000BD,
0x20380000,
0x8000000D,
0xCF800003,
0x20380001,
0xCF800003,
0xC8100082,
0xCC000081,
0xC808001A,
0x9480000E,
0x00000000,
0xCD80000E,
0x00000000,
0x840000A8,
0x20380002,
0xCC310000,
0x840000AA,
0x20380001,
0xCD800081,
0x84000097,
0x200C0000,
0x8000000D,
0x00000000,
0xC8380056,
0x9B80006B,
0x201C0000,
0xC8380057,
0x9B800068,
0x201C0001,
0x201C0000,
0xC8080081,
0x94800012,
0x00000000,
0xC8280000,
0x9680000F,
0x20080001,
0xCD80000E,
0xCC800000,
0x1C1C0000,
0x2A8801BB,
0x94800004,
0x00000000,
0x800000B8,
0x00000000,
0x2A8801BC,
0x98800044,
0x00000000,
0x95000023,
0x00000000,
0xC8280002,
0x96800006,
0x20080001,
0xCD80000E,
0xCC800002,
0x8000008F,
0x00000000,
0xC8280001,
0x96800007,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800001,
0x8000008F,
0x00000000,
0xC8280003,
0x96800009,
0x00000000,
0xCD80000E,
0x2A8C01E5,
0x98C0FF97,
0x20080001,
0xCC800003,
0x8000008F,
0x00000000,
0xC8280004,
0x9680FF85,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800004,
0x8000008F,
0x00000000,
0x84000093,
0x00000000,
0x8000000D,
0x00000000,
0x1EA800FF,
0xCE80000C,
0x88000000,
0x00000000,
0xC0300390,
0xCB390000,
0xC00BFFFE,
0x7F8B8006,
0x10CC0010,
0x7F8F8007,
0xCFB10000,
0x88000000,
0xCB390000,
0xCFB10000,
0xCD80000E,
0xCB390000,
0x17B80004,
0x9780FFFE,
0x00000000,
0x88000000,
0x00000000,
0x800000A0,
0xC03001C1,
0xC0302003,
0xCFB10000,
0x88000000,
0xCB390000,
0xC9F80083,
0x9B800004,
0x00000000,
0x8000000D,
0x00000000,
0xCC1C0083,
0x840000BD,
0x11B8001F,
0x8000000D,
0x00000000,
0xCD9C0083,
0x840000BD,
0x20380000,
0x9500FF54,
0x00000000,
0xC03001C0,
0x88000000,
0xCFB10000,
0x99C0000B,
0xC8300040,
0x23300002,
0xCF000040,
0x840000D5,
0x20380003,
0xC8300040,
0x1F3003FD,
0xCF000040,
0x80000054,
0xCC000056,
0xC8300040,
0x23300040,
0xCF000040,
0x840000E6,
0x20380001,
0xC8300040,
0x1F3003BF,
0xCF000040,
0x80000054,
0xCC000056,
0x840000F1,
0x00000000,
0xC0302008,
0x840000F9,
0x2038FFFF,
0xC0302008,
0xCC310000,
0xCB390000,
0xC0300398,
0x840000F9,
0x20380100,
0xC0300398,
0xCC310000,
0xCB090000,
0xC03021B6,
0x88000000,
0xCC310000,
0x840000F1,
0x00000000,
0x20380001,
0xC0300398,
0x840000F9,
0x13B80014,
0xCC000057,
0xC0300398,
0xCC310000,
0x88000000,
0xCB090000,
0xCF9C0016,
0xCD80000E,
0xC9F00018,
0x7F38800C,
0x9480FFFE,
0x00000000,
0x88000000,
0x00000000,
0xCFB10000,
0xCB390000,
0x2008001F,
0x98800000,
0x08880001,
0xCC1C0016,
0xC9F0001B,
0x9700FFFF,
0x00000000,
0x88000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
};

static const u32 CYPRESS_me_microcode[]={
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xD440007F,
0x1C8C0002,
0x98C0000B,
0x7C410000,
0xC80C000E,
0x98C00003,
0x043C0005,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F4,
0xCC000047,
0x80000000,
0xD0400060,
0xC80C0010,
0x98C00003,
0x043C0023,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F3,
0xCC000049,
0x80000000,
0xD0400060,
0xCC000046,
0x8400002D,
0xCC00004B,
0xCC412264,
0xCC412265,
0xCC412266,
0x80000000,
0xCC41A2DD,
0xCC400046,
0x8400002D,
0xCC00004B,
0x04142264,
0x04182265,
0x041C2266,
0xD8174100,
0xD81B4100,
0xD81F4100,
0x80000000,
0xCC41A2DD,
0xC03A0004,
0x0434226B,
0x0430225C,
0x7F7B4007,
0xCC350000,
0xC83C0004,
0x88000000,
0xCFF10000,
0x7C40C000,
0x94C0FFCA,
0xCC00001F,
0x80000000,
0xCC000041,
0x7C40C000,
0xC0160004,
0x1CD0FFFF,
0x7D150007,
0xCC110000,
0x18D8003E,
0x14DC001F,
0xC8200004,
0x95C00006,
0x7C424000,
0xCC00004D,
0x7E568007,
0xCC290000,
0xC8240004,
0x7E260006,
0x95800006,
0x7C42C000,
0xCC00004D,
0x7ED70007,
0xCC310000,
0xC82C0004,
0x7E2E0007,
0xCC00004D,
0x1D10FFFF,
0x80000000,
0xCE110000,
0x7C40C000,
0x80000000,
0xCC400040,
0xCD41225D,
0xCC400045,
0xCC00004A,
0xCD01225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC412257,
0x7C418000,
0xCC400045,
0xCC40004A,
0xCC41225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0xCC000045,
0x80000064,
0xCC00004A,
0x040CA1FD,
0xC0120001,
0xCC000045,
0xCC00004A,
0x7CD0C007,
0xCC41225C,
0xCC41A1FC,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC41225D,
0xCC000045,
0xCC00004A,
0x084C0001,
0x7C410000,
0x7C414000,
0x1D58FFFF,
0x195C03F0,
0x15600015,
0xCD81A102,
0xCDC12256,
0xCE01225C,
0x94C00005,
0x21240020,
0xCE41A1FC,
0x8000007D,
0x08CC0001,
0xCD01A1FC,
0xCC01A102,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C408000,
0x7C40C000,
0xC02A0002,
0x7C410000,
0x7D290007,
0x1C940001,
0x1C980006,
0x1C9C0300,
0x15DC0008,
0x7C420000,
0x7C424000,
0x9540000F,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0xCCC12169,
0xCD01216A,
0xCE81216B,
0x29B40002,
0xCC01216C,
0x9740000E,
0x29B40000,
0x800000BD,
0xC834000E,
0x29B40002,
0x97400009,
0x29B40000,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0x800000BD,
0xC834000E,
0x97400004,
0x7E028000,
0x800000BD,
0xC834000E,
0x29B40004,
0x9740FF49,
0x00000000,
0xCE01216D,
0xCE41216E,
0xC8280003,
0xC834000E,
0x9B400004,
0xC83C000E,
0x8400034E,
0xCC00004D,
0x29F40000,
0x97400007,
0x0430A2B6,
0x840000DF,
0xCE81A2B7,
0xCF81A2C4,
0x80000000,
0xCFC1A2D1,
0x29F40001,
0x97400007,
0x0430A2BA,
0x840000DF,
0xCE81A2BB,
0xCF81A2C5,
0x80000000,
0xCFC1A2D2,
0x29F40002,
0x97400007,
0x0430A2BE,
0x840000DF,
0xCE81A2BF,
0xCF81A2C6,
0x80000000,
0xCFC1A2D3,
0x0430A2C2,
0x840000DF,
0xCE81A2C3,
0xCF81A2C7,
0x80000000,
0xCFC1A2D4,
0xC02E0004,
0x7F2F0007,
0xCC310000,
0xC82C0004,
0xC0300006,
0x7EF34023,
0xC0300020,
0x7F6B8020,
0x88000000,
0x7FB3C024,
0xCC000042,
0x80000000,
0xCC40001F,
0x7C40C000,
0x7C410000,
0x1914003D,
0x99400013,
0x0414002E,
0x840004DA,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004DA,
0x0418002D,
0xCD41A2A4,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xCCC12100,
0xCD012101,
0xCCC12102,
0xCD012103,
0x800004D7,
0xCD81A2A4,
0x1D181000,
0x95800005,
0xC81C0013,
0x29E40040,
0x9640FFFF,
0xC81C0013,
0xCCC12175,
0xCD012176,
0xC8200014,
0x96000000,
0xC8200014,
0x16280001,
0x9A800004,
0xCC00004F,
0x800004D7,
0xCC00007F,
0x80000109,
0xCCC12175,
0x7C40C000,
0x7C410000,
0xCC000045,
0xCC00004A,
0x40D40003,
0xCD41225C,
0xCD01A1FC,
0xC01A0001,
0x041CA1FD,
0x7DD9C007,
0x7C420000,
0x08CC0001,
0x06240001,
0x06280002,
0xCE1D0000,
0xCE5D0000,
0x98C0FFFA,
0xCE9D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00001,
0x14CC0001,
0x7C414000,
0x95000006,
0x7C418000,
0xCD41216D,
0xCD81216E,
0x80000137,
0xC81C0003,
0xC0220004,
0x7E160007,
0xCC210000,
0xC81C0004,
0x7C424000,
0x98C00004,
0x7C428000,
0x80000000,
0xCDE50000,
0xCE412169,
0xCE81216A,
0xCDC1216B,
0x80000000,
0xCC01216C,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0x7C41C000,
0x18A41FE8,
0x2A68003C,
0x9680000A,
0x7C020000,
0x7C420000,
0x3A300003,
0xCC000058,
0x9B000003,
0x42200005,
0x04200040,
0x80000153,
0x7C024000,
0x7E024000,
0x9A400000,
0x0A640001,
0x1CEC0010,
0x9AC0000A,
0xCC00004D,
0xC02A0004,
0xC82C0020,
0x7E928007,
0xCC000041,
0xCC290000,
0xCEC0001E,
0x80000163,
0xC8300004,
0xCD01216D,
0xCD41216E,
0xC8300003,
0x7F1F0006,
0x1CF40007,
0x13780001,
0x9740002A,
0x07B80168,
0x9F800000,
0x00000000,
0x80000178,
0x7F1B800E,
0x8000017C,
0x7F1B800F,
0x80000180,
0x7F1B800C,
0x80000184,
0x7F1B800D,
0x80000188,
0x7F1B8011,
0x8000018C,
0x7F1B8010,
0x80000191,
0x14A40008,
0x9B800019,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800015,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800011,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B80000D,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800009,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800005,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x14A40008,
0x1E6400FF,
0x2A68003C,
0x9A80FE6D,
0x14EC0008,
0x7C434000,
0x7C438000,
0x7C43C000,
0x96C00007,
0xCC00004D,
0xCF412169,
0xCF81216A,
0xCFC1216B,
0x80000000,
0xCC01216C,
0x80000000,
0xCFF50000,
0xCC000059,
0x840004DA,
0x2A68003C,
0x9A800004,
0xC8280017,
0x80000000,
0xD440007F,
0x9680FFAB,
0x7E024000,
0x8400028C,
0xC00E0002,
0xCC000041,
0x800001AF,
0xCCC1304A,
0x94000000,
0xC83C001C,
0x7C40C000,
0x7C410000,
0xC01E0001,
0x15240012,
0xC0220002,
0x96400005,
0xC0260004,
0xC027FFFB,
0x7D250006,
0xC0260000,
0x7DD28006,
0x7E12C006,
0x7D250007,
0x7C414000,
0x7C418000,
0xCCC12169,
0x9A80000C,
0xCD01216A,
0xCD41216B,
0x96C0FE3C,
0xCD81216C,
0x840004DA,
0xCC00007F,
0xC830001A,
0x97000000,
0xC830001A,
0x80000001,
0x7C408000,
0x840004DA,
0xCC00007F,
0xC8140015,
0xC8180016,
0xCD41216B,
0x96C0FE2E,
0xCD81216C,
0x800001C6,
0xCC00007F,
0xCC0003E5,
0xC82C0020,
0xC00E2024,
0x04103000,
0x20CC226B,
0x04143001,
0xCC000041,
0xD0110000,
0xCCD50000,
0xCEC0001E,
0xC80C0009,
0x98C00000,
0xC80C0009,
0x7C410000,
0x7C414000,
0xCC400043,
0xCC400044,
0xC00E8000,
0x7C424000,
0x7C428000,
0x16AC001F,
0x96C0FE15,
0xC035F000,
0xCE4003E1,
0x1E780003,
0x127C0008,
0x7FF7C006,
0x7FFBC007,
0x16780018,
0xCFC003E2,
0xCF8003E3,
0x12B00002,
0x7F3F0000,
0xCF0003E4,
0x80000463,
0x7C80C000,
0x7C40C000,
0x18D001E8,
0x11280001,
0x95000010,
0x06A801FF,
0x9E800000,
0x00000000,
0x80000217,
0xC0120800,
0x80000225,
0xC8140011,
0x8000022C,
0xC8140012,
0x80000233,
0xCCC1A2A4,
0x8000023C,
0x1CE8003F,
0x80000264,
0x7CC1800B,
0x1CD0003F,
0x29280006,
0x292C0016,
0x7EAE8007,
0xC81C0013,
0x9A80003D,
0x0414002E,
0x80000000,
0xCCC1A2A4,
0xC0120800,
0x7C414000,
0x7D0CC007,
0xC0120008,
0x15580003,
0x155C000C,
0x7C420000,
0x7DD1C006,
0x12200014,
0x7E1E4007,
0x7E4E8007,
0xCE81A2A4,
0x80000000,
0xCD81A1FE,
0xC8140011,
0x04102118,
0x95400000,
0xC8140011,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xC8140012,
0x04102106,
0x95400000,
0xC8140012,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xCCC1A2A4,
0x04100001,
0xCD000019,
0x840004DA,
0xCC00007F,
0xC810001B,
0x99000000,
0xC810001B,
0x80000001,
0x7C408000,
0x2AA00004,
0x2AA40014,
0x7E260007,
0x0414002E,
0x96000008,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004DA,
0x040C002D,
0xCD41A2A4,
0x04102100,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xD4510000,
0x800004D7,
0xCCC1A2A4,
0x840004DA,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004DA,
0x0418002D,
0x8400025A,
0xC81C0013,
0x80000001,
0x7C408000,
0x95C00000,
0xC81C0013,
0xCD41A2A4,
0xCC012100,
0xCC012101,
0xCD812102,
0xCD812103,
0xCD81A2A4,
0x88000000,
0xCC00004D,
0x1D980001,
0x7C410000,
0x7C414000,
0x99800009,
0x7C420000,
0xC83C0032,
0x11980010,
0xC81C000B,
0x3BFC0001,
0x97C0FFFF,
0xC83C0032,
0x80000276,
0xC83C0033,
0x11980010,
0xC81C000A,
0x3BFC0001,
0x97C0FFFF,
0xC83C0033,
0x1568001D,
0x7D594007,
0x9A800004,
0x11E4000A,
0x7E260007,
0xCDC00066,
0xCD012158,
0xCD412159,
0xCE01215A,
0xCCC1A2A4,
0x9A800257,
0x05100004,
0x042C0001,
0x12F0001D,
0x7D714007,
0x12E00010,
0x2220000C,
0xCD012158,
0xCD412159,
0xCE01215A,
0x800004D7,
0xCCC1A2A4,
0x043C0005,
0xCFC1A2A4,
0xC0360002,
0x88000000,
0xCF412010,
0x7C40C000,
0x14D0001D,
0x99000008,
0x14D4001C,
0x9540FD6B,
0xC0260004,
0x22642154,
0xCC250000,
0x80000000,
0xC8280004,
0x800004D7,
0xCD400061,
0x840004DA,
0x7C414000,
0x1D740001,
0x1C780002,
0x9B400003,
0xC80C0029,
0x8400034D,
0x15540010,
0x9B800003,
0x04100010,
0x84000371,
0xCCC1A250,
0xCD01A050,
0x840002FE,
0x04180400,
0x840004DA,
0xCC000063,
0xC83C002D,
0x8400030C,
0xC8100029,
0xC81C002F,
0x1DDC0001,
0xC8240027,
0x95C0000C,
0xC8340031,
0xC8380030,
0xC83C002D,
0x17FC0010,
0x13FC0010,
0x7FD7C007,
0x53740020,
0x7FB78027,
0x47B80550,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240027,
0xC0300001,
0xC8280024,
0x9A800000,
0xC8280024,
0xCF00005B,
0x50D80008,
0x14DC0018,
0x21DC8000,
0xCD812180,
0xCDC12181,
0x51200008,
0x15240018,
0xCE012182,
0xCE412183,
0xCD412184,
0x7C408000,
0xA0000000,
0xCC80004D,
0x840004DA,
0x7C414000,
0x1D740001,
0x1C780002,
0x9B400003,
0xC80C002A,
0x8400034D,
0x15540010,
0x9B800003,
0x04100010,
0x84000371,
0xCCC1A260,
0xCD01A060,
0x840002FE,
0x04180980,
0x840004DA,
0xCC000064,
0xC83C002E,
0x8400030C,
0xC810002A,
0xC81C002F,
0x1DDC0001,
0xC8240028,
0x95C0000C,
0xC8340031,
0xC8380030,
0xC83C002E,
0x17FC0010,
0x13FC0010,
0x7FD7C007,
0x53740020,
0x7FB78027,
0x47B80554,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240028,
0xC8280025,
0x9A800000,
0xC8280025,
0x800002C6,
0xC0300002,
0x0598C000,
0x10DC0008,
0x14E00018,
0xCDD90000,
0xC81C0022,
0xC8240022,
0x1DDC0FFF,
0xCDD90001,
0x7E624007,
0xCE590002,
0xD8185103,
0xD8185104,
0x88000000,
0xD8185107,
0x1BF800F0,
0xC0360800,
0x97800003,
0xC0300080,
0x88000000,
0xC02A0004,
0xCF41217C,
0xCF01217D,
0xCD01217E,
0x22A8217F,
0x04240008,
0x9A400000,
0x0A640001,
0xCC290000,
0xC8200004,
0x1638001F,
0x9B80FFFB,
0x04240008,
0x88000000,
0x00000000,
0xC80C0024,
0x94C00024,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0024,
0x80000331,
0xC80C0025,
0x94C0001B,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0025,
0x840004DA,
0xCC00007F,
0xC83C03FB,
0x9BC00000,
0xC83C03FB,
0xD04003FC,
0xC03E0004,
0xD20121F8,
0x23FC21F9,
0x840004DA,
0xCC3D0000,
0xC8380004,
0x1BB4003E,
0x1FB00004,
0x7F02C00B,
0x1EE80004,
0x7EB64007,
0x9A40FFF6,
0xC03E0004,
0xD00003FC,
0x7C410000,
0x80000001,
0x7C408000,
0x8400034D,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC83C000E,
0x97C00003,
0xD30003E6,
0x88000000,
0x043C0026,
0xCFC1A2A4,
0xC83C03E6,
0x0BFC0001,
0xCFC003E6,
0x9BC0FFFB,
0xCC00004D,
0xC83C03E5,
0x97C0000C,
0xC83C0013,
0x97C00000,
0xC83C0013,
0x043C2100,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0x043C0029,
0xCFC1A2A4,
0xCC80004D,
0x043C0005,
0xCFC1A2A4,
0xCC01A1F4,
0x840004DA,
0xCC000047,
0x88000000,
0xCC00007F,
0x84000371,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x043C0022,
0xCFC1A2A4,
0x840004DA,
0xCC000048,
0x88000000,
0xCC00007F,
0x8400037C,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC83C03E5,
0x97C0000C,
0xC83C0013,
0x97C00000,
0xC83C0013,
0x043C2100,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0x043C0029,
0xCFC1A2A4,
0xCC80004D,
0x043C0023,
0xCFC1A2A4,
0xCC01A1F3,
0x840004DA,
0xCC000049,
0x88000000,
0xCC00007F,
0x80000000,
0x7C40C000,
0x80000000,
0x7C40C000,
0xC0120001,
0x7C514007,
0x80000000,
0xD4550000,
0x840004DA,
0xCC400065,
0xC81C0025,
0xC8240024,
0x7DE5C007,
0x99C0FFFE,
0xC81C0025,
0x80000001,
0x7C408000,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0x151C001F,
0xCCC000C7,
0xCD0000C8,
0x95C00003,
0xC01C8000,
0xCDC12010,
0xE1830000,
0x055C2000,
0xCC00004D,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000C9,
0xCD0000CA,
0xE1830000,
0x055CA000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CB,
0xCD0000CC,
0xE1830000,
0x055CE940,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CD,
0xCD0000CE,
0xE1830000,
0x055CE880,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CF,
0xCD0000D0,
0xE1830000,
0x055CC000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D1,
0xCD0000D2,
0xE1830000,
0x055CF000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D3,
0xCD0000D4,
0xE1830000,
0x055CF3FC,
0x80000000,
0xDC1F4100,
0xD4432000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443A000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E940,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E880,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F3FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CA000,
0xCC43A000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CC000,
0xCC43C000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0xC8130002,
0x94C00003,
0xC8170002,
0xC81B0002,
0x041CF3FC,
0xCC03F3FC,
0xD81FC100,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC8280026,
0xC82C0028,
0x2AB000FF,
0x2AF400FF,
0x7F738007,
0x9B80FFFB,
0xC01E0010,
0xC80C0029,
0x50D00008,
0x10540002,
0x8000043A,
0x7D158020,
0xC8280026,
0xC82C0027,
0x2AB000FF,
0x2AF400FF,
0x7F738007,
0x9B80FFFB,
0xC01E0020,
0xC80C002A,
0x50D00008,
0x08540400,
0x11540002,
0x7D518020,
0xCDC00062,
0xD45A0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00003,
0x11280001,
0x9500000A,
0x06A80444,
0x9E800000,
0x7C418000,
0x80000452,
0x7C41C000,
0x80000458,
0x7C41C000,
0x8000045E,
0x7C41C000,
0x7C418000,
0x7C41C000,
0x14D40010,
0x0554A000,
0x80000000,
0xCD950000,
0xC0220004,
0x0598A000,
0x7DA18007,
0xCC190000,
0x8000044E,
0xC8180004,
0xC0220004,
0xCD8125D6,
0x222025D7,
0xCC210000,
0x8000044E,
0xC8180004,
0xCD81216D,
0xCDC1216E,
0x8000044E,
0xC8180003,
0x7C40C000,
0xC81003E1,
0xC81403E4,
0xC81803E2,
0xC81C03E3,
0xCD812169,
0xCDC1216A,
0xCCC1216B,
0xCC01216C,
0x04200004,
0x7DA18000,
0x7D96400C,
0x9640FB92,
0xCD8003E2,
0x1D280003,
0xC02DF000,
0x11180008,
0x7DAD8006,
0x7DA98007,
0x80000000,
0xCD8003E2,
0x7C40C000,
0x80000000,
0xCC4C03E0,
0x1C8CFFFF,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC8140023,
0x31580004,
0x9580FFFF,
0xC8140023,
0xCC00005B,
0xCC412180,
0x204C8000,
0xCCC12181,
0x14D0001F,
0xCC412182,
0xCC412183,
0x9500FB76,
0xCC412184,
0xC8140023,
0x9940FFFF,
0xC8140023,
0x80000001,
0x7C408000,
0xC0160004,
0x21542140,
0xCC550000,
0xC8180004,
0x80000000,
0xCC0003E0,
0xC02A0004,
0x7C40C000,
0xCCC1217C,
0xCC41217D,
0xCC41217E,
0x7C418000,
0x14FC001F,
0x1D98FFFF,
0x39B00003,
0x22A0217F,
0x9B000003,
0x419C0005,
0x041C0040,
0x99C00000,
0x09DC0001,
0xCC210000,
0xC8240004,
0x166C001F,
0x419C0005,
0x9AC0FFFA,
0xCC80004D,
0x9BC0FB54,
0x00000000,
0x80000000,
0xCC0003E0,
0x7C40C000,
0x7C410000,
0x1518001F,
0x51140020,
0x99800012,
0x191C0031,
0xC8280027,
0xC82C0028,
0x2AB000FF,
0x2AF400FF,
0x7F738007,
0x9B80FFFC,
0xC8280027,
0xCD000062,
0x7D4D4027,
0xD4560000,
0x95C0FB40,
0xC8200026,
0x9A000000,
0xC8200026,
0x80000001,
0x7C408000,
0xE03A0000,
0xC0260004,
0xCCC12169,
0x7D250007,
0xCD01216A,
0x0BB80002,
0xCC41216B,
0x9B80FFFE,
0xCC41216C,
0x99C0FCF7,
0xCC00007F,
0x80000001,
0x7C408000,
0xC00E0100,
0xCC000041,
0xCCC1304A,
0xC83C007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x0001047A,
0x00100003,
0x00120005,
0x0015001A,
0x00160022,
0x00170035,
0x0021003A,
0x00240057,
0x00250057,
0x00270061,
0x00280054,
0x00290062,
0x002A005F,
0x002B0062,
0x002D0069,
0x002E006C,
0x002F0077,
0x00300079,
0x003200EA,
0x0034008E,
0x00350062,
0x003900EC,
0x003A0114,
0x003B0129,
0x003C0141,
0x003D01B1,
0x003F00E9,
0x0041047F,
0x00420491,
0x00430497,
0x004401D6,
0x00450141,
0x004601FA,
0x004701FA,
0x004801FA,
0x004A0291,
0x004B0390,
0x004C029D,
0x004D02D4,
0x004E0320,
0x004F0329,
0x00510377,
0x00520348,
0x0053036C,
0x00540392,
0x00570394,
0x006003A1,
0x006103B0,
0x00620398,
0x006303BA,
0x006403C4,
0x006503CE,
0x006603D8,
0x006703E2,
0x006803EC,
0x006903F0,
0x006A0422,
0x006B03F4,
0x006C03F8,
0x006D03FC,
0x006E0400,
0x006F0404,
0x007003FC,
0x0071042E,
0x00720416,
0x00730408,
0x0074040F,
0x0075043F,
0x007A04B0,
0x007C0462,
0x007D0477,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
};

static const u32 CYPRESS_pfp_microcode[]={
0x7C408000,
0xA0000000,
0x04280001,
0x80000000,
0xE0030000,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x104C0001,
0x98C00005,
0x1C900002,
0xCC400029,
0x800003AD,
0xCC40002A,
0x99000005,
0x00000000,
0xCC40002B,
0x800003AD,
0xCC40002C,
0xCC40002D,
0x800003AD,
0xCC40002E,
0x1C8C0002,
0xCC800040,
0x98C00004,
0xCC400040,
0x800003AD,
0xCC000052,
0x800003AD,
0xCC000054,
0x80000000,
0xCC4003FD,
0xC810002E,
0xC80C002D,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0C00043,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1000043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC000040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x45180008,
0xC99E0000,
0xC82403FD,
0x7DE68011,
0x96800003,
0x7E5EC001,
0x7C02C006,
0xCEC3A29E,
0x55140020,
0xCC00006C,
0xCD00006D,
0xCD40006D,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1400043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC800040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0xC83521A3,
0x1B7807F0,
0x2BB40008,
0x9740FFFD,
0xC83803FC,
0x9B800000,
0xC83803FC,
0x840003B0,
0xD04003FB,
0xC83803FC,
0x9B80FFFB,
0x043C001B,
0xCC00005B,
0x840003B0,
0xCFC121F8,
0xC83921F9,
0x1BB40078,
0x9B40FFFC,
0xCC00005B,
0xD00003FB,
0x7C408000,
0xA0000000,
0x04280001,
0xC8180015,
0x1D980001,
0x7C424000,
0x95800322,
0x7C428000,
0xC81C0020,
0xC037C000,
0x7C40C000,
0x7C410000,
0x7CB48006,
0xC0360003,
0x99C00000,
0xC81C0020,
0x7CB48007,
0x10D40002,
0x7D654000,
0xCD400043,
0xCE800043,
0xCD000043,
0xCC800040,
0xCE400040,
0xCE800040,
0xCCC00040,
0xE03A0000,
0x9780FF62,
0xCD000040,
0x7C40C000,
0x80000094,
0x7C410000,
0x1C8C0002,
0xC810001C,
0x98C00009,
0xC820001F,
0x99000004,
0xC81C0006,
0x840003B3,
0xCC000052,
0xC8180015,
0x80000088,
0x1D980002,
0xC810001E,
0x9900FFFC,
0xC81C0008,
0x840003B3,
0xCC000054,
0xC8180015,
0x80000088,
0x1D980002,
0x1C8C0002,
0xC810001D,
0x98C0000F,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x840003B3,
0xCC000053,
0xC8180015,
0x94C00003,
0x189401E8,
0x05540006,
0x20100001,
0x7D150003,
0x80000088,
0x7D918006,
0x9940FFF8,
0xC820001F,
0x840003B3,
0xC81C0007,
0x800000BF,
0xCC00006E,
0xC00E8080,
0xCC000067,
0x04D08080,
0xCC000068,
0xCD0003F1,
0xCD0003F2,
0xCD0003F3,
0xCD0003F4,
0xCD0003F6,
0xCD0003F7,
0xCD0003F8,
0x80000005,
0xCD0003F9,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0x800000E4,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0x800000F4,
0xCC000040,
0xC820001F,
0x800000F3,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xC80C0029,
0xC810002A,
0xCC800040,
0xCC400040,
0x51100020,
0x7CD0C027,
0x10500002,
0x7D0D0020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0400043,
0xCC000040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x1C8C0002,
0xC810001D,
0x98C00012,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x840003B3,
0xCC000053,
0xC80C002F,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7CC4C000,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x9940FFF5,
0xC820001F,
0x840003B3,
0xC81C0007,
0x80000115,
0xCC00006E,
0x7C40C000,
0xC8100047,
0x1CDC03FF,
0x1894FFF0,
0x9900000F,
0x7D5D4000,
0xC8180044,
0x99800004,
0xC8180009,
0xCD800040,
0xCC000040,
0x8000015D,
0xC81803F0,
0x7C40C000,
0xC8100047,
0x1CDC03FF,
0x1894FFF0,
0x9500FFF5,
0x7D5D4000,
0xC8180045,
0x99800004,
0xC818000A,
0xCD800040,
0xCC000040,
0xC81803F5,
0x1D9C0003,
0x15980002,
0xC9A403F6,
0x11DC0003,
0x7E5E8004,
0x1EA800FF,
0x05540007,
0x15540003,
0x7D6AC010,
0x96C00008,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0x7D5D4003,
0x7E564007,
0xCE5803F6,
0xD8000840,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0xC8100047,
0x1CDC03FF,
0x1894FFF0,
0x9900FFE4,
0x7D5D4000,
0xC81803F0,
0x1D9C0003,
0x15980002,
0xC9A403F1,
0x11DC0003,
0x7E5E8004,
0x1EA800FF,
0x05540007,
0x15540003,
0x7D6AC010,
0x96C00008,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0x7D5D4003,
0x7E564007,
0xCE5803F1,
0xCC800040,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC8100046,
0xC81803F0,
0x05980001,
0x1D98000F,
0xCD8003F0,
0x1D9C0003,
0x19980062,
0xC9A403F1,
0x11DC0003,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0xCE5803F1,
0x04180000,
0x041C0000,
0x840001C1,
0xC9E403F1,
0x840001C1,
0xC9E403F1,
0x840001C1,
0xC9E403F1,
0x840001C1,
0xC9E403F1,
0x7D210007,
0xD8000740,
0xCD000040,
0x840001B6,
0xCD000040,
0xC80C0043,
0x94C00022,
0xC8140048,
0x80000197,
0x04100003,
0xC8100046,
0xC81803F5,
0x05980001,
0x1D98000F,
0xCD8003F5,
0x1D9C0003,
0x19980062,
0xC9A403F6,
0x11DC0003,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0xCE5803F6,
0x04180000,
0x041C0000,
0x840001C1,
0xC9E403F6,
0x840001C1,
0xC9E403F6,
0x840001C1,
0xC9E403F6,
0x840001C1,
0xC9E403F6,
0x7D210007,
0xD80007C0,
0xCD000040,
0x840001B6,
0xCD000040,
0xC8140048,
0x9D400000,
0xCC00006A,
0xC8280016,
0x1EA80001,
0x9A800003,
0xC0290001,
0x88000000,
0xC02C0156,
0xCE80005C,
0xD80008C0,
0xCEC00040,
0x88000000,
0xCC000040,
0x1E6800FF,
0x7E9BC010,
0x97C00003,
0x1A6C1FE8,
0x7E818000,
0x7EDBC010,
0x97C00003,
0x1A701FF0,
0x7EC18000,
0x7F1BC010,
0x97C00003,
0x1A741FF8,
0x7F018000,
0x7F5BC010,
0x97C00003,
0x05DC0001,
0x7F418000,
0x11A00005,
0x88000000,
0x12200010,
0x1C8C0002,
0xC810001E,
0xC820001F,
0x94C00008,
0xC814001C,
0x9900000A,
0xC81C0008,
0x840003B3,
0xCC000054,
0x800001E5,
0xCC800040,
0x99400004,
0xC81C0006,
0x840003B3,
0xCC000052,
0xCC800040,
0x80000000,
0xD4400040,
0xCC400027,
0xCC400028,
0x800003AD,
0xCC00006B,
0xC0320003,
0xC037FFFF,
0x800001F0,
0x7CB08007,
0x7C434000,
0xC8200028,
0xC81C0027,
0xC8180026,
0xCF43A29E,
0x7C414000,
0x52200020,
0x7DE1C027,
0x7D58C003,
0x7CDCC020,
0x54D00020,
0x80000205,
0xCC800040,
0x7C418000,
0xCC800040,
0x80000202,
0xCD800040,
0xC019FFFF,
0xCC800040,
0xCD83A29E,
0x7C40C000,
0x7C410000,
0x7C414000,
0xCCC3A1FA,
0xCD03A1F9,
0xCD43A29D,
0xCCC00040,
0xCD000040,
0xCD400040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00001,
0xCCC3A29F,
0x95000003,
0xD0400026,
0xD0800026,
0xCC800040,
0x80000000,
0xCCC00040,
0x7C40C000,
0xCC800040,
0xCCC3A2A2,
0x80000000,
0xCCC00040,
0x7C40C000,
0x14D4001F,
0xCC800040,
0x95400003,
0x7C410000,
0xCCC00059,
0x1518001F,
0xCCC00040,
0x95800003,
0xCD000040,
0xCD00005A,
0x800003AD,
0xCC00007F,
0xC820001F,
0x7C410000,
0xD8200244,
0xCE200044,
0x7C414000,
0x7C418000,
0xCDA00049,
0xCD200041,
0xCD600041,
0xCDA00041,
0x15100008,
0x11540018,
0x7D53C007,
0xCFC0002F,
0x06200001,
0xCE000058,
0x800003AD,
0xCC00007F,
0xC820001F,
0xCA0C0017,
0x94C00005,
0x7C410000,
0xD82002C6,
0x8000022F,
0xCE200046,
0xCC000048,
0x80000245,
0x00000000,
0xC820001F,
0x7C418000,
0x0A200001,
0xCA14001A,
0xCA180017,
0x7D598007,
0x95800005,
0xCE000058,
0xCCA00046,
0x80000000,
0xCD600046,
0xCCA00044,
0x80000000,
0xCD600044,
0x800003AD,
0xCC40006A,
0xCC800040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0xCCC003FE,
0xCD0003FF,
0xCCC00042,
0xCD000042,
0x1514001F,
0x191800F0,
0x275C0001,
0x7D760006,
0x99800005,
0x7D5E4006,
0xCC000042,
0x800003AD,
0xCC00004D,
0x15980001,
0x152C0008,
0x9980004D,
0x1EEC0001,
0x96000004,
0x1530000C,
0x800003AD,
0xCC000042,
0x04140020,
0xCD400042,
0x1F300001,
0x20280001,
0x840002AC,
0xC8140003,
0x9B40002B,
0x0438001C,
0x840002AC,
0xC8140003,
0x9B400027,
0x04380018,
0x840002AC,
0xC8140003,
0x9B400023,
0x04380014,
0x840002AC,
0xC8140003,
0x9B40001F,
0x04380010,
0x840002AC,
0xC8140003,
0x9B40001B,
0x0438000C,
0x840002AC,
0xC8140003,
0x9B400017,
0x04380008,
0x840002AC,
0xC8140003,
0x9B400013,
0x04380004,
0x840002AC,
0xC8140003,
0x9B400015,
0xC80C03FE,
0x9A800009,
0xC81003FF,
0x9B000116,
0xCC00004D,
0x04140020,
0xCCC00042,
0xCD000042,
0x80000274,
0xCD400042,
0x96C0010F,
0xCC00004D,
0x800003AD,
0xCC00004E,
0x9AC00003,
0xCC00004D,
0xCC00004E,
0xE3830000,
0x80000000,
0xDC0301FF,
0x9AC00105,
0xCC00004D,
0x800003AD,
0xCC00004E,
0xC8180003,
0xC81C0003,
0xC8200003,
0x7D5D400D,
0x7DA1C00D,
0x7D5D4007,
0x1610001F,
0x159C001F,
0x7D1D0006,
0x7D174006,
0x88000000,
0x7E928006,
0x96400004,
0xCC00004E,
0x800003AD,
0xCC000042,
0xD2000042,
0xC8080003,
0xC80C0003,
0xC8100003,
0xC8140003,
0xC8180003,
0xC81C0003,
0xC8240003,
0xC8280003,
0x15FC001F,
0x16B0001F,
0x7FF3C006,
0x14F0001F,
0x7FF3C006,
0x1570001F,
0x7FF3C006,
0x7D888001,
0x97C0000D,
0x7DCCC001,
0x7E510001,
0x7E954001,
0x7C90800C,
0x7CD4C00C,
0x9AC00003,
0x7C8F4006,
0x24B40001,
0x9B4000D7,
0xCC00004D,
0x800003AD,
0xCC00004E,
0xC80C03FE,
0xC81003FF,
0xCCC00042,
0x800002BC,
0xCD000042,
0x7C40C000,
0x7C410000,
0x1914003B,
0xCC00005B,
0x95400013,
0xC8140040,
0x31580002,
0x9580FFFF,
0xC8140040,
0xCC000063,
0x211C8000,
0xCCC12185,
0xCDC12186,
0x1514001F,
0xCC412187,
0xCC412188,
0x9540FD11,
0xCC412189,
0xC8140040,
0x9940FFFF,
0xC8140040,
0x80000001,
0x7C408000,
0xCC800040,
0xCCC00040,
0xCD000040,
0x80000000,
0xD4400040,
0xD08003E0,
0xCC800040,
0x840003B0,
0xCC400040,
0xC80C03E0,
0x98C00000,
0xC80C03E0,
0x7C408000,
0xA0000000,
0x7E828006,
0x7C40C000,
0x8400030E,
0x14D0001F,
0x9900FCF8,
0xD04003E0,
0x840003B0,
0xCC00007F,
0x80000300,
0xC80C03E0,
0xCC800040,
0xCCC00040,
0x88000000,
0xD4400040,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7C40C000,
0xCCC00021,
0xCCC00040,
0xD4400040,
0xCC0003F0,
0xCC0003F1,
0xCC0003F2,
0xCC0003F3,
0xCC0003F4,
0xCC0003F5,
0xCC0003F6,
0xCC0003F7,
0xCC0003F8,
0xCC0003F9,
0xC037FFFF,
0xD00003FB,
0xD00003FC,
0x80000000,
0xCF4003FD,
0x7C40C000,
0x14DC001D,
0x99C00007,
0xCC800040,
0x18DC003C,
0x99C0007F,
0xCCC00040,
0x800003AD,
0xCC00006A,
0x18D8003C,
0xCD800066,
0xCC00006A,
0x800003AD,
0xCCC00040,
0x7C40C000,
0x50500020,
0x840003B0,
0xCC00005D,
0x7CD0C027,
0xC820001F,
0xC8D60000,
0x99400008,
0x7C438000,
0xE3830000,
0xCFA0004F,
0x840003B0,
0xCC00005E,
0x80000000,
0xD440007F,
0x800003AD,
0xCC00005E,
0x840003B0,
0xCC00005D,
0xC820001F,
0x7C40C000,
0xC036FF00,
0xC8100021,
0xC0303FFF,
0x7CF54006,
0x7D518006,
0x7D81800A,
0x99800008,
0x7CF38006,
0xE3830000,
0xCFA0004F,
0x840003B0,
0xCC00005E,
0x80000000,
0xD440007F,
0x800003AD,
0xCC00005E,
0x840003B0,
0x7C40C000,
0x14DC0008,
0x95C00019,
0x1CDC0010,
0x7C410000,
0x99C00004,
0x50540020,
0x80000368,
0xC91D0000,
0x7D150027,
0xC91E0000,
0x7C420000,
0x7C424000,
0x7C418000,
0x7DE5C006,
0x7DE28011,
0x9A80FC93,
0x41AC0005,
0x9AC00000,
0x0AEC0001,
0x1CDC0010,
0x99C00004,
0x00000000,
0x8000036B,
0xC91D0000,
0x8000036B,
0xC91E0000,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00006,
0x29100006,
0x99000007,
0xC814001C,
0x99400005,
0xCC000052,
0xC81C0006,
0x840003B3,
0xC820001F,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0x1518001F,
0xCD00005B,
0x99800004,
0x51140020,
0x80000000,
0xD44D0000,
0x7D4D4027,
0x191C0031,
0xD4560000,
0x95C0FC5B,
0xC8200041,
0x9A000000,
0xC8200041,
0x80000001,
0x7C408000,
0x80000000,
0xD440007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0xCDC00040,
0x88000000,
0xCC000040,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00020003,
0x0003037C,
0x00040384,
0x0005022B,
0x000600E2,
0x000700F1,
0x00080104,
0x000900EA,
0x000A00DF,
0x000B00EE,
0x000C0126,
0x000D0133,
0x000E0174,
0x000F0196,
0x001003AB,
0x0011000A,
0x00120018,
0x00130020,
0x00160022,
0x00240031,
0x0025004C,
0x002601E7,
0x00170247,
0x00180255,
0x00220337,
0x00230348,
0x002701FC,
0x0020025A,
0x0028021E,
0x002901EB,
0x002A0210,
0x002B0200,
0x002F0219,
0x0032023D,
0x0034038C,
0x003501EF,
0x00390257,
0x003C035C,
0x003E03AB,
0x003F022B,
0x004102DF,
0x004202FB,
0x00430305,
0x00440312,
0x004A0329,
0x0055037F,
0x00560387,
0x00600086,
0x006100A3,
0x006200CD,
0x006300B6,
0x006400B6,
0x006500B6,
0x006600B6,
0x006700B6,
0x006800DA,
0x006900E5,
0x006A0156,
0x006B0107,
0x006C0107,
0x006D0107,
0x006E0107,
0x006F0107,
0x0070010C,
0x007300F4,
0x007400F4,
0x007501D5,
0x007B039A,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
};

static const u32 CYPRESS_rlc_microcode[]={
0x20380010,
0x23B80000,
0xCF800012,
0xCC000085,
0x04180001,
0xCD80000E,
0xCD800083,
0xCC000082,
0xCD800081,
0xCC00000B,
0x8000004A,
0x00000000,
0xCC00000E,
0xCC00000E,
0xC8100082,
0x202801C3,
0x201C0000,
0xC8100082,
0xC8080085,
0x7F8B8007,
0xC8080081,
0x94800030,
0x00000000,
0x80000054,
0x00000000,
0xC9CC0083,
0x94C00017,
0x00000000,
0x84000097,
0x200C0001,
0x840000AA,
0x20380000,
0x97800011,
0x200C000D,
0xC0302009,
0xCCF10000,
0xC030200A,
0xC0341818,
0x13740008,
0x23741818,
0xCB0D0000,
0x7CF4C006,
0xC808001A,
0x98800006,
0x201C0001,
0x94C0FFFB,
0x00000000,
0x80000041,
0x7DC1C006,
0x840000BD,
0x11B8001F,
0x840000AA,
0x20380001,
0x84000097,
0x200C0000,
0xC03001C0,
0xCB390000,
0x20380000,
0x95C0FFD3,
0xCF800003,
0x7DC1C006,
0x840000BD,
0x20380000,
0x8000000D,
0xCF800003,
0x20380001,
0xCF800003,
0xC8100082,
0xCC000081,
0xC808001A,
0x9480000E,
0x00000000,
0xCD80000E,
0x00000000,
0x840000A8,
0x20380002,
0xCC310000,
0x840000AA,
0x20380001,
0xCD800081,
0x84000097,
0x200C0000,
0x8000000D,
0x00000000,
0xC8380056,
0x9B80006B,
0x201C0000,
0xC8380057,
0x9B800068,
0x201C0001,
0x201C0000,
0xC8080081,
0x94800012,
0x00000000,
0xC8280000,
0x9680000F,
0x20080001,
0xCD80000E,
0xCC800000,
0x1C1C0000,
0x2A8801BB,
0x94800004,
0x00000000,
0x800000B8,
0x00000000,
0x2A8801BC,
0x98800044,
0x00000000,
0x95000023,
0x00000000,
0xC8280002,
0x96800006,
0x20080001,
0xCD80000E,
0xCC800002,
0x8000008F,
0x00000000,
0xC8280001,
0x96800007,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800001,
0x8000008F,
0x00000000,
0xC8280003,
0x96800009,
0x00000000,
0xCD80000E,
0x2A8C01E5,
0x98C0FF97,
0x20080001,
0xCC800003,
0x8000008F,
0x00000000,
0xC8280004,
0x9680FF85,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800004,
0x8000008F,
0x00000000,
0x84000093,
0x00000000,
0x8000000D,
0x00000000,
0x1EA800FF,
0xCE80000C,
0x88000000,
0x00000000,
0xC0300390,
0xCB390000,
0xC00BFFFE,
0x7F8B8006,
0x10CC0010,
0x7F8F8007,
0xCFB10000,
0x88000000,
0xCB390000,
0xCFB10000,
0xCD80000E,
0xCB390000,
0x17B80004,
0x9780FFFE,
0x00000000,
0x88000000,
0x00000000,
0x800000A0,
0xC03001C1,
0xC0302003,
0xCFB10000,
0x88000000,
0xCB390000,
0xC9F80083,
0x9B800004,
0x00000000,
0x8000000D,
0x00000000,
0xCC1C0083,
0x840000BD,
0x11B8001F,
0x8000000D,
0x00000000,
0xCD9C0083,
0x840000BD,
0x20380000,
0x9500FF54,
0x00000000,
0xC03001C0,
0x88000000,
0xCFB10000,
0x99C0000B,
0xC8300040,
0x23300002,
0xCF000040,
0x840000D5,
0x20380003,
0xC8300040,
0x1F3003FD,
0xCF000040,
0x80000054,
0xCC000056,
0xC8300040,
0x23300040,
0xCF000040,
0x840000E6,
0x20380001,
0xC8300040,
0x1F3003BF,
0xCF000040,
0x80000054,
0xCC000056,
0x840000F1,
0x00000000,
0xC0302008,
0x840000F9,
0x2038FFFF,
0xC0302008,
0xCC310000,
0xCB390000,
0xC0300398,
0x840000F9,
0x20380100,
0xC0300398,
0xCC310000,
0xCB090000,
0xC03021B6,
0x88000000,
0xCC310000,
0x840000F1,
0x00000000,
0x20380001,
0xC0300398,
0x840000F9,
0x13B80014,
0xCC000057,
0xC0300398,
0xCC310000,
0x88000000,
0xCB090000,
0xCF9C0016,
0xCD80000E,
0xC9F00018,
0x7F38800C,
0x9480FFFE,
0x00000000,
0x88000000,
0x00000000,
0xCFB10000,
0xCB390000,
0x2008001F,
0x98800000,
0x08880001,
0xCC1C0016,
0xC9F0001B,
0x9700FFFF,
0x00000000,
0x88000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
};

static const u32 JUNIPER_me_microcode[]={
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xD440007F,
0x1C8C0002,
0x98C0000B,
0x7C410000,
0xC80C000E,
0x98C00003,
0x043C0005,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F4,
0xCC000047,
0x80000000,
0xD0400060,
0xC80C0010,
0x98C00003,
0x043C0023,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F3,
0xCC000049,
0x80000000,
0xD0400060,
0xCC000046,
0x8400002D,
0xCC00004B,
0xCC412264,
0xCC412265,
0xCC412266,
0x80000000,
0xCC41A2DD,
0xCC400046,
0x8400002D,
0xCC00004B,
0x04142264,
0x04182265,
0x041C2266,
0xD8174100,
0xD81B4100,
0xD81F4100,
0x80000000,
0xCC41A2DD,
0xC03A0004,
0x0434226B,
0x0430225C,
0x7F7B4007,
0xCC350000,
0xC83C0004,
0x88000000,
0xCFF10000,
0x7C40C000,
0x94C0FFCA,
0xCC00001F,
0x80000000,
0xCC000041,
0x7C40C000,
0xC0160004,
0x1CD0FFFF,
0x7D150007,
0xCC110000,
0x18D8003E,
0x14DC001F,
0xC8200004,
0x95C00006,
0x7C424000,
0xCC00004D,
0x7E568007,
0xCC290000,
0xC8240004,
0x7E260006,
0x95800006,
0x7C42C000,
0xCC00004D,
0x7ED70007,
0xCC310000,
0xC82C0004,
0x7E2E0007,
0xCC00004D,
0x1D10FFFF,
0x80000000,
0xCE110000,
0x7C40C000,
0x80000000,
0xCC400040,
0xCD41225D,
0xCC400045,
0xCC00004A,
0xCD01225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC412257,
0x7C418000,
0xCC400045,
0xCC40004A,
0xCC41225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0xCC000045,
0x80000064,
0xCC00004A,
0x040CA1FD,
0xC0120001,
0xCC000045,
0xCC00004A,
0x7CD0C007,
0xCC41225C,
0xCC41A1FC,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC41225D,
0xCC000045,
0xCC00004A,
0x084C0001,
0x7C410000,
0x7C414000,
0x1D58FFFF,
0x195C03F0,
0x15600015,
0xCD81A102,
0xCDC12256,
0xCE01225C,
0x94C00005,
0x21240020,
0xCE41A1FC,
0x8000007D,
0x08CC0001,
0xCD01A1FC,
0xCC01A102,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C408000,
0x7C40C000,
0xC02A0002,
0x7C410000,
0x7D290007,
0x1C940001,
0x1C980006,
0x1C9C0300,
0x15DC0008,
0x7C420000,
0x7C424000,
0x9540000F,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0xCCC12169,
0xCD01216A,
0xCE81216B,
0x29B40002,
0xCC01216C,
0x9740000E,
0x29B40000,
0x800000BD,
0xC834000E,
0x29B40002,
0x97400009,
0x29B40000,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0x800000BD,
0xC834000E,
0x97400004,
0x7E028000,
0x800000BD,
0xC834000E,
0x29B40004,
0x9740FF49,
0x00000000,
0xCE01216D,
0xCE41216E,
0xC8280003,
0xC834000E,
0x9B400004,
0xC83C000E,
0x8400034E,
0xCC00004D,
0x29F40000,
0x97400007,
0x0430A2B6,
0x840000DF,
0xCE81A2B7,
0xCF81A2C4,
0x80000000,
0xCFC1A2D1,
0x29F40001,
0x97400007,
0x0430A2BA,
0x840000DF,
0xCE81A2BB,
0xCF81A2C5,
0x80000000,
0xCFC1A2D2,
0x29F40002,
0x97400007,
0x0430A2BE,
0x840000DF,
0xCE81A2BF,
0xCF81A2C6,
0x80000000,
0xCFC1A2D3,
0x0430A2C2,
0x840000DF,
0xCE81A2C3,
0xCF81A2C7,
0x80000000,
0xCFC1A2D4,
0xC02E0004,
0x7F2F0007,
0xCC310000,
0xC82C0004,
0xC0300006,
0x7EF34023,
0xC0300020,
0x7F6B8020,
0x88000000,
0x7FB3C024,
0xCC000042,
0x80000000,
0xCC40001F,
0x7C40C000,
0x7C410000,
0x1914003D,
0x99400013,
0x0414002E,
0x840004DA,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004DA,
0x0418002D,
0xCD41A2A4,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xCCC12100,
0xCD012101,
0xCCC12102,
0xCD012103,
0x800004D7,
0xCD81A2A4,
0x1D181000,
0x95800005,
0xC81C0013,
0x29E40040,
0x9640FFFF,
0xC81C0013,
0xCCC12175,
0xCD012176,
0xC8200014,
0x96000000,
0xC8200014,
0x16280001,
0x9A800004,
0xCC00004F,
0x800004D7,
0xCC00007F,
0x80000109,
0xCCC12175,
0x7C40C000,
0x7C410000,
0xCC000045,
0xCC00004A,
0x40D40003,
0xCD41225C,
0xCD01A1FC,
0xC01A0001,
0x041CA1FD,
0x7DD9C007,
0x7C420000,
0x08CC0001,
0x06240001,
0x06280002,
0xCE1D0000,
0xCE5D0000,
0x98C0FFFA,
0xCE9D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00001,
0x14CC0001,
0x7C414000,
0x95000006,
0x7C418000,
0xCD41216D,
0xCD81216E,
0x80000137,
0xC81C0003,
0xC0220004,
0x7E160007,
0xCC210000,
0xC81C0004,
0x7C424000,
0x98C00004,
0x7C428000,
0x80000000,
0xCDE50000,
0xCE412169,
0xCE81216A,
0xCDC1216B,
0x80000000,
0xCC01216C,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0x7C41C000,
0x18A41FE8,
0x2A68003C,
0x9680000A,
0x7C020000,
0x7C420000,
0x3A300003,
0xCC000058,
0x9B000003,
0x42200005,
0x04200040,
0x80000153,
0x7C024000,
0x7E024000,
0x9A400000,
0x0A640001,
0x1CEC0010,
0x9AC0000A,
0xCC00004D,
0xC02A0004,
0xC82C0020,
0x7E928007,
0xCC000041,
0xCC290000,
0xCEC0001E,
0x80000163,
0xC8300004,
0xCD01216D,
0xCD41216E,
0xC8300003,
0x7F1F0006,
0x1CF40007,
0x13780001,
0x9740002A,
0x07B80168,
0x9F800000,
0x00000000,
0x80000178,
0x7F1B800E,
0x8000017C,
0x7F1B800F,
0x80000180,
0x7F1B800C,
0x80000184,
0x7F1B800D,
0x80000188,
0x7F1B8011,
0x8000018C,
0x7F1B8010,
0x80000191,
0x14A40008,
0x9B800019,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800015,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800011,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B80000D,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800009,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800005,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x14A40008,
0x1E6400FF,
0x2A68003C,
0x9A80FE6D,
0x14EC0008,
0x7C434000,
0x7C438000,
0x7C43C000,
0x96C00007,
0xCC00004D,
0xCF412169,
0xCF81216A,
0xCFC1216B,
0x80000000,
0xCC01216C,
0x80000000,
0xCFF50000,
0xCC000059,
0x840004DA,
0x2A68003C,
0x9A800004,
0xC8280017,
0x80000000,
0xD440007F,
0x9680FFAB,
0x7E024000,
0x8400028C,
0xC00E0002,
0xCC000041,
0x800001AF,
0xCCC1304A,
0x94000000,
0xC83C001C,
0x7C40C000,
0x7C410000,
0xC01E0001,
0x15240012,
0xC0220002,
0x96400005,
0xC0260004,
0xC027FFFB,
0x7D250006,
0xC0260000,
0x7DD28006,
0x7E12C006,
0x7D250007,
0x7C414000,
0x7C418000,
0xCCC12169,
0x9A80000C,
0xCD01216A,
0xCD41216B,
0x96C0FE3C,
0xCD81216C,
0x840004DA,
0xCC00007F,
0xC830001A,
0x97000000,
0xC830001A,
0x80000001,
0x7C408000,
0x840004DA,
0xCC00007F,
0xC8140015,
0xC8180016,
0xCD41216B,
0x96C0FE2E,
0xCD81216C,
0x800001C6,
0xCC00007F,
0xCC0003E5,
0xC82C0020,
0xC00E2024,
0x04103000,
0x20CC226B,
0x04143001,
0xCC000041,
0xD0110000,
0xCCD50000,
0xCEC0001E,
0xC80C0009,
0x98C00000,
0xC80C0009,
0x7C410000,
0x7C414000,
0xCC400043,
0xCC400044,
0xC00E8000,
0x7C424000,
0x7C428000,
0x16AC001F,
0x96C0FE15,
0xC035F000,
0xCE4003E1,
0x1E780003,
0x127C0008,
0x7FF7C006,
0x7FFBC007,
0x16780018,
0xCFC003E2,
0xCF8003E3,
0x12B00002,
0x7F3F0000,
0xCF0003E4,
0x80000463,
0x7C80C000,
0x7C40C000,
0x18D001E8,
0x11280001,
0x95000010,
0x06A801FF,
0x9E800000,
0x00000000,
0x80000217,
0xC0120800,
0x80000225,
0xC8140011,
0x8000022C,
0xC8140012,
0x80000233,
0xCCC1A2A4,
0x8000023C,
0x1CE8003F,
0x80000264,
0x7CC1800B,
0x1CD0003F,
0x29280006,
0x292C0016,
0x7EAE8007,
0xC81C0013,
0x9A80003D,
0x0414002E,
0x80000000,
0xCCC1A2A4,
0xC0120800,
0x7C414000,
0x7D0CC007,
0xC0120008,
0x15580003,
0x155C000C,
0x7C420000,
0x7DD1C006,
0x12200014,
0x7E1E4007,
0x7E4E8007,
0xCE81A2A4,
0x80000000,
0xCD81A1FE,
0xC8140011,
0x04102118,
0x95400000,
0xC8140011,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xC8140012,
0x04102106,
0x95400000,
0xC8140012,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xCCC1A2A4,
0x04100001,
0xCD000019,
0x840004DA,
0xCC00007F,
0xC810001B,
0x99000000,
0xC810001B,
0x80000001,
0x7C408000,
0x2AA00004,
0x2AA40014,
0x7E260007,
0x0414002E,
0x96000008,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004DA,
0x040C002D,
0xCD41A2A4,
0x04102100,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xD4510000,
0x800004D7,
0xCCC1A2A4,
0x840004DA,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004DA,
0x0418002D,
0x8400025A,
0xC81C0013,
0x80000001,
0x7C408000,
0x95C00000,
0xC81C0013,
0xCD41A2A4,
0xCC012100,
0xCC012101,
0xCD812102,
0xCD812103,
0xCD81A2A4,
0x88000000,
0xCC00004D,
0x1D980001,
0x7C410000,
0x7C414000,
0x99800009,
0x7C420000,
0xC83C0032,
0x11980010,
0xC81C000B,
0x3BFC0001,
0x97C0FFFF,
0xC83C0032,
0x80000276,
0xC83C0033,
0x11980010,
0xC81C000A,
0x3BFC0001,
0x97C0FFFF,
0xC83C0033,
0x1568001D,
0x7D594007,
0x9A800004,
0x11E4000A,
0x7E260007,
0xCDC00066,
0xCD012158,
0xCD412159,
0xCE01215A,
0xCCC1A2A4,
0x9A800257,
0x05100004,
0x042C0001,
0x12F0001D,
0x7D714007,
0x12E00010,
0x2220000C,
0xCD012158,
0xCD412159,
0xCE01215A,
0x800004D7,
0xCCC1A2A4,
0x043C0005,
0xCFC1A2A4,
0xC0360002,
0x88000000,
0xCF412010,
0x7C40C000,
0x14D0001D,
0x99000008,
0x14D4001C,
0x9540FD6B,
0xC0260004,
0x22642154,
0xCC250000,
0x80000000,
0xC8280004,
0x800004D7,
0xCD400061,
0x840004DA,
0x7C414000,
0x1D740001,
0x1C780002,
0x9B400003,
0xC80C0029,
0x8400034D,
0x15540010,
0x9B800003,
0x04100010,
0x84000371,
0xCCC1A250,
0xCD01A050,
0x840002FE,
0x04180400,
0x840004DA,
0xCC000063,
0xC83C002D,
0x8400030C,
0xC8100029,
0xC81C002F,
0x1DDC0001,
0xC8240027,
0x95C0000C,
0xC8340031,
0xC8380030,
0xC83C002D,
0x17FC0010,
0x13FC0010,
0x7FD7C007,
0x53740020,
0x7FB78027,
0x47B80550,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240027,
0xC0300001,
0xC8280024,
0x9A800000,
0xC8280024,
0xCF00005B,
0x50D80008,
0x14DC0018,
0x21DC8000,
0xCD812180,
0xCDC12181,
0x51200008,
0x15240018,
0xCE012182,
0xCE412183,
0xCD412184,
0x7C408000,
0xA0000000,
0xCC80004D,
0x840004DA,
0x7C414000,
0x1D740001,
0x1C780002,
0x9B400003,
0xC80C002A,
0x8400034D,
0x15540010,
0x9B800003,
0x04100010,
0x84000371,
0xCCC1A260,
0xCD01A060,
0x840002FE,
0x04180980,
0x840004DA,
0xCC000064,
0xC83C002E,
0x8400030C,
0xC810002A,
0xC81C002F,
0x1DDC0001,
0xC8240028,
0x95C0000C,
0xC8340031,
0xC8380030,
0xC83C002E,
0x17FC0010,
0x13FC0010,
0x7FD7C007,
0x53740020,
0x7FB78027,
0x47B80554,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240028,
0xC8280025,
0x9A800000,
0xC8280025,
0x800002C6,
0xC0300002,
0x0598C000,
0x10DC0008,
0x14E00018,
0xCDD90000,
0xC81C0022,
0xC8240022,
0x1DDC0FFF,
0xCDD90001,
0x7E624007,
0xCE590002,
0xD8185103,
0xD8185104,
0x88000000,
0xD8185107,
0x1BF800F0,
0xC0360800,
0x97800003,
0xC0300080,
0x88000000,
0xC02A0004,
0xCF41217C,
0xCF01217D,
0xCD01217E,
0x22A8217F,
0x04240008,
0x9A400000,
0x0A640001,
0xCC290000,
0xC8200004,
0x1638001F,
0x9B80FFFB,
0x04240008,
0x88000000,
0x00000000,
0xC80C0024,
0x94C00024,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0024,
0x80000331,
0xC80C0025,
0x94C0001B,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0025,
0x840004DA,
0xCC00007F,
0xC83C03FB,
0x9BC00000,
0xC83C03FB,
0xD04003FC,
0xC03E0004,
0xD20121F8,
0x23FC21F9,
0x840004DA,
0xCC3D0000,
0xC8380004,
0x1BB4003E,
0x1FB00004,
0x7F02C00B,
0x1EE80004,
0x7EB64007,
0x9A40FFF6,
0xC03E0004,
0xD00003FC,
0x7C410000,
0x80000001,
0x7C408000,
0x8400034D,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC83C000E,
0x97C00003,
0xD30003E6,
0x88000000,
0x043C0026,
0xCFC1A2A4,
0xC83C03E6,
0x0BFC0001,
0xCFC003E6,
0x9BC0FFFB,
0xCC00004D,
0xC83C03E5,
0x97C0000C,
0xC83C0013,
0x97C00000,
0xC83C0013,
0x043C2100,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0x043C0029,
0xCFC1A2A4,
0xCC80004D,
0x043C0005,
0xCFC1A2A4,
0xCC01A1F4,
0x840004DA,
0xCC000047,
0x88000000,
0xCC00007F,
0x84000371,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x043C0022,
0xCFC1A2A4,
0x840004DA,
0xCC000048,
0x88000000,
0xCC00007F,
0x8400037C,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC83C03E5,
0x97C0000C,
0xC83C0013,
0x97C00000,
0xC83C0013,
0x043C2100,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0xCC3D0000,
0x043C0029,
0xCFC1A2A4,
0xCC80004D,
0x043C0023,
0xCFC1A2A4,
0xCC01A1F3,
0x840004DA,
0xCC000049,
0x88000000,
0xCC00007F,
0x80000000,
0x7C40C000,
0x80000000,
0x7C40C000,
0xC0120001,
0x7C514007,
0x80000000,
0xD4550000,
0x840004DA,
0xCC400065,
0xC81C0025,
0xC8240024,
0x7DE5C007,
0x99C0FFFE,
0xC81C0025,
0x80000001,
0x7C408000,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0x151C001F,
0xCCC000C7,
0xCD0000C8,
0x95C00003,
0xC01C8000,
0xCDC12010,
0xE1830000,
0x055C2000,
0xCC00004D,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000C9,
0xCD0000CA,
0xE1830000,
0x055CA000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CB,
0xCD0000CC,
0xE1830000,
0x055CE940,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CD,
0xCD0000CE,
0xE1830000,
0x055CE880,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CF,
0xCD0000D0,
0xE1830000,
0x055CC000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D1,
0xCD0000D2,
0xE1830000,
0x055CF000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D3,
0xCD0000D4,
0xE1830000,
0x055CF3FC,
0x80000000,
0xDC1F4100,
0xD4432000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443A000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E940,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E880,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F3FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CA000,
0xCC43A000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CC000,
0xCC43C000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0xC8130002,
0x94C00003,
0xC8170002,
0xC81B0002,
0x041CF3FC,
0xCC03F3FC,
0xD81FC100,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC8280026,
0xC82C0028,
0x2AB000FF,
0x2AF400FF,
0x7F738007,
0x9B80FFFB,
0xC01E0010,
0xC80C0029,
0x50D00008,
0x10540002,
0x8000043A,
0x7D158020,
0xC8280026,
0xC82C0027,
0x2AB000FF,
0x2AF400FF,
0x7F738007,
0x9B80FFFB,
0xC01E0020,
0xC80C002A,
0x50D00008,
0x08540400,
0x11540002,
0x7D518020,
0xCDC00062,
0xD45A0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00003,
0x11280001,
0x9500000A,
0x06A80444,
0x9E800000,
0x7C418000,
0x80000452,
0x7C41C000,
0x80000458,
0x7C41C000,
0x8000045E,
0x7C41C000,
0x7C418000,
0x7C41C000,
0x14D40010,
0x0554A000,
0x80000000,
0xCD950000,
0xC0220004,
0x0598A000,
0x7DA18007,
0xCC190000,
0x8000044E,
0xC8180004,
0xC0220004,
0xCD8125D6,
0x222025D7,
0xCC210000,
0x8000044E,
0xC8180004,
0xCD81216D,
0xCDC1216E,
0x8000044E,
0xC8180003,
0x7C40C000,
0xC81003E1,
0xC81403E4,
0xC81803E2,
0xC81C03E3,
0xCD812169,
0xCDC1216A,
0xCCC1216B,
0xCC01216C,
0x04200004,
0x7DA18000,
0x7D96400C,
0x9640FB92,
0xCD8003E2,
0x1D280003,
0xC02DF000,
0x11180008,
0x7DAD8006,
0x7DA98007,
0x80000000,
0xCD8003E2,
0x7C40C000,
0x80000000,
0xCC4C03E0,
0x1C8CFFFF,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC8140023,
0x31580004,
0x9580FFFF,
0xC8140023,
0xCC00005B,
0xCC412180,
0x204C8000,
0xCCC12181,
0x14D0001F,
0xCC412182,
0xCC412183,
0x9500FB76,
0xCC412184,
0xC8140023,
0x9940FFFF,
0xC8140023,
0x80000001,
0x7C408000,
0xC0160004,
0x21542140,
0xCC550000,
0xC8180004,
0x80000000,
0xCC0003E0,
0xC02A0004,
0x7C40C000,
0xCCC1217C,
0xCC41217D,
0xCC41217E,
0x7C418000,
0x14FC001F,
0x1D98FFFF,
0x39B00003,
0x22A0217F,
0x9B000003,
0x419C0005,
0x041C0040,
0x99C00000,
0x09DC0001,
0xCC210000,
0xC8240004,
0x166C001F,
0x419C0005,
0x9AC0FFFA,
0xCC80004D,
0x9BC0FB54,
0x00000000,
0x80000000,
0xCC0003E0,
0x7C40C000,
0x7C410000,
0x1518001F,
0x51140020,
0x99800012,
0x191C0031,
0xC8280027,
0xC82C0028,
0x2AB000FF,
0x2AF400FF,
0x7F738007,
0x9B80FFFC,
0xC8280027,
0xCD000062,
0x7D4D4027,
0xD4560000,
0x95C0FB40,
0xC8200026,
0x9A000000,
0xC8200026,
0x80000001,
0x7C408000,
0xE03A0000,
0xC0260004,
0xCCC12169,
0x7D250007,
0xCD01216A,
0x0BB80002,
0xCC41216B,
0x9B80FFFE,
0xCC41216C,
0x99C0FCF7,
0xCC00007F,
0x80000001,
0x7C408000,
0xC00E0100,
0xCC000041,
0xCCC1304A,
0xC83C007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x0001047A,
0x00100003,
0x00120005,
0x0015001A,
0x00160022,
0x00170035,
0x0021003A,
0x00240057,
0x00250057,
0x00270061,
0x00280054,
0x00290062,
0x002A005F,
0x002B0062,
0x002D0069,
0x002E006C,
0x002F0077,
0x00300079,
0x003200EA,
0x0034008E,
0x00350062,
0x003900EC,
0x003A0114,
0x003B0129,
0x003C0141,
0x003D01B1,
0x003F00E9,
0x0041047F,
0x00420491,
0x00430497,
0x004401D6,
0x00450141,
0x004601FA,
0x004701FA,
0x004801FA,
0x004A0291,
0x004B0390,
0x004C029D,
0x004D02D4,
0x004E0320,
0x004F0329,
0x00510377,
0x00520348,
0x0053036C,
0x00540392,
0x00570394,
0x006003A1,
0x006103B0,
0x00620398,
0x006303BA,
0x006403C4,
0x006503CE,
0x006603D8,
0x006703E2,
0x006803EC,
0x006903F0,
0x006A0422,
0x006B03F4,
0x006C03F8,
0x006D03FC,
0x006E0400,
0x006F0404,
0x007003FC,
0x0071042E,
0x00720416,
0x00730408,
0x0074040F,
0x0075043F,
0x007A04B0,
0x007C0462,
0x007D0477,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
0x000F04D3,
};

static const u32 JUNIPER_pfp_microcode[]={
0x7C408000,
0xA0000000,
0x04280001,
0x80000000,
0xE0030000,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x104C0001,
0x98C00005,
0x1C900002,
0xCC400029,
0x800003AD,
0xCC40002A,
0x99000005,
0x00000000,
0xCC40002B,
0x800003AD,
0xCC40002C,
0xCC40002D,
0x800003AD,
0xCC40002E,
0x1C8C0002,
0xCC800040,
0x98C00004,
0xCC400040,
0x800003AD,
0xCC000052,
0x800003AD,
0xCC000054,
0x80000000,
0xCC4003FD,
0xC810002E,
0xC80C002D,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0C00043,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1000043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC000040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x45180008,
0xC99E0000,
0xC82403FD,
0x7DE68011,
0x96800003,
0x7E5EC001,
0x7C02C006,
0xCEC3A29E,
0x55140020,
0xCC00006C,
0xCD00006D,
0xCD40006D,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1400043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC800040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0xC83521A3,
0x1B7807F0,
0x2BB40008,
0x9740FFFD,
0xC83803FC,
0x9B800000,
0xC83803FC,
0x840003B0,
0xD04003FB,
0xC83803FC,
0x9B80FFFB,
0x043C001B,
0xCC00005B,
0x840003B0,
0xCFC121F8,
0xC83921F9,
0x1BB40078,
0x9B40FFFC,
0xCC00005B,
0xD00003FB,
0x7C408000,
0xA0000000,
0x04280001,
0xC8180015,
0x1D980001,
0x7C424000,
0x95800322,
0x7C428000,
0xC81C0020,
0xC037C000,
0x7C40C000,
0x7C410000,
0x7CB48006,
0xC0360003,
0x99C00000,
0xC81C0020,
0x7CB48007,
0x10D40002,
0x7D654000,
0xCD400043,
0xCE800043,
0xCD000043,
0xCC800040,
0xCE400040,
0xCE800040,
0xCCC00040,
0xE03A0000,
0x9780FF62,
0xCD000040,
0x7C40C000,
0x80000094,
0x7C410000,
0x1C8C0002,
0xC810001C,
0x98C00009,
0xC820001F,
0x99000004,
0xC81C0006,
0x840003B3,
0xCC000052,
0xC8180015,
0x80000088,
0x1D980002,
0xC810001E,
0x9900FFFC,
0xC81C0008,
0x840003B3,
0xCC000054,
0xC8180015,
0x80000088,
0x1D980002,
0x1C8C0002,
0xC810001D,
0x98C0000F,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x840003B3,
0xCC000053,
0xC8180015,
0x94C00003,
0x189401E8,
0x05540006,
0x20100001,
0x7D150003,
0x80000088,
0x7D918006,
0x9940FFF8,
0xC820001F,
0x840003B3,
0xC81C0007,
0x800000BF,
0xCC00006E,
0xC00E8080,
0xCC000067,
0x04D08080,
0xCC000068,
0xCD0003F1,
0xCD0003F2,
0xCD0003F3,
0xCD0003F4,
0xCD0003F6,
0xCD0003F7,
0xCD0003F8,
0x80000005,
0xCD0003F9,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0x800000E4,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0x800000F4,
0xCC000040,
0xC820001F,
0x800000F3,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xC80C0029,
0xC810002A,
0xCC800040,
0xCC400040,
0x51100020,
0x7CD0C027,
0x10500002,
0x7D0D0020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0400043,
0xCC000040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x1C8C0002,
0xC810001D,
0x98C00012,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x840003B3,
0xCC000053,
0xC80C002F,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7CC4C000,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x9940FFF5,
0xC820001F,
0x840003B3,
0xC81C0007,
0x80000115,
0xCC00006E,
0x7C40C000,
0xC8100047,
0x1CDC03FF,
0x1894FFF0,
0x9900000F,
0x7D5D4000,
0xC8180044,
0x99800004,
0xC8180009,
0xCD800040,
0xCC000040,
0x8000015D,
0xC81803F0,
0x7C40C000,
0xC8100047,
0x1CDC03FF,
0x1894FFF0,
0x9500FFF5,
0x7D5D4000,
0xC8180045,
0x99800004,
0xC818000A,
0xCD800040,
0xCC000040,
0xC81803F5,
0x1D9C0003,
0x15980002,
0xC9A403F6,
0x11DC0003,
0x7E5E8004,
0x1EA800FF,
0x05540007,
0x15540003,
0x7D6AC010,
0x96C00008,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0x7D5D4003,
0x7E564007,
0xCE5803F6,
0xD8000840,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0xC8100047,
0x1CDC03FF,
0x1894FFF0,
0x9900FFE4,
0x7D5D4000,
0xC81803F0,
0x1D9C0003,
0x15980002,
0xC9A403F1,
0x11DC0003,
0x7E5E8004,
0x1EA800FF,
0x05540007,
0x15540003,
0x7D6AC010,
0x96C00008,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0x7D5D4003,
0x7E564007,
0xCE5803F1,
0xCC800040,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC8100046,
0xC81803F0,
0x05980001,
0x1D98000F,
0xCD8003F0,
0x1D9C0003,
0x19980062,
0xC9A403F1,
0x11DC0003,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0xCE5803F1,
0x04180000,
0x041C0000,
0x840001C1,
0xC9E403F1,
0x840001C1,
0xC9E403F1,
0x840001C1,
0xC9E403F1,
0x840001C1,
0xC9E403F1,
0x7D210007,
0xD8000740,
0xCD000040,
0x840001B6,
0xCD000040,
0xC80C0043,
0x94C00022,
0xC8140048,
0x80000197,
0x04100003,
0xC8100046,
0xC81803F5,
0x05980001,
0x1D98000F,
0xCD8003F5,
0x1D9C0003,
0x19980062,
0xC9A403F6,
0x11DC0003,
0x042C00FF,
0x7EDEC003,
0x7EC2C00B,
0x7E6E4006,
0xCE5803F6,
0x04180000,
0x041C0000,
0x840001C1,
0xC9E403F6,
0x840001C1,
0xC9E403F6,
0x840001C1,
0xC9E403F6,
0x840001C1,
0xC9E403F6,
0x7D210007,
0xD80007C0,
0xCD000040,
0x840001B6,
0xCD000040,
0xC8140048,
0x9D400000,
0xCC00006A,
0xC8280016,
0x1EA80001,
0x9A800003,
0xC0290001,
0x88000000,
0xC02C0156,
0xCE80005C,
0xD80008C0,
0xCEC00040,
0x88000000,
0xCC000040,
0x1E6800FF,
0x7E9BC010,
0x97C00003,
0x1A6C1FE8,
0x7E818000,
0x7EDBC010,
0x97C00003,
0x1A701FF0,
0x7EC18000,
0x7F1BC010,
0x97C00003,
0x1A741FF8,
0x7F018000,
0x7F5BC010,
0x97C00003,
0x05DC0001,
0x7F418000,
0x11A00005,
0x88000000,
0x12200010,
0x1C8C0002,
0xC810001E,
0xC820001F,
0x94C00008,
0xC814001C,
0x9900000A,
0xC81C0008,
0x840003B3,
0xCC000054,
0x800001E5,
0xCC800040,
0x99400004,
0xC81C0006,
0x840003B3,
0xCC000052,
0xCC800040,
0x80000000,
0xD4400040,
0xCC400027,
0xCC400028,
0x800003AD,
0xCC00006B,
0xC0320003,
0xC037FFFF,
0x800001F0,
0x7CB08007,
0x7C434000,
0xC8200028,
0xC81C0027,
0xC8180026,
0xCF43A29E,
0x7C414000,
0x52200020,
0x7DE1C027,
0x7D58C003,
0x7CDCC020,
0x54D00020,
0x80000205,
0xCC800040,
0x7C418000,
0xCC800040,
0x80000202,
0xCD800040,
0xC019FFFF,
0xCC800040,
0xCD83A29E,
0x7C40C000,
0x7C410000,
0x7C414000,
0xCCC3A1FA,
0xCD03A1F9,
0xCD43A29D,
0xCCC00040,
0xCD000040,
0xCD400040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00001,
0xCCC3A29F,
0x95000003,
0xD0400026,
0xD0800026,
0xCC800040,
0x80000000,
0xCCC00040,
0x7C40C000,
0xCC800040,
0xCCC3A2A2,
0x80000000,
0xCCC00040,
0x7C40C000,
0x14D4001F,
0xCC800040,
0x95400003,
0x7C410000,
0xCCC00059,
0x1518001F,
0xCCC00040,
0x95800003,
0xCD000040,
0xCD00005A,
0x800003AD,
0xCC00007F,
0xC820001F,
0x7C410000,
0xD8200244,
0xCE200044,
0x7C414000,
0x7C418000,
0xCDA00049,
0xCD200041,
0xCD600041,
0xCDA00041,
0x15100008,
0x11540018,
0x7D53C007,
0xCFC0002F,
0x06200001,
0xCE000058,
0x800003AD,
0xCC00007F,
0xC820001F,
0xCA0C0017,
0x94C00005,
0x7C410000,
0xD82002C6,
0x8000022F,
0xCE200046,
0xCC000048,
0x80000245,
0x00000000,
0xC820001F,
0x7C418000,
0x0A200001,
0xCA14001A,
0xCA180017,
0x7D598007,
0x95800005,
0xCE000058,
0xCCA00046,
0x80000000,
0xCD600046,
0xCCA00044,
0x80000000,
0xCD600044,
0x800003AD,
0xCC40006A,
0xCC800040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0xCCC003FE,
0xCD0003FF,
0xCCC00042,
0xCD000042,
0x1514001F,
0x191800F0,
0x275C0001,
0x7D760006,
0x99800005,
0x7D5E4006,
0xCC000042,
0x800003AD,
0xCC00004D,
0x15980001,
0x152C0008,
0x9980004D,
0x1EEC0001,
0x96000004,
0x1530000C,
0x800003AD,
0xCC000042,
0x04140020,
0xCD400042,
0x1F300001,
0x20280001,
0x840002AC,
0xC8140003,
0x9B40002B,
0x0438001C,
0x840002AC,
0xC8140003,
0x9B400027,
0x04380018,
0x840002AC,
0xC8140003,
0x9B400023,
0x04380014,
0x840002AC,
0xC8140003,
0x9B40001F,
0x04380010,
0x840002AC,
0xC8140003,
0x9B40001B,
0x0438000C,
0x840002AC,
0xC8140003,
0x9B400017,
0x04380008,
0x840002AC,
0xC8140003,
0x9B400013,
0x04380004,
0x840002AC,
0xC8140003,
0x9B400015,
0xC80C03FE,
0x9A800009,
0xC81003FF,
0x9B000116,
0xCC00004D,
0x04140020,
0xCCC00042,
0xCD000042,
0x80000274,
0xCD400042,
0x96C0010F,
0xCC00004D,
0x800003AD,
0xCC00004E,
0x9AC00003,
0xCC00004D,
0xCC00004E,
0xE3830000,
0x80000000,
0xDC0301FF,
0x9AC00105,
0xCC00004D,
0x800003AD,
0xCC00004E,
0xC8180003,
0xC81C0003,
0xC8200003,
0x7D5D400D,
0x7DA1C00D,
0x7D5D4007,
0x1610001F,
0x159C001F,
0x7D1D0006,
0x7D174006,
0x88000000,
0x7E928006,
0x96400004,
0xCC00004E,
0x800003AD,
0xCC000042,
0xD2000042,
0xC8080003,
0xC80C0003,
0xC8100003,
0xC8140003,
0xC8180003,
0xC81C0003,
0xC8240003,
0xC8280003,
0x15FC001F,
0x16B0001F,
0x7FF3C006,
0x14F0001F,
0x7FF3C006,
0x1570001F,
0x7FF3C006,
0x7D888001,
0x97C0000D,
0x7DCCC001,
0x7E510001,
0x7E954001,
0x7C90800C,
0x7CD4C00C,
0x9AC00003,
0x7C8F4006,
0x24B40001,
0x9B4000D7,
0xCC00004D,
0x800003AD,
0xCC00004E,
0xC80C03FE,
0xC81003FF,
0xCCC00042,
0x800002BC,
0xCD000042,
0x7C40C000,
0x7C410000,
0x1914003B,
0xCC00005B,
0x95400013,
0xC8140040,
0x31580002,
0x9580FFFF,
0xC8140040,
0xCC000063,
0x211C8000,
0xCCC12185,
0xCDC12186,
0x1514001F,
0xCC412187,
0xCC412188,
0x9540FD11,
0xCC412189,
0xC8140040,
0x9940FFFF,
0xC8140040,
0x80000001,
0x7C408000,
0xCC800040,
0xCCC00040,
0xCD000040,
0x80000000,
0xD4400040,
0xD08003E0,
0xCC800040,
0x840003B0,
0xCC400040,
0xC80C03E0,
0x98C00000,
0xC80C03E0,
0x7C408000,
0xA0000000,
0x7E828006,
0x7C40C000,
0x8400030E,
0x14D0001F,
0x9900FCF8,
0xD04003E0,
0x840003B0,
0xCC00007F,
0x80000300,
0xC80C03E0,
0xCC800040,
0xCCC00040,
0x88000000,
0xD4400040,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7C40C000,
0xCCC00021,
0xCCC00040,
0xD4400040,
0xCC0003F0,
0xCC0003F1,
0xCC0003F2,
0xCC0003F3,
0xCC0003F4,
0xCC0003F5,
0xCC0003F6,
0xCC0003F7,
0xCC0003F8,
0xCC0003F9,
0xC037FFFF,
0xD00003FB,
0xD00003FC,
0x80000000,
0xCF4003FD,
0x7C40C000,
0x14DC001D,
0x99C00007,
0xCC800040,
0x18DC003C,
0x99C0007F,
0xCCC00040,
0x800003AD,
0xCC00006A,
0x18D8003C,
0xCD800066,
0xCC00006A,
0x800003AD,
0xCCC00040,
0x7C40C000,
0x50500020,
0x840003B0,
0xCC00005D,
0x7CD0C027,
0xC820001F,
0xC8D60000,
0x99400008,
0x7C438000,
0xE3830000,
0xCFA0004F,
0x840003B0,
0xCC00005E,
0x80000000,
0xD440007F,
0x800003AD,
0xCC00005E,
0x840003B0,
0xCC00005D,
0xC820001F,
0x7C40C000,
0xC036FF00,
0xC8100021,
0xC0303FFF,
0x7CF54006,
0x7D518006,
0x7D81800A,
0x99800008,
0x7CF38006,
0xE3830000,
0xCFA0004F,
0x840003B0,
0xCC00005E,
0x80000000,
0xD440007F,
0x800003AD,
0xCC00005E,
0x840003B0,
0x7C40C000,
0x14DC0008,
0x95C00019,
0x1CDC0010,
0x7C410000,
0x99C00004,
0x50540020,
0x80000368,
0xC91D0000,
0x7D150027,
0xC91E0000,
0x7C420000,
0x7C424000,
0x7C418000,
0x7DE5C006,
0x7DE28011,
0x9A80FC93,
0x41AC0005,
0x9AC00000,
0x0AEC0001,
0x1CDC0010,
0x99C00004,
0x00000000,
0x8000036B,
0xC91D0000,
0x8000036B,
0xC91E0000,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00006,
0x29100006,
0x99000007,
0xC814001C,
0x99400005,
0xCC000052,
0xC81C0006,
0x840003B3,
0xC820001F,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0x1518001F,
0xCD00005B,
0x99800004,
0x51140020,
0x80000000,
0xD44D0000,
0x7D4D4027,
0x191C0031,
0xD4560000,
0x95C0FC5B,
0xC8200041,
0x9A000000,
0xC8200041,
0x80000001,
0x7C408000,
0x80000000,
0xD440007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0xCDC00040,
0x88000000,
0xCC000040,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00020003,
0x0003037C,
0x00040384,
0x0005022B,
0x000600E2,
0x000700F1,
0x00080104,
0x000900EA,
0x000A00DF,
0x000B00EE,
0x000C0126,
0x000D0133,
0x000E0174,
0x000F0196,
0x001003AB,
0x0011000A,
0x00120018,
0x00130020,
0x00160022,
0x00240031,
0x0025004C,
0x002601E7,
0x00170247,
0x00180255,
0x00220337,
0x00230348,
0x002701FC,
0x0020025A,
0x0028021E,
0x002901EB,
0x002A0210,
0x002B0200,
0x002F0219,
0x0032023D,
0x0034038C,
0x003501EF,
0x00390257,
0x003C035C,
0x003E03AB,
0x003F022B,
0x004102DF,
0x004202FB,
0x00430305,
0x00440312,
0x004A0329,
0x0055037F,
0x00560387,
0x00600086,
0x006100A3,
0x006200CD,
0x006300B6,
0x006400B6,
0x006500B6,
0x006600B6,
0x006700B6,
0x006800DA,
0x006900E5,
0x006A0156,
0x006B0107,
0x006C0107,
0x006D0107,
0x006E0107,
0x006F0107,
0x0070010C,
0x007300F4,
0x007400F4,
0x007501D5,
0x007B039A,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
};

static const u32 JUNIPER_rlc_microcode[]={
0x20380010,
0x23B80000,
0xCF800012,
0xCC000085,
0x04180001,
0xCD80000E,
0xCD800083,
0xCC000082,
0xCD800081,
0xCC00000B,
0x8000004A,
0x00000000,
0xCC00000E,
0xCC00000E,
0xC8100082,
0x202801C3,
0x201C0000,
0xC8100082,
0xC8080085,
0x7F8B8007,
0xC8080081,
0x94800030,
0x00000000,
0x80000054,
0x00000000,
0xC9CC0083,
0x94C00017,
0x00000000,
0x84000097,
0x200C0001,
0x840000AA,
0x20380000,
0x97800011,
0x200C000D,
0xC0302009,
0xCCF10000,
0xC030200A,
0xC0341818,
0x13740008,
0x23741818,
0xCB0D0000,
0x7CF4C006,
0xC808001A,
0x98800006,
0x201C0001,
0x94C0FFFB,
0x00000000,
0x80000041,
0x7DC1C006,
0x840000BD,
0x11B8001F,
0x840000AA,
0x20380001,
0x84000097,
0x200C0000,
0xC03001C0,
0xCB390000,
0x20380000,
0x95C0FFD3,
0xCF800003,
0x7DC1C006,
0x840000BD,
0x20380000,
0x8000000D,
0xCF800003,
0x20380001,
0xCF800003,
0xC8100082,
0xCC000081,
0xC808001A,
0x9480000E,
0x00000000,
0xCD80000E,
0x00000000,
0x840000A8,
0x20380002,
0xCC310000,
0x840000AA,
0x20380001,
0xCD800081,
0x84000097,
0x200C0000,
0x8000000D,
0x00000000,
0xC8380056,
0x9B80006B,
0x201C0000,
0xC8380057,
0x9B800068,
0x201C0001,
0x201C0000,
0xC8080081,
0x94800012,
0x00000000,
0xC8280000,
0x9680000F,
0x20080001,
0xCD80000E,
0xCC800000,
0x1C1C0000,
0x2A8801BB,
0x94800004,
0x00000000,
0x800000B8,
0x00000000,
0x2A8801BC,
0x98800044,
0x00000000,
0x95000023,
0x00000000,
0xC8280002,
0x96800006,
0x20080001,
0xCD80000E,
0xCC800002,
0x8000008F,
0x00000000,
0xC8280001,
0x96800007,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800001,
0x8000008F,
0x00000000,
0xC8280003,
0x96800009,
0x00000000,
0xCD80000E,
0x2A8C01E5,
0x98C0FF97,
0x20080001,
0xCC800003,
0x8000008F,
0x00000000,
0xC8280004,
0x9680FF85,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800004,
0x8000008F,
0x00000000,
0x84000093,
0x00000000,
0x8000000D,
0x00000000,
0x1EA800FF,
0xCE80000C,
0x88000000,
0x00000000,
0xC0300390,
0xCB390000,
0xC00BFFFE,
0x7F8B8006,
0x10CC0010,
0x7F8F8007,
0xCFB10000,
0x88000000,
0xCB390000,
0xCFB10000,
0xCD80000E,
0xCB390000,
0x17B80004,
0x9780FFFE,
0x00000000,
0x88000000,
0x00000000,
0x800000A0,
0xC03001C1,
0xC0302003,
0xCFB10000,
0x88000000,
0xCB390000,
0xC9F80083,
0x9B800004,
0x00000000,
0x8000000D,
0x00000000,
0xCC1C0083,
0x840000BD,
0x11B8001F,
0x8000000D,
0x00000000,
0xCD9C0083,
0x840000BD,
0x20380000,
0x9500FF54,
0x00000000,
0xC03001C0,
0x88000000,
0xCFB10000,
0x99C0000B,
0xC8300040,
0x23300002,
0xCF000040,
0x840000D5,
0x20380003,
0xC8300040,
0x1F3003FD,
0xCF000040,
0x80000054,
0xCC000056,
0xC8300040,
0x23300040,
0xCF000040,
0x840000E6,
0x20380001,
0xC8300040,
0x1F3003BF,
0xCF000040,
0x80000054,
0xCC000056,
0x840000F1,
0x00000000,
0xC0302008,
0x840000F9,
0x2038FFFF,
0xC0302008,
0xCC310000,
0xCB390000,
0xC0300398,
0x840000F9,
0x20380100,
0xC0300398,
0xCC310000,
0xCB090000,
0xC03021B6,
0x88000000,
0xCC310000,
0x840000F1,
0x00000000,
0x20380001,
0xC0300398,
0x840000F9,
0x13B80014,
0xCC000057,
0xC0300398,
0xCC310000,
0x88000000,
0xCB090000,
0xCF9C0016,
0xCD80000E,
0xC9F00018,
0x7F38800C,
0x9480FFFE,
0x00000000,
0x88000000,
0x00000000,
0xCFB10000,
0xCB390000,
0x2008001F,
0x98800000,
0x08880001,
0xCC1C0016,
0xC9F0001B,
0x9700FFFF,
0x00000000,
0x88000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
};

static const u32 R600_rlc_microcode[]={
0x00280410,
0x00284400,
0x00D44011,
0x00D40079,
0x00041801,
0x00D5807A,
0x00D40074,
0x00D40073,
0x00D4000B,
0x008402B2,
0x0031841F,
0x0084023F,
0x00280401,
0x00D4000E,
0x00282004,
0x00C81074,
0x00C80436,
0x009842D0,
0x002829DE,
0x00C80479,
0x00984008,
0x00000000,
0x00C8280A,
0x00968005,
0x00000000,
0x002829DF,
0x00800088,
0x00D5800E,
0x00C82800,
0x00968029,
0x00280801,
0x00D48000,
0x000E89BB,
0x00948009,
0x00CAC401,
0x009500FD,
0x0030440C,
0x00D04804,
0x009480F1,
0x00282001,
0x0080012A,
0x00000000,
0x000E89BC,
0x009880DC,
0x00282006,
0x009501FB,
0x000E89BE,
0x00948004,
0x00000000,
0x00D58079,
0x0080000D,
0x000E89BD,
0x00948004,
0x00000000,
0x00D40079,
0x0080000D,
0x000E89B4,
0x009880F1,
0x00282004,
0x001689B7,
0x009881EC,
0x001E89BA,
0x009881EA,
0x00000000,
0x000E89BA,
0x009480E9,
0x00282004,
0x00282002,
0x0080012A,
0x00000000,
0x00C82802,
0x00968017,
0x00280801,
0x00D48002,
0x009501DE,
0x00268401,
0x00984003,
0x00000000,
0x00282000,
0x002289C8,
0x001A8DDD,
0x007C8C8B,
0x009880D8,
0x00228998,
0x001A8D9B,
0x007C8C8B,
0x009880D4,
0x002289A8,
0x001A8DAB,
0x007C8C8B,
0x009880D0,
0x00000000,
0x00800228,
0x00000000,
0x00C82801,
0x0096800B,
0x00280801,
0x00D48001,
0x009501C6,
0x000E89E8,
0x009880C6,
0x000E89EA,
0x009880C4,
0x00000000,
0x00800228,
0x00000000,
0x00C82803,
0x00968007,
0x000E8DE5,
0x0098C0FD,
0x00280801,
0x00D48003,
0x00800228,
0x00000000,
0x00C82804,
0x00968009,
0x00280801,
0x00D48004,
0x009501B2,
0x000E89E2,
0x009880B2,
0x00000000,
0x00800228,
0x00000000,
0x00C82805,
0x00968393,
0x00280801,
0x00D48005,
0x009501A8,
0x000E8992,
0x009880A8,
0x000E8994,
0x009481A4,
0x00000000,
0x0080012A,
0x00282002,
0x008400BD,
0x00282003,
0x00CAC400,
0x00244402,
0x00944006,
0x00000000,
0x00C80478,
0x00D44077,
0x0080012E,
0x00000000,
0x008402B2,
0x0031841F,
0x00CAC400,
0x00244401,
0x0098403F,
0x00000000,
0x00C8047A,
0x00D4007A,
0x00C8087D,
0x00CACC0B,
0x007C8C82,
0x00944006,
0x00000000,
0x0094800B,
0x00000000,
0x008000A7,
0x00000000,
0x0094808B,
0x00000000,
0x00800295,
0x00000000,
0x008402B2,
0x0031841F,
0x00800295,
0x00C8047D,
0x00C8087F,
0x007C4842,
0x00984004,
0x00000000,
0x008402B5,
0x00000000,
0x00CAC401,
0x0030440C,
0x00D04800,
0x00248801,
0x00988105,
0x00000000,
0x00840204,
0x00000000,
0x008402C8,
0x00000000,
0x00800295,
0x00000000,
0x00C80421,
0x00304408,
0x00280840,
0x00C81022,
0x0095034C,
0x00000000,
0x00D50078,
0x00D40077,
0x007C00C0,
0x0004CC0C,
0x00091001,
0x009903FE,
0x00000000,
0x00D05000,
0x00D50800,
0x0008CC01,
0x0094C006,
0x00000000,
0x00044404,
0x00048801,
0x008000CA,
0x00000000,
0x00880000,
0x00282C40,
0x00D58074,
0x00CAE40B,
0x00CADC02,
0x00D6407F,
0x00D6407D,
0x00366404,
0x00D6400B,
0x00D6402D,
0x00D5C07E,
0x00D5C07C,
0x00C80424,
0x00304408,
0x00D4407B,
0x00CAC400,
0x00244410,
0x00984329,
0x00000000,
0x00840237,
0x00280401,
0x000C4402,
0x00984198,
0x002805F1,
0x007DC04C,
0x007DC08C,
0x0084024F,
0x00000000,
0x00840237,
0x00280403,
0x000C4402,
0x0098418F,
0x002805F0,
0x00840237,
0x00280402,
0x000C4402,
0x0098418A,
0x002805F0,
0x00840237,
0x00280404,
0x000C4402,
0x00984185,
0x002805F2,
0x00840239,
0x00280402,
0x0084024A,
0x00000000,
0x00C101F0,
0x00280400,
0x00D87000,
0x0080000D,
0x00000000,
0x00C8047A,
0x00984004,
0x00000000,
0x0080000D,
0x00000000,
0x00D4007A,
0x00C80477,
0x00084401,
0x00D44077,
0x008402B2,
0x0031841F,
0x0080029E,
0x00000000,
0x00CAC401,
0x0030440C,
0x00DC0400,
0x00C80477,
0x00044401,
0x00D44077,
0x0006EC0C,
0x00C80878,
0x007C4882,
0x00948392,
0x00000000,
0x000AEC0C,
0x00D5807A,
0x008402B2,
0x00280400,
0x0095017B,
0x00000000,
0x00800295,
0x00000000,
0x00CAC401,
0x0030440C,
0x00DD8400,
0x00C80477,
0x00044401,
0x00D44077,
0x0006EC0C,
0x0084028E,
0x00000000,
0x0084023D,
0x00280400,
0x00840237,
0x00280401,
0x000C4402,
0x00944005,
0x00000000,
0x00282004,
0x002829F1,
0x00000000,
0x00C80477,
0x00C80878,
0x007C4882,
0x00948063,
0x00000000,
0x00840260,
0x00282005,
0x0084022C,
0x00000000,
0x00C8280A,
0x009683FF,
0x00282003,
0x002829DF,
0x008400BD,
0x00282003,
0x00CAC40B,
0x00C8087D,
0x007C4882,
0x00D48073,
0x00948053,
0x00000000,
0x00840202,
0x00000000,
0x00840237,
0x00280404,
0x000C4402,
0x0098412D,
0x002805F2,
0x00C80473,
0x0098400A,
0x00D40073,
0x00CAC401,
0x0030440C,
0x00D04800,
0x00248801,
0x00988004,
0x00000000,
0x008402C8,
0x00000000,
0x0084023D,
0x00280401,
0x00C80420,
0x002444FD,
0x00D44020,
0x00840239,
0x00280402,
0x00800295,
0x00000000,
0x00C8047A,
0x00944006,
0x00000000,
0x0084023F,
0x00280400,
0x00984009,
0x00000000,
0x008402B2,
0x0031841F,
0x00C101F0,
0x00CF0400,
0x00280400,
0x0080000D,
0x00D44003,
0x00280401,
0x00D44003,
0x00C101F1,
0x00CF0400,
0x00344404,
0x009843FE,
0x00000000,
0x00C4280A,
0x009A8019,
0x00C82800,
0x000E85BC,
0x00984013,
0x00000000,
0x00C12004,
0x00CF0400,
0x0034441F,
0x00984011,
0x00000000,
0x00C82805,
0x00968005,
0x00280801,
0x00D48005,
0x0084022C,
0x00000000,
0x00C82803,
0x000E85E5,
0x009443ED,
0x00000000,
0x00800199,
0x00000000,
0x00D4007A,
0x008402B2,
0x0031841F,
0x0084023B,
0x00280402,
0x00D83000,
0x0084023F,
0x00280401,
0x0080000D,
0x00000000,
0x00D40072,
0x00CAC401,
0x0030440C,
0x00D04800,
0x00248801,
0x00988005,
0x00000000,
0x00C8087E,
0x008001AB,
0x00D58072,
0x00CAC802,
0x00C8047C,
0x0084024F,
0x00000000,
0x00840237,
0x00280403,
0x000C4402,
0x00984004,
0x00000000,
0x0080014F,
0x00000000,
0x00C80472,
0x0094401F,
0x00000000,
0x00800281,
0x00000000,
0x0084028E,
0x00000000,
0x0084023D,
0x00280400,
0x00840237,
0x00280401,
0x000C4402,
0x00944005,
0x00000000,
0x00282004,
0x002829F1,
0x00000000,
0x00D40072,
0x00CAC802,
0x007C004C,
0x0084024F,
0x00000000,
0x00840237,
0x00280402,
0x000C4402,
0x00944381,
0x00000000,
0x00C80472,
0x00944004,
0x00000000,
0x00800281,
0x00000000,
0x00CAC40B,
0x00D44076,
0x00840260,
0x00000000,
0x00D6800C,
0x00282004,
0x002829F0,
0x00C80876,
0x00D4807D,
0x00348804,
0x00D4800B,
0x00C80477,
0x00044401,
0x00D44077,
0x0006EC0C,
0x00C80878,
0x007C4882,
0x0094800F,
0x00000000,
0x00C8140A,
0x009543FF,
0x00000000,
0x008400BD,
0x00000000,
0x00C8047D,
0x00CAC80B,
0x007C4842,
0x009843E5,
0x00C80476,
0x007C4842,
0x009843E2,
0x00000000,
0x00CAC401,
0x0030440C,
0x00D04800,
0x00248801,
0x009883CD,
0x00000000,
0x00D58072,
0x00C8087E,
0x007C004C,
0x0084024F,
0x00000000,
0x008001CB,
0x00000000,
0x00840243,
0x00280406,
0x00C10516,
0x00CAC40A,
0x00D87000,
0x00C10538,
0x00CAC408,
0x00D87000,
0x00C10539,
0x00CAC409,
0x00D87000,
0x00C1055F,
0x00CAC403,
0x00D87000,
0x00C10526,
0x00CAC406,
0x00D87000,
0x00C1052E,
0x00CAC407,
0x00D87000,
0x00C10567,
0x00CAC404,
0x00D87000,
0x00C1056F,
0x00CAC405,
0x00D87000,
0x00CF0400,
0x00CAC400,
0x00244404,
0x00984004,
0x00280401,
0x00800224,
0x00000000,
0x00280402,
0x00840243,
0x00000000,
0x00880000,
0x00000000,
0x0084022C,
0x00000000,
0x0080000D,
0x00000000,
0x0026A8FF,
0x00D6800C,
0x00880000,
0x00000000,
0x00D87000,
0x00CF0400,
0x00344404,
0x009443FE,
0x00000000,
0x00880000,
0x00000000,
0x00800230,
0x00C10EFB,
0x00800230,
0x00C10F91,
0x00800230,
0x00C101F1,
0x00800230,
0x00C10391,
0x00C12003,
0x00D87000,
0x00880000,
0x00CF0400,
0x00800230,
0x00C1051E,
0x00C83020,
0x002B3002,
0x00D70020,
0x00880000,
0x00000000,
0x00C83020,
0x002733FD,
0x00D70020,
0x00880000,
0x00000000,
0x0028141F,
0x0031541B,
0x007D444C,
0x00281408,
0x0031541B,
0x007D488C,
0x00C10F00,
0x00280C08,
0x00D8B000,
0x00D87001,
0x0008CC01,
0x0094C004,
0x00073010,
0x00800257,
0x00000000,
0x00880000,
0x00000000,
0x00D40030,
0x00C8087B,
0x00C80C7D,
0x007CE0CC,
0x00DCC800,
0x00C80C2E,
0x00DCC804,
0x00C80C2F,
0x00DCC808,
0x00C81425,
0x00C80C27,
0x00C81023,
0x0004CC01,
0x007CD107,
0x00990008,
0x00000000,
0x0004880C,
0x00D4807B,
0x00D4C027,
0x00DCD400,
0x0080027B,
0x00000000,
0x00C80824,
0x00308808,
0x00D4807B,
0x00D40027,
0x007C00CC,
0x00C80825,
0x00DCC800,
0x00840288,
0x00000000,
0x00880000,
0x00000000,
0x007C428C,
0x00840260,
0x00282004,
0x0084022C,
0x00000000,
0x00800286,
0x00000000,
0x00C8040D,
0x00084403,
0x009843FE,
0x00000000,
0x00880000,
0x00000000,
0x00C80420,
0x00284402,
0x00D44020,
0x00840239,
0x00280401,
0x00880000,
0x00000000,
0x00840260,
0x00000000,
0x00C13C81,
0x00CF0400,
0x00D87000,
0x00C13401,
0x00CF0400,
0x00D87000,
0x0084022C,
0x00C81074,
0x0095016E,
0x00000000,
0x00C8047A,
0x00944004,
0x00C8247F,
0x008002A7,
0x00000000,
0x00CAE40B,
0x00D6407D,
0x00366404,
0x00D6400B,
0x00D6402D,
0x00CACC02,
0x00D4C07C,
0x00CACC01,
0x0030CC0C,
0x00D4C075,
0x0080000D,
0x00000000,
0x00C101F0,
0x00880000,
0x00D87000,
0x00C80475,
0x00C1FFFF,
0x00D0480C,
0x00044404,
0x007CB0CB,
0x0094C00C,
0x00000000,
0x00CCD000,
0x00DD040C,
0x00044404,
0x00348810,
0x00948006,
0x00000000,
0x00CC9000,
0x00DD040C,
0x008002B7,
0x00044404,
0x00880000,
0x00000000,
0x00C13041,
0x0031841F,
0x00D87000,
0x00C13C82,
0x00D87000,
0x00C13400,
0x00D83000,
0x00CAC401,
0x0030440C,
0x00C1FFFF,
0x00D0480C,
0x00044404,
0x007CB0CB,
0x0094C00A,
0x00D0500C,
0x00D90C00,
0x00044404,
0x00348810,
0x00948005,
0x00D0500C,
0x00D90800,
0x008002D2,
0x00044404,
0x00880000,
0x00000000,
0x00C8040A,
0x00D40079,
0x00840237,
0x00280401,
0x00C8087E,
0x00C8047C,
0x0084024F,
0x00000000,
0x00840237,
0x00280403,
0x000C4402,
0x00984395,
0x00000000,
0x00840237,
0x00280404,
0x000C4402,
0x00984390,
0x002805F2,
0x00282004,
0x00840260,
0x00000000,
0x0084022C,
0x00000000,
0x00C8247F,
0x00D6407D,
0x00366404,
0x00D6400B,
0x00D6402D,
0x0080000D,
0x00D40036,
0x00000000,
};

static const u32 R700_rlc_microcode[]={
0x34380010,
0x37B80000,
0xCF800012,
0xCC0000D3,
0xCC0000DD,
0x04180001,
0xCC1800D3,
0xCC0000C9,
0xCC1800C9,
0xCD8000D5,
0xCD9800D5,
0xCC0000CB,
0xCC1800CB,
0xCC0000D9,
0xCC1800D9,
0xCC0000C3,
0xCD8000C8,
0xCC1800C1,
0xCC0000C1,
0xCC0000CC,
0xCC00000B,
0xCC00000E,
0x8000021F,
0x00000000,
0x34200004,
0xCC00000E,
0xC81000CB,
0xC83800CC,
0x9B80018A,
0x00000000,
0xC8380056,
0x342801C3,
0x9B80018C,
0x341C0000,
0xC81000CB,
0xC9EC00D9,
0xC9F800D3,
0xC80800DD,
0x7CB8C00C,
0x98C00017,
0x00000000,
0xC80800C8,
0x948001F1,
0x00000000,
0xC80C0040,
0x30CC0020,
0x94C0004A,
0xCD8000DD,
0xC4280009,
0x96800044,
0xCD8000DD,
0xC9C800D5,
0xC9CC00C9,
0x7CC8800C,
0x94800020,
0x00000000,
0xC8280009,
0x342801DF,
0xC9EC0000,
0x8000010A,
0xCD80000E,
0x00000000,
0xC8380057,
0x342801E1,
0x9B80016C,
0x341C0001,
0xC8080040,
0x30880020,
0x94800034,
0xCC0000DD,
0xC428000A,
0x96800031,
0xCC0000DD,
0x341C0001,
0xC9C800D5,
0xC9CC00C9,
0x7CC8800C,
0x94800009,
0x00000000,
0xC828000A,
0x342801F0,
0xC81000CB,
0xC9EC00D9,
0x8000010A,
0xCD80000E,
0x00000000,
0xC9EC00D9,
0xC9C800C1,
0x98800020,
0x00000000,
0x84000251,
0x7F03000B,
0xCB380042,
0x97800110,
0x00000000,
0xCB380041,
0x67B80008,
0x34340007,
0xCC000015,
0xCB8A0000,
0x0B740001,
0x9B40FFFE,
0x07B80004,
0xCACC0006,
0x7CC88002,
0x94800104,
0x00000000,
0x99C00006,
0x34200003,
0xC8280009,
0x342801DF,
0x8000010A,
0xCD80000E,
0xC828000A,
0x342801F0,
0x8000010A,
0xCD80000E,
0xC9C800C9,
0x9880FFA5,
0x00000000,
0xC80800C8,
0x94800047,
0x00000000,
0xC8280000,
0x96800044,
0x34080001,
0xCC800000,
0x301C0000,
0x0E8801BB,
0x94800004,
0x00000000,
0x8000019D,
0x34200001,
0x0E8801BC,
0x9880010B,
0x00000000,
0x950001B8,
0x00000000,
0x0E8801BE,
0x94800005,
0x00000000,
0xCD8000D3,
0x80000018,
0x00000000,
0x0E8801BD,
0x94800004,
0x00000000,
0xCC0000D3,
0x80000018,
0x0E8801C1,
0x988000B9,
0x34200006,
0x0E8801C2,
0x94800008,
0x00000000,
0xC8280009,
0x342801DF,
0xCD9C00C3,
0xCD9C00D5,
0x988000B0,
0x34200003,
0x0E8801C3,
0x9880011C,
0x34200004,
0x0E8801C0,
0x988000AA,
0x34200007,
0x0E8801B7,
0x98800116,
0x34200004,
0x0E8801B8,
0x98800113,
0x34200004,
0x0E8801B9,
0x98800110,
0x34200004,
0x0E8801B4,
0x9880010D,
0x34200004,
0x168801B4,
0x9880018C,
0x168801B7,
0x9880018A,
0x1E8801C0,
0x98800188,
0x00000000,
0x0E8801BA,
0x94800103,
0x34200004,
0x34200002,
0x8000014F,
0x00000000,
0xC8280002,
0x96800014,
0x34080001,
0xCC800002,
0x228801DC,
0x1A8C01DD,
0x7C8C800B,
0x98800009,
0x00000000,
0x228801C8,
0x1A8C01DB,
0x7C8C800B,
0x98800007,
0x301C0000,
0x80000240,
0x00000000,
0x341C0001,
0xC81000CB,
0xC9EC00D9,
0x800001BE,
0x34200004,
0xC8280001,
0x9680000B,
0x00000000,
0x301C0000,
0x34080001,
0xCC800001,
0x95000165,
0x0E8801E8,
0x988000E1,
0x34200004,
0x80000240,
0x00000000,
0xC8280003,
0x96800008,
0x00000000,
0x0E8C01E5,
0x98C0011A,
0x34080001,
0xCC800003,
0x80000240,
0x00000000,
0xC8280004,
0x341C0001,
0xC81000CB,
0x9680FF2E,
0xC9EC00D9,
0x34080001,
0xCC800004,
0x0E8801F0,
0x9480000A,
0x00000000,
0x8400026C,
0x00000000,
0xC828000A,
0x342801F0,
0xCD9C00C3,
0xCD9C00D5,
0x98800055,
0x34200003,
0x0E8801E2,
0x98800052,
0x34200002,
0x0E8801F6,
0x9880004F,
0x34200006,
0x0E8801F3,
0x9880009A,
0x34200001,
0x0E8801E1,
0x988000B8,
0x00000000,
0x80000240,
0x00000000,
0xCC1C00C3,
0xCC000015,
0x84000131,
0x34200003,
0x99C00004,
0x00000000,
0x84000341,
0x25B8001F,
0xC9F800C9,
0x9B80000F,
0x00000000,
0xCAF80000,
0x33B80001,
0x9B800063,
0x00000000,
0xC9F400D5,
0xCC1C00D5,
0xC9C800DB,
0xCACC0006,
0x7C8C8002,
0x97400206,
0x00000000,
0x80000304,
0xCC8000C3,
0xCAC80000,
0x30880010,
0x98800054,
0x00000000,
0xCC1C00C9,
0x99C00004,
0xCC1C0016,
0x8400023C,
0x34380007,
0x8400023C,
0x34380001,
0x99C001D2,
0x00000000,
0x80000324,
0x00000000,
0x84000251,
0x7F03000B,
0xCB380041,
0x67B80008,
0x25C80005,
0x34880080,
0x7C82C00C,
0xCEDC00D9,
0xCB100042,
0x950001EA,
0x00000000,
0xCD1C00D1,
0x7D18C001,
0xCCDC00CF,
0x7C00C000,
0x04CC0007,
0x09100001,
0x9900FFFE,
0x00000000,
0xCB920000,
0xCD080000,
0x08CC0001,
0x94C00006,
0x00000000,
0x47B80004,
0x04880001,
0x80000144,
0x00000000,
0x88000000,
0x00000000,
0x84000344,
0x00000000,
0x99C00008,
0x00000000,
0xC0302192,
0xCB090000,
0x07740008,
0xCCB6000C,
0x0774002C,
0xCCB6000C,
0x84000289,
0x00000000,
0x80000161,
0x00000000,
0x84000344,
0x00000000,
0x800001DB,
0x00000000,
0x99C00006,
0xCD9C00D5,
0x84000290,
0x00000000,
0x800001DB,
0x00000000,
0x840002AC,
0x00000000,
0x84000271,
0x00000000,
0x800001DB,
0x00000000,
0xCD9C00C1,
0x99C00006,
0x00000000,
0xC03021B9,
0xCDB10000,
0x8000001B,
0x00000000,
0xC0303418,
0xCDB10000,
0x8000001B,
0x00000000,
0x80000324,
0x34200008,
0xCD8000CB,
0xCAE40006,
0xCE5C00DE,
0xCE5C00DB,
0x2A640004,
0xCE40000B,
0x84000251,
0x7F03000B,
0xCE70004D,
0xCB380044,
0x27B80008,
0xCF9C00D7,
0x6BB80020,
0xCF9C00C6,
0x99C0FE90,
0x00000000,
0x84000341,
0x34380000,
0x99C0FE8C,
0x00000000,
0xC0302355,
0x80000018,
0xCE710000,
0xC9F800D5,
0x9B800004,
0x00000000,
0x80000018,
0x00000000,
0xCC1C00D5,
0x99C0FE81,
0x00000000,
0x84000341,
0x25B8001F,
0x80000018,
0x00000000,
0xCD9C00D5,
0x99C00004,
0x00000000,
0x84000341,
0x34380000,
0x9500FE79,
0x00000000,
0x8000015D,
0x00000000,
0x2B9C001F,
0x2BB80010,
0x33A800FF,
0xCC0000CC,
0x800001BE,
0x34200004,
0xC9EC00D9,
0xC81000CB,
0xC9F80009,
0xCC1C00D3,
0x99C00008,
0x00000000,
0x84000290,
0x00000000,
0x84000271,
0x00000000,
0x80000327,
0xCD9C00D5,
0x840002AC,
0x00000000,
0x84000271,
0x00000000,
0x80000327,
0xCD9C00D5,
0xC8080040,
0x30880020,
0x94800080,
0x00000000,
0xC9EC00D9,
0xC9F800CD,
0xC9C800C4,
0x64880020,
0x7F8B802C,
0x668C0010,
0x7CE0C00C,
0xCCFA0004,
0x840002F0,
0x00000000,
0xC8080040,
0x30880010,
0x98800024,
0x00000000,
0x99C00006,
0x00000000,
0x84000290,
0x00000000,
0x800001D8,
0x00000000,
0x840002AC,
0x00000000,
0xCD9C00D5,
0x800001EB,
0x00000000,
0xC9C800C3,
0x9880FF2E,
0x00000000,
0x84000271,
0x00000000,
0xC9F800C1,
0x9B80000A,
0x00000000,
0xC9F800CF,
0x97800007,
0x00000000,
0x0BB80001,
0xCF9C00CF,
0x06EC0007,
0x80000304,
0x00000000,
0x84000271,
0x00000000,
0xCD9C00D5,
0x84000289,
0x00000000,
0x80000324,
0x00000000,
0x99C00005,
0x3408001F,
0x34380003,
0x800001F9,
0xCF9C0016,
0x34380001,
0xCF9C0016,
0x98800000,
0x08880001,
0x84000284,
0x00000000,
0x80000324,
0x00000000,
0xC9CC00D5,
0x94C00008,
0x00000000,
0x84000248,
0x340C0001,
0x84000263,
0x34380000,
0x9B80000B,
0x00000000,
0x84000248,
0x340C0000,
0x84000341,
0x25B8001F,
0xC03001C0,
0xCB390000,
0x34380000,
0x80000018,
0xCF800003,
0x34380001,
0xCF800003,
0xC81000CB,
0xC03001C1,
0xCB390000,
0x2BB80004,
0x9B80FFFE,
0x00000000,
0xCC0000C8,
0x00000000,
0xC808001A,
0x9480FDFF,
0xCD8000DD,
0x00000000,
0x84000261,
0x34380002,
0xCC310000,
0x84000263,
0x34380001,
0xCD8000C8,
0x84000248,
0x340C0000,
0x80000018,
0x00000000,
0xC0300515,
0x7F1F0020,
0xCAF80005,
0xCFB10000,
0xC0300550,
0x7F1F0020,
0xCAF80002,
0xCFB10000,
0xC0300558,
0x7F1F0020,
0xCAF80003,
0xCFB10000,
0xC0300560,
0x7F1F0020,
0xCAF80004,
0xCFB10000,
0xCB390000,
0x88000000,
0x00000000,
0x84000267,
0x00000000,
0x88000000,
0x00000000,
0x84000244,
0x00000000,
0x80000018,
0x00000000,
0x32A800FF,
0xCE80000C,
0x88000000,
0x00000000,
0xC0300390,
0xCB390000,
0xC00BFFFE,
0x7F8B800B,
0x24CC0010,
0x7F8F800C,
0xCFB10000,
0x88000000,
0xCB390000,
0x95C00003,
0x00000000,
0x07300028,
0x88000000,
0x00000000,
0x88000000,
0x00000000,
0xCFB10000,
0xCD80000E,
0xCB390000,
0x33B80010,
0x2BB80004,
0x9780FFFD,
0x00000000,
0x88000000,
0x00000000,
0x80000258,
0xC03001C1,
0xC0302003,
0xCFB10000,
0x88000000,
0xCB390000,
0xCD80000E,
0x7C1C800C,
0xC030051D,
0x80000258,
0x7F1F0020,
0xC8300040,
0x37300002,
0xCF000040,
0x88000000,
0x00000000,
0xC8300040,
0x333003FD,
0xCF000040,
0x88000000,
0x00000000,
0xCF9C0016,
0xCD80000E,
0xC9F00018,
0x7F388002,
0x9480FFFE,
0x00000000,
0x88000000,
0x00000000,
0xCFB10000,
0xCB390000,
0x3408001F,
0x98800000,
0x08880001,
0xCC1C0016,
0xC9F0001B,
0x9700FFFF,
0x00000000,
0x88000000,
0x00000000,
0x99C00004,
0xCC1C00C1,
0x8000028E,
0xC03021B9,
0xC0303418,
0x88000000,
0xCC310000,
0xC0302356,
0xC0080100,
0xC03AFF00,
0x7F8B800C,
0xCFB10000,
0xCB390000,
0x84000276,
0x34380003,
0xC0302008,
0x8400027E,
0x3438FFFF,
0xC0302008,
0xCC310000,
0xCB390000,
0xC0300398,
0x8400027E,
0x34380100,
0xCC000056,
0xC0300398,
0xCC310000,
0xCB090000,
0xC0302356,
0xC0080100,
0xCCB10000,
0xCB390000,
0xC03021B6,
0x88000000,
0xCC310000,
0x84000276,
0x34380001,
0x34380001,
0xC0300398,
0x8400027E,
0x27B80014,
0xCC000057,
0xC0300398,
0xCC310000,
0x88000000,
0xCB090000,
0xCC000050,
0xC9C800D7,
0xC9CC00C6,
0x64CC0020,
0x7C8C802C,
0x84000251,
0x7F03000B,
0xCB0C004D,
0x24CC0004,
0x7CE0C00C,
0xCCCA0000,
0xC80C004E,
0xCCCA0004,
0xC80C004F,
0xCCCA0008,
0x84000251,
0x7F03000B,
0xCB0C0046,
0x64CC0020,
0xCB140045,
0x7D4D402C,
0xCB0C0047,
0xCB100043,
0x04CC0001,
0x7CD10007,
0x9900000A,
0x00000000,
0x4488000C,
0xCC9C00D7,
0x68880020,
0xCC9C00C6,
0xCCF00047,
0xCCD60000,
0x800002E1,
0x00000000,
0xCB080044,
0x24880008,
0xCC9C00D7,
0x68880020,
0xCC9C00C6,
0xCC300047,
0x7C00C00C,
0xCB140046,
0x65540020,
0xCB080045,
0x7C94802C,
0xCCCA0000,
0x840002EA,
0x00000000,
0x88000000,
0x00000000,
0xC838000D,
0x0BB80001,
0x9B80FFFE,
0x00000000,
0x88000000,
0x00000000,
0x8400026C,
0x00000000,
0x88000000,
0x00000000,
0x99C0000B,
0x00000000,
0xC0303041,
0xCB390000,
0xC00BFEFF,
0x7F88C00B,
0xCCF10000,
0xCB0D0000,
0xCFB10000,
0x80000324,
0x00000000,
0xC0303400,
0xCB390000,
0xCFB10000,
0x80000324,
0x00000000,
0x84000341,
0x25B8001F,
0xCAF80001,
0x67B8000C,
0xCB8E0004,
0x34C80004,
0x7C8CC002,
0xCC1C00D5,
0x98C00015,
0x00000000,
0x84000229,
0x00000000,
0x8400023C,
0x34380001,
0x00000000,
0xC80800C3,
0x9880FFE0,
0xCC0000C3,
0xC9C800C1,
0x94800006,
0x00000000,
0x84000289,
0x00000000,
0x80000324,
0x00000000,
0x84000361,
0x00000000,
0x80000324,
0x00000000,
0x65CC001F,
0x7CC8800C,
0xCC8000CC,
0x840002B7,
0x00000000,
0x84000244,
0x00000000,
0xC9F800D5,
0x97800007,
0xC9E400DE,
0x32080001,
0x98800005,
0x00000000,
0x80000331,
0xCE5C00DB,
0xCAE40006,
0x2A640004,
0xCE40000B,
0x84000251,
0x7F03000B,
0xCE70004D,
0xCACC0001,
0x24CC000C,
0xCCDC00CD,
0x68CC0020,
0xCCDC00C4,
0xCEDC00D9,
0x99C0FCDC,
0x00000000,
0xC0302355,
0x80000018,
0xCE710000,
0xC03001C0,
0x88000000,
0xCFB10000,
0xC9F800CD,
0xC9C800C4,
0x64880020,
0x7F8B802C,
0x07B40000,
0xC030FFFF,
0xCB8E0004,
0x34080004,
0x30CC000F,
0x7CC8C002,
0x98C00011,
0x00000000,
0xCB8A000C,
0x47B80004,
0x7CB0C00B,
0x94C0000C,
0x00000000,
0xC8D10000,
0xCD3A000C,
0x07B80004,
0x28880010,
0x94800006,
0x00000000,
0xC8910000,
0xCD3A000C,
0x80000350,
0x07B80004,
0x88000000,
0x00000000,
0xCAF00006,
0xCF1C00DB,
0xCC1C00D5,
0x95C00006,
0x00000000,
0xC0303400,
0xCC310000,
0x80000375,
0x00000000,
0xC8080000,
0x94800003,
0x340C0001,
0xCCC00000,
0xC0303041,
0x25B8001F,
0xCFB10000,
0xC030218E,
0xC00A0001,
0x348800FF,
0xCCB10000,
0xCAF80001,
0x67B8000C,
0xC030FFFF,
0xCB8A0004,
0xCB8A000C,
0x47B80004,
0x7CB0C00B,
0x94C0000A,
0xCB92000C,
0xCD0D0000,
0x47B80004,
0x28880010,
0x94800005,
0xCB92000C,
0xCD090000,
0x80000379,
0x47B80004,
0x88000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
};

static const u32 REDWOOD_me_microcode[]={
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xD440007F,
0x1C8C0002,
0x98C0000B,
0x7C410000,
0xC80C000E,
0x98C00003,
0x043C0005,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F4,
0xCC000047,
0x80000000,
0xD0400060,
0xC80C0010,
0x98C00003,
0x043C0023,
0xCFC1A2A4,
0xCC000060,
0xCC01A1F3,
0xCC000049,
0x80000000,
0xD0400060,
0xCC000046,
0x8400002D,
0xCC00004B,
0xCC412264,
0xCC412265,
0xCC412266,
0x80000000,
0xCC41A2DD,
0xCC400046,
0x8400002D,
0xCC00004B,
0x04142264,
0x04182265,
0x041C2266,
0xD8174100,
0xD81B4100,
0xD81F4100,
0x80000000,
0xCC41A2DD,
0xC03A0004,
0x0434226B,
0x0430225C,
0x7F7B4007,
0xCC350000,
0xC83C0004,
0x88000000,
0xCFF10000,
0x7C40C000,
0x94C0FFCA,
0xCC00001F,
0x80000000,
0xCC000041,
0x7C40C000,
0xC0160004,
0x1CD0FFFF,
0x7D150007,
0xCC110000,
0x18D8003E,
0x14DC001F,
0xC8200004,
0x95C00006,
0x7C424000,
0xCC00004D,
0x7E568007,
0xCC290000,
0xC8240004,
0x7E260006,
0x95800006,
0x7C42C000,
0xCC00004D,
0x7ED70007,
0xCC310000,
0xC82C0004,
0x7E2E0007,
0xCC00004D,
0x1D10FFFF,
0x80000000,
0xCE110000,
0x7C40C000,
0x80000000,
0xCC400040,
0xCD41225D,
0xCC400045,
0xCC00004A,
0xCD01225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC412257,
0x7C418000,
0xCC400045,
0xCC40004A,
0xCC41225C,
0xCC41A1FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0xCC000045,
0x80000064,
0xCC00004A,
0x040CA1FD,
0xC0120001,
0xCC000045,
0xCC00004A,
0x7CD0C007,
0xCC41225C,
0xCC41A1FC,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x80000000,
0xCC41225D,
0xCC000045,
0xCC00004A,
0x084C0001,
0x7C410000,
0x7C414000,
0x1D58FFFF,
0x195C03F0,
0x15600015,
0xCD81A102,
0xCDC12256,
0xCE01225C,
0x94C00005,
0x21240020,
0xCE41A1FC,
0x8000007D,
0x08CC0001,
0xCD01A1FC,
0xCC01A102,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C408000,
0x7C40C000,
0xC02A0002,
0x7C410000,
0x7D290007,
0x1C940001,
0x1C980006,
0x1C9C0300,
0x15DC0008,
0x7C420000,
0x7C424000,
0x9540000F,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0xCCC12169,
0xCD01216A,
0xCE81216B,
0x29B40002,
0xCC01216C,
0x9740000E,
0x29B40000,
0x800000BD,
0xC834000E,
0x29B40002,
0x97400009,
0x29B40000,
0xC02E0004,
0x05F02258,
0x7F2F0007,
0xCC310000,
0xC8280004,
0x800000BD,
0xC834000E,
0x97400004,
0x7E028000,
0x800000BD,
0xC834000E,
0x29B40004,
0x9740FF49,
0x00000000,
0xCE01216D,
0xCE41216E,
0xC8280003,
0xC834000E,
0x9B400004,
0xC83C000E,
0x8400034E,
0xCC00004D,
0x29F40000,
0x97400007,
0x0430A2B6,
0x840000DF,
0xCE81A2B7,
0xCF81A2C4,
0x80000000,
0xCFC1A2D1,
0x29F40001,
0x97400007,
0x0430A2BA,
0x840000DF,
0xCE81A2BB,
0xCF81A2C5,
0x80000000,
0xCFC1A2D2,
0x29F40002,
0x97400007,
0x0430A2BE,
0x840000DF,
0xCE81A2BF,
0xCF81A2C6,
0x80000000,
0xCFC1A2D3,
0x0430A2C2,
0x840000DF,
0xCE81A2C3,
0xCF81A2C7,
0x80000000,
0xCFC1A2D4,
0xC02E0004,
0x7F2F0007,
0xCC310000,
0xC82C0004,
0xC0300006,
0x7EF34023,
0xC0300020,
0x7F6B8020,
0x88000000,
0x7FB3C024,
0xCC000042,
0x80000000,
0xCC40001F,
0x7C40C000,
0x7C410000,
0x1914003D,
0x99400013,
0x0414002E,
0x840004C1,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004C1,
0x0418002D,
0xCD41A2A4,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xCCC12100,
0xCD012101,
0xCCC12102,
0xCD012103,
0x800004BE,
0xCD81A2A4,
0x1D181000,
0x95800005,
0xC81C0013,
0x29E40040,
0x9640FFFF,
0xC81C0013,
0xCCC12175,
0xCD012176,
0xC8200014,
0x96000000,
0xC8200014,
0x16280001,
0x9A800004,
0xCC00004F,
0x800004BE,
0xCC00007F,
0x80000109,
0xCCC12175,
0x7C40C000,
0x7C410000,
0xCC000045,
0xCC00004A,
0x40D40003,
0xCD41225C,
0xCD01A1FC,
0xC01A0001,
0x041CA1FD,
0x7DD9C007,
0x7C420000,
0x08CC0001,
0x06240001,
0x06280002,
0xCE1D0000,
0xCE5D0000,
0x98C0FFFA,
0xCE9D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00001,
0x14CC0001,
0x7C414000,
0x95000006,
0x7C418000,
0xCD41216D,
0xCD81216E,
0x80000137,
0xC81C0003,
0xC0220004,
0x7E160007,
0xCC210000,
0xC81C0004,
0x7C424000,
0x98C00004,
0x7C428000,
0x80000000,
0xCDE50000,
0xCE412169,
0xCE81216A,
0xCDC1216B,
0x80000000,
0xCC01216C,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0x7C41C000,
0x18A41FE8,
0x2A68003C,
0x9680000A,
0x7C020000,
0x7C420000,
0x3A300003,
0xCC000058,
0x9B000003,
0x42200005,
0x04200040,
0x80000153,
0x7C024000,
0x7E024000,
0x9A400000,
0x0A640001,
0x1CEC0010,
0x9AC0000A,
0xCC00004D,
0xC02A0004,
0xC82C0020,
0x7E928007,
0xCC000041,
0xCC290000,
0xCEC0001E,
0x80000163,
0xC8300004,
0xCD01216D,
0xCD41216E,
0xC8300003,
0x7F1F0006,
0x1CF40007,
0x13780001,
0x9740002A,
0x07B80168,
0x9F800000,
0x00000000,
0x80000178,
0x7F1B800E,
0x8000017C,
0x7F1B800F,
0x80000180,
0x7F1B800C,
0x80000184,
0x7F1B800D,
0x80000188,
0x7F1B8011,
0x8000018C,
0x7F1B8010,
0x80000191,
0x14A40008,
0x9B800019,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800015,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800011,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B80000D,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800009,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x9B800005,
0x14A40008,
0x800001A1,
0x1E6400FF,
0x14A40008,
0x1E6400FF,
0x2A68003C,
0x9A80FE6D,
0x14EC0008,
0x7C434000,
0x7C438000,
0x7C43C000,
0x96C00007,
0xCC00004D,
0xCF412169,
0xCF81216A,
0xCFC1216B,
0x80000000,
0xCC01216C,
0x80000000,
0xCFF50000,
0xCC000059,
0x840004C1,
0x2A68003C,
0x9A800004,
0xC8280017,
0x80000000,
0xD440007F,
0x9680FFAB,
0x7E024000,
0x8400028C,
0xC00E0002,
0xCC000041,
0x800001AF,
0xCCC1304A,
0x94000000,
0xC83C001C,
0x7C40C000,
0x7C410000,
0xC01E0001,
0x15240012,
0xC0220002,
0x96400005,
0xC0260004,
0xC027FFFB,
0x7D250006,
0xC0260000,
0x7DD28006,
0x7E12C006,
0x7D250007,
0x7C414000,
0x7C418000,
0xCCC12169,
0x9A80000C,
0xCD01216A,
0xCD41216B,
0x96C0FE3C,
0xCD81216C,
0x840004C1,
0xCC00007F,
0xC830001A,
0x97000000,
0xC830001A,
0x80000001,
0x7C408000,
0x840004C1,
0xCC00007F,
0xC8140015,
0xC8180016,
0xCD41216B,
0x96C0FE2E,
0xCD81216C,
0x800001C6,
0xCC00007F,
0xCC0003E5,
0xC82C0020,
0xC00E2024,
0x04103000,
0x20CC226B,
0x04143001,
0xCC000041,
0xD0110000,
0xCCD50000,
0xCEC0001E,
0xC80C0009,
0x98C00000,
0xC80C0009,
0x7C410000,
0x7C414000,
0xCC400043,
0xCC400044,
0xC00E8000,
0x7C424000,
0x7C428000,
0x16AC001F,
0x96C0FE15,
0xC035F000,
0xCE4003E1,
0x1E780003,
0x127C0008,
0x7FF7C006,
0x7FFBC007,
0x16780018,
0xCFC003E2,
0xCF8003E3,
0x12B00002,
0x7F3F0000,
0xCF0003E4,
0x80000451,
0x7C80C000,
0x7C40C000,
0x18D001E8,
0x11280001,
0x95000010,
0x06A801FF,
0x9E800000,
0x00000000,
0x80000217,
0xC0120800,
0x80000225,
0xC8140011,
0x8000022C,
0xC8140012,
0x80000233,
0xCCC1A2A4,
0x8000023C,
0x1CE8003F,
0x80000264,
0x7CC1800B,
0x1CD0003F,
0x29280006,
0x292C0016,
0x7EAE8007,
0xC81C0013,
0x9A80003D,
0x0414002E,
0x80000000,
0xCCC1A2A4,
0xC0120800,
0x7C414000,
0x7D0CC007,
0xC0120008,
0x15580003,
0x155C000C,
0x7C420000,
0x7DD1C006,
0x12200014,
0x7E1E4007,
0x7E4E8007,
0xCE81A2A4,
0x80000000,
0xCD81A1FE,
0xC8140011,
0x04102118,
0x95400000,
0xC8140011,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xC8140012,
0x04102106,
0x95400000,
0xC8140012,
0xD4510000,
0x80000000,
0xCCC1A2A4,
0xCCC1A2A4,
0x04100001,
0xCD000019,
0x840004C1,
0xCC00007F,
0xC810001B,
0x99000000,
0xC810001B,
0x80000001,
0x7C408000,
0x2AA00004,
0x2AA40014,
0x7E260007,
0x0414002E,
0x96000008,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004C1,
0x040C002D,
0xCD41A2A4,
0x04102100,
0xC81C0013,
0x95C00000,
0xC81C0013,
0xD4510000,
0x800004BE,
0xCCC1A2A4,
0x840004C1,
0x04180029,
0x8400025A,
0xC81C0013,
0x0414002A,
0x840004C1,
0x0418002D,
0x8400025A,
0xC81C0013,
0x80000001,
0x7C408000,
0x95C00000,
0xC81C0013,
0xCD41A2A4,
0xCC012100,
0xCC012101,
0xCD812102,
0xCD812103,
0xCD81A2A4,
0x88000000,
0xCC00004D,
0x1D980001,
0x7C410000,
0x7C414000,
0x99800009,
0x7C420000,
0xC83C0032,
0x11980010,
0xC81C000B,
0x3BFC0001,
0x97C0FFFF,
0xC83C0032,
0x80000276,
0xC83C0033,
0x11980010,
0xC81C000A,
0x3BFC0001,
0x97C0FFFF,
0xC83C0033,
0x1568001D,
0x7D594007,
0x9A800004,
0x11E4000A,
0x7E260007,
0xCDC00066,
0xCD012158,
0xCD412159,
0xCE01215A,
0xCCC1A2A4,
0x9A80023E,
0x05100004,
0x042C0001,
0x12F0001D,
0x7D714007,
0x12E00010,
0x2220000C,
0xCD012158,
0xCD412159,
0xCE01215A,
0x800004BE,
0xCCC1A2A4,
0x043C0005,
0xCFC1A2A4,
0xC0360002,
0x88000000,
0xCF412010,
0x7C40C000,
0x14D0001D,
0x99000008,
0x14D4001C,
0x9540FD6B,
0xC0260004,
0x22642154,
0xCC250000,
0x80000000,
0xC8280004,
0x800004BE,
0xCD400061,
0x840004C1,
0x1C740001,
0x1C780002,
0x9B400003,
0xC80C0029,
0x8400034D,
0xC814002B,
0x9B800003,
0x04100010,
0x84000364,
0xCCC1A250,
0xCD01A050,
0x840002FE,
0x04180400,
0x840004C1,
0xCC000063,
0xC83C002D,
0x8400030C,
0xC8100029,
0xC81C002F,
0x1DDC0001,
0xC8240027,
0x95C00009,
0xC8340031,
0xC8380030,
0xC83C002D,
0x53740020,
0x7FB78027,
0x47B80550,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240027,
0xC8280023,
0x3AA80002,
0x9A80FFFF,
0xC8280023,
0xC0300001,
0xC8280024,
0x9A800000,
0xC8280024,
0xCF00005B,
0x50D80008,
0x14DC0018,
0x21DC8000,
0xCD812180,
0xCDC12181,
0x51200008,
0x15240018,
0xCE012182,
0xCE412183,
0xCD412184,
0x7C408000,
0xA0000000,
0xCC80004D,
0x840004C1,
0x1C740001,
0x1C780002,
0x9B400003,
0xC80C002A,
0x8400034D,
0xC814002C,
0x9B800003,
0x04100010,
0x84000364,
0xCCC1A260,
0xCD01A060,
0x840002FE,
0x04180980,
0x840004C1,
0xCC000064,
0xC83C002E,
0x8400030C,
0xC810002A,
0xC81C002F,
0x1DDC0001,
0xC8240028,
0x95C00009,
0xC8340031,
0xC8380030,
0xC83C002E,
0x53740020,
0x7FB78027,
0x47B80554,
0xCC000062,
0xCFFA0000,
0x9A400000,
0xC8240028,
0xC8280025,
0xC8280023,
0x3AA80002,
0x9A80FFFF,
0xC8280023,
0x9A800000,
0xC8280025,
0x800002C6,
0xC0300002,
0x0598C000,
0x10DC0008,
0x14E00018,
0xCDD90000,
0xC81C0022,
0xC8240022,
0x1DDC0FFF,
0xCDD90001,
0x7E624007,
0xCE590002,
0xD8185103,
0xD8185104,
0x88000000,
0xD8185107,
0x1BF800F0,
0xC0360800,
0x97800003,
0xC0300080,
0x88000000,
0xC02A0004,
0xCF41217C,
0xCF01217D,
0xCD01217E,
0x22A8217F,
0x04240008,
0x9A400000,
0x0A640001,
0xCC290000,
0xC8200004,
0x1638001F,
0x9B80FFFB,
0x04240008,
0x88000000,
0x00000000,
0xC80C0024,
0x94C00024,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0024,
0x80000331,
0xC80C0025,
0x94C0001B,
0x38D40001,
0x9940FFFD,
0xC8100023,
0x7D0D0001,
0x9900FFFB,
0xC80C0025,
0x840004C1,
0xCC00007F,
0xC83C03FB,
0x9BC00000,
0xC83C03FB,
0xD04003FC,
0xC03E0004,
0xD20121F8,
0x23FC21F9,
0x840004C1,
0xCC3D0000,
0xC8380004,
0x1BB4003E,
0x1FB00004,
0x7F02C00B,
0x1EE80004,
0x7EB64007,
0x9A40FFF6,
0xC03E0004,
0xD00003FC,
0x7C410000,
0x80000001,
0x7C408000,
0x8400034D,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC83C000E,
0x97C00003,
0xD30003E6,
0x88000000,
0x043C0026,
0xCFC1A2A4,
0xC83C03E6,
0x0BFC0001,
0xCFC003E6,
0x9BC0FFFB,
0xCC00004D,
0x043C0005,
0xCFC1A2A4,
0xCC01A1F4,
0x840004C1,
0xCC000047,
0x88000000,
0xCC00007F,
0x84000364,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x043C0022,
0xCFC1A2A4,
0x840004C1,
0xCC000048,
0x88000000,
0xCC00007F,
0x8400036F,
0x7C40C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x043C0023,
0xCFC1A2A4,
0xCC01A1F3,
0x840004C1,
0xCC000049,
0x88000000,
0xCC00007F,
0x80000000,
0x7C40C000,
0x80000000,
0x7C40C000,
0xC0120001,
0x7C514007,
0x80000000,
0xD4550000,
0xCC400065,
0xC838002D,
0xC83C002E,
0xC035E000,
0xC0320004,
0x7FB78006,
0x7FF7C006,
0x23B81000,
0x23FC1000,
0xCF812154,
0xCFC12155,
0xCC312155,
0xC82C0004,
0xC81C0025,
0xC8240024,
0x7DE5C007,
0x99C0FFFE,
0xC81C0025,
0x80000001,
0x7C408000,
0x7C40C000,
0x7C410000,
0x19280030,
0x96800008,
0xC8280027,
0xC8240028,
0x9A400000,
0xC8240027,
0x9A400000,
0xC8240028,
0xCC0003E0,
0x7C414000,
0x7C418000,
0x151C001F,
0xCCC000C7,
0xCD0000C8,
0x95C00003,
0xC01C8000,
0xCDC12010,
0xE1830000,
0x055C2000,
0xCC00004D,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000C9,
0xCD0000CA,
0xE1830000,
0x055CA000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CB,
0xCD0000CC,
0xE1830000,
0x055CE940,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CD,
0xCD0000CE,
0xE1830000,
0x055CE880,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000CF,
0xCD0000D0,
0xE1830000,
0x055CC000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D1,
0xCD0000D2,
0xE1830000,
0x055CF000,
0x80000000,
0xDC1F4100,
0x7C40C000,
0x7C410000,
0x7C414000,
0x7C418000,
0xCCC000D3,
0xCD0000D4,
0xE1830000,
0x055CF3FC,
0x80000000,
0xDC1F4100,
0xD4432000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443A000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E940,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443E880,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443C000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xD443F3FC,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CA000,
0xCC43A000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x041CC000,
0xCC43C000,
0x7C40C000,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0xC8130002,
0x94C00003,
0xC8170002,
0xC81B0002,
0x041CF3FC,
0xCC03F3FC,
0xD81FC100,
0xD81FC100,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC01E0010,
0xC80C0029,
0x50D00008,
0x10540002,
0x80000428,
0x7D158020,
0xC01E0020,
0xC80C002A,
0x50D00008,
0x08540400,
0x11540002,
0x7D518020,
0xCDC00062,
0xD45A0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0x7C40C000,
0x1CD00003,
0x11280001,
0x9500000A,
0x06A80432,
0x9E800000,
0x7C418000,
0x80000440,
0x7C41C000,
0x80000446,
0x7C41C000,
0x8000044C,
0x7C41C000,
0x7C418000,
0x7C41C000,
0x14D40010,
0x0554A000,
0x80000000,
0xCD950000,
0xC0220004,
0x0598A000,
0x7DA18007,
0xCC190000,
0x8000043C,
0xC8180004,
0xC0220004,
0xCD8125D6,
0x222025D7,
0xCC210000,
0x8000043C,
0xC8180004,
0xCD81216D,
0xCDC1216E,
0x8000043C,
0xC8180003,
0x7C40C000,
0xC81003E1,
0xC81403E4,
0xC81803E2,
0xC81C03E3,
0xCD812169,
0xCDC1216A,
0xCCC1216B,
0xCC01216C,
0x04200004,
0x7DA18000,
0x7D96400C,
0x9640FBA4,
0xCD8003E2,
0x1D280003,
0xC02DF000,
0x11180008,
0x7DAD8006,
0x7DA98007,
0x80000000,
0xCD8003E2,
0x7C40C000,
0x80000000,
0xCC4C03E0,
0x1C8CFFFF,
0xD44D0000,
0x7C408000,
0xA0000000,
0xCC80004D,
0xC8140023,
0x31580004,
0x9580FFFF,
0xC8140023,
0xCC00005B,
0xCC412180,
0x204C8000,
0xCCC12181,
0x14D0001F,
0xCC412182,
0xCC412183,
0x9500FB88,
0xCC412184,
0xC8140023,
0x9940FFFF,
0xC8140023,
0x80000001,
0x7C408000,
0xC0160004,
0x21542140,
0xCC550000,
0xC8180004,
0x80000000,
0xCC0003E0,
0xC02A0004,
0x7C40C000,
0xCCC1217C,
0xCC41217D,
0xCC41217E,
0x7C418000,
0x14FC001F,
0x1D98FFFF,
0x39B00003,
0x22A0217F,
0x9B000003,
0x419C0005,
0x041C0040,
0x99C00000,
0x09DC0001,
0xCC210000,
0xC8240004,
0x166C001F,
0x419C0005,
0x9AC0FFFA,
0xCC80004D,
0x9BC0FB66,
0x00000000,
0x80000000,
0xCC0003E0,
0x7C40C000,
0x7C410000,
0x1518001F,
0x51140020,
0x9980000B,
0x191C0031,
0xCD000062,
0x7D4D4027,
0xD4560000,
0x95C0FB59,
0xC8200026,
0x9A000000,
0xC8200026,
0x80000001,
0x7C408000,
0xE03A0000,
0xC0260004,
0xCCC12169,
0x7D250007,
0xCD01216A,
0x0BB80002,
0xCC41216B,
0x9B80FFFE,
0xCC41216C,
0x99C0FD10,
0xCC00007F,
0x80000001,
0x7C408000,
0xC00E0100,
0xCC000041,
0xCCC1304A,
0xC83C007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00010468,
0x00100003,
0x00120005,
0x0015001A,
0x00160022,
0x00170035,
0x0021003A,
0x00240057,
0x00250057,
0x00270061,
0x00280054,
0x00290062,
0x002A005F,
0x002B0062,
0x002D0069,
0x002E006C,
0x002F0077,
0x00300079,
0x003200EA,
0x0034008E,
0x00350062,
0x003900EC,
0x003A0114,
0x003B0129,
0x003C0141,
0x003D01B1,
0x003F00E9,
0x0041046D,
0x0042047F,
0x00430485,
0x004401D6,
0x00450141,
0x004601FA,
0x004701FA,
0x004801FA,
0x004A0291,
0x004B0376,
0x004C029D,
0x004D02D4,
0x004E0320,
0x004F0329,
0x0051036A,
0x00520348,
0x0053035F,
0x00540378,
0x0057037A,
0x00600392,
0x006103AA,
0x0062037E,
0x006303B4,
0x006403BE,
0x006503C8,
0x006603D2,
0x006703DC,
0x006803E6,
0x006903EA,
0x006A041C,
0x006B03EE,
0x006C03F2,
0x006D03F6,
0x006E03FA,
0x006F03FE,
0x007003F6,
0x00710422,
0x00720410,
0x00730402,
0x00740409,
0x0075042D,
0x007A049E,
0x007C0450,
0x007D0465,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
0x000F04BA,
};

static const u32 REDWOOD_pfp_microcode[]={
0x7C408000,
0xA0000000,
0x04280001,
0x80000000,
0xE0030000,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x104C0001,
0x98C00005,
0x1C900002,
0xCC400029,
0x80000337,
0xCC40002A,
0x99000005,
0x00000000,
0xCC40002B,
0x80000337,
0xCC40002C,
0xCC40002D,
0x80000337,
0xCC40002E,
0x1C8C0002,
0xCC800040,
0x98C00004,
0xCC400040,
0x80000337,
0xCC000052,
0x80000337,
0xCC000054,
0x80000000,
0xCC4003FD,
0xC810002E,
0xC80C002D,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0C00043,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x55140020,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1000043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC000040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC810002C,
0xC80C002B,
0x51100020,
0x7CD0C027,
0x7CC50020,
0x45180008,
0xC99E0000,
0xC82403FD,
0x7DE68011,
0x96800003,
0x7E5EC001,
0x7C02C006,
0xCEC3A29E,
0x55140020,
0xCC00006C,
0xCD00006D,
0xCD40006D,
0xCD000043,
0xCD400043,
0xC81C001D,
0xD1400043,
0x99C00005,
0xCC000055,
0xC820001F,
0xD80003C0,
0xCC000040,
0xC8280016,
0xD80006C0,
0x1AA80027,
0x96800003,
0xCC800040,
0xD080005C,
0xCC800040,
0xCC000040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC8180015,
0x1D980001,
0x7C424000,
0x958002C0,
0x7C428000,
0xC81C0020,
0xC037C000,
0x7C40C000,
0x7C410000,
0x7CB48006,
0xC0360003,
0x1AB801E8,
0x97800007,
0xD04003E0,
0x8400033A,
0xCC00007F,
0xC83803E0,
0x9B800000,
0xC83803E0,
0x99C00000,
0xC81C0020,
0x7CB48007,
0x10D40002,
0x7D654000,
0xCD400043,
0xCE800043,
0xCD000043,
0xCC800040,
0xCE400040,
0xCE800040,
0xCCC00040,
0xE03A0000,
0x9780FF6E,
0xCD000040,
0x7C40C000,
0x80000088,
0x7C410000,
0x1C8C0002,
0xC810001C,
0x98C00009,
0xC820001F,
0x99000004,
0xC81C0006,
0x8400033D,
0xCC000052,
0xC8180015,
0x80000074,
0x1D980002,
0xC810001E,
0x9900FFFC,
0xC81C0008,
0x8400033D,
0xCC000054,
0xC8180015,
0x80000074,
0x1D980002,
0x1C8C0002,
0xC810001D,
0x98C0000F,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x8400033D,
0xCC000053,
0xC8180015,
0x94C00003,
0x189401E8,
0x05540006,
0x20100001,
0x7D150003,
0x80000074,
0x7D918006,
0x9940FFF8,
0xC820001F,
0x8400033D,
0xC81C0007,
0x800000B3,
0xCC00006E,
0xC00E8080,
0xCC000067,
0x04D08080,
0xCC000068,
0xCD0003F1,
0xCD0003F2,
0xCD0003F3,
0xCD0003F4,
0xCD0003F6,
0xCD0003F7,
0xCD0003F8,
0x80000005,
0xCD0003F9,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0x800000D8,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0x800000E8,
0xCC000040,
0xC820001F,
0x800000E7,
0xD8000440,
0xC820001F,
0xD8000340,
0xCC000040,
0xC80C0029,
0xC810002A,
0xCC800040,
0xCC400040,
0x51100020,
0x7CD0C027,
0x10500002,
0x7D0D0020,
0x55140020,
0xCD000043,
0xCD400043,
0xD0400043,
0xCC000040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x1C8C0002,
0xC810001D,
0x98C00012,
0xC8140049,
0x99000005,
0xC820001F,
0xC81C0007,
0x8400033D,
0xCC000053,
0xC80C002F,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7CC4C000,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x9940FFF5,
0xC820001F,
0x8400033D,
0xC81C0007,
0x80000109,
0xCC00006E,
0x7C40C000,
0xC8100047,
0x9900000B,
0xC8140044,
0x99400004,
0xC8180009,
0xCD800040,
0xCC000040,
0x80000133,
0xCC800040,
0x7C40C000,
0xC8100047,
0x9500FFF7,
0xC8140045,
0x99400004,
0xC818000A,
0xCD800040,
0xCC000040,
0x80000133,
0xD8000840,
0x7C40C000,
0xC8100047,
0x9900FFFC,
0x00000000,
0xCC800040,
0xCCC00040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC8100046,
0xD8000740,
0xCD000040,
0x8400014A,
0xCD000040,
0xC80C0043,
0x94C0000A,
0xC8140048,
0x80000143,
0x04100003,
0xC8100046,
0xD80007C0,
0xCD000040,
0x8400014A,
0xCD000040,
0xC8140048,
0x9D400000,
0xCC00006A,
0xC8280016,
0x1EA80001,
0x9A800003,
0xC0290001,
0x88000000,
0xC02C0156,
0xCE80005C,
0xD80008C0,
0xCEC00040,
0x88000000,
0xCC000040,
0x1C8C0002,
0xC810001E,
0xC820001F,
0x94C00008,
0xC814001C,
0x9900000A,
0xC81C0008,
0x8400033D,
0xCC000054,
0x80000165,
0xCC800040,
0x99400004,
0xC81C0006,
0x8400033D,
0xCC000052,
0xCC800040,
0x80000000,
0xD4400040,
0xCC400027,
0xCC400028,
0x80000337,
0xCC00006B,
0xC0320003,
0xC037FFFF,
0x80000170,
0x7CB08007,
0x7C434000,
0xC8200028,
0xC81C0027,
0xC8180026,
0xCF43A29E,
0x7C414000,
0x52200020,
0x7DE1C027,
0x7D58C003,
0x7CDCC020,
0x54D00020,
0x80000185,
0xCC800040,
0x7C418000,
0xCC800040,
0x80000182,
0xCD800040,
0xC019FFFF,
0xCC800040,
0xCD83A29E,
0x7C40C000,
0x7C410000,
0x7C414000,
0xCCC3A1FA,
0xCD03A1F9,
0xCD43A29D,
0xCCC00040,
0xCD000040,
0xCD400040,
0xCC400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00001,
0xCCC3A29F,
0x95000003,
0xD0400026,
0xD0800026,
0xCC800040,
0x80000000,
0xCCC00040,
0x7C40C000,
0xCC800040,
0xCCC3A2A2,
0x80000000,
0xCCC00040,
0x7C40C000,
0x14D4001F,
0xCC800040,
0x95400003,
0x7C410000,
0xCCC00059,
0x1518001F,
0xCCC00040,
0x95800003,
0xCD000040,
0xCD00005A,
0x80000337,
0xCC00007F,
0xC820001F,
0x7C410000,
0xD8200244,
0xCE200044,
0x7C414000,
0x7C418000,
0xCDA00049,
0xCD200041,
0xCD600041,
0xCDA00041,
0x15100008,
0x11540018,
0x7D53C007,
0xCFC0002F,
0x06200001,
0xCE000058,
0x80000337,
0xCC00007F,
0xC820001F,
0xCA0C0017,
0x94C00005,
0x7C410000,
0xD82002C6,
0x800001AF,
0xCE200046,
0xCC000048,
0x800001C5,
0x00000000,
0xC820001F,
0x7C418000,
0x0A200001,
0xCA14001A,
0xCA180017,
0x7D598007,
0x95800005,
0xCE000058,
0xCCA00046,
0x80000000,
0xCD600046,
0xCCA00044,
0x80000000,
0xCD600044,
0x80000337,
0xCC40006A,
0xCC800040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0x7C438000,
0x7C43C000,
0x041C0002,
0xCF800042,
0xCFC00042,
0xCDC00042,
0x041C0020,
0xCCC00042,
0xCD000042,
0xCDC00042,
0x041C0007,
0x04200001,
0x7C024000,
0xC8140003,
0xC8180003,
0x51980020,
0x7D594027,
0xC8280003,
0xC82C0003,
0xC8300003,
0xC8340003,
0x52EC0020,
0x7EAE8027,
0x53740020,
0x7F370027,
0x7F2B4021,
0x7E764020,
0x56A8003F,
0x5730003F,
0x7EB28006,
0x7E2A0006,
0x99C0FFF2,
0x09DC0001,
0x9680FFE1,
0x53F40020,
0x7F7B4027,
0x7D654020,
0x55580020,
0xCC00005B,
0xCD760000,
0xCDB60000,
0xC8200041,
0x9A000000,
0xC8200041,
0x80000001,
0x7C408000,
0x7C40C000,
0x7C410000,
0xCCC003FE,
0xCD0003FF,
0xCCC00042,
0xCD000042,
0x1514001F,
0x191800F0,
0x275C0001,
0x7D760006,
0x99800005,
0x7D5E4006,
0xCC000042,
0x80000337,
0xCC00004D,
0x15980001,
0x152C0008,
0x99800031,
0x1EEC0001,
0x96000004,
0x1530000C,
0x80000337,
0xCC000042,
0x04140020,
0xCD400042,
0x1F300001,
0x20280001,
0x04380020,
0x043C0007,
0xC8140003,
0xC8180003,
0xC81C0003,
0xC8200003,
0x7D5D400D,
0x7DA1C00D,
0x7D5D4007,
0x1610001F,
0x159C001F,
0x7D1D0006,
0x7D174006,
0x7E928006,
0x9B400012,
0x0BB80004,
0x9BC0FFF2,
0x0BFC0001,
0xC80C03FE,
0x9A800009,
0xC81003FF,
0x9B0000FD,
0xCC00004D,
0x04140020,
0xCCC00042,
0xCD000042,
0x80000224,
0xCD400042,
0x96C000F6,
0xCC00004D,
0x80000337,
0xCC00004E,
0x9AC00003,
0xCC00004D,
0xCC00004E,
0x9780FDB8,
0xE3830000,
0x80000000,
0xDC0301FF,
0x96400004,
0xCC00004E,
0x80000337,
0xCC000042,
0xD2000042,
0xC8080003,
0xC80C0003,
0xC8100003,
0xC8140003,
0xC8180003,
0xC81C0003,
0xC8240003,
0xC8280003,
0x15FC001F,
0x16B0001F,
0x7FF3C006,
0x14F0001F,
0x7FF3C006,
0x1570001F,
0x7FF3C006,
0x7D888001,
0x97C0000D,
0x7DCCC001,
0x7E510001,
0x7E954001,
0x7C90800C,
0x7CD4C00C,
0x9AC00003,
0x7C8F4006,
0x24B40001,
0x9B4000CD,
0xCC00004D,
0x80000337,
0xCC00004E,
0xC80C03FE,
0xC81003FF,
0xCCC00042,
0x80000250,
0xCD000042,
0x7C40C000,
0x7C410000,
0x1914003B,
0xCC00005B,
0x95400013,
0xC8140040,
0x31580002,
0x9580FFFF,
0xC8140040,
0xCC000063,
0x211C8000,
0xCCC12185,
0xCDC12186,
0x1514001F,
0xCC412187,
0xCC412188,
0x9540FD7D,
0xCC412189,
0xC8140040,
0x9940FFFF,
0xC8140040,
0x80000001,
0x7C408000,
0xCC800040,
0xCCC00040,
0xCD000040,
0x80000000,
0xD4400040,
0xD08003E0,
0xCC800040,
0x8400033A,
0xCC400040,
0xC80C03E0,
0x98C00000,
0xC80C03E0,
0x7C408000,
0xA0000000,
0x7E828006,
0x7C40C000,
0x840002A2,
0x14D0001F,
0x9900FD64,
0xD04003E0,
0x8400033A,
0xCC00007F,
0x80000294,
0xC80C03E0,
0xCC800040,
0xCCC00040,
0x88000000,
0xD4400040,
0xCC800040,
0xCC400040,
0xCC400040,
0xCC400040,
0x7C40C000,
0xCCC00021,
0xCCC00040,
0xD4400040,
0xC037FFFF,
0xD00003FB,
0xD00003FC,
0x80000000,
0xCF4003FD,
0x7C40C000,
0x14DC001D,
0x99C00007,
0xCC800040,
0x18DC003C,
0x99C0007F,
0xCCC00040,
0x80000337,
0xCC00006A,
0x18D8003C,
0xCD800066,
0xCC00006A,
0x80000337,
0xCCC00040,
0x7C40C000,
0x50500020,
0x8400033A,
0xCC00005D,
0x7CD0C027,
0xC820001F,
0xC8D60000,
0x99400008,
0x7C438000,
0xE3830000,
0xCFA0004F,
0x8400033A,
0xCC00005E,
0x80000000,
0xD440007F,
0x80000337,
0xCC00005E,
0x8400033A,
0xCC00005D,
0xC820001F,
0x7C40C000,
0xC036FF00,
0xC8100021,
0xC0303FFF,
0x7CF54006,
0x7D518006,
0x7D81800A,
0x99800008,
0x7CF38006,
0xE3830000,
0xCFA0004F,
0x8400033A,
0xCC00005E,
0x80000000,
0xD440007F,
0x80000337,
0xCC00005E,
0x8400033A,
0x7C40C000,
0x14DC0008,
0x95C00019,
0x1CDC0010,
0x7C410000,
0x99C00004,
0x50540020,
0x800002F2,
0xC91D0000,
0x7D150027,
0xC91E0000,
0x7C420000,
0x7C424000,
0x7C418000,
0x7DE5C006,
0x7DE28011,
0x9A80FD09,
0x41AC0005,
0x9AC00000,
0x0AEC0001,
0x1CDC0010,
0x99C00004,
0x00000000,
0x800002F5,
0xC91D0000,
0x800002F5,
0xC91E0000,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0xC820001F,
0xD8000340,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0xC820001F,
0xD80003C0,
0xCC000040,
0xCC800040,
0xD4400040,
0x7C408000,
0xA0000000,
0x04280001,
0x7C40C000,
0x1CD00006,
0x29100006,
0x99000007,
0xC814001C,
0x99400005,
0xCC000052,
0xC81C0006,
0x8400033D,
0xC820001F,
0xCC800040,
0xCCC00040,
0x80000000,
0xD4400040,
0x7C40C000,
0x7C410000,
0x1518001F,
0xCD00005B,
0x99800004,
0x51140020,
0x80000000,
0xD44D0000,
0x7D4D4027,
0x191C0031,
0xD4560000,
0x95C0FCD1,
0xC8200041,
0x9A000000,
0xC8200041,
0x80000001,
0x7C408000,
0x80000000,
0xD440007F,
0xCC00007F,
0x80000000,
0xCC00007F,
0xCC00007F,
0x88000000,
0xCC00007F,
0xCDC00040,
0x88000000,
0xCC000040,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00020003,
0x00030306,
0x0004030E,
0x000501AB,
0x000600D6,
0x000700E5,
0x000800F8,
0x000900DE,
0x000A00D3,
0x000B00E2,
0x000C011A,
0x000D0124,
0x000E0138,
0x000F0142,
0x00100335,
0x0011000A,
0x00120018,
0x00130020,
0x00160022,
0x00240031,
0x0025004C,
0x00260167,
0x001701C7,
0x001801D5,
0x002202C1,
0x002302D2,
0x0027017C,
0x001F01DA,
0x0020020A,
0x0028019E,
0x0029016B,
0x002A0190,
0x002B0180,
0x002F0199,
0x003201BD,
0x00340316,
0x0035016F,
0x003901D7,
0x003C02E6,
0x003E0335,
0x003F01AB,
0x00410273,
0x0042028F,
0x00430299,
0x004402A6,
0x004A02B3,
0x00550309,
0x00560311,
0x00600072,
0x00610097,
0x006200C1,
0x006300AA,
0x006400AA,
0x006500AA,
0x006600AA,
0x006700AA,
0x006800CE,
0x006900D9,
0x006A012E,
0x006B00FB,
0x006C00FB,
0x006D00FB,
0x006E00FB,
0x006F00FB,
0x00700100,
0x007300E8,
0x007400E8,
0x00750155,
0x007B0324,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
0x00000005,
};

static const u32 REDWOOD_rlc_microcode[]={
0x20380010,
0x23B80000,
0xCF800012,
0xCC000085,
0x04180001,
0xCD80000E,
0xCD800083,
0xCC000082,
0xCD800081,
0xCC00000B,
0x8000004A,
0x00000000,
0xCC00000E,
0xCC00000E,
0xC8100082,
0x202801C3,
0x201C0000,
0xC8100082,
0xC8080085,
0x7F8B8007,
0xC8080081,
0x94800030,
0x00000000,
0x80000054,
0x00000000,
0xC9CC0083,
0x94C00017,
0x00000000,
0x84000097,
0x200C0001,
0x840000AA,
0x20380000,
0x97800011,
0x200C000D,
0xC0302009,
0xCCF10000,
0xC030200A,
0xC0341818,
0x13740008,
0x23741818,
0xCB0D0000,
0x7CF4C006,
0xC808001A,
0x98800006,
0x201C0001,
0x94C0FFFB,
0x00000000,
0x80000041,
0x7DC1C006,
0x840000BD,
0x11B8001F,
0x840000AA,
0x20380001,
0x84000097,
0x200C0000,
0xC03001C0,
0xCB390000,
0x20380000,
0x95C0FFD3,
0xCF800003,
0x7DC1C006,
0x840000BD,
0x20380000,
0x8000000D,
0xCF800003,
0x20380001,
0xCF800003,
0xC8100082,
0xCC000081,
0xC808001A,
0x9480000E,
0x00000000,
0xCD80000E,
0x00000000,
0x840000A8,
0x20380002,
0xCC310000,
0x840000AA,
0x20380001,
0xCD800081,
0x84000097,
0x200C0000,
0x8000000D,
0x00000000,
0xC8380056,
0x9B80006B,
0x201C0000,
0xC8380057,
0x9B800068,
0x201C0001,
0x201C0000,
0xC8080081,
0x94800012,
0x00000000,
0xC8280000,
0x9680000F,
0x20080001,
0xCD80000E,
0xCC800000,
0x1C1C0000,
0x2A8801BB,
0x94800004,
0x00000000,
0x800000B8,
0x00000000,
0x2A8801BC,
0x98800044,
0x00000000,
0x95000023,
0x00000000,
0xC8280002,
0x96800006,
0x20080001,
0xCD80000E,
0xCC800002,
0x8000008F,
0x00000000,
0xC8280001,
0x96800007,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800001,
0x8000008F,
0x00000000,
0xC8280003,
0x96800009,
0x00000000,
0xCD80000E,
0x2A8C01E5,
0x98C0FF97,
0x20080001,
0xCC800003,
0x8000008F,
0x00000000,
0xC8280004,
0x9680FF85,
0x00000000,
0x20080001,
0xCD80000E,
0xCC800004,
0x8000008F,
0x00000000,
0x84000093,
0x00000000,
0x8000000D,
0x00000000,
0x1EA800FF,
0xCE80000C,
0x88000000,
0x00000000,
0xC0300390,
0xCB390000,
0xC00BFFFE,
0x7F8B8006,
0x10CC0010,
0x7F8F8007,
0xCFB10000,
0x88000000,
0xCB390000,
0xCFB10000,
0xCD80000E,
0xCB390000,
0x17B80004,
0x9780FFFE,
0x00000000,
0x88000000,
0x00000000,
0x800000A0,
0xC03001C1,
0xC0302003,
0xCFB10000,
0x88000000,
0xCB390000,
0xC9F80083,
0x9B800004,
0x00000000,
0x8000000D,
0x00000000,
0xCC1C0083,
0x840000BD,
0x11B8001F,
0x8000000D,
0x00000000,
0xCD9C0083,
0x840000BD,
0x20380000,
0x9500FF54,
0x00000000,
0xC03001C0,
0x88000000,
0xCFB10000,
0x99C0000B,
0xC8300040,
0x23300002,
0xCF000040,
0x840000D5,
0x20380003,
0xC8300040,
0x1F3003FD,
0xCF000040,
0x80000054,
0xCC000056,
0xC8300040,
0x23300040,
0xCF000040,
0x840000E6,
0x20380001,
0xC8300040,
0x1F3003BF,
0xCF000040,
0x80000054,
0xCC000056,
0x840000F1,
0x00000000,
0xC0302008,
0x840000F9,
0x2038FFFF,
0xC0302008,
0xCC310000,
0xCB390000,
0xC0300398,
0x840000F9,
0x20380100,
0xC0300398,
0xCC310000,
0xCB090000,
0xC03021B6,
0x88000000,
0xCC310000,
0x840000F1,
0x00000000,
0x20380001,
0xC0300398,
0x840000F9,
0x13B80014,
0xCC000057,
0xC0300398,
0xCC310000,
0x88000000,
0xCB090000,
0xCF9C0016,
0xCD80000E,
0xC9F00018,
0x7F38800C,
0x9480FFFE,
0x00000000,
0x88000000,
0x00000000,
0xCFB10000,
0xCB390000,
0x2008001F,
0x98800000,
0x08880001,
0xCC1C0016,
0xC9F0001B,
0x9700FFFF,
0x00000000,
0x88000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
0x00000000,
};
