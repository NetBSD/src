/*	$NetBSD: imx8mn-power.h,v 1.1.1.1.10.1 2026/11/04 23:27:32 perseant Exp $	*/

/* SPDX-License-Identifier: (GPL-2.0 OR MIT) */
/*
 *  Copyright (C) 2020 Compass Electronics Group, LLC
 */

#ifndef __DT_BINDINGS_IMX8MN_POWER_H__
#define __DT_BINDINGS_IMX8MN_POWER_H__

#define IMX8MN_POWER_DOMAIN_HSIOMIX	0
#define IMX8MN_POWER_DOMAIN_OTG1	1
#define IMX8MN_POWER_DOMAIN_GPUMIX	2
#define IMX8MN_POWER_DOMAIN_DISPMIX	3
#define IMX8MN_POWER_DOMAIN_MIPI	4

#define IMX8MN_DISPBLK_PD_MIPI_DSI	0
#define IMX8MN_DISPBLK_PD_MIPI_CSI	1
#define IMX8MN_DISPBLK_PD_LCDIF	2
#define IMX8MN_DISPBLK_PD_ISI	3

#endif
