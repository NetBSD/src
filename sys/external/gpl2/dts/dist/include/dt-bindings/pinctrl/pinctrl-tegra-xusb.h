/*	$NetBSD: pinctrl-tegra-xusb.h,v 1.1.1.1.4.2 2017/07/18 16:08:59 snj Exp $	*/

#ifndef _DT_BINDINGS_PINCTRL_TEGRA_XUSB_H
#define _DT_BINDINGS_PINCTRL_TEGRA_XUSB_H 1

#define TEGRA_XUSB_PADCTL_PCIE 0
#define TEGRA_XUSB_PADCTL_SATA 1

#endif /* _DT_BINDINGS_PINCTRL_TEGRA_XUSB_H */
