int libsodium_errno;
