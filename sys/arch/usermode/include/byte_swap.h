/* $NetBSD: byte_swap.h,v 1.11.28.1 2018/05/21 04:36:02 pgoyette Exp $ */

/*
 * Automatically generated by ./genheaders.sh on Wed May 16 14:39:02 CEST 2018
 * Do not modify directly!
 */
#ifndef _USERMODE_BYTE_SWAP_H
#define _USERMODE_BYTE_SWAP_H

#if defined(__i386__)
#include "../../i386/include/byte_swap.h"
#elif defined(__x86_64__)
#include "../../amd64/include/byte_swap.h"
#elif defined(__arm__)
#include "../../arm/include/byte_swap.h"
#else
#error port me
#endif

#endif
