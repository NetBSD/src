/* $NetBSD: ptrace.h,v 1.13.28.1 2018/05/21 04:36:02 pgoyette Exp $ */

/*
 * Automatically generated by ./genheaders.sh on Wed May 16 14:39:02 CEST 2018
 * Do not modify directly!
 */
#ifndef _USERMODE_PTRACE_H
#define _USERMODE_PTRACE_H

#if defined(__i386__)
#include "../../i386/include/ptrace.h"
#elif defined(__x86_64__)
#include "../../amd64/include/ptrace.h"
#elif defined(__arm__)
#include "../../arm/include/ptrace.h"
#else
#error port me
#endif
#undef __HAVE_PTRACE_MACHDEP
#undef __HAVE_PROCFS_MACHDEP

#endif
