/* $NetBSD: cdefs.h,v 1.6.28.1 2018/05/21 04:36:02 pgoyette Exp $ */

/*
 * Automatically generated by ./genheaders.sh on Wed May 16 14:39:02 CEST 2018
 * Do not modify directly!
 */
#ifndef _USERMODE_CDEFS_H
#define _USERMODE_CDEFS_H

#if defined(__i386__)
#include "../../i386/include/cdefs.h"
#elif defined(__x86_64__)
#include "../../amd64/include/cdefs.h"
#elif defined(__arm__)
#include "../../arm/include/cdefs.h"
#else
#error port me
#endif

#endif
