/* $NetBSD: int_types.h,v 1.10.6.1 2014/08/20 00:03:27 tls Exp $ */

/*
 * Automatically generated by genheaders.sh on Sun Nov 10 15:47:58 AST 2013
 * Do not modify directly!
 */
#ifndef _USERMODE_INT_TYPES_H
#define _USERMODE_INT_TYPES_H

#if defined(__i386__)
#include "../../i386/include/int_types.h"
#elif defined(__x86_64__)
#include "../../amd64/include/int_types.h"
#elif defined(__arm__)
#include "../../arm/include/int_types.h"
#else
#error port me
#endif

#endif
