/* $NetBSD: cpufunc.h,v 1.1.6.2 2019/06/10 22:06:50 christos Exp $ */

/*
 * Automatically generated by ./genheaders.sh on Wed May 16 14:39:02 CEST 2018
 * Do not modify directly!
 */
#ifndef _USERMODE_INT_LIMITS_H
#define _USERMODE_INT_LIMITS_H

#if defined(__i386__)
#include "../../i386/include/cpufunc.h"
#elif defined(__x86_64__)
#include "../../amd64/include/cpufunc.h"
#elif defined(__arm__)
#include "../../arm/include/cpufunc.h"
#else
#error port me
#endif

#endif
