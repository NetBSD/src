#	$NetBSD: Makefile.inc,v 1.3.198.1 2011/06/06 09:07:04 jruoho Exp $

WARNS?=		4
BINDIR?=	/usr/bin
