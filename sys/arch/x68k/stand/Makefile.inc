#	$NetBSD: Makefile.inc,v 1.3.4.1 2021/04/17 17:26:17 thorpej Exp $

DBG=-Os -fno-unwind-tables -Wno-attributes -fcommon
