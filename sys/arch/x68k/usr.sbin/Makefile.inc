#	from: @(#)Makefile.inc	5.1 (Berkeley) 5/11/90
#	$NetBSD: Makefile.inc,v 1.1.1.1.12.1 1997/10/14 10:20:53 thorpej Exp $

BINDIR?=	/usr/sbin
