# $NetBSD: Makefile.inc,v 1.2.122.1 2017/12/03 11:35:50 jdolecek Exp $

NOPIE=	# defined

BINDIR?=	/usr/mdec
