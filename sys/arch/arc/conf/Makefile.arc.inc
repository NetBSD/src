#	$NetBSD: Makefile.arc.inc,v 1.14.4.1 2006/09/09 02:37:43 rpaulo Exp $

CPUFLAGS?=	-march=r4000 -mabi=32
