#	$NetBSD: Makefile.inc,v 1.1.8.2 2008/01/21 09:38:59 yamt Exp $

BINDIR=		/usr/mdec
