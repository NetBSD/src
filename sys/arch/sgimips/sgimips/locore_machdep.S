/*	$NetBSD: locore_machdep.S,v 1.4.4.1 2006/09/09 02:42:58 rpaulo Exp $	*/

/* This file intentionally left blank. */
