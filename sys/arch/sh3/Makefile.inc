#	$NetBSD: Makefile.inc,v 1.1.8.2 2002/03/16 15:59:34 jdolecek Exp $

SSH3=	../sh3/sh3/*.[ch] ../sh3/include/*.h ../sh3/dev/*.[ch]
ASH3=	../sh3/sh3/*.S
