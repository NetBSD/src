#	$NetBSD: Makefile.inc,v 1.1 2003/04/29 05:35:08 thorpej Exp $

.if exists(${.CURDIR}/../../Makefile.inc)
.include "${.CURDIR}/../../Makefile.inc"
.endif
