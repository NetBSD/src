#	$NetBSD: Makefile.inc,v 1.1.142.1 2014/05/22 11:39:43 yamt Exp $

BINDIR?=	/usr/mdec
FILESDIR?=	/usr/mdec
KLINK_MACHINE=	evbarm
