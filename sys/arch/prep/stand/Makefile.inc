#	$NetBSD: Makefile.inc,v 1.1.6.2 2000/11/20 20:23:07 bouyer Exp $

BINDIR=		/usr/mdec
