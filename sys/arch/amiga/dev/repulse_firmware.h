/* $NetBSD: repulse_firmware.h,v 1.1.4.2 2001/09/13 01:13:00 thorpej Exp $ */

/*
 * Copyright 2001 ALiENDESiGN GbR.
 *
 * This file may be used, copied, redistributed, and transformed into
 * a different format, but must not be changed otherwise.
 * This copyright notice and license must not be changed or removed.
 */

const u_int32_t repulse_firmware[] = {
	0xffffffff, 0x5599aa66, 0x0c000180, 0x000000e0, 0x0c800680, 0x000000d0, 
	0x0c800480, 0x00017c13, 0x0c000380, 0x00008063, 0x0c000180, 0x00000090, 
	0x0c000480, 0x00000000, 0x0c000180, 0x00000080, 0x0c000200, 0x0a007c20, 
	0x00480400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x01000000, 0x00000000, 
	0x20480400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x01000000, 0x00000000, 
	0x11400200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00001c03, 0x01000000, 0x00000000, 
	0x00400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000004, 0x01000000, 0x00000000, 
	0x00480000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00002000, 0x05000000, 0x00000000, 
	0x11480000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0b000000, 0x00000000, 
	0x31c80000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x01000000, 0x00000000, 
	0xce480203, 0x00040010, 0x00400000, 0x00000400, 0x10004000, 0x00000000, 
	0x00000000, 0x00000000, 0x40000001, 0x0001c024, 0x0d000000, 0x00000000, 
	0x03a03900, 0x3320cc08, 0xf003e82d, 0x88eb04fc, 0x00300fc0, 0x3c09e300, 
	0xcc00f002, 0xc03f05ab, 0x00fc2030, 0x02c00c00, 0x0e000000, 0x00000000, 
	0x01083710, 0x11002c00, 0xd1014834, 0x00fd0a74, 0x2110ad40, 0x3407f102, 
	0x4550d101, 0x48b40091, 0x10748010, 0x41400420, 0x0c000000, 0x00000000, 
	0x11203300, 0x11800410, 0xd0404130, 0x08c92034, 0x01520c40, 0x3001c102, 
	0x1600d001, 0x40320089, 0x04740410, 0x00414580, 0x0e000000, 0x00000000, 
	0x03a83500, 0x11026403, 0xd2854834, 0x21dd0074, 0x01500d50, 0x3400d100, 
	0x5440d045, 0x40740491, 0x00741114, 0x11400d20, 0x06000000, 0x00000000, 
	0x00a8f701, 0x130b4c4c, 0xf0315034, 0x00d9007e, 0xca700d80, 0x3400d300, 
	0x5c00f051, 0xc866009b, 0x083c0430, 0x21d10120, 0x0e000000, 0x00000000, 
	0x87803d31, 0x7f11fc25, 0xf00fc06e, 0x00ff00fc, 0x03b00dc0, 0x3344ef00, 
	0xec09f013, 0x042a00ff, 0x00fc04f0, 0x07c21e02, 0x06000000, 0x00000000, 
	0x02081500, 0x93027c02, 0x3029d034, 0x00df001c, 0x4b300dc0, 0x3440db00, 
	0x5c097015, 0xc1a700df, 0x004c0030, 0x01c00820, 0x04000000, 0x00000000, 
	0x13a0b010, 0xc1007403, 0x100d40b4, 0x10fd4e44, 0x07100e40, 0xfc04f12a, 
	0x40011004, 0xc0a400dd, 0x00542514, 0x05004d00, 0x02000000, 0x00000000, 
	0x07a03210, 0xc1003400, 0x8c014830, 0x06cd0014, 0x22111c40, 0x7100c903, 
	0x3400d000, 0x6031208d, 0x20042810, 0x01401e00, 0x0a000000, 0x00000000, 
	0x0482f800, 0xa121b406, 0x941b4078, 0x02ed4184, 0x07101e45, 0x7901e911, 
	0xe4059016, 0x42f800fd, 0x81942410, 0x17421b00, 0x02000000, 0x00000000, 
	0x1210300c, 0x43103c01, 0xb00cc020, 0x02cf8014, 0x03320cc0, 0x3130cb00, 
	0x3c01f000, 0xc01112cf, 0x004c0030, 0x40c24a40, 0x00000000, 0x00000000, 
	0x02b23d00, 0x3f02fc23, 0x700ec03f, 0x02ff10bc, 0x23f00fc1, 0x3e09f710, 
	0x9c217087, 0xc03f00ff, 0x08fc01f0, 0x07c00940, 0x06000000, 0x00000000, 
	0x15a02700, 0xdf827c07, 0xa005c037, 0x00d3007c, 0x02701dc0, 0x3500d314, 
	0x7c003005, 0xc037009f, 0x003c0330, 0x09c05400, 0x0e000000, 0x00000000, 
	0x12883900, 0xed00f403, 0x100e403b, 0x20eb34b4, 0x03124e40, 0x3831e104, 
	0xf403100e, 0x403b00ed, 0x00b40210, 0x0f504820, 0x06000000, 0x00000000, 
	0x83007924, 0xed01b647, 0xd01e60ff, 0x00e10534, 0x07101c40, 0x7343e105, 
	0xb4051016, 0x407b00ed, 0x01b40710, 0x12400c02, 0x04000000, 0x00000000, 
	0x12283321, 0xcd42340f, 0x505c4263, 0x80c90034, 0x03100c40, 0x3200c100, 
	0x3403000c, 0x403306dd, 0x00740710, 0x1d404824, 0x0c000000, 0x00000000, 
	0x17a81d20, 0x5f00f489, 0xf017c157, 0x005140fc, 0x893405c0, 0x17005300, 
	0xfc093427, 0xc0df005d, 0x00fc4920, 0x77d85c20, 0x06000000, 0x00000000, 
	0x12020700, 0x1f187c00, 0xa001c007, 0x000f027c, 0x40b001c0, 0x05000f00, 
	0x7c24fa11, 0xca07001d, 0x007c04f4, 0x11c04b08, 0x0c000000, 0x00000000, 
	0x1008e600, 0xdf007c42, 0xe009c024, 0x009b084c, 0x223089c0, 0x63519300, 
	0x4c021099, 0xc0a7009f, 0x004c0630, 0x09c04020, 0x0c000000, 0x00000000, 
	0x0120a608, 0x9d047402, 0xc00942e0, 0x00910515, 0x0e540940, 0x27009108, 
	0x44021039, 0x4027009d, 0x00452250, 0x09400500, 0x08000000, 0x00000000, 
	0x18a0a400, 0x9d007402, 0xd00c4024, 0x05990044, 0x0a100940, 0x27009100, 
	0x05025029, 0x4027209d, 0x00440210, 0x09406000, 0x02000000, 0x00000000, 
	0x10202010, 0x8d003422, 0xd0085020, 0x20810054, 0x12504841, 0x63038104, 
	0x048a5408, 0x4823018d, 0x00040b50, 0x28404180, 0x00000000, 0x00000000, 
	0x1db00610, 0x1f007c08, 0xf081c004, 0x001b044c, 0x003001c0, 0xc7241331, 
	0x4c087101, 0xc017041f, 0x024c0830, 0x21c074c0, 0x0a000000, 0x00000000, 
	0x19b22f00, 0x9f60fc02, 0xf00bc42b, 0x009f02ec, 0x0af009c8, 0x67009f00, 
	0xfc16b00b, 0xc02f20bf, 0x15fc12f2, 0x4bc06740, 0x0e000000, 0x00000000, 
	0x18a82b00, 0xbf005c02, 0x3228e02f, 0x00bf34fc, 0x42300bc1, 0xaf44bb04, 
	0x7c02f00f, 0xc02f04df, 0x00fc0230, 0x29d26400, 0x0e000000, 0x00000000, 
	0x9c180700, 0x1d004580, 0x10414407, 0x001d0274, 0x00100148, 0x87011102, 
	0x7410d001, 0x4087001d, 0x007400b2, 0x41407022, 0x0c000000, 0x00000000, 
	0x10a02300, 0x85004452, 0x54084023, 0x08cd0064, 0x82140840, 0x23018502, 
	0x3442d008, 0x4023008d, 0x14345210, 0x09404080, 0x0e000000, 0x00000000, 
	0x18a02408, 0x9d804402, 0x41494027, 0x009d0074, 0x02100944, 0x27009400, 
	0x7412d009, 0x40a7009d, 0x40740290, 0x09406020, 0x06000000, 0x00000000, 
	0x0528e404, 0x8f844c16, 0x72294167, 0x109f407c, 0x021009c4, 0x27009700, 
	0x7c02fb09, 0xc0a7209d, 0x417c0610, 0x49405421, 0x0e000000, 0x00000000, 
	0x14006512, 0x9f007ca6, 0xb009c2e7, 0x089d207c, 0x12f009c8, 0x27409b00, 
	0x7c82f049, 0xc027089f, 0x057c0af0, 0x09c05300, 0x06000000, 0x00000000, 
	0x1408c500, 0x13017c00, 0x30015044, 0x001b005c, 0x103001c0, 0x07061f01, 
	0x7c80f011, 0xc047301f, 0x007c0030, 0x01c05020, 0x04000000, 0x00000000, 
	0x14209c10, 0x71022401, 0x0005005c, 0x00714284, 0x05500542, 0xdf007d06, 
	0x7401d037, 0xc19f005d, 0x00f40112, 0x04405000, 0x02000000, 0x00000000, 
	0x14a07210, 0xc1403403, 0xc40c4070, 0x00cd0614, 0x0b108848, 0xf700cd01, 
	0x3403d00c, 0x482300cd, 0x00741910, 0x0c401000, 0x0a000000, 0x00000000, 
	0x0482fc40, 0xe100a423, 0xd05f40f8, 0x20e521c4, 0x0b500e00, 0x3b006d20, 
	0xb413d006, 0x402b00ed, 0x00b40314, 0x4f421402, 0x02000000, 0x00000000, 
	0x14107820, 0xe321fc17, 0xf01ecc78, 0xb0ef4194, 0x87301ec2, 0x7b00ef01, 
	0xbc5ff016, 0xc07b00ef, 0x01fc0731, 0x5ed05440, 0x00000000, 0x00000000, 
	0x10b03500, 0xdf007c43, 0x300dc333, 0x08cb003c, 0x03f00dc6, 0x17005f20, 
	0x7c1bf001, 0xc43500df, 0x327c03f0, 0x0cc84340, 0x06000000, 0x00000000, 
	0x02a07f42, 0xf309fc07, 0x321f817f, 0x08fb01fc, 0x07309f40, 0x7f027f01, 
	0xfc07f017, 0xe04b02f3, 0x19b42730, 0x1ec10c00, 0x0e000000, 0x00000000, 
	0x15883907, 0xe148b413, 0xb44e403a, 0x206d88b4, 0xa2b08a40, 0x3a022d08, 
	0xb4a3f006, 0x692b00e1, 0x00b433b0, 0x8e505420, 0x06000000, 0x00000000, 
	0x00001d80, 0xe110f643, 0x110e620b, 0x00ad00b4, 0x01100e60, 0x3b006d00, 
	0xb403d026, 0x401f10e1, 0x20f60311, 0x0f412000, 0x04000000, 0x00000000, 
	0x06281200, 0xc101340f, 0x104c0442, 0x020d4034, 0xa0900c40, 0x32000d00, 
	0x34635000, 0x40b301c1, 0x40360790, 0x3c401820, 0x0c000000, 0x00000000, 
	0x15a8f100, 0x9301fc0b, 0x103f4077, 0x20dba07c, 0x07310dc0, 0x37005f00, 
	0xfc03d00d, 0xc03700f3, 0x007c4030, 0x2ec05c20, 0x06000000, 0x00000000, 
	0x01001701, 0xdf027843, 0xf08dc206, 0x009b007c, 0x89f00dc2, 0xb6005f40, 
	0x7c03f005, 0xc03700df, 0x017c03f0, 0x0dc42700, 0x0c000000, 0x00000000, 
	0x8008bf00, 0xb303fc03, 0xf00fc03f, 0x006f088c, 0x22308a80, 0x38003305, 
	0xfc03f017, 0xc03f00f3, 0x00cc03f0, 0x0fc10820, 0x0c000000, 0x00000000, 
	0x8120d601, 0xd5057403, 0xd00d4087, 0x00160044, 0x10100d40, 0xf5001103, 
	0x7403d001, 0x403340d1, 0x204407d0, 0x0d508402, 0x08000000, 0x00000000, 
	0x01803600, 0x19007403, 0xd00d6277, 0x04d80044, 0x03100d40, 0x75045110, 
	0x7403d081, 0x40d700c1, 0x004406d0, 0x0d400000, 0x02000000, 0x00000000, 
	0x10201400, 0xc5003603, 0xd00c4003, 0x00050101, 0x00140c40, 0x31400100, 
	0x3403d000, 0x401300c1, 0x000403d2, 0x0d404080, 0x00000000, 0x00000000, 
	0x00100600, 0x9300fc03, 0xf00fc007, 0x001f004c, 0x00300dc0, 0x35001320, 
	0xfc03f001, 0xc01700f3, 0x004c03f0, 0x0dc004c0, 0x0a000000, 0x00000000, 
	0x05301b00, 0xfc00b883, 0xf00fe00f, 0x003600bc, 0x00f00bc0, 0x0f003f00, 
	0xfc03f003, 0xc03f00ff, 0x00fc03f0, 0x0fc01360, 0x0e000000, 0x00000000, 
	0x03a02f00, 0xff80be00, 0xb083c80d, 0x00ff04ec, 0x00f04fc2, 0x3c00fb0d, 
	0xcc33f04f, 0xc23b00f3, 0x02cc4290, 0x0fc00e00, 0x0e000000, 0x00000000, 
	0x01086704, 0xdd007400, 0x10014804, 0x00dd0a44, 0x00d08f00, 0x3c23f10f, 
	0xc433d0cf, 0x41bf00c1, 0x05540b10, 0x8d400420, 0x0c000000, 0x00000000, 
	0x11a02301, 0x4d403400, 0xd0414000, 0x00c50024, 0x00d00c42, 0x3104c100, 
	0x0513d00c, 0x40b100d1, 0x04150290, 0x0c484680, 0x0e000000, 0x00000000, 
	0x03a83500, 0xdd147442, 0x10054035, 0x00d90044, 0x00d00d40, 0x3510d100, 
	0x4403900d, 0x403700d1, 0xa0540310, 0x0d400c20, 0x06000000, 0x00000000, 
	0x02a86700, 0xdf0234a0, 0xf001c004, 0x01cf0068, 0x00f20dd0, 0x3500d300, 
	0x4c83d00d, 0xc03700c1, 0x005c02b0, 0x0cc00a20, 0x0e000000, 0x00000000, 
	0x07806d12, 0xff00fc01, 0xf13fc06e, 0x02df00fc, 0x08f00fc1, 0x3e00df20, 
	0xfc03f00d, 0xc03b00ff, 0x00bc02f0, 0x0de01f00, 0x02000000, 0x00000000, 
	0x02083501, 0xd7087c0f, 0xb209c415, 0x00df084c, 0x04300cc8, 0x3308c300, 
	0x6d03b00d, 0xc0340193, 0x004c9278, 0x0dc00820, 0x04000000, 0x00000000, 
	0x13a07420, 0xd1037407, 0x110c4077, 0x80fd0144, 0x02b10f41, 0x3f00f100, 
	0xd403b00f, 0xd03c04db, 0x006c87d0, 0x7f404c00, 0x02000000, 0x00000000, 
	0x07a06200, 0xc5013400, 0x10004841, 0x00cd0114, 0x18180c40, 0x3300c100, 
	0x0403180c, 0x04f200c1, 0x20042e50, 0x4c501c00, 0x0a000000, 0x00000000, 
	0x04807800, 0xa103f407, 0x101a405a, 0x00ed01d4, 0x04911e40, 0x7ba0e101, 
	0x1407981e, 0x407a00e9, 0x01a487d0, 0x1e421000, 0x02000000, 0x00000000, 
	0x12102404, 0xc5083c01, 0x300cc021, 0x04cd8015, 0x20120c40, 0x3700c300, 
	0x2c03328c, 0xe03200c3, 0x000c2270, 0x0cc24840, 0x00000000, 0x00000000, 
	0x02b03d02, 0xfd00f403, 0x708fc03f, 0x00ff10ac, 0x81f00fc0, 0x3f04ff00, 
	0xfd03d00f, 0xe93d80ff, 0x00fc83f1, 0x8fc00b60, 0x06000000, 0x00000000, 
	0x15a03700, 0xd7807c02, 0xe005c037, 0x00df007c, 0x0070cdc0, 0x7500d384, 
	0x4d47304d, 0xc1b700df, 0x004c02f0, 0x1dc45608, 0x0e000000, 0x00000000, 
	0x12883900, 0xed00b403, 0xd00e4038, 0x00ed04b4, 0x01d0ce40, 0x3324e10a, 
	0xac0b514e, 0x423b04ed, 0x008402d0, 0x0e404820, 0x06000000, 0x00000000, 
	0x03007900, 0xed01940f, 0xd01f4878, 0x00ec05b4, 0x04d81e40, 0x7b01e901, 
	0x0417901e, 0x407b0bad, 0x118506d2, 0x1c640e00, 0x04000000, 0x00000000, 
	0x12283310, 0xcd023407, 0xd00c4030, 0x00cd0034, 0x03d00c40, 0x3308cd40, 
	0x2403d00c, 0x443300cd, 0x000403d0, 0x0c004820, 0x0c000000, 0x00000000, 
	0x17a85504, 0x7f00fc01, 0xf007d21c, 0x005f80fc, 0x0df004c0, 0x15705b40, 
	0x44019005, 0x4017005f, 0x004411d0, 0x05c45e20, 0x06000000, 0x00000000, 
	0x12000700, 0x1e087c48, 0xf0c18004, 0x231f007c, 0x24f001c0, 0x07100200, 
	0x7d007001, 0xc007081f, 0x007c00e0, 0x01c84b00, 0x0c000000, 0x00000000, 
	0x10082790, 0x9f104e02, 0xf009c024, 0x0083056c, 0x12f089e0, 0x24009f00, 
	0x4c02f009, 0x0027009f, 0x004c16f0, 0x09c44320, 0x0c000000, 0x00000000, 
	0x0120e609, 0x8d085402, 0xd0095020, 0x00910144, 0x0af009e0, 0x26209d00, 
	0x5402d009, 0x4027008d, 0x006c02d2, 0x09400700, 0x08000000, 0x00000000, 
	0x18a06400, 0x9d104402, 0xd10c4024, 0xc1910064, 0x0ad00942, 0x24009d00, 
	0x4402d809, 0x4465009c, 0x004402d0, 0x09406300, 0x02000000, 0x00000000, 
	0x10202002, 0x9d001403, 0xd0084224, 0x00818504, 0x02d00840, 0x22008d10, 
	0x1452d808, 0x4123119d, 0x022596d8, 0x78404380, 0x00000000, 0x00000000, 
	0x1db08600, 0x1d004480, 0xf001c004, 0x0013946c, 0x00f25550, 0xc4010f07, 
	0x4d0cf171, 0xc047040f, 0x024c00f0, 0x01c577c0, 0x0a000000, 0x00000000, 
	0x19b02f01, 0xbf00fc02, 0xf20ac12f, 0x009f00fc, 0x027029c0, 0xe5049f11, 
	0x7c46f019, 0xc12700bf, 0x05fc0af2, 0x09c06760, 0x0e000000, 0x00000000, 
	0x18a82f00, 0xbf00fc02, 0xf009c02e, 0x88bf04f8, 0x02300bc0, 0x25069f46, 
	0x4c52f009, 0xc12f049f, 0x088c42f1, 0x1ac16300, 0x0e000000, 0x00000000, 
	0x1c080724, 0x5d807400, 0xd0414114, 0x001d8874, 0x0110a148, 0x84201d06, 
	0x4510d300, 0x4007001d, 0x005408d0, 0x21487320, 0x0c000000, 0x00000000, 
	0x10a02301, 0x8d003402, 0xd0484022, 0x80894034, 0x03900846, 0x21008d02, 
	0x0452d008, 0x4123008d, 0xc40402d2, 0x08444380, 0x0e000000, 0x00000000, 
	0x18a06580, 0x9d20740a, 0xd0094424, 0x809d0074, 0x02900904, 0x24089d00, 
	0x4402c009, 0x4037009d, 0x405402d0, 0x09406320, 0x06000000, 0x00000000, 
	0x05a02600, 0x9f287c06, 0xf059c0a6, 0x209d007c, 0x0aac08c0, 0x25009f00, 
	0x4c02f009, 0xc027009d, 0x014c06d0, 0x09c01720, 0x0e000000, 0x00000000, 
	0x14802500, 0x9f007c26, 0xf159c026, 0x029f007c, 0xa67809c0, 0x27009f00, 
	0x7c02f009, 0xc027809f, 0x057c0ef0, 0x09c05300, 0x06000000, 0x00000000, 
	0x14000504, 0x17037c04, 0xf001c007, 0x001f214c, 0x0cf001c0, 0x07001300, 
	0x4d00f001, 0xc044001f, 0x004c0430, 0x81d05020, 0x04000000, 0x00000000, 
	0x14a09c20, 0x7702f409, 0xd0050817, 0x247d4284, 0x01d04740, 0x16005100, 
	0x7d01d005, 0x50dc005d, 0x00eccd10, 0x07405000, 0x02000000, 0x00000000, 
	0x14a8b200, 0xc5003007, 0xc00d6063, 0x00cc0904, 0x03586c40, 0x3340d100, 
	0x0403d00c, 0x407022dd, 0x00040710, 0x04405000, 0x0a000000, 0x00000000, 
	0x0580b800, 0xe510b48a, 0xd04e403b, 0x10cc0184, 0x03d00e48, 0x7202e10c, 
	0xb413da5e, 0x401800ed, 0x08a40510, 0x1e401400, 0x02000000, 0x00000000, 
	0x15107800, 0xe701bc05, 0xf01e407b, 0x002e018c, 0x07f01e44, 0x7b04f315, 
	0x8c37f05e, 0xc07800ff, 0x058c0530, 0x16c05440, 0x00000000, 0x00000000, 
	0x10981500, 0x5f007c00, 0xf02dc427, 0x201f007d, 0x03f00de0, 0xb710df00, 
	0x7c13e04d, 0xc11700df, 0x027c03f4, 0x05c04360, 0x06000000, 0x00000000, 
	0x00a27f20, 0xef41cc24, 0xf0bfc97b, 0x127309fc, 0x07321f40, 0x7f02fe01, 
	0xcd47301f, 0xc15c80fb, 0x03840530, 0x17c00000, 0x0e000000, 0x00000000, 
	0x15881800, 0xed0884a0, 0xd20ec03b, 0x14210cb4, 0x21b28e40, 0x3b03e904, 
	0xc423500e, 0x401808fd, 0x04841112, 0x8b485420, 0x06000000, 0x00000000, 
	0x00003906, 0xed008420, 0xd10e613f, 0x002000b6, 0x0a100240, 0x3b30cd00, 
	0x8503100c, 0x400802ed, 0x40840194, 0x06400000, 0x04000000, 0x00000000, 
	0x04281300, 0x4d030608, 0xd01c40b1, 0x01010034, 0x04900840, 0x3310c900, 
	0x0403500d, 0x400000cd, 0x00040190, 0x00441020, 0x0c000000, 0x00000000, 
	0x15a87500, 0xdf034dc8, 0xf02f4033, 0x28116074, 0x03100dc0, 0x3f00fd00, 
	0xcc03300f, 0xc01400fb, 0x044d03b0, 0x05c05420, 0x06000000, 0x00000000, 
	0x01000700, 0xdf0a7c40, 0xe00dc537, 0x401f007c, 0x22f029c0, 0x3700db20, 
	0x7c03f00d, 0xc08300df, 0x007c0570, 0x0dc00700, 0x0c000000, 0x00000000, 
	0x80082f00, 0xff13cc08, 0xf00fc43f, 0x823700fc, 0x05f00ec0, 0x3c00f300, 
	0xcc03300f, 0xc01c02f3, 0x00cc01f0, 0x07400322, 0x0c000000, 0x00000000, 
	0x81204600, 0x4d014404, 0xd00d4037, 0x00150f74, 0x08d02900, 0x3400d100, 
	0x5503b00d, 0x488400c1, 0x005583d0, 0x05400702, 0x08000000, 0x00000000, 
	0x01a06400, 0x1d105408, 0xd20d4227, 0x00100074, 0x1bd03d40, 0x3000c100, 
	0x0403100d, 0x401600d1, 0x004405d0, 0x07400700, 0x02000000, 0x00000000, 
	0x10204000, 0x4d001400, 0xd00c4033, 0x00040034, 0x00900840, 0x3000c100, 
	0x0403900c, 0x400040d1, 0x001401d8, 0x08404380, 0x00000000, 0x00000000, 
	0x00b02600, 0x5f005d00, 0xf00fc037, 0x8814007c, 0x00f009d0, 0x3c00f300, 
	0xcc03300f, 0xc00400f3, 0x004d00f0, 0x05c003c0, 0x0a000000, 0x00000000, 
	0x05b00f00, 0x7f00ec00, 0xf00fc02f, 0x003f00b4, 0x00f80bc0, 0x3f00ff00, 
	0xfc03f00f, 0xc00f00ff, 0x00fc01f0, 0x03c01760, 0x0e000000, 0x00000000, 
	0x03a8bf01, 0xa300ec80, 0x3006c0bc, 0x00f724cc, 0x20f1cfc2, 0x3f00fb04, 
	0xbc03b00f, 0xc02b01fb, 0x10fc0330, 0xcfc00c00, 0x0e000000, 0x00000000, 
	0x0108bf01, 0x11004400, 0x100540b4, 0x03510a44, 0x10d0cf40, 0x3c0af002, 
	0x7403500d, 0x409708f1, 0x02740350, 0xfd400520, 0x0c000000, 0x00000000, 
	0x11a0b300, 0x91003400, 0x10044832, 0x00c10004, 0x00d00c70, 0x3080c908, 
	0x7401900c, 0x483382c9, 0x00340110, 0x4c404480, 0x0e000000, 0x00000000, 
	0x03a03508, 0x51805420, 0x140d41b2, 0x00510046, 0x1ad00c40, 0x3420d100, 
	0x7403500d, 0x445708d1, 0x40741350, 0x0d400d20, 0x06000000, 0x00000000, 
	0x82a03700, 0x934b3c00, 0x3004d086, 0x08939044, 0x01f00dc0, 0x3000db00, 
	0x7c0bb0bd, 0xc17701db, 0x407e0330, 0x0dc00820, 0x0e000000, 0x00000000, 
	0x07803d40, 0xbf01ec40, 0xf04f800d, 0x006b40fc, 0x00f00fc0, 0x3e20d710, 
	0xfc03f00f, 0xc03b00df, 0x00fc83f0, 0x0ec01f00, 0x06000000, 0x00000000, 
	0x02003900, 0xd3025c00, 0x7001c015, 0x0093026c, 0x0bf00dc0, 0x3702df00, 
	0x4c0e302d, 0xc07440db, 0x004c0334, 0x0dc00820, 0x04000000, 0x00000000, 
	0x13a03c00, 0xc100444e, 0x102d4015, 0x00500044, 0x02d01f41, 0xbc02fd07, 
	0x0406b41d, 0x403440f1, 0x0a040714, 0x0f504c00, 0x02000000, 0x00000000, 
	0x03283240, 0x81131400, 0xd0244731, 0x00cc0804, 0x00921c00, 0xf200cd21, 
	0x0403123c, 0x413000c1, 0x00040710, 0x0c401c00, 0x0a000000, 0x00000000, 
	0x04087a02, 0xe101c404, 0x90174979, 0x00c90184, 0x07d01e4c, 0x7800ed01, 
	0xc507909e, 0x43fc02e1, 0x01846710, 0x9e401000, 0x02000000, 0x00000000, 
	0x12103600, 0x83101c00, 0xf88cc035, 0x02cd040c, 0x00f00ce0, 0x3311cf00, 
	0x0c23380c, 0xc43030c3, 0x080c2030, 0x0dc04840, 0x00000000, 0x00000000, 
	0x02a8bd00, 0xff40bc00, 0x700fc03f, 0x1af700dc, 0x23f00ec0, 0x3d00ff0a, 
	0xfc03f00e, 0xc03f00f4, 0x08bc22f0, 0x0fc10b60, 0x06000000, 0x00000000, 
	0x10a03743, 0xd3007404, 0x700dc027, 0x809f007c, 0x0730cdc0, 0xb700df04, 
	0x7c03f01d, 0xc07200d7, 0x123c0330, 0x0dc05400, 0x0e000000, 0x00000000, 
	0x12993100, 0xe100b400, 0xb00e442b, 0x00ed00b4, 0x03144e41, 0xbb02ed02, 
	0xb403d00e, 0x403800e1, 0x40b40310, 0x5e404920, 0x06000000, 0x00000000, 
	0x04007940, 0xe911b604, 0x501e407b, 0x20ad01b4, 0x0f905e40, 0x7b00ed05, 
	0xb406d01b, 0x6a7a00e5, 0x09b40750, 0x1c400c00, 0x04000000, 0x00000000, 
	0x16203390, 0xc9023403, 0x901c4233, 0x20cd2034, 0x03910c48, 0x3300cd20, 
	0x7406d244, 0x407001c1, 0x00340711, 0x0c404920, 0x0c000000, 0x00000000, 
	0x17a81700, 0x7b02fc4d, 0x7026401f, 0x066f50fc, 0x0db005c4, 0x17004f00, 
	0xf419f007, 0xc55e0057, 0x00bc1d74, 0x05c05c20, 0x06000000, 0x00000000, 
	0x12800500, 0x17007c0c, 0xf091e003, 0x001f8074, 0x00720048, 0x87001f00, 
	0x7c04f021, 0xca07020f, 0x207c04f0, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x10082500, 0x93107c02, 0xf019e025, 0x60930445, 0x42f019c0, 0x64229f20, 
	0x5c023049, 0xc027009f, 0x804c0230, 0x09404020, 0x0c000000, 0x00000000, 
	0x01002608, 0x9105740e, 0xd0a9d027, 0x00910244, 0x02d08940, 0x24099d1b, 
	0x4c025019, 0x40a7089d, 0x416d0250, 0x09500400, 0x08000000, 0x00000000, 
	0x1ca02000, 0xd1017452, 0xd0294225, 0x00910054, 0x02d00940, 0x24209d00, 
	0x54031109, 0x4027009d, 0x04440212, 0x08406100, 0x02000000, 0x00000000, 
	0x14282025, 0x81003402, 0xd0084023, 0x0dd18414, 0x0ad06841, 0x20018d04, 
	0x240a5808, 0x4863118d, 0x05240250, 0xc8504180, 0x00000000, 0x00000000, 
	0x1db08600, 0x13007c00, 0xf0016285, 0x0013101c, 0x08f02144, 0x44041f00, 
	0x5c083005, 0xc007041f, 0x114c0030, 0x21c575c0, 0x0a000000, 0x00000000, 
	0x19a92744, 0xbf00bc02, 0xf00bc82d, 0x04bf80ec, 0x12f009d0, 0x27009f02, 
	0xdc92f00a, 0x402f109e, 0x00dc02f0, 0x19c06660, 0x0e000000, 0x00000000, 
	0x18a02745, 0xb300fc02, 0xb00bc027, 0x01a3103c, 0x0a110b01, 0x2d01bf44, 
	0xfc0ab00b, 0xc02c04bf, 0x00fc0230, 0x69c06000, 0x0e000000, 0x00000000, 
	0x1c1086a1, 0x11807401, 0x10014087, 0x09110274, 0x00306140, 0x05001d02, 
	0x7400b001, 0x4084081f, 0x0a740010, 0x61407020, 0x0c000000, 0x00000000, 
	0x12082104, 0x81003402, 0xd00840a3, 0x04850034, 0x16120861, 0xb1008902, 
	0x34121008, 0x6020808d, 0x20740250, 0x28404080, 0x0e000000, 0x00000000, 
	0x18202100, 0x91047403, 0x50294427, 0x02958074, 0x02100940, 0x2500dd00, 
	0x76028009, 0x6024819d, 0x00740a10, 0x09406020, 0x06000000, 0x00000000, 
	0x05aa2710, 0x91007422, 0xf0994827, 0x0097407c, 0x023809c8, 0x25109b00, 
	0x74be3038, 0xc124089f, 0x003c2674, 0x09d01420, 0x0e000000, 0x00000000, 
	0x12802500, 0x9f007c02, 0xb019c063, 0x4099807c, 0x02740980, 0x26289f10, 
	0x7c02f099, 0xd0270097, 0x007c06f4, 0x08c05300, 0x06000000, 0x00000000, 
	0x10080500, 0x13017c08, 0xf011c007, 0x0817814c, 0x00b381c0, 0x44001f00, 
	0x6c00f001, 0xc007101f, 0x015c0830, 0x01d45020, 0x04000000, 0x00000000, 
	0x14a01448, 0x7103b401, 0xd0274217, 0x00710745, 0x01100460, 0x9c087d00, 
	0x4c01d097, 0x419f147d, 0x526c4154, 0x05405000, 0x02000000, 0x00000000, 
	0x14a03240, 0xc9203403, 0xd01c4433, 0x10c80044, 0x03901c48, 0x3210cd0a, 
	0x4403d82c, 0x405321cd, 0x41150710, 0x0c405000, 0x0a000000, 0x00000000, 
	0x01803040, 0x2182b40b, 0xd02e423f, 0x01f801c4, 0x23100c40, 0x1a00ed01, 
	0xa403d80e, 0x403b00ed, 0x01e40350, 0xce401400, 0x02000000, 0x00000000, 
	0x11007800, 0x2b01bc07, 0xf01e64fb, 0x40eb018c, 0x47b01e40, 0x5a00cf01, 
	0x8c07f01e, 0xc07b20ef, 0x019d0720, 0x9fc05440, 0x00000000, 0x00000000, 
	0x10a8b502, 0x1f007c03, 0xf00dc0b3, 0x05d6207c, 0x1bf02dd0, 0x0500df00, 
	0x5d03f009, 0x803700cf, 0x003c03f0, 0x6dc04360, 0x06000000, 0x00000000, 
	0x0020fd00, 0x3109f427, 0x709ec07c, 0x02eb018c, 0x07303ac0, 0x5d22f301, 
	0xfc07f29e, 0xc07c00ff, 0x01bc0632, 0x1fc00000, 0x0e000000, 0x00000000, 
	0x15183922, 0x2108b483, 0x10864138, 0x8be100bd, 0x03b00ec0, 0x1a00aa04, 
	0xa403d08e, 0xc1aa006d, 0x00b40350, 0x0f405420, 0x06000000, 0x00000000, 
	0x00003940, 0x2140b44a, 0xd08f083c, 0x106100e5, 0x23148e40, 0x18206800, 
	0xb403d007, 0x603a00ed, 0x00b42210, 0x0e500000, 0x04000000, 0x00000000, 
	0x04203100, 0x01093402, 0x90444030, 0x00400234, 0x13100d40, 0x01c00100, 
	0x3403d020, 0x48e2084d, 0x00340b50, 0x0c401020, 0x0c000000, 0x00000000, 
	0x15a83d00, 0xd3007c07, 0xf03d503c, 0x40db1be4, 0x13100d50, 0x3400d900, 
	0x7c23f12d, 0xc08601df, 0x007c0b30, 0x0fc05420, 0x06000000, 0x00000000, 
	0x01003300, 0x1f007c00, 0x7009c437, 0x20df007e, 0x03f00d40, 0x12005fc2, 
	0x6c02f025, 0xc02700df, 0x007c03f8, 0x0dcc0700, 0x0c000000, 0x00000000, 
	0x84083708, 0x3310fc01, 0x7017c03f, 0x00ff00fc, 0x03f15fc0, 0x1420bb21, 
	0xdc03f02f, 0xc10f4473, 0x04cc43f0, 0x0fc40022, 0x0c000000, 0x00000000, 
	0x85203600, 0x1100740c, 0xd0854037, 0x208d0044, 0x03d01d40, 0x05400101, 
	0x4406d031, 0x40420041, 0x014483d0, 0x0d500402, 0x08000000, 0x00000000, 
	0x01a03400, 0x11007423, 0xd80d4037, 0x20dd0454, 0x03d00d40, 0x0481d104, 
	0x5423d029, 0x40270291, 0x304402d0, 0x0c400400, 0x02000000, 0x00000000, 
	0x10283000, 0x01803400, 0x90144033, 0x00cd0006, 0x03d00c40, 0x00000100, 
	0x0402d000, 0x40220001, 0x000403d0, 0x0c404080, 0x00000000, 0x00000000, 
	0x00303e00, 0x12007c00, 0x7005c03f, 0x005f00fc, 0x03f00fc0, 0x04001300, 
	0x5c03f001, 0xc0270053, 0x004c02f0, 0x0fc000c0, 0x0a000000, 0x00000000, 
	0x05a03d00, 0x3f00bc00, 0xd007c03b, 0x007d00fe, 0x03f00fc8, 0x0f003f00, 
	0xfc02f003, 0x002e007f, 0x80fc83f0, 0x0fc01740, 0x0e000000, 0x00000000, 
	0x03a03f00, 0xff00cc00, 0xf003420e, 0x083388cc, 0x03f0cfc0, 0x0c082700, 
	0xec4b309f, 0xd00c40fb, 0x0dcc6330, 0x4fc00f00, 0x0e000000, 0x00000000, 
	0x01083710, 0xdd004400, 0xf0014284, 0x001b24c4, 0x23d06fc0, 0x36001100, 
	0xc41b10bf, 0x400404f1, 0x08c41b10, 0xad420720, 0x0c000000, 0x00000000, 
	0x11a03300, 0x8d001400, 0xd00140b7, 0x08050006, 0x03d08c40, 0x35001580, 
	0x2413984c, 0x540030c1, 0x04050214, 0x0c404780, 0x0e000000, 0x00000000, 
	0x03a83521, 0x9d035490, 0x50014035, 0x00dd1044, 0x03d00d40, 0x37005148, 
	0x4403900c, 0x401400d1, 0x00440312, 0x0d400f20, 0x06000000, 0x00000000, 
	0x00a83708, 0x9f025c04, 0xd011c047, 0x2117424c, 0x03f00dc4, 0xf1001500, 
	0x6c03b40d, 0x000404d3, 0x00450214, 0x0dc40320, 0x0e000000, 0x00000000, 
	0x87803d00, 0xaf00e404, 0xf083c08e, 0x00f8047d, 0x03f00f40, 0xfe403f00, 
	0x7c03700f, 0x801f12ef, 0x007c03f0, 0x0fc01f0a, 0x06000000, 0x00000000, 
	0x02083504, 0x9f404c40, 0xf001c037, 0x0417027c, 0x43300dc0, 0xb7105b00, 
	0x5e03320d, 0xd08400db, 0x404c0330, 0x0dd00820, 0x04000000, 0x00000000, 
	0x13a03400, 0x9d014402, 0xd0880033, 0x10d080f4, 0x0f140f40, 0x37004104, 
	0xc403100f, 0xc01600fb, 0x006c0714, 0x1fc04e00, 0x02000000, 0x00000000, 
	0x07a0a200, 0x4d002484, 0xd0000233, 0x22118034, 0x2b120d00, 0x33000901, 
	0x5403980c, 0x400500c1, 0x00443b10, 0x8c501c00, 0x0a000000, 0x00000000, 
	0x04806804, 0x4d13a404, 0xd0124073, 0x002101b4, 0x07101e40, 0x7b806101, 
	0x8407909c, 0x404f80c9, 0x01a40710, 0x1e401a00, 0x02000000, 0x00000000, 
	0x12103000, 0xcf202c50, 0xf000c033, 0x01c70434, 0x23100c40, 0xb3200b08, 
	0x1403b40c, 0xcc1102c3, 0x000d2230, 0x0cc04840, 0x00000000, 0x00000000, 
	0x02b83d00, 0xff80dc00, 0xf003c03f, 0x40ff00fc, 0x03f02fc0, 0x3b007700, 
	0xfc43700f, 0xc01802ff, 0x0afc0bf0, 0x0ec00b40, 0x06000000, 0x00000000, 
	0x15a83700, 0x53007c00, 0xb001c037, 0x40d30074, 0x13706dc0, 0x33405b00, 
	0x7c03f04d, 0xc01400df, 0x024c0af0, 0x0fc05700, 0x0e000000, 0x00000000, 
	0x12983900, 0x6b40b400, 0x1202003b, 0x00e100b4, 0x4bd04e40, 0x3b40e100, 
	0xa433d00c, 0x413900cd, 0x048403d0, 0x2e404b20, 0x06000000, 0x00000000, 
	0x83007d00, 0xe101b404, 0x90124071, 0x00e101b4, 0x17d0de40, 0xfb006101, 
	0xb417d09e, 0x40d800ed, 0x09840fd0, 0x5e400f02, 0x04000000, 0x00000000, 
	0x12203302, 0xc9013403, 0x101c4033, 0x00c11a34, 0x03d20c44, 0x7321c101, 
	0x2403d00d, 0x003110dd, 0x000483c0, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17a85500, 0x7310bc19, 0xb037c11b, 0x0073037c, 0x01f005c0, 0x9f007306, 
	0x7401d105, 0x409c005d, 0x004d05f1, 0x05c45f20, 0x06000000, 0x00000000, 
	0x12000708, 0x1f827c04, 0xf0114087, 0x301f007c, 0x88f001c0, 0x07001703, 
	0x6880f001, 0xc847081f, 0x807c08f2, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x10086702, 0x93014c26, 0x3009c0e7, 0x3893007c, 0x06f009c0, 0xe7009302, 
	0x7c02f009, 0xc024209f, 0x001c0230, 0x19c04320, 0x0c000000, 0x00000000, 
	0x0120a241, 0x81095402, 0x118941a7, 0x00910074, 0x22d00942, 0x63049501, 
	0x7402d009, 0xc0240097, 0x80443a54, 0x89400700, 0x08000000, 0x00000000, 
	0x18a02400, 0x91904402, 0x100940a7, 0x00910074, 0x02d00940, 0x2700d100, 
	0x7682d009, 0x4024009d, 0x00540210, 0x09406300, 0x02000000, 0x00000000, 
	0x10202000, 0x81005402, 0x14084023, 0x00810034, 0x0ad04840, 0x27808500, 
	0x3442d0c8, 0x5020028d, 0x32041a50, 0x48404380, 0x00000000, 0x00000000, 
	0x1db00600, 0x13944c80, 0x3001c807, 0x40130274, 0x09d031c1, 0x07205380, 
	0x7c1cf231, 0xd184001f, 0x075c0830, 0x01c077c0, 0x0a000000, 0x00000000, 
	0x19b82b00, 0xbf80bc02, 0xf00bc02f, 0x0abf347c, 0x22f059c1, 0x2f08bd00, 
	0x7c56f019, 0xc06d0097, 0x00fc0af0, 0x29c26760, 0x0e000000, 0x00000000, 
	0x18a02f00, 0xb314cc02, 0xb00be02f, 0x249100cc, 0x42f80bc1, 0x2808bf00, 
	0x7c5230c9, 0xc024909f, 0x009e2230, 0x4b426400, 0x0e000000, 0x00000000, 
	0x9c080710, 0x11024500, 0xd2014087, 0x005ba044, 0x08d921c8, 0x06001100, 
	0x5c1011c1, 0x4005041d, 0x15442010, 0x01507022, 0x0c000000, 0x00000000, 
	0x10a02340, 0x81400402, 0xd8084827, 0x10851404, 0x52d04845, 0x30008900, 
	0x34521848, 0x5020018d, 0x28040214, 0x88404080, 0x0e000000, 0x00000000, 
	0x18a86540, 0x91004642, 0xd0196827, 0x088d8044, 0x03d20940, 0x26009100, 
	0x14021109, 0x4065009d, 0x00442210, 0x09406020, 0x06000000, 0x00000000, 
	0x05286500, 0x93074d26, 0xb1294123, 0x0197094d, 0x02d009c2, 0xe0049f00, 
	0x74021409, 0x1024809d, 0x00450230, 0x08c01420, 0x0e000000, 0x00000000, 
	0x14002500, 0x9f097c06, 0xf009c027, 0x069b007c, 0x02f009c0, 0x67019f02, 
	0x5c02f008, 0xc227808f, 0x007c02f0, 0x09c05300, 0x06000000, 0x00000000, 
	0x14084500, 0x1f097c04, 0xf001c087, 0x201f007c, 0x103200c0, 0x07001b21, 
	0x7800b001, 0xc004001d, 0x203c8070, 0x11c05320, 0x04000000, 0x00000000, 
	0x1420d804, 0x6d22f41d, 0xd007409f, 0x105d00f4, 0x01501540, 0x9f007503, 
	0x74013005, 0x4014005d, 0x00f42510, 0x37415300, 0x02000000, 0x00000000, 
	0x14a03200, 0x8d213403, 0xd08c40b3, 0x00cd0034, 0x03908840, 0x3301c981, 
	0x3603110c, 0x603100c5, 0x00300750, 0x08605300, 0x0a000000, 0x00000000, 
	0x04803800, 0xed00b400, 0xd00e40bb, 0x00ed28b4, 0x47500a60, 0x3e40e502, 
	0xb613100e, 0x403900ed, 0x00b40b10, 0x0e481700, 0x02000000, 0x00000000, 
	0x14106800, 0xef01bc06, 0xf012c07b, 0x20ed31fc, 0x06b01ac2, 0x7b106b01, 
	0x3c07347f, 0xd0f908ef, 0x21bc0670, 0x1ac05740, 0x00000000, 0x00000000, 
	0x10b83520, 0xdf007c00, 0xf001c027, 0x00df067c, 0x02f00bc4, 0x37601e00, 
	0x7c0be06d, 0xc1360ddf, 0x007c02f0, 0x0dc04360, 0x06000000, 0x00000000, 
	0x02a07f00, 0xff29fc04, 0xf09e407c, 0x02ef09cc, 0x07311fc0, 0x78027f89, 
	0xfc4ff21f, 0xc07c00ff, 0x01cc0734, 0x13c40b00, 0x0e000000, 0x00000000, 
	0x15883900, 0xed02b400, 0xd00e4018, 0x00ed08ac, 0x22108e40, 0x39036b00, 
	0xb403d00e, 0x403912ed, 0x08d421b0, 0x86405720, 0x06000000, 0x00000000, 
	0x00001900, 0xed00b460, 0xd0026038, 0x10fd4014, 0x00100e40, 0xb8206510, 
	0xb403d00e, 0x403800ed, 0x00840210, 0x02402300, 0x04000000, 0x00000000, 
	0x06283300, 0xcd00344c, 0xd0204000, 0x00cd2134, 0x00100c44, 0x31000900, 
	0x3403d20c, 0x40b100cd, 0x00140490, 0x00405b20, 0x0c000000, 0x00000000, 
	0x15a83500, 0xdd007c04, 0xf03dd034, 0x20ff0c5c, 0x023009c0, 0x7000550a, 
	0xfc03f00f, 0x807c02fc, 0x004c0220, 0x01407720, 0x06000000, 0x00000000, 
	0x01003708, 0xdf407c00, 0xf035c037, 0x00df0068, 0x08f009c2, 0x37025f02, 
	0x7803f00c, 0xc03702cf, 0x003ca3f0, 0x01c00700, 0x0c000000, 0x00000000, 
	0x8008ff00, 0xf308fc04, 0xf093c11f, 0x01f340cc, 0x02f049c0, 0x3f007304, 
	0xfc03f20f, 0x403c00d3, 0x00cc0430, 0x32c00020, 0x0c000000, 0x00000000, 
	0x81203214, 0xd5006404, 0xd0314283, 0x00c50044, 0x0cd00944, 0x77401505, 
	0x7403d00d, 0xd83600d1, 0x00440816, 0x11400402, 0x08000000, 0x00000000, 
	0x01a03600, 0xd1007420, 0xd20943a7, 0x00d10044, 0x06d00940, 0x37021140, 
	0x7403d00d, 0x403100d1, 0x00442b10, 0x01410000, 0x02000000, 0x00000000, 
	0x10003000, 0xc5003404, 0xd0004003, 0x00d50004, 0x00d00840, 0x77c00500, 
	0x3403d00c, 0x403300c1, 0x00040000, 0x04404088, 0x00000000, 0x00000000, 
	0x00103690, 0x53207c00, 0xf001c007, 0x00f30044, 0x00f009c0, 0x07081300, 
	0xfc03f00e, 0xc03d88d3, 0x004d0030, 0x01e004c0, 0x0a000000, 0x00000000, 
	0x05b83f00, 0xff00ec00, 0xf003c80f, 0x20ff00fc, 0x00f00bc0, 0x0f403d00, 
	0xfc03e10f, 0xc03e00ff, 0x00fc00f0, 0x03c01360, 0x0e000000, 0x00000000, 
	0x03802f00, 0x3f00bc13, 0x7007800e, 0x012300cc, 0x033003c4, 0x3c01b300, 
	0xf400f00b, 0xc01c026f, 0x00bc01f0, 0x4fc00f00, 0x0e000000, 0x00000000, 
	0x01082720, 0x1700fc03, 0xb04540a4, 0x009b0044, 0x2b100140, 0xbc02d160, 
	0x7401d00d, 0x4014205d, 0x207401d0, 0xaf470720, 0x0c000000, 0x00000000, 
	0x11a22308, 0x0d803623, 0x50044112, 0x02050004, 0x03100040, 0x3020c180, 
	0x34024049, 0x6500014d, 0x80340150, 0x4c404780, 0x0e000000, 0x00000000, 
	0x03a87500, 0x95005603, 0x10054034, 0x009d2a45, 0x03101140, 0x3400d100, 
	0x7422d009, 0x703401dd, 0x027409d0, 0x0d400f20, 0x02000000, 0x00000000, 
	0x00a82700, 0x1f027483, 0x5115c096, 0x4087004c, 0x833811d0, 0x3400d300, 
	0x7c15f118, 0xc094195f, 0x0a7c01f1, 0x0dc00b20, 0x0a000000, 0x00000000, 
	0x87802d00, 0xbf02bc43, 0xf05fc03b, 0x00fb01bc, 0x43f30ac0, 0x3f08ff15, 
	0xfc05f24f, 0xc03f807e, 0x00fc0ff0, 0x0fc01f00, 0x06000000, 0x00000000, 
	0x02083500, 0x17227c03, 0x3009c095, 0x00d3124e, 0x233249d0, 0x31009300, 
	0x7c043409, 0xc19600d3, 0x025c0230, 0x0dc00b20, 0x04000000, 0x00000000, 
	0x13a03402, 0x9d87f40f, 0x100d4034, 0x00d406fe, 0x0f102944, 0x7c00d144, 
	0x742e1229, 0xc03500d1, 0x07444714, 0x0f404f00, 0x02000000, 0x00000000, 
	0x07a0e202, 0x0d00340f, 0x10056020, 0x02098314, 0x0f100040, 0x7048c102, 
	0x34021008, 0x40132008, 0x21140510, 0x0c441f00, 0x0a000000, 0x00000000, 
	0x06806800, 0x2d03b447, 0x101e446c, 0x016d01b4, 0x07901a40, 0x7804a001, 
	0xb407109e, 0x405910e9, 0x03c42714, 0x1e401300, 0x02000000, 0x00000000, 
	0x1210309a, 0xc7003c83, 0x302dc0b1, 0x004b0014, 0x033049c0, 0x3102c308, 
	0x7c22318c, 0xc836414b, 0x281e0330, 0x0cc04b40, 0x00000000, 0x00000000, 
	0x02b83d88, 0xff40fc2b, 0xf08fe83b, 0x09f700ac, 0x03740bc4, 0x3b02ff00, 
	0xfc03f28f, 0xc03e00b7, 0x00f403d0, 0x0fc40b60, 0x06000000, 0x00000000, 
	0x15a02700, 0x9f007813, 0xf004c030, 0x0013007c, 0x037001c0, 0x3700df00, 
	0x7801f009, 0xc0350893, 0x803c8130, 0x4dc15700, 0x0e000000, 0x00000000, 
	0x12882900, 0xa740b403, 0xd00e4038, 0x006b0084, 0x0b100e40, 0xbb05ec00, 
	0xb403d00e, 0x403da0e1, 0x00b40350, 0x2e404b20, 0x06000000, 0x00000000, 
	0x83007800, 0xed21b627, 0xd01f407e, 0x00e11105, 0x17501a40, 0x7b01ec03, 
	0xb405d01e, 0x446a00e5, 0x01b40710, 0x1e400f08, 0x04000000, 0x00000000, 
	0x12283300, 0xc5003483, 0xd00c4272, 0x00c90204, 0x03100c40, 0x33008d21, 
	0x340fd20c, 0x40730085, 0x00340351, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17a81500, 0x7f027801, 0xf027d15a, 0x04630b5c, 0x017057c8, 0x17105f00, 
	0xfc21f005, 0xc0db4c77, 0x02b44930, 0x05405f20, 0x06000000, 0x00000000, 
	0x12000700, 0x17013c00, 0xf011c805, 0x001f005c, 0x007831c0, 0x07001f00, 
	0x7c20f001, 0xcc45001b, 0x017c0cf0, 0x00c04b00, 0x0c000000, 0x00000000, 
	0x1008a700, 0x97007c16, 0x3a09d027, 0x0197052c, 0x02b009c6, 0x67109a03, 
	0x7402f009, 0xc8240093, 0x027c1600, 0x09c04020, 0x0c000000, 0x00000000, 
	0x0120e200, 0x91427416, 0x12085824, 0x00910144, 0x6e102945, 0x67009b00, 
	0x7402d009, 0x48240891, 0x00749eb0, 0x09400400, 0x08000000, 0x00000000, 
	0x18a02400, 0xdd0a7402, 0x50096027, 0x08950066, 0x029a8d48, 0x27a29980, 
	0x7602d008, 0x40240891, 0x80740210, 0x09406000, 0x02000000, 0x00000000, 
	0x10206008, 0x81003402, 0x54096020, 0x00918006, 0x02100841, 0x2304c100, 
	0x3403d008, 0x08240081, 0x01340294, 0xc8404080, 0x00000000, 0x00000000, 
	0x1db00600, 0x17007c00, 0x5081d007, 0x20170068, 0x00b161c0, 0x47011902, 
	0x7c08f221, 0x90844013, 0xa07e0030, 0x31d174c0, 0x0a000000, 0x00000000, 
	0x19b82f00, 0xbf807c22, 0xb00bc82f, 0x02af007c, 0x22f14bc9, 0x2700be14, 
	0xfc52f00a, 0x812f05bf, 0x00fe82f0, 0x19c06760, 0x0e000000, 0x00000000, 
	0x19a03f88, 0xaf00fc42, 0x7089c02f, 0x01af808c, 0x02f06b00, 0x2f00bf02, 
	0xcc0af02a, 0xc02300bf, 0x00fc0231, 0x49c06080, 0x0e000000, 0x00000000, 
	0x9c080708, 0x1d807408, 0x10014207, 0x081d0054, 0x00d06140, 0x07081d24, 
	0x5400d041, 0x4017001d, 0x00740010, 0x60517020, 0x0c000000, 0x00000000, 
	0x10a02380, 0x8d803402, 0x514848a1, 0xa0850004, 0x0ad03862, 0xa3009d00, 
	0x1412d008, 0x4023058d, 0x00340214, 0x68404000, 0x0c000000, 0x00000000, 
	0x18a82520, 0x9d007602, 0x10094127, 0x809d2054, 0x03d00942, 0x2700dd00, 
	0x5402d009, 0x4027209d, 0x24740210, 0x09406020, 0x06000000, 0x00000000, 
	0x05a82702, 0x9d937c02, 0x7019c027, 0x089f104c, 0x02f009c0, 0x27008f01, 
	0x5c36f009, 0xc0e70a9f, 0x077c4230, 0x09c01420, 0x0e000000, 0x00000000, 
	0x14806520, 0x9f097c42, 0xf0598067, 0x119f087c, 0x02f109c0, 0x27089f19, 
	0x6d02f029, 0xc027089f, 0x007c16f0, 0x08c05300, 0x06000000, 0x00000000, 
	0x14084500, 0x1f831c00, 0xf001c007, 0x001f124c, 0x003001c1, 0x07221f20, 
	0x4c08f041, 0xc0041011, 0x097c0034, 0x01d05020, 0x04000000, 0x00000000, 
	0x14a09c09, 0x7d07c405, 0xd0054017, 0x046140c4, 0x01b82740, 0x17007c02, 
	0xc405f037, 0x4014087a, 0x03b44110, 0x05405000, 0x02000000, 0x00000000, 
	0x14a03200, 0x4d01340f, 0x900c6862, 0x00c50b04, 0x1390ac40, 0x2300cd02, 
	0x021fd03c, 0x403000cd, 0x01341710, 0x0c405000, 0x0a000000, 0x00000000, 
	0x05803800, 0x6d01a4c3, 0xd14e607b, 0x00e14094, 0x0e100e60, 0x3b20ac00, 
	0x85425237, 0x407c016d, 0x00f40310, 0xce001400, 0x02000000, 0x00000000, 
	0x15105890, 0x6d01bc07, 0xb03ee473, 0x00e5018c, 0x07901ac0, 0x7b20bf81, 
	0x8c87d01e, 0xc8784067, 0xa1bc0530, 0xde805440, 0x00000000, 0x00000000, 
	0x10b81520, 0x5f005c03, 0xf00de037, 0x0097406d, 0x02fc09c0, 0x37109f00, 
	0x7c02f005, 0xd037401b, 0x003c81f0, 0x0dc04360, 0x06000000, 0x00000000, 
	0x02a05f00, 0x7f05fc07, 0x301fc47f, 0x00f301ec, 0x17d09bc0, 0x7f00ff05, 
	0xf426b43b, 0xc07f047f, 0x41fc07f0, 0x1fc80000, 0x0e000000, 0x00000000, 
	0x15881902, 0x6d00b400, 0x118e403b, 0x10652084, 0x03700200, 0x3b20ad00, 
	0x9ce8100a, 0x403b006f, 0x00a403d0, 0x0f405420, 0x06000000, 0x00000000, 
	0x00000900, 0x2d04b423, 0x100e4023, 0x00f502a4, 0x91d00a40, 0x2b002d14, 
	0xf402100a, 0x403b006d, 0x08b403d0, 0x0e400200, 0x04000000, 0x00000000, 
	0x06285300, 0x0d023000, 0x10ac60b3, 0x00050004, 0x01d0a000, 0x33000d01, 
	0x14081199, 0x40730c0d, 0x85241bd0, 0x0c401220, 0x0c000000, 0x00000000, 
	0x15a83404, 0xdd083403, 0x14af4037, 0x00d54068, 0x01fab984, 0x37009f40, 
	0x74063019, 0xc03f815f, 0x42780ff1, 0x0fc05620, 0x06000000, 0x00000000, 
	0x01001700, 0x1f807c0b, 0xf00dc027, 0x00dd017c, 0x0a7809c2, 0x27201f02, 
	0x7c027001, 0xc0379057, 0x0a6c06d0, 0x0dc80500, 0x0c000000, 0x00000000, 
	0x80085f00, 0x77007c24, 0x700fc23f, 0x04f300cc, 0x04f003e2, 0x3b00b300, 
	0xfc40f00b, 0xc03c807f, 0x81cd01f0, 0x0fc20322, 0x0c000000, 0x00000000, 
	0x81211600, 0x1d90640c, 0x500d4073, 0x10851044, 0x0ad03140, 0x37021101, 
	0x740cd001, 0x4834800d, 0x077901d0, 0x0d400702, 0x08000000, 0x00000000, 
	0x00a01411, 0x5d017443, 0x500d6037, 0x01910444, 0x11503940, 0x370095c1, 
	0x7606d849, 0x40340015, 0x044007d0, 0x0d6c0700, 0x02000000, 0x00000000, 
	0x10204000, 0x0d002400, 0x100c4037, 0x00840004, 0x03d00040, 0x33080100, 
	0x3600d808, 0x4030001d, 0x003503d0, 0x0c604380, 0x00000000, 0x00000000, 
	0x01b00600, 0x1f007c00, 0x780dc837, 0x8093004d, 0x00f00148, 0x37101340, 
	0x7e00f00b, 0xc034201f, 0x004d03f0, 0x0fc003c0, 0x0a000000, 0x00000000, 
	0x04b80f00, 0x3f00ec00, 0xf00fc02f, 0x10af00fc, 0x00f103c0, 0x2f103f40, 
	0xbc00e00b, 0xc03f003f, 0x40fc02f0, 0x0fc01760, 0x0e000000, 0x00000000, 
	0x42a81f20, 0x3f20dc00, 0xb003d00c, 0x003d20cc, 0x001103c0, 0x0e30fb08, 
	0xcc02f003, 0x000f002f, 0x40bc0030, 0x03c00b00, 0x0e000000, 0x00000000, 
	0x03081608, 0x5d004500, 0x10014004, 0x000d8050, 0x00100040, 0x0400f106, 
	0x4403d00d, 0x440700d9, 0x20740010, 0x01400f20, 0x0c000000, 0x00000000, 
	0x11a01100, 0x9d201501, 0x12084400, 0x00858000, 0x80110840, 0x0200c906, 
	0x1403d00c, 0x400300cd, 0x00740010, 0x00404588, 0x0e000000, 0x00000000, 
	0x02281500, 0xdd000101, 0x11084004, 0x028c0014, 0x00108940, 0x9400c000, 
	0x5402d00d, 0x401700dd, 0x18742214, 0x01400b20, 0x02000000, 0x00000000, 
	0x82a89720, 0x0f005d08, 0x3001c864, 0x0057004c, 0x033411c0, 0xc200db00, 
	0x5d03f00d, 0x400710df, 0x037c0032, 0xd1c40f22, 0x0a000000, 0x00000000, 
	0x07801d00, 0x7f00fd00, 0xf483442f, 0x087f00fc, 0x03e013c0, 0x4f02ff80, 
	0xec0bf09b, 0xc02e08fb, 0x10fc03f0, 0x03c81f00, 0x06000000, 0x00000000, 
	0x2a08d540, 0x93005c0d, 0x3419c827, 0x41db114c, 0x173059d0, 0x9402df00, 
	0x7c03b025, 0xc0372117, 0x015c2170, 0x09c08b20, 0x04000000, 0x00000000, 
	0x13a0d400, 0xd100442d, 0x10b94227, 0x00d12344, 0x071019c0, 0x5608fd00, 
	0x7403d05d, 0x40f708d1, 0x02040310, 0x19446f00, 0x02000000, 0x00000000, 
	0x03203210, 0x0100140a, 0x10244092, 0x00050204, 0x00100542, 0x4001c900, 
	0x3403d11c, 0x410310cd, 0x00140450, 0x10401f00, 0x0a000000, 0x00000000, 
	0x0d00fa08, 0x61099436, 0x1016405b, 0x04250184, 0x24121600, 0x5a20ed01, 
	0xb40fd016, 0x404f0029, 0x01840512, 0x16403700, 0x02000000, 0x00000000, 
	0x1210b600, 0x9300541b, 0x388cc013, 0x0087004d, 0x00340c80, 0x0000cb00, 
	0x3c03f828, 0xc00394cf, 0xe01ca370, 0x84c14b42, 0x00000000, 0x00000000, 
	0x02b83d00, 0xff20ec13, 0xe00fc01b, 0x00b300fc, 0x00f00fc4, 0x1d82fd00, 
	0xf823f18f, 0xc01b20f7, 0x00f483d0, 0x07c20b60, 0x06000000, 0x00000000, 
	0x10203500, 0x0f804c02, 0xb405c037, 0xa05f414c, 0x033015c8, 0x1400df00, 
	0x7402d01d, 0xc00400cf, 0x004c02d0, 0x09c05700, 0x0e000000, 0x00000000, 
	0x13193900, 0x6d80a802, 0x1006483b, 0x007d0090, 0x03510740, 0x1910ed08, 
	0xb403d00f, 0x422900ed, 0x809403d0, 0x0e404f24, 0x06000000, 0x00000000, 
	0x14007800, 0xbd01c487, 0x581e407b, 0x00ed8184, 0x87101e40, 0x7a00ed0d, 
	0xb407d03e, 0x407884fd, 0x01a407d0, 0x1e480700, 0x04000000, 0x00000000, 
	0x06003100, 0xdd402503, 0x100d40b3, 0x00cd0954, 0xab500c40, 0x3300cd40, 
	0x3402d000, 0x4131000d, 0x82340bd0, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17a81700, 0x5f000c01, 0xb405c217, 0x005d0044, 0x853005c0, 0x9e015f00, 
	0x7c11d037, 0xc0dc007e, 0x04ec05f0, 0x27c05f20, 0x06000000, 0x00000000, 
	0x12808500, 0x1f007c00, 0xf001c087, 0x211f807c, 0xc0f201c0, 0x45001f40, 
	0x7c00f001, 0xc0c7001f, 0x045c60f0, 0x31c04b00, 0x0c000000, 0x00000000, 
	0x10082580, 0x9f006c02, 0x3029c024, 0x009f0074, 0x0a3019c0, 0xa7009f00, 
	0x7c06b309, 0xc427009f, 0x004c02f0, 0x09c00120, 0x0c000000, 0x00000000, 
	0x0120a610, 0x9d434c0a, 0x402940a0, 0x00952274, 0x0ea0b940, 0x67009d00, 
	0x34021029, 0x40e7008d, 0x01440ed0, 0x48402400, 0x08000000, 0x00000000, 
	0x1ca0a400, 0xbd01f402, 0x400b60ac, 0x02b100f4, 0x02130b68, 0x27209d00, 
	0x742a9009, 0x40272195, 0x04460fd0, 0x09406100, 0x02000000, 0x00000000, 
	0x14282002, 0xad09c426, 0x509a5028, 0x80a549b0, 0x26929a40, 0x23008d50, 
	0x74021018, 0x4033009d, 0x400502d1, 0x08604080, 0x00000000, 0x00000000, 
	0x1fb08600, 0x1d827c08, 0x7421c004, 0x00130238, 0x083023c0, 0x07001f47, 
	0x7c20b081, 0xc0070017, 0x004c00f0, 0x01c075c0, 0x0a000000, 0x00000000, 
	0x19a12709, 0x9f441c12, 0xd0494027, 0x009f047c, 0x92f049c4, 0x2f009f55, 
	0xfc02d00b, 0xc02f00bf, 0x00fc02f0, 0x0bc86f64, 0x0e000000, 0x00000000, 
	0x18a82f00, 0xbf02dc0a, 0xf00bc02f, 0x00bb00ee, 0x02f00bc0, 0x2c809f02, 
	0xcc02f00b, 0xe02f00ba, 0x00fc02d1, 0x0bc06300, 0x0e000000, 0x00000000, 
	0x1c080705, 0x1d044010, 0xd2414007, 0x00558476, 0x10d14540, 0x05a01d00, 
	0x4410d041, 0x40170059, 0x007400d0, 0x05447b00, 0x0c000000, 0x00000000, 
	0x120021a0, 0x8d051412, 0x50084127, 0x00811024, 0x42d00841, 0x20808982, 
	0x0442d108, 0x0b23008d, 0x003402d0, 0x08424ba8, 0x0e000000, 0x00000000, 
	0x19202500, 0x8d004482, 0xd0294027, 0x00958074, 0x02d80840, 0x25009c00, 
	0x4412d009, 0x4077809d, 0x007442d8, 0x09606320, 0x06000000, 0x00000000, 
	0x05a02700, 0x9f005c06, 0xf009c023, 0x00900264, 0x02f929c0, 0xa4019900, 
	0x4d02f019, 0x09e7209f, 0x037c0ef9, 0x39801720, 0x0e000000, 0x00000000, 
	0x12802500, 0x9f007c12, 0xf009c027, 0x0097007c, 0x02f809c0, 0x67028d00, 
	0x7c02f049, 0xc027009b, 0x297c12f8, 0x39c05b00, 0x06000000, 0x00000000, 
	0x10000500, 0x1b084c00, 0xf081c107, 0x001f024d, 0x00f021d0, 0xc4001720, 
	0x7c40f1a1, 0xc0851c1f, 0x837c04f2, 0xb1c05120, 0x00000000, 0x00000000, 
	0x14a09c52, 0x710ac505, 0xd027405f, 0x017d30c4, 0x09d00748, 0x9c005100, 
	0xf445d087, 0xc01d107d, 0x02f49dd8, 0x27485000, 0x02000000, 0x00000000, 
	0x1428b340, 0xc9c01407, 0xd01c60b3, 0x04cd0104, 0x1bd00c40, 0x7002cd00, 
	0x3403d03c, 0x60b300cd, 0x00340758, 0x0c405300, 0x0a000000, 0x00000000, 
	0x01086e50, 0xf9008442, 0xd00a603b, 0x00ad0184, 0x02d00a40, 0x5c80e504, 
	0xb483d00e, 0x44bb08ad, 0x00b403d9, 0x1f441700, 0x02000000, 0x00000000, 
	0x11117a00, 0xeb018c05, 0xf016c27b, 0x007e0184, 0x85f017c0, 0x7800ef01, 
	0xbc27f01e, 0xc07b00ef, 0x01bc06f0, 0x1ec05704, 0x00000000, 0x00000000, 
	0x10a00140, 0xc7007800, 0xf801c017, 0x001f007c, 0x00f001c0, 0x0300d316, 
	0xf003f00d, 0xc025009f, 0x007c02f0, 0x0cc24020, 0x06000000, 0x00000000, 
	0x00215d08, 0x2f81cc07, 0xf01fc07c, 0x00f301fc, 0x07f01fc0, 0x5c00fd19, 
	0xcc27301f, 0x407f027d, 0x09f805f0, 0x13c00304, 0x0e000000, 0x00000000, 
	0x15180900, 0x2700a802, 0xf08a4239, 0x00ab08b4, 0x22d00b40, 0x1904ed00, 
	0xc463500e, 0x401b022d, 0x20bc40d0, 0x02405720, 0x06000000, 0x00000000, 
	0x00001900, 0x3d00a421, 0xd007402c, 0x006500b4, 0x01d00640, 0x1802cd80, 
	0x8423100e, 0x403b086d, 0x00b400d0, 0x02410300, 0x04000000, 0x00000000, 
	0x04200108, 0x15002400, 0x510c4001, 0x000c2034, 0x02d00040, 0x0110dd20, 
	0x0403500c, 0x4083020d, 0x05141cd0, 0x10401320, 0x0c000000, 0x00000000, 
	0x15a83708, 0xdf006c03, 0xd00cd030, 0x00d70078, 0x03f00dc0, 0x1400ff00, 
	0x4d03328c, 0xc1f700df, 0x107407d0, 0x1dc05720, 0x06000000, 0x00000000, 
	0x01803500, 0xdf417c02, 0xf009c827, 0x0098807c, 0x02f029c0, 0x1700df00, 
	0x7c03f02d, 0xc0b7011f, 0x027c0bf0, 0x29c00700, 0x0c000000, 0x00000000, 
	0x84083d00, 0xf301dc05, 0xf007c03c, 0x007304fc, 0x01f017c0, 0x5f00ff00, 
	0xcc03320f, 0xc4dc00bb, 0x04fc00f0, 0x17c00322, 0x0c000000, 0x00000000, 
	0x85001200, 0xd1014406, 0xd101d087, 0x009b0774, 0x85d00d48, 0x4604dd00, 
	0x4447503d, 0x40000011, 0x017408d0, 0x21420700, 0x08000000, 0x00000000, 
	0x0180140a, 0x1106561b, 0xd20d4014, 0x05d50074, 0x13d06d40, 0x0702dd00, 
	0x0407003d, 0x40240059, 0x027441d0, 0x61400700, 0x02000000, 0x00000000, 
	0x102010c0, 0x01000603, 0xd0095207, 0x00c90034, 0x02900840, 0x0200cd40, 
	0x04035009, 0x50000001, 0x002400d0, 0x00604380, 0x00000000, 0x00000000, 
	0x00b01600, 0xd3005c01, 0xf005d004, 0x0057007c, 0x01f005c0, 0x0710ff00, 
	0xcd02300d, 0xc004001b, 0x007c00f0, 0x01c003c0, 0x0a000000, 0x00000000, 
	0x85b81f00, 0xfe40fc03, 0xf10ec00b, 0x20ff00fc, 0x03f00fc0, 0x0e00ff40, 
	0xfc00f003, 0xc00f003f, 0x00fc00f0, 0x03c01760, 0x0e000000, 0x00000000, 
	0x03a00f02, 0xff08bc00, 0xb00fc10c, 0x10ff04dc, 0x20706fc4, 0x08003b08, 
	0xac20710f, 0xc20d18eb, 0x00f42330, 0x4fc00e00, 0x0e000000, 0x00000000, 
	0x01083700, 0xdd087402, 0x102f5004, 0x04e11c44, 0x0a108e40, 0x04001004, 
	0x4410d00d, 0x400700d1, 0x0a748b50, 0xad400420, 0x0c000000, 0x00000000, 
	0x11000320, 0xcd007600, 0x924c6104, 0x01c50014, 0x19504c40, 0x04201900, 
	0x3600d004, 0x600720c9, 0x00342310, 0x0c424680, 0x0e000000, 0x00000000, 
	0x03a83da1, 0xdd007402, 0x100c4034, 0x00c12044, 0x83020d40, 0x1420d004, 
	0x540bd069, 0x443724d1, 0x00740352, 0x0d400c20, 0x06000000, 0x00000000, 
	0x06a84708, 0xdf803c02, 0xb00dc0c0, 0x01d7005e, 0x10700dc0, 0xc0060b02, 
	0x7c887019, 0xc0c100db, 0x007c0330, 0x0dc00a20, 0x0e000000, 0x00000000, 
	0x07825d08, 0xff00fc0b, 0xf00dc04e, 0x12f700fc, 0x12f00fc0, 0x7f00ff21, 
	0xec20f21b, 0xc05f02ff, 0x007c03f0, 0x0ec01f00, 0x06000000, 0x00000000, 
	0x02080500, 0xd3004c03, 0x704dd0b5, 0x28db000c, 0x01700dc0, 0xa4001702, 
	0x7c833039, 0xc02740d3, 0x904c0334, 0x1dc40920, 0x04000000, 0x00000000, 
	0x13a01400, 0xf0804437, 0x102f4034, 0x30f14044, 0x03120f48, 0x7401db00, 
	0x4403051d, 0xc43602f1, 0x92ec0310, 0x0f604f00, 0x02000000, 0x00000000, 
	0x03a00220, 0xc9402400, 0x500c4002, 0x00cd0004, 0x00500d40, 0x01000100, 
	0x1000100c, 0x000100c1, 0x03440312, 0x0c401c00, 0x0a000000, 0x00000000, 
	0x00826800, 0xe901a407, 0x181e407e, 0x00e10184, 0x05501e40, 0x69803901, 
	0xd407101b, 0x406a00e1, 0x01a40711, 0x1e481300, 0x02000000, 0x00000000, 
	0x16100410, 0xdb002c01, 0x500cd003, 0x00cb0044, 0x00700c40, 0x3103c302, 
	0x1c20308c, 0xd01502c2, 0x000c6330, 0x0cc04940, 0x00000000, 0x00000000, 
	0x02b02d00, 0xf700dc03, 0xf0afc039, 0x82ff10fc, 0x01b10fd0, 0x3e2aeb08, 
	0xcc23f20a, 0xc03f02ff, 0x10fc83f0, 0x8fc00b60, 0x06000000, 0x00000000, 
	0x15a80700, 0xdf007c02, 0x706dc076, 0x30df0470, 0x02d05dc0, 0x1420df20, 
	0x7c03f009, 0xc03700df, 0x207c23e1, 0x0d805720, 0x0e000000, 0x00000000, 
	0x12880900, 0xed84b403, 0xd06e403c, 0x80e14cb4, 0x03d14e41, 0x3820ed00, 
	0xb403d00e, 0x403b00ed, 0xa0b413d0, 0x3e404b20, 0x06000000, 0x00000000, 
	0x03004900, 0xed09b407, 0xd01e407a, 0x00e905b4, 0x06d19c40, 0x7b00ed41, 
	0xb447d01a, 0x48fb80ed, 0x05b417d0, 0x5e400f00, 0x04000000, 0x00000000, 
	0x12200700, 0xdd00341f, 0xd20c4030, 0x11c14034, 0x0bd00c40, 0xf101dd25, 
	0x3407d22c, 0x41b308cd, 0x203483d0, 0x0c404b00, 0x0c000000, 0x00000000, 
	0x17a01d02, 0x5f00f411, 0xf004c09e, 0x045e00fc, 0x01f005c0, 0x5f117f47, 
	0xfc09f057, 0xc05b005f, 0x007c01f0, 0x05c05f00, 0x06000000, 0x00000000, 
	0x12000600, 0x1f007c08, 0xf001c007, 0x001f007c, 0x10f00150, 0x06201f00, 
	0x7c40f021, 0xe807001f, 0x007c00f0, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x10002700, 0x93004c06, 0xf009c824, 0x008f006c, 0x02700940, 0x27209f80, 
	0x4c023009, 0xc0670497, 0x043c0230, 0x39c84300, 0x0c000000, 0x00000000, 
	0x01202620, 0x9100440e, 0xd0195824, 0x009d0044, 0x02100942, 0xa7009d00, 
	0x44821009, 0x40670091, 0x83748a10, 0x19400700, 0x08000000, 0x00000000, 
	0x18a82400, 0x91205512, 0x90894024, 0x109d4024, 0x02500940, 0xe7009d00, 
	0x04021019, 0x40270a95, 0x02746210, 0x09426320, 0x02000000, 0x00000000, 
	0x10202002, 0x81141402, 0xd0484120, 0x008d9404, 0x32104842, 0x23188d02, 
	0x0402140c, 0x48370081, 0x04341a10, 0x08414380, 0x00000000, 0x00000000, 
	0x1db08600, 0x13085c01, 0xf020c084, 0x301f426c, 0x487081c0, 0x07001f02, 
	0x4d203001, 0xc0870017, 0x007c0834, 0x41c077c0, 0x0a000000, 0x00000000, 
	0x19b8af40, 0x9f00ec82, 0xf209c12f, 0x059f10fc, 0x02f029c0, 0x2f08bf40, 
	0xfc06f00b, 0xc02f059f, 0x027c0af1, 0x09c86760, 0x0e000000, 0x00000000, 
	0x18a02500, 0x9300c982, 0xf18bc124, 0x0097105c, 0x1ae049c0, 0x2f009f00, 
	0x4c0a300b, 0xc02f00bf, 0x24fc1af0, 0x4bc06000, 0x0e000000, 0x00000000, 
	0x1c080705, 0x11044400, 0x10215000, 0x00110044, 0xa8d06144, 0x07001d14, 
	0x45001101, 0x4017001d, 0x4a7438d0, 0x21407020, 0x0c000000, 0x00000000, 
	0x10222340, 0x81120402, 0x90486020, 0x85815014, 0x92d08841, 0x23108d00, 
	0x16121018, 0x4223058d, 0x003402d9, 0x88404080, 0x0e000000, 0x00000000, 
	0x18a82500, 0x91004422, 0x00094064, 0x80910044, 0x12d00942, 0xa7018d00, 
	0x540e1049, 0x4027009d, 0x007403d0, 0x09406020, 0x06000000, 0x00000000, 
	0x05a82700, 0x93000c02, 0xb008c8a4, 0x4193a05c, 0x06f109c0, 0x27009f18, 
	0x5c023019, 0xc267009f, 0x007c02f2, 0x09d01420, 0x0e000000, 0x00000000, 
	0x14802400, 0x8f007c02, 0xb009c027, 0x009b007e, 0x06f009c0, 0x67009d21, 
	0x6c02f409, 0xc427819f, 0x007c02f0, 0x09c05300, 0x06000000, 0x00000000, 
	0x14080000, 0x1f007c80, 0x7001ca85, 0x0003007c, 0x00b301c0, 0xc4001702, 
	0x7c00f011, 0xc0871013, 0x017c00f0, 0x01c05320, 0x04000000, 0x00000000, 
	0x14a01400, 0x5d40f441, 0x12074c15, 0x20518074, 0x01100542, 0xdc005100, 
	0x7001d037, 0x401f4070, 0x07f40dd0, 0x04405300, 0x02000000, 0x00000000, 
	0x14a03200, 0xcd003403, 0x000c4037, 0x40c00034, 0x83900c60, 0x3000c500, 
	0x7403d09c, 0x407303c1, 0x013497d0, 0x8c405300, 0x0a000000, 0x00000000, 
	0x05803801, 0xed08f403, 0x500e403b, 0x01e80434, 0x0710de70, 0xfc00e580, 
	0xb403d00e, 0x407b0061, 0x00b443d0, 0x0e401700, 0x02000000, 0x00000000, 
	0x15107801, 0xef85bc07, 0x741cc07b, 0x05e313b8, 0x37b05cc2, 0x5800e70f, 
	0xbc07f016, 0x846f0063, 0x01bc85f0, 0x1ec05740, 0x00000000, 0x00000000, 
	0x10b03500, 0xdf003c01, 0xa00dc035, 0x09d7067e, 0x93f02dc0, 0x0320db04, 
	0x7c5bf005, 0xc027205f, 0x00fc01f2, 0x0dc04360, 0x06000000, 0x00000000, 
	0x00a07f04, 0xfd09bc07, 0x301fc07e, 0x0cf301dc, 0xc7f13fc0, 0x5d00ff09, 
	0xbc473017, 0xc07c0073, 0x09fc27f0, 0x9fc00300, 0x0e000000, 0x00000000, 
	0x15803904, 0xed28b442, 0xb02f4238, 0x40f10084, 0x03d00e40, 0x1b00ed10, 
	0xb4631002, 0x403c0121, 0x009c22d0, 0x8a405720, 0x06000000, 0x00000000, 
	0x00083900, 0xed40b403, 0x900e403a, 0x00e500b5, 0x03d08e40, 0x1900ed00, 
	0xf60b1007, 0x40382061, 0x00b400d9, 0x0e400300, 0x04000000, 0x00000000, 
	0x0428f300, 0xcd003418, 0x900c50b0, 0x00d50034, 0x2fd00c42, 0xc300cd13, 
	0x36031860, 0x40700801, 0x801001d8, 0x08401320, 0x0c000000, 0x00000000, 
	0x15a8fd00, 0xfd007403, 0x900cc03e, 0x00f500fc, 0x0fe10fc0, 0x1501ff02, 
	0xfc073005, 0xc0e40053, 0x007002f0, 0x0dc05720, 0x06000000, 0x00000000, 
	0x01003700, 0xdf407c03, 0xf005c277, 0x04da0044, 0x13f00dc0, 0x1720df00, 
	0x7c83f035, 0xc027065f, 0x805402f0, 0x0dc80700, 0x0c000000, 0x00000000, 
	0x80083b04, 0xe300dc22, 0x700bc23c, 0x00fb80cc, 0x03f90fc0, 0x5f05fe20, 
	0xfc03b083, 0xc01c0023, 0x01cc00f0, 0x3bc00322, 0x0c000000, 0x00000000, 
	0x81203640, 0xd1004400, 0xd0b15034, 0x00d1006c, 0x03d00d40, 0x0700dd00, 
	0x7403d050, 0x40d10013, 0x20440cd0, 0x19400702, 0x08000000, 0x00000000, 
	0x01a03400, 0xd1005403, 0xd00d4030, 0x08d90046, 0x03d00d40, 0x0700dd00, 
	0x7403d005, 0x40f40051, 0x244404d0, 0x0d440700, 0x02000000, 0x00000000, 
	0x10203000, 0xc1000402, 0xd8044630, 0x20c12024, 0x03d20c42, 0x4308cd00, 
	0x36839000, 0x40112001, 0x010400d0, 0x08484380, 0x00000000, 0x00000000, 
	0x00a03600, 0xd3005c82, 0xfa09c438, 0x00fb00cc, 0x03d00fc0, 0x0700ff00, 
	0xfc03b001, 0xc0142013, 0x004d00f0, 0x09c003c0, 0x0a000000, 0x00000000, 
	0x05883f00, 0xff00fc80, 0xf303c03f, 0x00ff00fc, 0x03f10fc8, 0x0f10ff00, 
	0xfc83f002, 0xc01f0037, 0x00fc00f0, 0x0bc01760, 0x0e000000, 0x00000000, 
	0x03803f00, 0x2340bc07, 0xb003c03e, 0x033f08cc, 0x00f002c0, 0x0c003f00, 
	0xfc00d003, 0x440f103d, 0x00f400e0, 0x02c00e00, 0x0e000000, 0x00000000, 
	0x01002781, 0x11007c0b, 0x300140bf, 0x001d0444, 0x00d00d40, 0x07101d00, 
	0x7403d00d, 0x40370019, 0x007403d0, 0x01400420, 0x0c000000, 0x00000000, 
	0x11a02304, 0x0500340b, 0x90004033, 0x03050005, 0x04d00440, 0x03800d40, 
	0x2403d80c, 0x4033900d, 0x003402d0, 0x00424680, 0x0e000000, 0x00000000, 
	0x03882500, 0xd5015407, 0x900d4037, 0x00cd0444, 0x06d08540, 0x17001d10, 
	0x7403d04d, 0x40370058, 0x00740fd0, 0x81400c20, 0x06000000, 0x00000000, 
	0x02a82740, 0x15027417, 0xb011c137, 0x0017034c, 0x04f04dc0, 0x04001f2b, 
	0x7c4bf03d, 0xc4f7041f, 0x007c07f0, 0x50c00a20, 0x0e000000, 0x00000000, 
	0x07806d01, 0x7b00bc03, 0x708b883f, 0x003f01fc, 0x00f01fc1, 0x2f00bf00, 
	0xfc25f01f, 0x402f01fb, 0x006c03f8, 0x1fc01f00, 0x06000000, 0x00000000, 
	0x02083500, 0x97006c2a, 0xf035c037, 0x00df024f, 0x02f005d0, 0x34001b06, 
	0x7c0ab001, 0xc0970013, 0x105c6b30, 0x1d410a20, 0x04000000, 0x00000000, 
	0x13802400, 0xd1034506, 0x300d443f, 0x00d7004c, 0x06d035c0, 0x36049110, 
	0x744f108d, 0xc0f501d1, 0x06440350, 0x1d404c00, 0x02000000, 0x00000000, 
	0x07a03608, 0x050c0603, 0x50604033, 0x000d0024, 0x14d2a450, 0x41100902, 
	0x3447900c, 0x4033040d, 0x80160b90, 0x00401c00, 0x0a000000, 0x00000000, 
	0x04826808, 0xb181c6a7, 0x1016407b, 0x08e50184, 0x46d01f50, 0x4e002905, 
	0xf406d012, 0x445d523d, 0x418407d1, 0x1f401000, 0x02000000, 0x00000000, 
	0x12002400, 0x470a0403, 0x7008c033, 0x001f2224, 0x80f004d0, 0x01024b00, 
	0x3c01b92c, 0xc023020f, 0x001c23b0, 0x8cc04840, 0x00000000, 0x00000000, 
	0x02b82d20, 0xff08dc03, 0xf00fc03f, 0x00ff88fc, 0x03f08fc0, 0x1b007704, 
	0xb803300f, 0xc03b0263, 0x40fc8378, 0x8fc00960, 0x06000000, 0x00000000, 
	0x15a03700, 0xd7007c03, 0xb00d50b4, 0x00df804c, 0x02f01d40, 0x0400df00, 
	0x6c03f00d, 0x80730092, 0x007803f0, 0x01805700, 0x0e000000, 0x00000000, 
	0x12882900, 0xed40b401, 0x100e4038, 0x05ed2084, 0x03d10e40, 0x2800ed00, 
	0x8403d00e, 0x403b00e1, 0x00bc03d0, 0x0ec84b20, 0x06000000, 0x00000000, 
	0x03006900, 0xe501f607, 0x901e4478, 0x23ed0184, 0x86d01e41, 0x7800ed03, 
	0xa607d01e, 0x407b00a9, 0x01b607d8, 0x3e400f00, 0x04000000, 0x00000000, 
	0x12282702, 0xcd03340d, 0x101c4034, 0x00cd4905, 0x4bd30c40, 0x3000cd01, 
	0x044cd830, 0x610309c9, 0x00144bd0, 0x3c404920, 0x0c000000, 0x00000000, 
	0x17a85500, 0x6701fc9d, 0xb116c414, 0x006f0acc, 0x4df027d0, 0xdc016f02, 
	0xec01f017, 0xc09f447b, 0x02f409f0, 0x07405f20, 0x06000000, 0x00000000, 
	0x12000700, 0x1f0c7c10, 0xf0e1c007, 0x001f007c, 0x00f011c4, 0x47001f03, 
	0x7c28f081, 0xc8870017, 0x497c08f0, 0x41c84b00, 0x0c000000, 0x00000000, 
	0x10086700, 0x97404c02, 0x7009c024, 0x0093244c, 0x02f039c0, 0x27009f04, 
	0x6c06f099, 0xc067009f, 0x017c06f0, 0x89e04320, 0x0c000000, 0x00000000, 
	0x01002600, 0x91401426, 0x5109c026, 0x009a0245, 0x02d029c1, 0x25029d02, 
	0x546ad029, 0x40a7009d, 0x107462d0, 0x19400700, 0x08000000, 0x00000000, 
	0x18802401, 0x95044602, 0x50194024, 0x00910244, 0x12d10940, 0x27009d00, 
	0x6402d009, 0x402701dd, 0x087402d0, 0x09406100, 0x02000000, 0x00000000, 
	0x10202002, 0x91015602, 0x500c4022, 0x05890004, 0x46d00840, 0x21009d00, 
	0x0402d018, 0x4033108d, 0x003412d0, 0x08404380, 0x00000000, 0x00000000, 
	0x1db08600, 0x17004450, 0x7001d004, 0x0213284c, 0x10f001c0, 0x07005f00, 
	0x6c00f021, 0xc007001f, 0x007c00f0, 0x01c077c0, 0x0a000000, 0x00000000, 
	0x19b82f01, 0xbf00bc02, 0xf00ec025, 0x51a700fc, 0x02f20ac0, 0x3d10af20, 
	0xfc02f00b, 0xc52f00bf, 0x00fc0af1, 0x0bc06760, 0x0e000000, 0x00000000, 
	0x18a02f80, 0xb700bc02, 0x310bc024, 0x0db308cc, 0x02f00bc0, 0x2f00bf00, 
	0xfc02100b, 0xc02b00bf, 0x00f843d0, 0x0b406300, 0x0e000000, 0x00000000, 
	0x1c000704, 0x17007420, 0x10015004, 0x01110444, 0x28d10140, 0x07001d00, 
	0x74001405, 0x4007001d, 0x007400d0, 0x05407320, 0x0c000000, 0x00000000, 
	0x10a02301, 0x85207402, 0x10096020, 0x05810405, 0x02d00840, 0x23008d00, 
	0x34021008, 0x4123808d, 0x003402d0, 0x08404380, 0x0e000000, 0x00000000, 
	0x18a82530, 0x95027402, 0x10094020, 0x00910444, 0x02d08d40, 0x27009d80, 
	0x74021109, 0x4027849d, 0x00740ada, 0x89406320, 0x06000000, 0x00000000, 
	0x05a86700, 0x97807c02, 0x3438c424, 0x40838644, 0x46f029c1, 0x27009f01, 
	0x7c423089, 0xc0e7009f, 0x017c02f0, 0x09401720, 0x0e000000, 0x00000000, 
	0x1480a500, 0x9f037c0a, 0xf0394027, 0x009f0074, 0x0ef019c0, 0x67029f08, 
	0x7c12f009, 0xc027029f, 0x057c02f1, 0x09c05300, 0x06000000, 0x00000000, 
	0x14080500, 0x17027c20, 0x7021c007, 0x0013104c, 0x683011c0, 0x84001f88, 
	0x7810f0a1, 0xc9074213, 0x047c00f1, 0x11805320, 0x04000000, 0x00000000, 
	0x14a05401, 0x7f003405, 0x10274017, 0x007145d4, 0x0d103742, 0x14007d03, 
	0xb401d027, 0x409f0275, 0x83f48dd0, 0x27405300, 0x02000000, 0x00000000, 
	0x14a07200, 0xcd103406, 0x50bc4132, 0x08c90004, 0x0f149c50, 0x6000cd13, 
	0x3400d02c, 0x404320c9, 0x813440d2, 0x0c405300, 0x0a000000, 0x00000000, 
	0x05883800, 0xed10f403, 0x100e403b, 0x01f90014, 0x07101f40, 0x3804ed00, 
	0xb443d00e, 0x407b00e9, 0x10b443d0, 0x0a401700, 0x02000000, 0x00000000, 
	0x15007800, 0xe701bc07, 0x721ee073, 0x44eb218c, 0x05301ec0, 0x7800ef01, 
	0xbc07f01e, 0xc07b00eb, 0x01bc07f0, 0x1ec05740, 0x00000000, 0x00000000, 
	0x10883d00, 0x17007c83, 0xf005c037, 0x02c7007c, 0x01f008c0, 0x3700df00, 
	0x7c00f00f, 0xc03700d7, 0x007c01f0, 0x09c24360, 0x06000000, 0x00000000, 
	0x00a07f00, 0xeb01cc07, 0xb01ec07c, 0x00e309cc, 0x07f01fc0, 0x7f02ff01, 
	0xfc07301f, 0xc07c00ef, 0x01cc0730, 0x17c00300, 0x0e000000, 0x00000000, 
	0x15883904, 0xe300ac03, 0x300ec03a, 0x01eb0c84, 0x01d08e40, 0x3b042d00, 
	0xbc63108f, 0x40b9086d, 0x00840250, 0x02405720, 0x06000000, 0x00000000, 
	0x00002d00, 0xe900c402, 0x900b4138, 0x102100a6, 0x00d00640, 0x2b80e900, 
	0xb403100e, 0x410a04ad, 0x00840390, 0x06400300, 0x04000000, 0x00000000, 
	0x04282300, 0x01422403, 0x10304032, 0x800d0125, 0x48d01440, 0x73000d12, 
	0x144b100c, 0x40f3000d, 0x12044bd0, 0x50401320, 0x0c000000, 0x00000000, 
	0x15a83500, 0xdb060c23, 0xb09dc23c, 0x08d3092c, 0x0ef084c1, 0x7320cb02, 
	0x740f302c, 0xc07602df, 0x030c0fb0, 0x2dc15720, 0x06000000, 0x00000000, 
	0x01003700, 0xd7267c02, 0xf009c037, 0x00da085c, 0x07f02dc0, 0x2704df00, 
	0x7c0bf06d, 0xc005009f, 0x017c8f70, 0x21c00700, 0x0c000000, 0x00000000, 
	0x80083f00, 0xff25cc03, 0x300fc037, 0x00ff00cc, 0x0a309780, 0x3c003301, 
	0xcc0f300f, 0x407e0073, 0x006c1230, 0x8bc00222, 0x0c000000, 0x00000000, 
	0x81203600, 0x0d005423, 0x50f14037, 0x00cd406c, 0x0b143d40, 0x35001b04, 
	0x044b105d, 0x40b00211, 0x057403b0, 0x21420702, 0x08000000, 0x00000000, 
	0x01a03400, 0x1d024403, 0x10054037, 0x00dd0044, 0x0a100540, 0x3502d008, 
	0x4400141d, 0x403700d1, 0x08740918, 0x05410700, 0x02000000, 0x00000000, 
	0x10203008, 0x0d001403, 0x50004033, 0x00dd0034, 0x01100c50, 0x31000d00, 
	0x4403120d, 0x60352001, 0x00240390, 0x00404380, 0x00000000, 0x00000000, 
	0x00b02600, 0x1f004c03, 0x1001c43f, 0x001f004c, 0x823005d0, 0x35101100, 
	0x4d033009, 0xc0374013, 0x006c0330, 0x01c002c0, 0x0a000000, 0x00000000, 
	0x05982b00, 0x3f00bc02, 0xf003c03f, 0x003f00ec, 0x00f007c0, 0x2f003b00, 
	0xbc00f003, 0xc00e103f, 0x00fc00f0, 0x03c01760, 0x0e000000, 0x00000000, 
	0x03a03f00, 0xbf00ec20, 0x784f803f, 0x012300ec, 0xa0f103c0, 0x0b003f00, 
	0xdc20300b, 0xc03c00ab, 0x02fcb230, 0x03c00f00, 0x0e000000, 0x00000000, 
	0x01083700, 0x1d407410, 0x100f44bf, 0xa0110004, 0x88d02140, 0x07051010, 
	0x04001024, 0x40b40291, 0x00743250, 0x41410720, 0x0c000000, 0x00000000, 
	0x11a03300, 0x8d006400, 0x502c40b3, 0x05010024, 0x09d02040, 0x06010900, 
	0x1414129c, 0x42300889, 0x04341210, 0x00424780, 0x0e000000, 0x00000000, 
	0x03a83500, 0x5d187441, 0x500d4037, 0x00912844, 0x00d04141, 0x17004104, 
	0x4401104d, 0x427404d0, 0x0074c750, 0x0d400f20, 0x06000000, 0x00000000, 
	0x02a83700, 0x1f032cac, 0x500dc037, 0x0010056d, 0x44f01d40, 0xc7001f07, 
	0x5c042019, 0xc0f4009b, 0x017c0c30, 0x51c00b20, 0x0e000000, 0x00000000, 
	0x07803d00, 0x7f01fc07, 0xb00fc237, 0x20bd01fc, 0xa6f20f40, 0x3f027f00, 
	0xfc0df006, 0xc03b00bf, 0x04bc01f0, 0x9bc01f00, 0x06000000, 0x00000000, 
	0x02083500, 0x9f805c8a, 0xb08dc437, 0x2017024c, 0x013425c0, 0x27001300, 
	0x4c00300d, 0xc09400d3, 0x004c44f0, 0x05c00b20, 0x04000000, 0x00000000, 
	0x13a03c00, 0x5d00442b, 0x141f40bf, 0x00810144, 0x821045c2, 0x31005100, 
	0x6c01100d, 0x407444d1, 0x004405d0, 0x0d404f00, 0x02000000, 0x00000000, 
	0x07a03200, 0x8d011400, 0x003c4137, 0x04011214, 0x02121040, 0x02000100, 
	0x4400d00c, 0x40200085, 0x200400d0, 0x00401f00, 0x0a000000, 0x00000000, 
	0x04807800, 0x2d098426, 0x101e447b, 0x00651195, 0x05101602, 0x6d003181, 
	0xa484d0ba, 0x40fd02f5, 0x018004d0, 0x16401300, 0x02000000, 0x00000000, 
	0x12103000, 0xcf101423, 0x300c4033, 0x0087001c, 0x03300880, 0xb3004340, 
	0x0c01f00c, 0xc0304287, 0x800c11f0, 0x08c04b40, 0x00000000, 0x00000000, 
	0x02b83d00, 0x6f00bc23, 0x700fc03f, 0x00fb00cc, 0x21f00fc0, 0x3f106f40, 
	0xfc01310f, 0xd23a02fb, 0x40fc01f2, 0x8fc00b60, 0x06000000, 0x00000000, 
	0x15a03f02, 0xd3016e05, 0x30adc031, 0x0493004c, 0x023009c0, 0x14085f00, 
	0x7c81d00d, 0xd03608d3, 0x014c03e0, 0x1dc05400, 0x0e000000, 0x00000000, 
	0x12883901, 0x6b008603, 0x104e413b, 0x01e10085, 0x03100c40, 0x38006c00, 
	0xb401d00a, 0x402820e1, 0x00850390, 0x0f404820, 0x06000000, 0x00000000, 
	0x03007100, 0xf503a487, 0x101e407b, 0x03a12104, 0x07101a40, 0x78006d01, 
	0xb405d11c, 0x407200e9, 0x018407d0, 0x3e400c00, 0x04000000, 0x00000000, 
	0x12283700, 0x4900044f, 0x190c4233, 0x00c12004, 0x03153c40, 0xf411cd00, 
	0x3403d00c, 0x42b481c9, 0x00040380, 0x4c404820, 0x0c000000, 0x00000000, 
	0x17a81510, 0x7140e841, 0x3404c017, 0x006302cc, 0x093006c0, 0x9c047e06, 
	0xfc09f006, 0xc09ef05b, 0x10cc19f0, 0x17f05c20, 0x06000000, 0x00000000, 
	0x12020700, 0x1f107c00, 0xf001c887, 0x401f813c, 0x00f181d1, 0x07001f01, 
	0x7c24f001, 0xd4070017, 0x007c10b2, 0x01e04b00, 0x0c000000, 0x00000000, 
	0x10082700, 0x93057c02, 0xf019c064, 0x4093005c, 0xc2b009c0, 0x25009300, 
	0x7c02f009, 0xd0240093, 0x007ca270, 0x09c04320, 0x0c000000, 0x00000000, 
	0x01202620, 0x95007426, 0xd00943e0, 0x00914a44, 0x02101940, 0x24009100, 
	0x7402d209, 0xc0264091, 0x00740a10, 0x094c0700, 0x08000000, 0x00000000, 
	0x18a02408, 0x90007402, 0xd0494025, 0x12910054, 0x02904940, 0x25809100, 
	0x5402d009, 0x44640091, 0x0034c252, 0x09406300, 0x02000000, 0x00000000, 
	0x10202000, 0x85003402, 0xd04841a1, 0x05c10004, 0x02000840, 0x20408102, 
	0x3402d028, 0x4d224081, 0x02341a10, 0x08404380, 0x00000000, 0x00000000, 
	0x1db08610, 0x13403c08, 0xf001cc95, 0x00130054, 0xa0b001c0, 0x05021302, 
	0x5c20f061, 0xd0840103, 0x027c0870, 0x21c077c0, 0x0a000000, 0x00000000, 
	0x19b22707, 0xaf00fc42, 0xf009d026, 0x08af40fc, 0xa2f08bc0, 0x2f08bf00, 
	0xfc86f04b, 0x80af04bf, 0x00fc0af0, 0x5bc96760, 0x0e000000, 0x00000000, 
	0x18a0a705, 0xb300fc02, 0xb00bc6ac, 0x10a3204c, 0x02f04bc0, 0x27009b00, 
	0x7e02f04b, 0xd03e019b, 0x00fc1ae0, 0x28c06000, 0x0e000000, 0x00000000, 
	0x1c088700, 0x1b207410, 0xd001ca02, 0x8111006c, 0x18f02540, 0x06201d00, 
	0x7450d101, 0x48842011, 0x047438d0, 0x41407020, 0x0c000000, 0x00000000, 
	0x10a02301, 0x81813442, 0x902840a0, 0x01950004, 0x4ad02848, 0x23158d54, 
	0x3402d07c, 0x43220789, 0x103403d0, 0x18404080, 0x0e000000, 0x00000000, 
	0x18a82500, 0x99207406, 0xd0094426, 0x00950060, 0x02d10948, 0xa6019d02, 
	0x7442d81d, 0x44240091, 0x087492d0, 0x88406020, 0x06000000, 0x00000000, 
	0x05a82700, 0x93017c4a, 0xb208c824, 0x1095104c, 0x22f80940, 0x27009f02, 
	0x742ef009, 0xc066019b, 0x017c02f0, 0x19d01420, 0x0e000000, 0x00000000, 
	0x14802500, 0x9f057c02, 0xf009c227, 0x589b007c, 0x827009c0, 0x27009f43, 
	0x7c06f009, 0xc4e3049f, 0x007c06f0, 0x19c05300, 0x06000000, 0x00000000, 
	0x14080500, 0x1b007c08, 0x7041c000, 0x20170b4d, 0x00f021c4, 0x84001f82, 
	0x4c083210, 0xc004001f, 0x007c0070, 0x01c45020, 0x04000000, 0x00000000, 
	0x14a01400, 0x51b0f401, 0x1007401c, 0x20618055, 0x01c00540, 0x14005d00, 
	0x46011007, 0x40dc005d, 0x00f42910, 0x05c05200, 0x02000000, 0x00000000, 
	0x14a03600, 0xc9013403, 0x401c4032, 0x40c10114, 0x03d01c40, 0x3000cd00, 
	0x0403900c, 0x509100cd, 0x00340350, 0x0c405000, 0x0a000000, 0x00000000, 
	0x05803801, 0xe140f405, 0x102c401a, 0x00f10094, 0x23d01c41, 0x3802ed05, 
	0xc4039106, 0x48a908ed, 0x0cb40700, 0x8f441600, 0x02000000, 0x00000000, 
	0x15107c01, 0xeb01bc07, 0x701ed07a, 0x00e3019c, 0x27f11ec2, 0x7821ff0d, 
	0x8503b01c, 0xc04900ef, 0x01fc0560, 0x9ec05440, 0x00000000, 0x00000000, 
	0x10b83d00, 0xdf003c01, 0xf205c035, 0x10de007c, 0x1bf009d0, 0x370ddf04, 
	0x3c437005, 0xd03610df, 0x067c01f0, 0x4dc04360, 0x06000000, 0x00000000, 
	0x00a07f04, 0xf301fc07, 0x219fc07f, 0x02ef01c8, 0x07f01fc0, 0x7f00f319, 
	0xfc67f01f, 0x805e00f3, 0x0bfc07f0, 0x1ec80000, 0x0e000000, 0x00000000, 
	0x15883900, 0xeb00f461, 0x14ca401b, 0x036d04bc, 0x43d20e40, 0x3b00e10c, 
	0xb473d00e, 0x403800e1, 0x08b402f0, 0x0e405520, 0x06000000, 0x00000000, 
	0x00003900, 0xa100b40b, 0x900e483b, 0x80ad10a6, 0x03d08e40, 0x3b02e180, 
	0xb00bd08e, 0x401a02e1, 0x28b401d0, 0x0f400000, 0x04000000, 0x00000000, 
	0x04283340, 0x89d23401, 0x90004033, 0x100d5356, 0x07d00842, 0x3302c003, 
	0x3403d00c, 0x403200d1, 0x09340450, 0x2c411120, 0x0c000000, 0x00000000, 
	0x15a83d00, 0xc3107c06, 0xb00dc227, 0x00de01e4, 0x0ff01dc0, 0xff40f104, 
	0xfc07f05d, 0xc0d640f3, 0x003c03d0, 0x0fc05420, 0x06000000, 0x00000000, 
	0x01003700, 0x9f007c0a, 0x700cc007, 0x009f027e, 0x03f08dc4, 0x3700df00, 
	0x7c03f027, 0xc06524df, 0x00fc21f8, 0x1dc40700, 0x0c000000, 0x00000000, 
	0x80083700, 0xff03cc0b, 0x300bc07c, 0x007f05cc, 0xc3301fc2, 0x3e04f730, 
	0xfc03f03d, 0xc11000f3, 0x80cc0831, 0x0fc20322, 0x0c000000, 0x00000000, 
	0x81203600, 0x9d00140b, 0x14015134, 0x02070444, 0x03509940, 0x3700d700, 
	0x7403d005, 0x46e414d5, 0x40440454, 0x0d400702, 0x08000000, 0x00000000, 
	0x01803400, 0xdd004642, 0x10854024, 0x00dd0044, 0x03110940, 0x3700dd00, 
	0x7403d000, 0x607400d1, 0x00440110, 0x0d440700, 0x02000000, 0x00000000, 
	0x10003000, 0x9d001402, 0x10004000, 0x10050006, 0x03500840, 0x3300c580, 
	0x3403d000, 0x403000c5, 0x00450650, 0x0c484380, 0x00000000, 0x00000000, 
	0x00303600, 0x9f004c03, 0x1001c034, 0x001f00cc, 0x033009c0, 0x3a00ff40, 
	0xfc03f001, 0xc03408f3, 0x804c0034, 0x0fc003c0, 0x0a000000, 0x00000000, 
	0x05b83f00, 0xbf00fc03, 0xe003c03f, 0x003700fd, 0x03f00bc0, 0x3f00f700, 
	0xfc03f003, 0xc03f10ff, 0x00fc00f8, 0x0fc01760, 0x0e000000, 0x00000000, 
	0x03a03f02, 0xf7109c02, 0xf08fc00e, 0x01bb40cc, 0x03f00bc0, 0x0d003f80, 
	0xcc00d102, 0xc00f002f, 0x008c00c0, 0x03c00c00, 0x0e000000, 0x00000000, 
	0x0108bf20, 0xf1227403, 0xd1af4497, 0x20dd10fc, 0x0bd10940, 0x3500d100, 
	0x5403d00d, 0x403700dd, 0x005483d1, 0x01400520, 0x0c000000, 0x00000000, 
	0x1100b311, 0xc5943003, 0xd00c4093, 0x00dd0404, 0x23d00840, 0x15800540, 
	0x1401d004, 0x64032095, 0x400600d8, 0x00404480, 0x0e000000, 0x00000000, 
	0x07a83520, 0xd1007403, 0xd00d0097, 0x00dd0474, 0x03d08900, 0xb480d500, 
	0x5402c009, 0x4037025d, 0x005483d8, 0x05410d20, 0x06000000, 0x00000000, 
	0x02a83700, 0xd7007c27, 0xf00dc4a6, 0x00cb804c, 0x03e241c0, 0x91005f50, 
	0x5c02f001, 0x8067005f, 0x004401f0, 0x20c00820, 0x0e000000, 0x00000000, 
	0x03803d00, 0xdf00fc03, 0xd00f403f, 0x00be01de, 0x03e01308, 0x3f02bb00, 
	0xfc01f00f, 0xc01f00bf, 0x10fc02f0, 0x0fc01f00, 0x06000000, 0x00000000, 
	0x02083100, 0xdf005c02, 0x300dc877, 0x40d7004c, 0x03f001c2, 0x06005b04, 
	0x7c13f025, 0xc02400df, 0x006c0930, 0x61c00920, 0x04000000, 0x00000000, 
	0x13a03c00, 0xfd204507, 0x110f4036, 0x00d001c6, 0x2bf050c0, 0xb7029b01, 
	0x7480d009, 0xc096120b, 0x406c0610, 0x2d404c00, 0x02000000, 0x00000000, 
	0x07a03220, 0xcd200407, 0x900c4823, 0x08c10806, 0x07d01c40, 0x32009109, 
	0x3400d028, 0x41930801, 0x20042290, 0x20401d00, 0x0a000000, 0x00000000, 
	0x04807800, 0xed8dc406, 0x901e607f, 0x80e10184, 0x07501e40, 0x49006989, 
	0xb447d097, 0x406f10f9, 0x01e41990, 0x13401000, 0x02000000, 0x00000000, 
	0x12103002, 0xcd041643, 0x920cc833, 0x01972804, 0xc3d08c64, 0x36048300, 
	0x3c01f00c, 0xc3130483, 0x380ca2b0, 0x00c04940, 0x00000000, 0x00000000, 
	0x02b03d08, 0xff84fd03, 0x600fc83a, 0x00ff00f1, 0x03f00fe2, 0x1f307f40, 
	0xfc02f003, 0xc02a007f, 0x00fc1170, 0x86c40b60, 0x06000000, 0x00000000, 
	0x15a03702, 0xdf164c03, 0xf14dc020, 0x00d3007c, 0x4bf009c0, 0x3700d300, 
	0x4802e118, 0x0034005e, 0x00300720, 0x09c05700, 0x0e000000, 0x00000000, 
	0x12883903, 0xcd048403, 0xd0cec83a, 0x00e180b4, 0x03d00a40, 0x1b002500, 
	0xac01d006, 0x400910ad, 0x00b40050, 0x0e004b20, 0x06000000, 0x00000000, 
	0x03007901, 0xed098407, 0xd8de407c, 0x20e103b0, 0x27d01a40, 0x7b00f141, 
	0x8607991f, 0x407820ed, 0x51b44712, 0x1a480f00, 0x04000000, 0x00000000, 
	0x12283320, 0xdd800422, 0xd00c4032, 0x10810134, 0x03d00849, 0x43000501, 
	0x2418d000, 0x6481010d, 0x01348050, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17881500, 0x5f204c01, 0xf805c81c, 0x5253007c, 0x01f007c3, 0x13095304, 
	0x0c01b005, 0xc414005f, 0x017c0130, 0x37405f20, 0x06000000, 0x00000000, 
	0x12000700, 0x1f007d00, 0xf000c007, 0x001f007c, 0x00f221c0, 0x07203f80, 
	0xfc00f223, 0xc00f003f, 0x02f400f0, 0x91c04b00, 0x0c000000, 0x00000000, 
	0x10082300, 0x93204c16, 0xf009c064, 0x0093000c, 0x223039c0, 0x26009300, 
	0x4c023099, 0xc067029f, 0x047c82f0, 0x89c04320, 0x0c000000, 0x00000000, 
	0x01202600, 0x91004406, 0x70095060, 0x80810144, 0x02142841, 0x24008b00, 
	0x5482b039, 0x4127089d, 0x017422d0, 0x19400700, 0x08000000, 0x00000000, 
	0x18a02400, 0x91804502, 0xd0094024, 0x01910445, 0x02100940, 0x2608b100, 
	0xc402100f, 0x402f00bd, 0x10d403d0, 0x09406300, 0x02000000, 0x00000000, 
	0x1020a000, 0x81860482, 0x50c84024, 0x01810206, 0x0a102940, 0x2403a936, 
	0xd402900a, 0x482b00ad, 0x00b486d2, 0x08404380, 0x00000000, 0x00000000, 
	0x1db08601, 0x13024c00, 0xd020c004, 0x4411024c, 0x193021c0, 0x82041302, 
	0x4c103001, 0xc007001f, 0x00fc00f0, 0x01c077c0, 0x0a000000, 0x00000000, 
	0x19b8a761, 0x9f02fc02, 0xf029c02f, 0x00bf006c, 0x0af00bc0, 0x2f008f04, 
	0x7c0af009, 0x8027009f, 0x007c02f1, 0x0bc06760, 0x0e000000, 0x00000000, 
	0x18802701, 0x93149c02, 0xf049c02f, 0x05b308fc, 0x32d20ac4, 0x20029104, 
	0x04523009, 0xc8270091, 0x00f002c0, 0x0bc06300, 0x0e000000, 0x00000000, 
	0x1c080709, 0x1a046c00, 0xd041c105, 0x00110474, 0x80d04140, 0x05021114, 
	0x6c005101, 0x44070035, 0x007400d0, 0x01407320, 0x0c000000, 0x00000000, 
	0x10a02326, 0x81141002, 0xd0c84023, 0x40802434, 0x32d84941, 0x2880a90c, 
	0x8602190a, 0x642f00a1, 0x003682d0, 0x08404380, 0x0e000000, 0x00000000, 
	0x18882500, 0x89806412, 0xd0096025, 0x00910074, 0x02980940, 0x2d00b920, 
	0xe402580b, 0x602f00b5, 0x007482d0, 0x89406320, 0x06000000, 0x00000000, 
	0x05882700, 0x93405c02, 0xf009c027, 0x2a93297c, 0x02f009c2, 0x64029b00, 
	0x0c263009, 0xc0238093, 0x127c02d0, 0x19c01720, 0x0e000000, 0x00000000, 
	0x14802508, 0x9f007c02, 0xf009c027, 0x009e007c, 0x02f009c8, 0x27109700, 
	0x7c02f049, 0xc027089f, 0x007c02f0, 0x19c05300, 0x06000000, 0x00000000, 
	0x14080500, 0x1f007c20, 0x3401c001, 0x0013107c, 0x007001c0, 0x0800230c, 
	0xcc003003, 0xc00c013f, 0x004c80f1, 0x11405320, 0x04000000, 0x00000000, 
	0x14a01400, 0x5d007601, 0x1005c415, 0x907f80fc, 0x2170b4c8, 0x17005140, 
	0x5441b005, 0xc216185d, 0x20ec31c0, 0x67405300, 0x02000000, 0x00000000, 
	0x14a03600, 0xcd803606, 0x100c4061, 0x00c50034, 0x27503040, 0x80040901, 
	0x244c9000, 0x4000000d, 0x002480d8, 0x0c405300, 0x0a000000, 0x00000000, 
	0x05803801, 0xed04f407, 0x180e4031, 0x1ced0094, 0x02502640, 0x7903f904, 
	0xf403901e, 0x403a10ed, 0x01a403d0, 0x0e401600, 0x02000000, 0x00000000, 
	0x15107801, 0xed13b407, 0x305ec079, 0x08e101b4, 0x87701e00, 0x08412b03, 
	0xac04b01e, 0xc05800ef, 0x01ac07f0, 0x1ec45740, 0x00000000, 0x00000000, 
	0x10b83500, 0xdf007c83, 0xf0cde837, 0x0097007c, 0x02f02dc0, 0xff05e701, 
	0x5c03f000, 0xc427180f, 0x007c03f1, 0x0dc24360, 0x06000000, 0x00000000, 
	0x00a87f44, 0xf301cc87, 0xf03fc078, 0x02e309ec, 0x07b03fc0, 0x6a13e301, 
	0x8c073013, 0x806f1230, 0x29fc07e0, 0x93800320, 0x0e000000, 0x00000000, 
	0x15883900, 0xf1008443, 0xd00ec028, 0x43e1028c, 0x0a300ec0, 0x18022b08, 
	0x9400528e, 0x401b06e5, 0x1cb46ad0, 0x02405760, 0x06000000, 0x00000000, 
	0x00003100, 0xe1008402, 0xd00e403a, 0x20e10004, 0x20101240, 0x68c1e900, 
	0xa403100e, 0x403b80e1, 0x00b401d0, 0x02600300, 0x04000000, 0x00000000, 
	0x04203300, 0xc1000407, 0xd00d4070, 0x00810144, 0x00100440, 0x10010900, 
	0x34845000, 0x40030005, 0x00340bd0, 0x20401300, 0x0c000000, 0x00000000, 
	0x15a03d00, 0xf3800c03, 0xf00fc034, 0x04d31040, 0x023105d0, 0x1c013b03, 
	0x6d003031, 0xc1430013, 0x017c0fe0, 0x0dc05700, 0x06000000, 0x00000000, 
	0x01003700, 0xcf007c02, 0xf00dc037, 0x30d7807d, 0x00f003c0, 0x2f10df8c, 
	0x5c23f24d, 0xc03700df, 0x807c81f0, 0x55c80700, 0x0c000000, 0x00000000, 
	0x80003b00, 0xfb00cc03, 0x300dc02c, 0x00f300cc, 0x02304fc0, 0xdc002300, 
	0x8c40300f, 0xc01c04f3, 0x10fc4630, 0x1bc00302, 0x0c000000, 0x00000000, 
	0x81203600, 0xd1004603, 0x500d4030, 0x0091026c, 0x0c100d40, 0x6100db00, 
	0x6c83b000, 0xc026001b, 0x00342710, 0x11420702, 0x08000000, 0x00000000, 
	0x01a83400, 0xd9806413, 0x120d4234, 0x81412045, 0x06100c40, 0x3400d940, 
	0x44031001, 0x40240011, 0x00740310, 0x41410700, 0x02000000, 0x00000000, 
	0x10203008, 0xc1000403, 0x580c4035, 0x00450004, 0x00100c40, 0x01000900, 
	0x2600920c, 0x401220c9, 0x00348310, 0x00404380, 0x00000000, 0x00000000, 
	0x00b03600, 0xfb004c03, 0x100f4034, 0x40510044, 0x001107c0, 0x3c00db00, 
	0x4c03300d, 0xc03400d3, 0x007c0330, 0x01c003c0, 0x0a000000, 0x00000000, 
	0x05903f20, 0xff00fc02, 0xf00fc02e, 0x083b00fc, 0x00f002c0, 0x0f003f00, 
	0xf800f003, 0xc00b003f, 0x00fc00f0, 0x03c01740, 0x0e000000, 0x00000000, 
	0x03a23f16, 0x7360fc03, 0x3083c00f, 0x08fb00c8, 0x237063c0, 0x3f00f356, 
	0x8d00300f, 0x147e0037, 0x06fc2330, 0x0fc00c00, 0x0e000000, 0x00000000, 
	0x01003708, 0x5100c40b, 0x10414027, 0x005140c4, 0x3b10c140, 0xbf4ae106, 
	0x4401144d, 0xc8be0391, 0x4af41b10, 0xed410420, 0x0c000000, 0x00000000, 
	0x11a83300, 0xd1003423, 0x19004007, 0x80d90004, 0x03500442, 0x3300c120, 
	0x44001018, 0x55320c49, 0x04340b10, 0x0c444480, 0x0e000000, 0x00000000, 
	0x03a83500, 0xd1a04403, 0x10094037, 0x00d40004, 0x03100540, 0x3700d100, 
	0x44081009, 0x523600d5, 0x20740310, 0x0c400c20, 0x06000000, 0x00000000, 
	0x02a83740, 0x83007c03, 0x3001c087, 0x008b004c, 0x037901c0, 0x3720d300, 
	0x0c003101, 0xc4364057, 0x807c8331, 0x0d800820, 0x0e000000, 0x00000000, 
	0x07803d00, 0xbf02bd03, 0xf197c42f, 0x01fb00fd, 0x837a07c0, 0x3b00ef00, 
	0xfc01f207, 0xc03200fb, 0x20bc03f0, 0x0fc01f00, 0x06000000, 0x00000000, 
	0x02083510, 0xd7006c03, 0x312dc097, 0x08db007c, 0x03b129c0, 0x3602df20, 
	0x44003001, 0xcd37105f, 0x004c4330, 0x0dc00820, 0x04000000, 0x00000000, 
	0x13a23c00, 0xdd05ec67, 0x100d4433, 0x00dd40f4, 0x43100d48, 0xfc00fd20, 
	0x440c1028, 0x40bf00d1, 0x00c00310, 0x0f424c00, 0x02000000, 0x00000000, 
	0x07803600, 0x4500040b, 0x90006023, 0x04c92934, 0x87900840, 0x3204cd00, 
	0x1416900c, 0x40f30685, 0x40242391, 0x0c441d00, 0x0a000000, 0x00000000, 
	0x04807800, 0x6d012407, 0x901e487b, 0x186d09b4, 0x87101840, 0x7800ed01, 
	0x9407989e, 0x447b02a1, 0x01240790, 0x1e601100, 0x02000000, 0x00000000, 
	0x12003001, 0xc7000c33, 0xb004c0a3, 0x00cb407c, 0x13b06cc0, 0x3230cf88, 
	0x1c40b008, 0xc23300df, 0x042d13b3, 0xcdc04940, 0x00000000, 0x00000000, 
	0x02a83d00, 0xef80f823, 0x700fc03f, 0x00ff00fc, 0x43f00fc0, 0xbf02fd10, 
	0xed02700b, 0xc0bf08ff, 0x00dc0371, 0x8fc00a40, 0x06000000, 0x00000000, 
	0x15a03700, 0xcf016c53, 0xf009d034, 0x108f004c, 0x4b3001c0, 0xf403d704, 
	0x3c043008, 0xc0b408d3, 0x007c1714, 0x0dc05700, 0x0e000000, 0x00000000, 
	0x1288f900, 0xed00840b, 0xd00e4038, 0x10ed4004, 0x03100640, 0x3100e10c, 
	0xb401100e, 0x403800e5, 0x00f44310, 0x7e404b20, 0x06000000, 0x00000000, 
	0x03007989, 0xfd01a407, 0xd01e407a, 0x00fd1185, 0x07101a61, 0x7840e905, 
	0xf4041013, 0x407802e1, 0x01b43710, 0x1e400f00, 0x04000000, 0x00000000, 
	0x12283300, 0xcd081403, 0xd05d4072, 0x80cd0004, 0x83120c40, 0x3100d900, 
	0x34001489, 0x443000c5, 0x01340310, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17a81500, 0x7f036c01, 0xf077c05e, 0x006f024c, 0x013437c0, 0x14005b00, 
	0xf0013037, 0xe0149873, 0x057c0130, 0x05c05f20, 0x06000000, 0x00000000, 
	0x12000720, 0x1f016800, 0xf001c085, 0x221f017c, 0x00f001c0, 0x07001760, 
	0x7c00f011, 0xd407800f, 0x007000f0, 0x01c84b08, 0x0c000000, 0x00000000, 
	0x10082610, 0x9f007c12, 0xe109c024, 0x009c012c, 0x023008cb, 0x24089f00, 
	0x4c42f009, 0x4060009f, 0x404c02f0, 0x09ca4320, 0x0c000000, 0x00000000, 
	0x01222600, 0x9d007402, 0xd0094064, 0x00990944, 0x02b009c8, 0xa6029d00, 
	0x4426d009, 0x40648291, 0x604402d0, 0x09400708, 0x08000000, 0x00000000, 
	0x18a02400, 0x9d047402, 0xd00d4064, 0xa89d0064, 0x82900940, 0x24089d00, 
	0x4702d009, 0x40a500d5, 0x004402d0, 0x09606300, 0x02000000, 0x00000000, 
	0x10202000, 0x8d003403, 0xd0085020, 0x80994004, 0x1a908840, 0x22008d00, 
	0x0602d098, 0x40210181, 0x140452d0, 0x88404380, 0x00000000, 0x00000000, 
	0x1db00602, 0x1d007440, 0xf000c414, 0x001f0068, 0x103020c0, 0x14201f08, 
	0x4e01f021, 0xd0410e1f, 0x044d10f0, 0x61c077c0, 0x0a000000, 0x00000000, 
	0x19b82702, 0xbf807c02, 0xf00bc12f, 0x00bb807c, 0x1af19fd0, 0x25029f08, 
	0xf602f01b, 0xc02600bf, 0x147c52f0, 0x39c06740, 0x0e000000, 0x00000000, 
	0x18a02700, 0xb700bc02, 0xf109c02f, 0x00b700cd, 0x1ab089c0, 0x2b009328, 
	0xfc02f02b, 0xc02c0193, 0x14cc2230, 0x89c06380, 0x0e000000, 0x00000000, 
	0x1c088704, 0x1d005c20, 0xd0414107, 0x001f0044, 0x2810a1c0, 0x0502110a, 
	0x5c01f041, 0x4004251f, 0x04041010, 0xa1407320, 0x04000000, 0x00000000, 
	0x10a02303, 0x8d801482, 0xd0484823, 0x109d2004, 0x12904842, 0x21208104, 
	0x3402d21d, 0x40200381, 0x90051a10, 0x48404388, 0x0c000000, 0x00000000, 
	0x18882580, 0x9d205402, 0xd0294027, 0x829d0444, 0x02184942, 0x25009140, 
	0x5403d019, 0x4024009d, 0x20448210, 0x09486320, 0x06000000, 0x00000000, 
	0x05a82728, 0x9fa65c82, 0xf089c027, 0x2097124c, 0x82b929c6, 0x25009300, 
	0x7c0af029, 0xc2240093, 0x014c0234, 0x09c01720, 0x0e000000, 0x00000000, 
	0x14802500, 0x9f235c02, 0xf009c027, 0x8097007c, 0x42f819c0, 0x25409f80, 
	0x5c167809, 0xd9230097, 0x027c02f0, 0x09c05300, 0x06000000, 0x00000000, 
	0x14080500, 0x13027c24, 0x3001c047, 0x821f020c, 0x80f021c0, 0x04241700, 
	0x7800f001, 0xc0070407, 0x004c0034, 0x01c05320, 0x04000000, 0x00000000, 
	0x14a01408, 0x53b1f409, 0x1205409f, 0x004f01c4, 0x01d005ca, 0x5a045100, 
	0xf469f006, 0x40df0151, 0x80c40110, 0x05c45108, 0x02000000, 0x00000000, 
	0x14a03200, 0xc1013403, 0x120c2073, 0x008d2804, 0x0b510c40, 0x7000c500, 
	0x240fd00c, 0x40b300c5, 0x40440310, 0x0c405300, 0x0a000000, 0x00000000, 
	0x05807841, 0xe100b607, 0x108e601b, 0x90f50085, 0x03d05e60, 0x3a00e104, 
	0xb403500e, 0x403b00c1, 0x84870310, 0x4e401508, 0x02000000, 0x00000000, 
	0x15107c41, 0xe381b407, 0x341ec24b, 0x18ed018c, 0x07f09fc2, 0x7800e701, 
	0xa407d01e, 0xc07300e7, 0x418c0730, 0x1ec05740, 0x00000000, 0x00000000, 
	0x10907502, 0xdf007c03, 0xf06dc107, 0x08cf207c, 0x83f00dc0, 0x3720df82, 
	0x7403f00d, 0xc83700df, 0x027c03f0, 0x4dc04340, 0x06000000, 0x00000000, 
	0x00a27f10, 0xf301fc07, 0xe01fc05c, 0x20ed21dc, 0x27305fc1, 0x7f01ff1b, 
	0xfc27f09f, 0xc07c03fb, 0x13cc07f0, 0x3fc10000, 0x0e000000, 0x00000000, 
	0x15883d00, 0xe120b403, 0xd08e4018, 0x12ad0484, 0x03b00e04, 0x2b00ed00, 
	0x8460d08e, 0x403813e5, 0x008403d0, 0x0ec45620, 0x02000000, 0x00000000, 
	0x00003900, 0xe100b403, 0xd00f400a, 0x00fd4094, 0x83104e08, 0x1b01cd80, 
	0x9403c00e, 0x480083e9, 0x029403d0, 0x0e400200, 0x04000000, 0x00000000, 
	0x04283300, 0x81203401, 0xd01c4042, 0x00c92304, 0x03981c40, 0x0300cd00, 
	0x0608904c, 0x400480c5, 0x000483d0, 0x0c401220, 0x0c000000, 0x00000000, 
	0x15a83d00, 0x93003c01, 0xf04e5016, 0x00cf075c, 0x03100fc0, 0x3700ff00, 
	0x1c27f03d, 0xc43400fb, 0x005d03f0, 0x0fc05620, 0x06000000, 0x00000000, 
	0x01003740, 0x9f007c01, 0xf00dc195, 0x03df047c, 0x0a708dc0, 0x1720df20, 
	0x5c03f21d, 0xc00700df, 0x006c00f0, 0x0dc00700, 0x0c000000, 0x00000000, 
	0x80083b10, 0xbb00fc05, 0x300fc00c, 0x02b3004c, 0x07f20fc0, 0x2f30ff00, 
	0xfc10300f, 0xd0fc00da, 0x00cc0370, 0x0dc00322, 0x08000000, 0x00000000, 
	0x81223600, 0x9100644d, 0x100d4000, 0x01d5286c, 0xe2d20d40, 0x0701d900, 
	0x740c103c, 0x428480db, 0x0044a410, 0x0d400702, 0x08000000, 0x00000000, 
	0x01a03400, 0x99047411, 0x100d5004, 0x08d50044, 0x01d00d40, 0x3601dd00, 
	0x76031031, 0x403404c5, 0x80048b10, 0x0d600700, 0x02000000, 0x00000000, 
	0x10203000, 0x81002401, 0x1c0d4000, 0x00c50024, 0x00d00c40, 0x0300c900, 
	0x34005409, 0x400000cd, 0x00040010, 0x0c604380, 0x00000000, 0x00000000, 
	0x00b03600, 0x9b807c01, 0x300fc004, 0x00d7004c, 0x01d00fc4, 0x0600ff00, 
	0x7c003009, 0xc00400f3, 0x004d0334, 0x0fc003c0, 0x0a000000, 0x00000000, 
	0x05903f00, 0xbf00e002, 0xf10ec00f, 0x00bf40fc, 0x00f80f80, 0x0f00ff20, 
	0xf400800a, 0xc00f00fb, 0x00fc00f0, 0x0fc01740, 0x0e000000, 0x00000000, 
	0x82a83d06, 0xb300cc00, 0xf043c23c, 0x023304cc, 0x50b003c0, 0x0f007300, 
	0xcd003083, 0xc00e023b, 0x00cc2032, 0x02c80b40, 0x0e000000, 0x00000000, 
	0x03003741, 0xd1004491, 0xc025c026, 0x014a0645, 0x48100944, 0x37454150, 
	0x54001000, 0x48011101, 0x84040012, 0x41410f00, 0x0c000000, 0x00000000, 
	0x11203120, 0xd1401441, 0xd02d4031, 0x08911204, 0x10920040, 0x33014501, 
	0x05545440, 0x60404001, 0x11150054, 0x10404780, 0x0e000000, 0x00000000, 
	0x06283518, 0xd1045503, 0xd80d4063, 0x20dd4004, 0xe0100142, 0x330a4100, 
	0x14001011, 0x40050005, 0x00140450, 0x01000b20, 0x06000000, 0x00000000, 
	0x80203480, 0xc3005849, 0xf041c035, 0x20d3804c, 0x07b28dc8, 0xb7045700, 
	0x4d017409, 0xc016005b, 0x005d0270, 0x05c00722, 0x0e000000, 0x00000000, 
	0x87083d00, 0xbf21ec0d, 0xf107c03e, 0x00fb20fe, 0x87f11fc8, 0x3f007f00, 
	0xec01f00b, 0xc01f007b, 0x00ec02b0, 0x07c01f02, 0x06000000, 0x00000000, 
	0x06083520, 0xd3004c03, 0xb10dd034, 0x00d3404c, 0x0b3001c0, 0x87085f04, 
	0x4d11f009, 0xc0170053, 0x004c1230, 0x85c00920, 0x00000000, 0x00000000, 
	0x5b203c00, 0xd1006803, 0xd01c4434, 0x00c50044, 0x03512540, 0x37005f02, 
	0x4419d009, 0xc0154051, 0x00411ab0, 0x25406c00, 0x02000000, 0x00000000, 
	0x53003410, 0xc1011401, 0xd0084031, 0x00092004, 0x03100443, 0x3300cc00, 
	0x04028005, 0x40240081, 0x00040110, 0x18411f00, 0x0a000000, 0x00000000, 
	0x8b8a7842, 0xe111b405, 0xd09e4078, 0x006d0986, 0x07509e40, 0x4b02e541, 
	0x8406d016, 0x406902a1, 0x09842591, 0x1a427f00, 0x02000000, 0x00000000, 
	0x12003400, 0x83081c23, 0xd20cc135, 0x008b4044, 0x033000c0, 0x3300cd04, 
	0x0c02f004, 0xc0210083, 0x080c0130, 0x08c84b00, 0x00000000, 0x00000000, 
	0x02a83d04, 0xef08e423, 0xf00ec03f, 0x10f700f8, 0x03f00740, 0x3f00fc00, 
	0xfc22f087, 0xc02f00bf, 0x08fc81d0, 0x0bd00824, 0x06000000, 0x00000000, 
	0x14283508, 0xd3007c01, 0xf019d034, 0x00df004d, 0x03f01dd0, 0x3400d300, 
	0x4c83b00d, 0x503400d3, 0x004c0334, 0x0dc05740, 0x0e000000, 0x00000000, 
	0x13117901, 0xe100bc01, 0xd00e4028, 0x00ef0084, 0x03d00f40, 0x3800e140, 
	0xc403100e, 0x403800eb, 0x00840310, 0x0e404f04, 0x06000000, 0x00000000, 
	0x90007901, 0xe901b40f, 0xd01c4078, 0x00fd1186, 0x07d01240, 0x7a04e101, 
	0x8407901e, 0x407810e1, 0x01a40710, 0x1e400702, 0x04000000, 0x00000000, 
	0x02003148, 0x89a13407, 0xd00c4020, 0x82cd0404, 0x33d02440, 0xc240c100, 
	0x4403140c, 0x403000d9, 0x00240310, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x13281500, 0x5b05f40d, 0xf007e014, 0x007f00cc, 0x09f0a7c0, 0x9e004300, 
	0x4d01b404, 0xd0100053, 0x006d0120, 0x05c07f24, 0x06000000, 0x00000000, 
	0x16000700, 0x17005004, 0xf001c007, 0x0007007c, 0x00f021c0, 0x05011fc0, 
	0x7c00f011, 0xc007001f, 0x005c04f2, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x14082100, 0x93807c82, 0x3029c027, 0x009b005c, 0x02f009c0, 0x27009300, 
	0x4c023809, 0xc0240093, 0x004c0230, 0x19c04320, 0x0c000000, 0x00000000, 
	0x01202610, 0x91011c02, 0x10094027, 0x009d0044, 0x02d02940, 0x27449100, 
	0x54027c09, 0x40245091, 0x40448250, 0x19480708, 0x08000000, 0x00000000, 
	0x18a02400, 0x91817402, 0x10094027, 0x009d0054, 0x02d00965, 0x23209180, 
	0xc482100b, 0x502c00b1, 0x00860210, 0x8b406300, 0x02000000, 0x00000000, 
	0x1020a089, 0x81007602, 0x10484023, 0x008d1c04, 0x42d00848, 0x23009100, 
	0x9402508b, 0x443c00e1, 0x00842210, 0x0a404380, 0x00000000, 0x00000000, 
	0x1b200211, 0x13007c20, 0x3401c107, 0x0219405c, 0x00f021c0, 0x83000302, 
	0x4c081000, 0xc0000003, 0x080d0034, 0x87c0f780, 0x00000000, 0x00000000, 
	0x1933a761, 0xbf80dc02, 0xf00bc02f, 0x08af00fc, 0x42f04bc1, 0x2f159f50, 
	0x7cd23109, 0xc027149f, 0x047c12f0, 0x09c06fac, 0x0e000000, 0x00000000, 
	0x19b02501, 0xbf007c0a, 0xf04ac024, 0x8087007c, 0x4a300ec0, 0x23009f00, 
	0x0c033029, 0xc03400d3, 0x004c0230, 0x8fc26420, 0x0e000000, 0x00000000, 
	0x98100605, 0x1d007480, 0xd021c006, 0x01110474, 0x00b04140, 0x47101d85, 
	0x44041051, 0x4844201b, 0x81c41432, 0x01c0fa22, 0x0c000000, 0x00000000, 
	0x1222a120, 0x85003412, 0xd0294820, 0x8c811234, 0x12100841, 0x2304ad10, 
	0x8452100b, 0x522d04b1, 0x10854214, 0x48404988, 0x0e000000, 0x00000000, 
	0x19002500, 0x9d00700a, 0xd0094026, 0x00918076, 0x02900940, 0x2700bd80, 
	0xc402100b, 0x402c10b9, 0x00c40200, 0x09406320, 0x06000000, 0x00000000, 
	0x05202500, 0x9f087822, 0xf048c024, 0x4095067c, 0x02308981, 0x27049f00, 
	0x4d021408, 0x40210083, 0x004c0234, 0x09c01500, 0x0e000000, 0x00000000, 
	0x12002500, 0x9f817c06, 0xf059c027, 0x809f003e, 0x02f019c0, 0xe7009f00, 
	0x7c02f009, 0xc027009f, 0x007c0271, 0x09c25a00, 0x06000000, 0x00000000, 
	0x10000500, 0x13007c00, 0xf0a1c004, 0x001f204c, 0x003221d0, 0x84001300, 
	0x4d003001, 0xc0044013, 0x004d0030, 0x01c05100, 0x04000000, 0x00000000, 
	0x10011440, 0x51057401, 0x70054015, 0x00578044, 0x01105740, 0x14005500, 
	0x44011105, 0x40540055, 0x00450150, 0x17017004, 0x02000000, 0x00000000, 
	0x00203000, 0xc1403603, 0xd0084034, 0x00cd0024, 0x03101c41, 0x3100d900, 
	0x4403100c, 0x403000c1, 0x81440358, 0x05405100, 0x0a000000, 0x00000000, 
	0x90007002, 0xe100b413, 0x500f4039, 0x10fd05e4, 0x13101f40, 0x7d106d00, 
	0xc400140e, 0x403804e5, 0x02840050, 0x0e421402, 0x02000000, 0x00000000, 
	0x100178b1, 0xe301bc1f, 0xf01ec878, 0x15ef0dad, 0x0f341ec2, 0x5900fb01, 
	0x8c07301f, 0xd05c0073, 0x01cd0770, 0x1fc05544, 0x00000000, 0x00000000, 
	0x1428b540, 0xdf007c07, 0xf00dc0b7, 0x0bd7061c, 0x5bf00dc4, 0x16005700, 
	0x7c00f00d, 0xc015005f, 0x407d00f0, 0x0dc04360, 0x06000000, 0x00000000, 
	0x0221fd48, 0xf381ec07, 0x301fc87c, 0x10f391cc, 0x87301b40, 0x7f02f321, 
	0x8c07301f, 0x806f00b3, 0x018c2731, 0x13c00f04, 0x0e000000, 0x00000000, 
	0x15003909, 0xe100f403, 0xb00ac13a, 0x04e11084, 0x93100240, 0x3b0f7108, 
	0x8400310e, 0x402b0aa1, 0x08843010, 0x8a405720, 0x06000000, 0x00000000, 
	0x1d023910, 0xe110a40b, 0x900c4038, 0x00e500c4, 0x03118a40, 0x1b00e100, 
	0xc403908e, 0x400b0021, 0x00e40318, 0x0a402300, 0x04000000, 0x00000000, 
	0x02203120, 0x81013403, 0x981c4072, 0x10d50005, 0x03110040, 0x93015100, 
	0x0500150d, 0x40070001, 0x00250018, 0x08405b20, 0x0c000000, 0x00000000, 
	0x11203d20, 0x9341ac17, 0xb01cc03c, 0x00f700c6, 0x03365840, 0xf3409100, 
	0x4c03b001, 0xc03748c1, 0x00640330, 0x05c07f20, 0x06000000, 0x00000000, 
	0x09003500, 0x9f007403, 0xf00dc237, 0x00da003c, 0x03f029c1, 0x37001f00, 
	0x7c00f001, 0xc03700df, 0x005c00f0, 0x0dc40700, 0x0c000000, 0x00000000, 
	0x80023900, 0xb308fc03, 0x304bc03c, 0x00d600cc, 0x033403c0, 0x1e00b308, 
	0xcc03b083, 0xc01c0073, 0x00cc0330, 0x0fc00820, 0x0c000000, 0x00000000, 
	0x83293408, 0x91007403, 0x141d4231, 0x00d1c044, 0x83125140, 0x14001500, 
	0x44001421, 0x40150055, 0x00140011, 0x18400400, 0x08000000, 0x00000000, 
	0x00203408, 0x91007403, 0x100d4034, 0x00d50045, 0x03101940, 0x36009100, 
	0x04039021, 0x40241091, 0x00440310, 0x11400000, 0x02000000, 0x00000000, 
	0x10283000, 0x81007403, 0x100d4035, 0x00c50004, 0x03100144, 0x34000500, 
	0x05001000, 0x54210095, 0x00540010, 0x09404080, 0x00000000, 0x00000000, 
	0x01803a00, 0x93007c03, 0x300dc038, 0x00f700ce, 0x033201e0, 0x12009300, 
	0x4c03b001, 0xc0000003, 0x004c0330, 0x09d004c0, 0x0a000000, 0x00000000, 
	0x00a93f40, 0xff80fc03, 0xf00bc03f, 0x00fb00bc, 0x03f003e4, 0x1f003f00, 
	0xfc00f003, 0xc40f003f, 0x00fc00f0, 0x0bc01360, 0x0e000000, 0x00000000, 
	0x03a80f00, 0x3f00fc93, 0xf04fc83e, 0x01ff00cd, 0x003003c0, 0xbe01ff45, 
	0xec13f10f, 0xc03e0033, 0x04fc5330, 0x83c00b00, 0x0e000000, 0x00000000, 
	0x01100710, 0x1d00f423, 0xd02f403c, 0x02fd0244, 0x01140142, 0xbf09fd12, 
	0x4523d02d, 0x403c06d5, 0x0ef44b50, 0xe1400f20, 0x0c000000, 0x00000000, 
	0x11a80300, 0x05003403, 0xd02c4033, 0x00cd0844, 0x05100040, 0xb380cd06, 
	0x04d3d028, 0x40300101, 0x10341310, 0x0c404580, 0x0e000000, 0x00000000, 
	0x03a01c00, 0x9d807403, 0xd00d4835, 0x00dd0044, 0x01130548, 0x3700dd00, 
	0x4503c019, 0x403008d5, 0x00348350, 0x0d400b20, 0x06000000, 0x00000000, 
	0x02a08704, 0x5f207403, 0xf20dc036, 0x20cf004d, 0x013001c0, 0x3708df20, 
	0x6c03f26d, 0xc2360013, 0x307c0330, 0x91c00322, 0x0a000000, 0x00000000, 
	0x0780cd00, 0x7f027c03, 0xf00f4036, 0x00ff00fc, 0x13f22fc0, 0x3f00fd00, 
	0xfc03f00f, 0xc03f00df, 0x04fc03f0, 0x13c01f02, 0x06000000, 0x00000000, 
	0x02008504, 0x77c04c23, 0x318cc037, 0x41d3104c, 0x23f009c0, 0x3710c300, 
	0x7c037059, 0xc035021f, 0x004c03f0, 0x0d40ab20, 0x04000000, 0x00000000, 
	0x13a00400, 0xd100c503, 0x002f40bf, 0x01f10404, 0x2bd2ad40, 0x3f00f100, 
	0xc403102d, 0x4afc00dd, 0x00c463d1, 0x0d424f00, 0x02000000, 0x00000000, 
	0x07a08200, 0x4500041f, 0x541c4132, 0x00c90104, 0x85d02044, 0x3300c900, 
	0x24035005, 0x52f104cd, 0x400407d0, 0x0c401f00, 0x0a000000, 0x00000000, 
	0x04804804, 0x41058407, 0x501e4c7b, 0x00e90981, 0x07d01a44, 0x7310c921, 
	0x80071014, 0x4078a0ed, 0x018407d0, 0x9e403f00, 0x02000000, 0x00000000, 
	0x12002000, 0x47200c03, 0x700cc033, 0x00cb080c, 0x23f00cc8, 0x3340cb80, 
	0x6803700c, 0xc03100cf, 0x240c13f0, 0x0cc04b40, 0x00000000, 0x00000000, 
	0x02a80900, 0xff04fc4b, 0xb0afc03f, 0x02e78afc, 0x03f00fc0, 0xbf00f750, 
	0xfc03b00f, 0x803f00ff, 0x00f403f0, 0x0fc20b60, 0x06000000, 0x00000000, 
	0x15a00700, 0x7f004c0b, 0xf0cdc034, 0x46d3004e, 0x017015c0, 0xb401d326, 
	0x7c03f00d, 0xd03408db, 0x407c33f0, 0x0dc05400, 0x0e000000, 0x00000000, 
	0x12880900, 0x6d008413, 0xc00c4030, 0x81e10486, 0x83d00ec0, 0x3e01e514, 
	0xb403d00e, 0x503804ed, 0x00b443d0, 0x0e424d24, 0x06000000, 0x00000000, 
	0x03004900, 0x4d018407, 0xd05e427a, 0x88e50da5, 0x47501e40, 0x7a03e101, 
	0xb407d83e, 0x407803e1, 0x01b417d0, 0x1e400402, 0x04000000, 0x00000000, 
	0x12284302, 0xdd010403, 0xd10c5832, 0x00c10024, 0x03d0bc40, 0x3220c500, 
	0x3403d00d, 0x403000cd, 0x003403d0, 0x0c404920, 0x0c000000, 0x00000000, 
	0x17a8dd00, 0x7f054d01, 0xf005c816, 0x205100ec, 0x097117c0, 0x16005300, 
	0x7c01f017, 0xc814087b, 0x007c01f0, 0x07c05c20, 0x06000000, 0x00000000, 
	0x12000300, 0x1f003c08, 0xd001c005, 0x000f005c, 0x04f041c0, 0x07001f00, 
	0x7c00f011, 0xc087000d, 0x803c08f0, 0x00c04b00, 0x0c000000, 0x00000000, 
	0x10082704, 0x93004c02, 0x7889c864, 0x009b004c, 0x027019c0, 0x26008300, 
	0x4c02f019, 0xc0600093, 0xa04c8630, 0x09504020, 0x0c000000, 0x00000000, 
	0x01206600, 0x9100444a, 0x12285060, 0x00912944, 0x0ef0b940, 0x27009b00, 
	0x6c02d099, 0x40a40091, 0x00446210, 0x09400400, 0x08000000, 0x00000000, 
	0x18a02442, 0x91004402, 0x50094124, 0x16980044, 0x46d00d60, 0x22009100, 
	0x4602d009, 0x40240291, 0x20450210, 0x0d406100, 0x02000000, 0x00000000, 
	0x10202000, 0x81040412, 0x10086020, 0x24c14004, 0x02d11840, 0xa301890c, 
	0x2422d038, 0x50200581, 0x1404f214, 0x48514180, 0x00000000, 0x00000000, 
	0x1db00600, 0x11184d00, 0x50014804, 0x811b004c, 0x007801c0, 0xc6001313, 
	0x4d18d060, 0xc0140113, 0x044c1030, 0x40c475c0, 0x08000000, 0x00000000, 
	0x19b8af10, 0xbf007c0a, 0xf089c827, 0x288f08fd, 0x82700ac0, 0xe7009f01, 
	0x5c0af02b, 0xc02744bd, 0x347c12f0, 0x4bc166e4, 0x06000000, 0x00000000, 
	0x18a02f00, 0x9b00bc42, 0x304b482e, 0x11bf048c, 0x02b10bc0, 0x27019f10, 
	0x6c06308b, 0xc0ac009f, 0xa0cccaf8, 0x89c06700, 0x0e000000, 0x00000000, 
	0x1c081700, 0x11027408, 0x10214404, 0x001d0254, 0x01d00140, 0x07001d02, 
	0x547c50a1, 0xc086031d, 0x0e4418d0, 0x01407322, 0x0c000000, 0x00000000, 
	0x10a02708, 0x8d163402, 0x502840a0, 0x08850804, 0x02d20848, 0xa3048d14, 
	0x04021049, 0x4020008d, 0x101402d0, 0x68404b80, 0x0e000000, 0x00000000, 
	0x18a82510, 0x91807402, 0x52094024, 0x00990054, 0x02d00940, 0x27008d00, 
	0x54025049, 0x4026089d, 0xa05682d0, 0x49416320, 0x06000000, 0x00000000, 
	0x05a86320, 0x9b847c02, 0x7009c024, 0x309f804c, 0x0ab029c1, 0x27009f20, 
	0x4c023028, 0xc124009f, 0x005d02d0, 0x29c01720, 0x0e000000, 0x00000000, 
	0x14802505, 0x9d003c02, 0xb408d027, 0x009d207c, 0x22f089c0, 0x27009f00, 
	0x3c02f009, 0xc027009e, 0x006c42f0, 0x09c05b00, 0x06000000, 0x00000000, 
	0x14088500, 0x13024c04, 0x7081d145, 0x000f005c, 0x043411c0, 0x07001f20, 
	0x5c00f001, 0xc0440007, 0x004d00f0, 0x01c25020, 0x04000000, 0x00000000, 
	0x14801c00, 0x5180c40d, 0xb02740dc, 0x047d31c4, 0x89b02748, 0x17005d00, 
	0x4501d017, 0x405c085a, 0x00c415d0, 0x05405000, 0x02000000, 0x00000000, 
	0x14a00200, 0xc1400403, 0x001c6030, 0x00c91234, 0x07100c48, 0x3320cd00, 
	0x1503d010, 0x507000c1, 0x00200fd0, 0x0c605000, 0x0a000000, 0x00000000, 
	0x0580084c, 0xe10d8408, 0x900c6038, 0x00cd00e4, 0x45820641, 0x3b02cd0c, 
	0x9403d10a, 0x417814e8, 0x04a403d0, 0x9e401400, 0x02000000, 0x00000000, 
	0x15104000, 0xf1018d05, 0x301ec078, 0xa0ef01bc, 0x051416c0, 0x7b23ef05, 
	0x9e07f01c, 0xc07c00f6, 0xc5ac07f1, 0x5fd05440, 0x00000000, 0x00000000, 
	0x10b00500, 0xdf007400, 0xf009c036, 0x809f005c, 0x01d805e8, 0x3700df12, 
	0x6e03f10d, 0xc02700df, 0x105c02f0, 0x2dc04360, 0x06000000, 0x00000000, 
	0x00a04f20, 0xf381dd05, 0xf11fc07f, 0x20ff81cc, 0x05f192c0, 0x7c02f301, 
	0xec07d013, 0xc07e00fb, 0x11cc0730, 0x3fc00800, 0x0e000000, 0x00000000, 
	0x15800902, 0xeb208420, 0xf02e403b, 0x80ed0094, 0x89d00240, 0x3800e100, 
	0x8c03d04a, 0x403882e1, 0x00840314, 0x0e405420, 0x06000000, 0x00000000, 
	0x00080c04, 0xe1008401, 0xd086401b, 0x00ed0084, 0x00d00348, 0x3800c100, 
	0xa403d00c, 0x401200e1, 0x00840110, 0x0e402000, 0x04000000, 0x00000000, 
	0x04284300, 0xc9020400, 0x58004413, 0x188d8014, 0x08d03048, 0x3000d100, 
	0x0403d01d, 0x400280c1, 0x0a450012, 0x0c405820, 0x0c000000, 0x00000000, 
	0x15a8e500, 0xf3604c01, 0xd00cc033, 0x00df004c, 0x29d06dd0, 0x3c40f300, 
	0xec03d04d, 0xd03640fb, 0x004c0310, 0x0fd05420, 0x06000000, 0x00000000, 
	0x01009701, 0xdf002808, 0xf025c217, 0x10dd027c, 0x28f045c0, 0x3710df00, 
	0x7c03f009, 0xc09500df, 0x007c01f0, 0x0dc02700, 0x0c000000, 0x00000000, 
	0x80082f00, 0xcb10ce01, 0x305fc07c, 0x08e720cc, 0x0db013e0, 0x3700ff00, 
	0xcc03f007, 0xc0fc00df, 0x105c0330, 0x0dc00320, 0x0c000000, 0x00000000, 
	0x81208210, 0xd1004444, 0x10214044, 0x40114604, 0x885011c0, 0x3700dd00, 
	0x6c03d0bd, 0x408431dd, 0x404c08b0, 0x0d400700, 0x08000000, 0x00000000, 
	0x01a0c400, 0xd9004410, 0x54094034, 0x01952155, 0x01128142, 0x3700dd20, 
	0x4403d02d, 0x602400cd, 0x20540e10, 0x0d440300, 0x02000000, 0x00000000, 
	0x10200010, 0xc1000400, 0x50004050, 0x00810004, 0x00580040, 0x3100cd00, 
	0x2403d80c, 0x400000cd, 0x00040090, 0x0c484380, 0x00000000, 0x00000000, 
	0x00a00600, 0xdb004500, 0x70014014, 0x00970048, 0x00b00140, 0x3f00fd00, 
	0x4c03f005, 0xd00400ff, 0x805c0038, 0x0fc007c0, 0x0a000000, 0x00000000, 
	0x05a80b00, 0xff00fc00, 0x9003c01f, 0x40af20fc, 0x00f803c0, 0x3f00ff00, 
	0xfc03f00f, 0xc00f00ff, 0x00dc00f8, 0x0fc41360, 0x0e000000, 0x00000000, 
	0x02a82b00, 0x770d8c0b, 0xf04fd13c, 0x0a3f20f0, 0x933003c1, 0x2f007f00, 
	0xcc503042, 0xc20c0123, 0x00cc4030, 0x03100800, 0x0e000000, 0x00000000, 
	0x47113710, 0x5d0f4d80, 0xd02f40b4, 0x011d04f6, 0x23102541, 0x37005d02, 
	0x4400b001, 0x5004001b, 0x00450014, 0xa14b0c20, 0x0c000000, 0x00000000, 
	0x51002190, 0x0d000413, 0xd00c40b0, 0x81051034, 0x03964860, 0x33104d02, 
	0x04005028, 0x40100a41, 0x08140010, 0x48444480, 0x0e000000, 0x00000000, 
	0x06203580, 0x0d006402, 0xd80d4034, 0x809d0174, 0x03906d42, 0x27005d00, 
	0x4420d009, 0x40140459, 0x00542010, 0x09600820, 0x06000000, 0x00000000, 
	0x80a86700, 0x57024c4b, 0xf00de034, 0x001f2374, 0x03b031c0, 0x7702df00, 
	0x0d147011, 0xc0840093, 0x005d0634, 0x10408422, 0x0e000000, 0x00000000, 
	0x87007d02, 0x7e00dc88, 0xf00dc03f, 0x003f00bc, 0x037007c0, 0x3f00ff00, 
	0x7c04b093, 0xc00700bf, 0x006c06f0, 0x93c01f02, 0x06000000, 0x00000000, 
	0x2e082510, 0x5b124d03, 0x300dc434, 0x009f007c, 0x333009c0, 0x3700cf00, 
	0x7c003408, 0xc09400c3, 0x000c0234, 0x09c10a20, 0x04000000, 0x00000000, 
	0x13202401, 0x5a824400, 0x002f483d, 0x009d80f4, 0x0f120d40, 0x3700dd00, 
	0x76004419, 0x405100d5, 0x00540254, 0x29d06e00, 0x02000000, 0x00000000, 
	0x03207000, 0x418a2403, 0x900d4930, 0x000d0034, 0x03100c40, 0x33004d00, 
	0x34031084, 0x40200201, 0x00040110, 0x24401c00, 0x0a000000, 0x00000000, 
	0x8b027843, 0x6901e407, 0x941e4078, 0x00ad2134, 0x07101e40, 0xfb006d03, 
	0xb42f5036, 0x40690025, 0x03942d50, 0x96403e00, 0x02000000, 0x00000000, 
	0x12003001, 0x13822c03, 0xb20cc830, 0xa04f083c, 0x03340cc0, 0x33024f00, 
	0x3423310c, 0xc0300143, 0x000c0130, 0x8dc44840, 0x00000000, 0x00000000, 
	0x02183d01, 0x3708dc03, 0x700fc03f, 0x00ff20fc, 0x03f00fc0, 0x3f207f00, 
	0xfc23f08f, 0xc03f007f, 0x00fc01f8, 0x8fe00b64, 0x06000000, 0x00000000, 
	0x10287510, 0xd3007c03, 0xf04dc137, 0x029f007c, 0x13f00dd0, 0x2400df00, 
	0x0c033005, 0xc0240083, 0x800c0332, 0x05c25400, 0x0e000000, 0x00000000, 
	0x13012900, 0xe100b401, 0xd04e403b, 0x01ad00b4, 0x53d00f40, 0x3800cd00, 
	0xac03b006, 0xc02200a1, 0x00ac03b0, 0x06684c24, 0x06000000, 0x00000000, 
	0x8000718c, 0xe501b407, 0xd89e407b, 0x00ed01b4, 0x27501e40, 0x7800ed01, 
	0x8607101c, 0x407800e1, 0x01840710, 0x1c404402, 0x04000000, 0x00000000, 
	0x12283120, 0xc5213411, 0xc00c4033, 0x10cd0234, 0x03d00c40, 0x6000cd00, 
	0x2403910c, 0x503200c9, 0x00240390, 0x0c044820, 0x0c000000, 0x00000000, 
	0x13281540, 0x7785bc01, 0xf005c017, 0x007f027c, 0x01f007c2, 0x14014f02, 
	0x4c013005, 0xd8144853, 0x424c0930, 0x05d05c24, 0x06000000, 0x00000000, 
	0x12000500, 0x09067c00, 0xe021c007, 0x001f447c, 0x00f001c0, 0x07101f10, 
	0x7c00f000, 0xc0870007, 0x503c40f1, 0x20c04b00, 0x0c000000, 0x00000000, 
	0x10082500, 0x9f004c02, 0x3409c027, 0x009f007c, 0x22f008c0, 0x24009f00, 
	0x0c023209, 0xc0240093, 0x004c0230, 0x09c00020, 0x0c000000, 0x00000000, 
	0x1120a401, 0x9d084402, 0x10094027, 0x009d0074, 0x02d00940, 0x25009d00, 
	0x44021009, 0x40a10495, 0x00540214, 0x09c10700, 0x08000000, 0x00000000, 
	0x18202402, 0x9dc04402, 0x12194027, 0x00dd4074, 0x02d20944, 0x24009d01, 
	0xc406140b, 0x402c00b1, 0x01c40210, 0x0b406000, 0x02000000, 0x00000000, 
	0x10202000, 0xcda84422, 0x10484022, 0x008d1434, 0x02d04840, 0x21008d14, 
	0x8512104a, 0x502900a5, 0x14944210, 0x6a544380, 0x00000000, 0x00000000, 
	0x3b000405, 0x1f164d08, 0x3025c087, 0x051f027c, 0x11f021c0, 0x04001f00, 
	0x44403001, 0xc1040113, 0x004c1030, 0x23c174c0, 0x0a000000, 0x00000000, 
	0x19b92f08, 0xbf24fc17, 0xf069c127, 0x04bf147c, 0x0af02bc1, 0x2f009f80, 
	0x7c02f009, 0xc0a7009f, 0x007c02f0, 0x09c06f64, 0x0e000000, 0x00000000, 
	0x19b02f04, 0xbf107c22, 0xf06bc025, 0x059318fc, 0x12f849c0, 0x24009f05, 
	0x50163059, 0xc0640193, 0x054c1630, 0x5be06400, 0x0e000000, 0x00000000, 
	0xb8008508, 0x1d127400, 0xd0414004, 0x011b0474, 0x08d02060, 0x04101d42, 
	0x440810a1, 0x4485101b, 0x40c40031, 0x01607822, 0x0c000000, 0x00000000, 
	0x12202100, 0x8d003402, 0xd0884020, 0x05818434, 0x8ad02941, 0x2000ad02, 
	0x840a100a, 0x40a800a1, 0x02840a10, 0x68654880, 0x0e000000, 0x00000000, 
	0x19202520, 0x9d007402, 0xd0094024, 0x60910476, 0x02d10951, 0x6520bda0, 
	0xc402102b, 0x402d00b8, 0x00c40210, 0x29406020, 0x06000000, 0x00000000, 
	0x15202510, 0x9f407c0a, 0xf0094024, 0x0091077c, 0x02d00940, 0x24008f00, 
	0x45023409, 0x40244093, 0x004d0234, 0x09501420, 0x0e000000, 0x00000000, 
	0x56006502, 0x9f027c02, 0xf009d826, 0x009f007c, 0x02f209c0, 0x26109f00, 
	0x7c02f009, 0xc067018f, 0x053c0270, 0x08c01b01, 0x06000000, 0x00000000, 
	0x14004500, 0x140c7c08, 0xf000e007, 0x001f804c, 0x00f221c0, 0x04001f80, 
	0x0c003001, 0xc0025013, 0x004c2030, 0x01e85020, 0x04000000, 0x00000000, 
	0x1028dc00, 0x77007401, 0xd0274017, 0x085d00c4, 0x6dd20448, 0x14105d00, 
	0x4d015004, 0xc0140051, 0x00540150, 0xa7415100, 0x02000000, 0x00000000, 
	0x10217000, 0xc5803403, 0xc02c4137, 0x00cd0024, 0x0fd20c48, 0x3000cd20, 
	0x0403100c, 0x403200c5, 0x00040710, 0x04465204, 0x0a000000, 0x00000000, 
	0x8002b900, 0xe500b413, 0xd00e483b, 0x01cc05a4, 0x03da4e40, 0x18806d00, 
	0xa4015002, 0x40220045, 0x00940150, 0x0c405502, 0x02000000, 0x00000000, 
	0x10017800, 0x2701bc0f, 0xf01a407b, 0x21ef01a5, 0x07f23ed1, 0x78008f01, 
	0x0c06301c, 0xc05a40a7, 0x010d0730, 0x16c05644, 0x00000000, 0x00000000, 
	0x10082500, 0x9f007c07, 0xf021c037, 0x08de085c, 0x03f06dc0, 0x17001d00, 
	0x5c00f001, 0xc005001b, 0x007c01f0, 0x05c04160, 0x06000000, 0x00000000, 
	0x42285d00, 0x7b09cc27, 0x303fc07c, 0x04f3038c, 0x07701fc0, 0x7c20ef01, 
	0x8807301f, 0xc07800e3, 0x01cc0630, 0x12c00c01, 0x0e000000, 0x00000000, 
	0x15001900, 0x6d20c403, 0x108ec03a, 0x00fb048c, 0x81b00e40, 0x18106700, 
	0x84011002, 0x40280061, 0x00840010, 0x82405420, 0x06000000, 0x00000000, 
	0x89011900, 0x2d808403, 0x181a4038, 0x00e96284, 0x02500f41, 0x3800bd00, 
	0xc402100f, 0x401c00b9, 0x00d40210, 0x03406104, 0x04000000, 0x00000000, 
	0x02280188, 0x8d004443, 0x10004830, 0x00c10024, 0x00101c40, 0x100005c0, 
	0x04001000, 0x40000009, 0x00140010, 0x00401920, 0x0c000000, 0x00000000, 
	0x19206509, 0xdf00c50f, 0x3409503c, 0x00f9204c, 0x03501fd0, 0x7400dd00, 
	0x4c03300c, 0xc03400db, 0x001c0330, 0x05c05d20, 0x06000000, 0x00000000, 
	0x01082500, 0x9f027c23, 0xf009c237, 0x28df005d, 0x02f00ce0, 0x57004f00, 
	0x6c01f001, 0xc0273057, 0x006c01f0, 0x25802600, 0x0c000000, 0x00000000, 
	0x800a5910, 0xc301cc03, 0x300b4035, 0x00ff00ce, 0x15300fc0, 0x3c00b340, 
	0xce02300f, 0xc01c00b3, 0x00cc0330, 0x37c00820, 0x0c000000, 0x00000000, 
	0x8b20c404, 0x91084403, 0x51314135, 0x08dc0006, 0x48500d40, 0x10101500, 
	0x06001001, 0xc0020001, 0x00440110, 0x34c10600, 0x08000000, 0x00000000, 
	0x04201402, 0x11106403, 0x10104034, 0x00cc2045, 0x03100d48, 0x3480d180, 
	0x5403120d, 0x403480d1, 0x00440210, 0x05400000, 0x02000000, 0x00000000, 
	0x10201000, 0x01000403, 0x50004031, 0x00cd8004, 0x00400c40, 0x14804500, 
	0x44011001, 0x40260051, 0x00448010, 0x05444280, 0x00000000, 0x00000000, 
	0x05001440, 0x93006d03, 0x3002c234, 0x00ff0044, 0x00200fc0, 0x34809300, 
	0x5502300d, 0xc0140093, 0x004c0230, 0x05c004c0, 0x0a000000, 0x00000000, 
	0x80b80f00, 0xbf00fc03, 0xf003c03f, 0x00ff00fc, 0x00c00ec4, 0x1f203f00, 
	0xfc00f002, 0xc00d003f, 0x00bc00f0, 0x07c01160, 0x0e000000, 0x00000000, 
	0x03a01f00, 0xff20fc00, 0xb006c01c, 0x00bf08ec, 0x00b04fc0, 0x1b00f300, 
	0xfc02b0c3, 0xc0ac01b3, 0x00fc0830, 0xcfc00f00, 0x0e000000, 0x00000000, 
	0x01080701, 0xdd007410, 0x1005c016, 0x05dd0044, 0x50d2a144, 0x1441d106, 
	0x741210e1, 0x40ac0201, 0x12342a10, 0x6f400720, 0x0c000000, 0x00000000, 
	0x11a01304, 0x4d003442, 0x90044810, 0x099d4424, 0x00900d40, 0x1624c112, 
	0x34421000, 0x402001c1, 0x86341010, 0x8c404780, 0x0e000000, 0x00000000, 
	0x03a80500, 0xdd007403, 0x10054036, 0x00dd3044, 0x28d30d42, 0x9500d100, 
	0x74021020, 0x52200951, 0x20740210, 0x0d400f20, 0x06000000, 0x00000000, 
	0x02a81701, 0x9f007c10, 0xb000c054, 0x005f026c, 0x08b00dc4, 0xd620d300, 
	0x7806309d, 0xc0740093, 0x0a7c0734, 0x0dc00b20, 0x0e000000, 0x00000000, 
	0x07800d00, 0xbf84fc25, 0xf03fc07f, 0x02ff05fc, 0x01f20bc0, 0x5e21ff10, 
	0xbc0ef40f, 0xc03f003f, 0x00fc27f0, 0x0dc01f00, 0x06000000, 0x00000000, 
	0x0208b504, 0x93015c02, 0x7005c095, 0x00d3024c, 0x09700dc0, 0x3501d380, 
	0x4c82f02d, 0xc03400ff, 0x020c0330, 0x0dc40820, 0x04000000, 0x00000000, 
	0x13a01400, 0x91014003, 0x100d4034, 0x00c10044, 0x01104cc4, 0xa200f113, 
	0x4402d10d, 0x40f4135d, 0x006c0310, 0x0f404c00, 0x02000000, 0x00000000, 
	0x07a09200, 0x81005000, 0x50344901, 0x08800004, 0x00501c40, 0xb140c141, 
	0x1402d00c, 0x40a0104d, 0x06040110, 0x0c401c00, 0x0a000000, 0x00000000, 
	0x04804800, 0xa1038406, 0x10174558, 0x08a10984, 0x05101340, 0x7e00e101, 
	0x9406d01e, 0x4068006d, 0x11a40710, 0x3e401000, 0x02000000, 0x00000000, 
	0x12101408, 0x83085403, 0x7004c0b5, 0x0893084c, 0x21700c48, 0x3100d300, 
	0x1d02f00d, 0xd030004f, 0x000c1132, 0x0cd04840, 0x00000000, 0x00000000, 
	0x02b00d00, 0xaf28fc03, 0xf007c03f, 0x02fd88fc, 0x01f08ec0, 0x3f42ff00, 
	0xec22f08f, 0xd03f007f, 0x40fc03f0, 0x8fc10b60, 0x06000000, 0x00000000, 
	0x15a01700, 0x9d007c03, 0xf00dc037, 0x0097404c, 0x00f80dd0, 0x3400d340, 
	0x6c03f00d, 0xc0a4045b, 0x004c03f0, 0x4dc05400, 0x0e000000, 0x00000000, 
	0x12880910, 0xad00b403, 0xd00e403b, 0x20ad0084, 0x01d00a40, 0x3c00e102, 
	0x8403d10c, 0x40201041, 0x408503d2, 0xce404820, 0x06000000, 0x00000000, 
	0x03007904, 0xadc1b407, 0xd11e40fb, 0x00e50185, 0x05d81f40, 0x7800e105, 
	0xa407d01e, 0x507a0069, 0x018407d0, 0x1e400c00, 0x04000000, 0x00000000, 
	0x12287380, 0x8d293483, 0xd01c4073, 0x00cd0604, 0x07d20c60, 0x7410d100, 
	0x4403d02c, 0x40760041, 0x0004b3d0, 0x0d404820, 0x0c000000, 0x00000000, 
	0x17a8dd00, 0x7f02fc15, 0xd067849b, 0x007700cc, 0x1df026c0, 0xdc515300, 
	0x6c41f007, 0xc856017b, 0x00cc05f0, 0x05d05c20, 0x06000000, 0x00000000, 
	0x12004700, 0x1d017840, 0xf011c047, 0x001f087c, 0x04f811c0, 0x47001f00, 
	0x7c00f0a1, 0xd105001f, 0x807c00f0, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x1008a700, 0x9b417c02, 0xf009c027, 0x0093004c, 0x02f009c0, 0x24009300, 
	0x4c023208, 0xc4244083, 0x000d0230, 0x09c24020, 0x0c000000, 0x00000000, 
	0x0120e200, 0x91007402, 0xd0194227, 0x00814044, 0x02d049c0, 0xa4009100, 
	0x44021049, 0x50250091, 0x204402b0, 0x09500400, 0x08000000, 0x00000000, 
	0x18a02404, 0xd9047402, 0xd01d4027, 0x00910044, 0x82d04950, 0x24009100, 
	0x44021409, 0x402402d1, 0x00440210, 0x09406000, 0x02000000, 0x00000000, 
	0x10202002, 0x8100340a, 0xd0184027, 0x80910004, 0x02d24841, 0xe0008100, 
	0x05521048, 0x61210581, 0x16045290, 0x48414080, 0x00000000, 0x00000000, 
	0x1db08600, 0x1b007408, 0xf001c087, 0x4003024c, 0x08f001c0, 0x844051c8, 
	0x4c003241, 0xc0040113, 0x064c1030, 0x40c474c0, 0x0a000000, 0x00000000, 
	0x19b82f00, 0xbf00fc02, 0xf00bc42f, 0x24bf10fd, 0x42f20ad4, 0x2d008f48, 
	0xfc52f04b, 0xc12f05bf, 0x40fc52f0, 0x49c16760, 0x0e000000, 0x00000000, 
	0x18a02f00, 0xaf007c0a, 0x700bc0a6, 0x109f4270, 0x0af84ac1, 0x2c10b702, 
	0x4c02300b, 0xc02c44b3, 0x006c4234, 0x2bc06300, 0x0e000000, 0x00000000, 
	0x1c080701, 0x5d007401, 0x10014003, 0x011d0074, 0x00d02144, 0x04011d00, 
	0x44101041, 0xc006011b, 0x0e441810, 0x01407320, 0x0c000000, 0x00000000, 
	0x10a06304, 0x8d007612, 0x500c4021, 0x018d0434, 0x16d80840, 0x210c8502, 
	0x044a1128, 0x49200481, 0x10244210, 0x28404380, 0x0e000000, 0x00000000, 
	0x18a82580, 0x9d007602, 0x10096027, 0x049d0476, 0x02c01954, 0xa4009d00, 
	0x44021c09, 0x402600d1, 0x44440210, 0x09406320, 0x06000000, 0x00000000, 
	0x05a82700, 0x9f423c2e, 0x7099c065, 0x129f0578, 0x06c229c1, 0x25209700, 
	0x4d021009, 0xc0240091, 0x006c0230, 0x09c41720, 0x0e000000, 0x00000000, 
	0x14806502, 0x9f007c02, 0xf019c067, 0x009f007c, 0x22e008c0, 0xe7049f00, 
	0x7c02f008, 0xc063029f, 0x417c02f0, 0x09c05300, 0x06000000, 0x00000000, 
	0x14080506, 0x1f014c00, 0x7011c807, 0x4017007c, 0x00f131c2, 0x05401301, 
	0x4c00f001, 0xc004001f, 0x004d00f0, 0x81c05020, 0x04000000, 0x00000000, 
	0x14a09c00, 0x7d424501, 0x10274a17, 0x00518074, 0x01f03740, 0xdc407303, 
	0x4401d017, 0x501c007d, 0x204401d0, 0x17425000, 0x02000000, 0x00000000, 
	0x14a06200, 0xcd002403, 0x500c6033, 0x00c10036, 0x03901c40, 0xf102d101, 
	0x4403d01c, 0x40b004dd, 0x004403d0, 0x1c405000, 0x0a000000, 0x00000000, 
	0x05800800, 0x3d01a413, 0x1002607b, 0x00e104b4, 0x13d00e41, 0x7800a910, 
	0x8403d00c, 0x413810ed, 0x608403d0, 0x1e401400, 0x02000000, 0x00000000, 
	0x15104800, 0xed01ed17, 0x5012c07b, 0x04e309bc, 0x17f01ec0, 0x7d20f301, 
	0x8d0ff01e, 0xc07800cf, 0x018c27f2, 0x1cd05440, 0x00000000, 0x00000000, 
	0x10b80508, 0x1f405c23, 0xf001c437, 0x03dc087c, 0x03710dc0, 0x37001700, 
	0x7c03f00d, 0xc02730df, 0x407c1bf0, 0x0dc04360, 0x06000000, 0x00000000, 
	0x00a07f00, 0x7f018407, 0xb017c07f, 0x0afb09fc, 0x47d01bc0, 0x7c00ff01, 
	0xcc07f01f, 0xc07c00ff, 0x89cc6720, 0x1fc00000, 0x0e000000, 0x00000000, 
	0x15803900, 0x2d028413, 0x1802413b, 0x07e100b4, 0x03d84e41, 0x1800fd00, 
	0x8403d00e, 0xc01a10ef, 0x0c840310, 0x0f405420, 0x06000000, 0x00000000, 
	0x00080900, 0x6d00c403, 0x10a2403f, 0x60e900b6, 0x23d00640, 0x3800ed00, 
	0xa403d00e, 0x403800cd, 0x8004831c, 0x0e400000, 0x04000000, 0x00000000, 
	0x04280311, 0x0d86050f, 0x10004073, 0x00c10134, 0x07d00441, 0x14004d00, 
	0x2403d00c, 0x400200cd, 0x00044310, 0x0c401020, 0x0c000000, 0x00000000, 
	0x15a8e104, 0xdf008c1f, 0x3414c0ff, 0x40eb0db4, 0x47d00d50, 0x2400dd00, 
	0xec03f00d, 0x500400df, 0x00cd0b30, 0x0dc05420, 0x06000000, 0x00000000, 
	0x01000700, 0x9f007c03, 0x7021c037, 0x01df007c, 0x13f00dc0, 0x67089e02, 
	0x5c03f00d, 0xc0950017, 0x127c03f0, 0x05c00700, 0x0c000000, 0x00000000, 
	0x80080f02, 0xbb80fc43, 0x3043c83c, 0x00ff00ec, 0x03b04cc0, 0x0c20e300, 
	0x8c033496, 0xc04c01ef, 0x03cc03f0, 0x8fc00022, 0x0c000000, 0x00000000, 
	0x81204650, 0x91017403, 0x52014834, 0x18dd404c, 0x03100d40, 0xc4001112, 
	0x44031035, 0x4044001d, 0x024403d0, 0x25400402, 0x08000000, 0x00000000, 
	0x01a02400, 0x51047403, 0x18014134, 0x00dd0064, 0x03900d40, 0x74845100, 
	0x44031029, 0x40a400dd, 0x004403d0, 0x28400400, 0x02000000, 0x00000000, 
	0x10202400, 0x01007403, 0x50016030, 0x00dd0064, 0x03100c42, 0x10404100, 
	0x05031208, 0x4010000d, 0x000403d0, 0x00504080, 0x00000000, 0x00000000, 
	0x00a00600, 0x13207c03, 0x3001d03c, 0x20ff006e, 0x03b005c0, 0x14005300, 
	0x4d033000, 0xc02400df, 0x00cd03f0, 0x09c000c0, 0x0a000000, 0x00000000, 
	0x05880f10, 0x2f00fc03, 0xf103c03b, 0x00ff00de, 0x03f807e6, 0x1f007f00, 
	0xfc03f003, 0xe00f003f, 0x00fc03f0, 0x03c01760, 0x0e000000, 0x00000000, 
	0x03a03f00, 0x730dcc08, 0x3003ca0f, 0x013bc0fc, 0x80f0cec2, 0x0f007302, 
	0xfc003043, 0xc00c0133, 0x08cc2030, 0x03d20e20, 0x0e000000, 0x00000000, 
	0x01087715, 0x918e4401, 0x30054003, 0x061d9074, 0x00d06f40, 0x07015b06, 
	0x74f81081, 0xc1a60011, 0x026c18b0, 0x89400460, 0x0c000000, 0x00000000, 
	0x11a03300, 0x41041513, 0x100c4023, 0x090d0034, 0x01d06c40, 0x0305c10c, 
	0x14101000, 0x40004f45, 0x06070812, 0x004c4780, 0x0e000000, 0x00000000, 
	0x03a83500, 0x1100d403, 0x900d4227, 0x009d3174, 0x09d00d00, 0xc300d900, 
	0x74401001, 0x40260045, 0x10642093, 0x09400d00, 0x06000000, 0x00000000, 
	0x02a8d740, 0x53005c10, 0x3031c017, 0x001b017c, 0x06f00dc0, 0x87085300, 
	0x7c093451, 0xd0400017, 0x024c063c, 0x05c00300, 0x0e000000, 0x00000000, 
	0x07805512, 0xff08ac01, 0x7493c1df, 0x083f00fc, 0x0ef00fc1, 0x2f007f00, 
	0xbc81f092, 0xc06f023b, 0x007c06f1, 0x0dc01e02, 0x06000000, 0x00000000, 
	0x02089140, 0xd3004c03, 0xf031c0b7, 0x0093027c, 0x40f00dd0, 0x1400db00, 
	0x7c093001, 0xc0040053, 0x060d0234, 0x05c30800, 0x04000000, 0x00000000, 
	0x13a01400, 0xd1004403, 0xd0194637, 0x00902074, 0x0bd00f40, 0xb402d384, 
	0x442950a1, 0x50244151, 0x034c0250, 0x6c404c00, 0x02000000, 0x00000000, 
	0x07a03200, 0x11000002, 0xd1284033, 0x00000034, 0x0bd02c00, 0x01004900, 
	0x2402100c, 0x40100089, 0x80240110, 0x00401c00, 0x0a000000, 0x00000000, 
	0x04807800, 0x8101a407, 0xd01e407b, 0x00a109b4, 0x07d01e41, 0x4d006101, 
	0x8406505e, 0x407881a9, 0x1184a550, 0x9a401800, 0x02000000, 0x00000000, 
	0x1210b001, 0x03000d03, 0xd00cc033, 0x4143003c, 0x11f04c40, 0x0102db20, 
	0x7c02300c, 0xc01000db, 0x002c0130, 0x00d04840, 0x00000000, 0x00000000, 
	0x02b83d00, 0x3f00dc03, 0xf08fc03f, 0x00ff00fc, 0x03f00fc1, 0x0a00ff08, 
	0xfc22f04e, 0xc03b81f7, 0x08fc81f0, 0x0bc40b60, 0x06000000, 0x00000000, 
	0x15a02700, 0x13007c02, 0x7011c036, 0x0093004d, 0x02f04dc0, 0x34005f00, 
	0x4c03300d, 0xc0140093, 0x00440330, 0x04c85400, 0x0e000000, 0x00000000, 
	0x12882808, 0xe100b403, 0xd00f4638, 0x00a10084, 0x83d1cf40, 0x38006d00, 
	0x2c03b00e, 0xc03a088b, 0x00940310, 0x0e404920, 0x06000000, 0x00000000, 
	0x03006100, 0xa101b407, 0xd0364070, 0x04e10184, 0x04501e40, 0xf800ed01, 
	0x8407101c, 0x405000e1, 0x01840711, 0x16680c02, 0x00000000, 0x00000000, 
	0x1228a30b, 0xc1293003, 0xd00c4434, 0x00d10204, 0x4fd00c4a, 0x7000dd00, 
	0x2523920c, 0x403608d9, 0x00540314, 0x9c424924, 0x0c000000, 0x00000000, 
	0x17a8dd40, 0x7342fc01, 0xf007d05e, 0x407302cc, 0x45f005d0, 0xdc005f00, 
	0x4c853405, 0xd0144053, 0x204d0930, 0x04c05c20, 0x06000000, 0x00000000, 
	0x12000300, 0x1f107c00, 0xf061c207, 0x081fa47c, 0x00f001c0, 0x47001f00, 
	0x7c00f001, 0xc007001f, 0x006c40f0, 0x21c04b00, 0x0c000000, 0x00000000, 
	0x10082700, 0x83005802, 0xf009c027, 0x0093004c, 0x02f208c0, 0x24009380, 
	0x4c023009, 0xc0240093, 0x004c0230, 0x09c04120, 0x0c000000, 0x00000000, 
	0x01202600, 0x91004402, 0xd0294027, 0x00910044, 0x0ed00940, 0x24409102, 
	0x54025409, 0x50250095, 0x00540a50, 0xa9400400, 0x08000000, 0x00000000, 
	0x18a02420, 0x91405402, 0xd00d4137, 0x00910044, 0x46d00944, 0x21009110, 
	0x8402100a, 0x402c00b1, 0x00c44210, 0x0b406100, 0x02000000, 0x00000000, 
	0x1020200c, 0x81021422, 0xd0084023, 0x01811405, 0x02d02849, 0x20028108, 
	0x941a506a, 0x40a900a5, 0x06941a54, 0x4e404080, 0x00000000, 0x00000000, 
	0x1db08641, 0x13165c08, 0xf081c087, 0x4003084c, 0x08f061d0, 0x85100306, 
	0x4c083021, 0xc1840113, 0x020c0830, 0x03c075c0, 0x0a000000, 0x00000000, 
	0x19b82f0c, 0xbf20ec1a, 0xf00fc0af, 0x05ff00fc, 0x52f009c0, 0x2f009f22, 
	0x7c0af009, 0xc0a7019c, 0x027c0ad0, 0x29c06760, 0x0e000000, 0x00000000, 
	0x18a02780, 0x9f107c22, 0x300bc027, 0x059f0cfc, 0x02f08bc0, 0x24009f11, 
	0x4c163059, 0xc0640193, 0x054c1630, 0x5a146400, 0x0e000000, 0x00000000, 
	0x1c088704, 0x1d027401, 0x1041c905, 0x011d0c74, 0x40f0a140, 0x40011d07, 
	0x4c5cb0f1, 0xc1c6051b, 0x1fec2c10, 0xa1407122, 0x0c000000, 0x00000000, 
	0x10a02303, 0x8d143402, 0x10484023, 0x0d8d0434, 0x12d04842, 0x2004ad10, 
	0x850a100a, 0x40a800a1, 0x00844214, 0x08504080, 0x0e000000, 0x00000000, 
	0x18a82508, 0x9d007402, 0x100940a5, 0x009d0074, 0x42d00d40, 0x2400bd00, 
	0xc402900b, 0x482e08b9, 0x00e40218, 0x09446120, 0x06000000, 0x00000000, 
	0x05a82700, 0x9d067c0e, 0x342940a7, 0x009fa27c, 0x8af909d0, 0x64009f04, 
	0x4d023009, 0xd0244093, 0x004c0230, 0x09c05424, 0x0e000000, 0x00000000, 
	0x14802500, 0x9f007c0e, 0xf099c025, 0x009f897c, 0x267809c0, 0xa7009f00, 
	0x1c02f009, 0xc027009f, 0x057c02f0, 0x09c81300, 0x06000000, 0x00000000, 
	0x14080500, 0x13c27c08, 0x7001c107, 0x0013007c, 0x182201c0, 0x07001342, 
	0x4c003400, 0xd0040404, 0x006c0030, 0x01c15020, 0x04000000, 0x00000000, 
	0x14a01400, 0x53407401, 0x10074017, 0x005140f4, 0x01521640, 0x17005500, 
	0x54051015, 0x4014005f, 0x00140150, 0x46c05200, 0x02000000, 0x00000000, 
	0x14a03200, 0xc9007403, 0x502c6033, 0x10c10034, 0x03100c40, 0x3300d100, 
	0x0403100c, 0x40b400c1, 0x00240790, 0x08405000, 0x0a000000, 0x00000000, 
	0x05807801, 0xe908b403, 0x100a607f, 0x21e104b4, 0x07520e47, 0x5b00a500, 
	0x94411006, 0x4120800d, 0x001443d0, 0x0a401602, 0x02000000, 0x00000000, 
	0x15107c41, 0xeb013c17, 0x701ec0fb, 0x40e309fc, 0x06101ec0, 0x7b004301, 
	0xc507341f, 0xc07800e3, 0x01ad05b0, 0x1ac05440, 0x00000000, 0x00000000, 
	0x10987502, 0xd7007c03, 0xf001c4b3, 0x05dfce7c, 0x02f00dc0, 0x16001f00, 
	0x7c01f005, 0xc027081f, 0x007c0170, 0x09c84360, 0x06000000, 0x00000000, 
	0x00a07f00, 0xfb01dc47, 0x301fc07d, 0x00f301f8, 0x07f01fc0, 0x7c00f201, 
	0xec06301b, 0xc05c40f3, 0x01c80610, 0x1bc00c00, 0x0e000000, 0x00000000, 
	0x15883d00, 0xfb088403, 0x100a423b, 0x01e108b4, 0x5bd08a40, 0x1800a300, 
	0x84001002, 0x4008002b, 0x00840211, 0x4ac25620, 0x06000000, 0x00000000, 
	0x00003900, 0xe1009443, 0x148e403f, 0x08e100b4, 0x00d00e40, 0x38006900, 
	0x8402100a, 0x401800e1, 0x00840010, 0x0a402008, 0x04000000, 0x00000000, 
	0x04283300, 0xc9000407, 0x10304133, 0x90c18436, 0x0cd00840, 0x90000180, 
	0x04001001, 0x40800009, 0x00040010, 0x2c485a20, 0x0c000000, 0x00000000, 
	0x15a83d00, 0xf307dc07, 0x1019c13d, 0x40f3023c, 0x02f00dd8, 0xb410cb00, 
	0x0c03300d, 0xc03410c3, 0x004c0330, 0x09c07c20, 0x06000000, 0x00000000, 
	0x01003300, 0xdf047c03, 0xf009c033, 0x20df207c, 0x48f024c0, 0x17049f00, 
	0x5c01f005, 0xc023341f, 0x007c03f0, 0x28c50700, 0x0c000000, 0x00000000, 
	0x80083f40, 0xf3003c03, 0x340bc03c, 0x00e300cc, 0x02300fc0, 0x3c007f00, 
	0xcc03300f, 0xc03c00f3, 0x00cc0130, 0x19c00820, 0x0c000000, 0x00000000, 
	0x81003620, 0xd1007403, 0x1010c036, 0x00d10044, 0x0c102540, 0x14001d00, 
	0x44011005, 0xc027001f, 0x00440150, 0xf9420502, 0x08000000, 0x00000000, 
	0x01a03400, 0xd1007403, 0x90114034, 0x00d50045, 0x06100d40, 0x3400dd00, 
	0x46021009, 0x441400d1, 0x00040210, 0x09400000, 0x02000000, 0x00000000, 
	0x10203000, 0xc1003403, 0x10114032, 0x00c50046, 0x00100040, 0x10008d00, 
	0x04001000, 0x4403400d, 0x00040250, 0x08504180, 0x00000000, 0x00000000, 
	0x00b03600, 0xd3807c03, 0xb801c43c, 0x40f70044, 0x00140cd0, 0x34005f00, 
	0x4c023009, 0xc01000d3, 0x004c0030, 0x09c004c0, 0x0a000000, 0x00000000, 
	0x05b83f00, 0xff00fc03, 0xf003c039, 0x00fb00fc, 0x00f003c0, 0x1b002f00, 
	0xbc00f002, 0xc20f0027, 0x00bc00f0, 0x03c01360, 0x0e000000, 0x00000000, 
	0x03a00b00, 0xf3409e43, 0x300fc01e, 0x003300cc, 0x00304fcc, 0x0d50f300, 
	0xfc20b0cf, 0xc02f0033, 0x08ec23b0, 0x43c00c00, 0x0e000000, 0x00000000, 
	0x01080780, 0xd146460b, 0x10af4014, 0x001b4044, 0x00102f40, 0x0404d100, 
	0x74181089, 0x40af0411, 0x02442b10, 0xe5400420, 0x0c000000, 0x00000000, 
	0x11a00300, 0xc1925403, 0x140c4052, 0x00010005, 0x00108d4c, 0x0501c500, 
	0x341a104c, 0x40a34101, 0x0c241390, 0x14414480, 0x0e000000, 0x00000000, 
	0x03a80500, 0xd1814043, 0x140d4034, 0x09191044, 0x08100d40, 0x0400d500, 
	0x74041c09, 0x402700d1, 0x06440310, 0x05400c20, 0x06000000, 0x00000000, 
	0x02a8c600, 0xd101540b, 0x100dc012, 0x0011020c, 0x2c396dd0, 0x0500d700, 
	0x3c053009, 0xc8770213, 0x036c03b0, 0x09c00020, 0x0e000000, 0x00000000, 
	0x07808d10, 0x6f00fc17, 0xf00dc01f, 0x00ff02fc, 0x00f93fd0, 0xaf00bb20, 
	0xfc03f10b, 0xc03f005f, 0x00bc03f0, 0x0fd01f02, 0x06000000, 0x00000000, 
	0x02088504, 0xd3917c8b, 0x300cc075, 0x08de007c, 0x08f02dc0, 0x2740d308, 
	0x7c833009, 0xc0330087, 0x005c03f0, 0x0cc00b20, 0x04000000, 0x00000000, 
	0x13a02010, 0x1103043b, 0x54ff4874, 0x00cd5174, 0x00d26840, 0x30049101, 
	0x741f1009, 0x44f710d1, 0x40c403d0, 0x0d404f00, 0x02000000, 0x00000000, 
	0x07a0c200, 0xc900240d, 0x100c6091, 0x010d0034, 0xe4d01c01, 0x0100c000, 
	0x3400500c, 0x44331105, 0x011403d0, 0x08401f00, 0x0a000000, 0x00000000, 
	0x04804850, 0xe1018427, 0x501e6868, 0x00ed01b4, 0x04d09c00, 0x4820e103, 
	0xb40e5c1a, 0x407b20a1, 0x018607d2, 0x1e401300, 0x02000000, 0x00000000, 
	0x12100004, 0xd3002c23, 0x300cc011, 0x00cf083c, 0x00f00c80, 0x1701c300, 
	0x7c0b700c, 0xc0370447, 0x101c03f0, 0x0cc44b40, 0x00000000, 0x00000000, 
	0x02b81d00, 0xff00ec23, 0xf00fc03f, 0x00fd20fc, 0x01f03fc0, 0x0f00ff00, 
	0xfc03340b, 0xc03f00ff, 0x00fc03f0, 0x0fc00b60, 0x06000000, 0x00000000, 
	0x15a00780, 0xdf000c02, 0x300dc037, 0x801e007c, 0x00f02cc0, 0x0020d300, 
	0x7c017009, 0xc4e704db, 0x007c2730, 0x19c05400, 0x0e000000, 0x00000000, 
	0x12883900, 0x6d808403, 0xb0ee403b, 0x00ed20b4, 0x00d90e42, 0x2800a120, 
	0xb403140a, 0x402b20e1, 0x00f41314, 0x0e084820, 0x06000000, 0x00000000, 
	0x03024904, 0xeda18487, 0x101e407b, 0x00ed01b4, 0x07d01650, 0x7e00e101, 
	0x3407541a, 0x406b00e9, 0x01b40710, 0x1c120c02, 0x04000000, 0x00000000, 
	0x12287300, 0x4d5b042b, 0x900c4033, 0x20cd0234, 0x03d00444, 0x74008101, 
	0x74071008, 0x40230ad1, 0x00340302, 0x4c404820, 0x0c000000, 0x00000000, 
	0x17a8dd00, 0x6d03cd85, 0x3005c0df, 0x007d05fc, 0x49f007c0, 0xdc415301, 
	0xfc4d7005, 0xc457007b, 0x587c0130, 0x07c05c20, 0x06000000, 0x00000000, 
	0x1200c708, 0x1f007c48, 0xf021c0c7, 0x021f107c, 0x04f031d8, 0x47201f08, 
	0x7c08f401, 0xc007001f, 0x007c00f0, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x10082701, 0x9f053c06, 0x3099c024, 0x009f037c, 0x02f009c0, 0x24029305, 
	0x4d423008, 0xc064009f, 0x004002f0, 0x09c04320, 0x0c000000, 0x00000000, 
	0x0100a614, 0x9d40444a, 0x1668c8a6, 0x019d0074, 0x2ad02841, 0x24008101, 
	0x44365009, 0x4224129d, 0x004502d0, 0x09400700, 0x08000000, 0x00000000, 
	0x18a03480, 0x9d0074a2, 0x10094024, 0x029d0074, 0x0ad01950, 0x24009100, 
	0x44021409, 0x54a4009d, 0x004402d0, 0x09406300, 0x02000000, 0x00000000, 
	0x10202000, 0xcd020512, 0x10084022, 0x088d0034, 0x02d00940, 0x20408100, 
	0x04525448, 0x41a0058d, 0x15145290, 0x484143a0, 0x00000000, 0x00000000, 
	0x1db00600, 0x1f067d00, 0x3401c004, 0x001f807c, 0x80f001c0, 0x14225300, 
	0x4c103041, 0xca80111f, 0x204c10f0, 0x41c077c0, 0x0a000000, 0x00000000, 
	0x19b82f20, 0xaf82fd0a, 0xf089c02f, 0x00bf00fc, 0x02f08bc8, 0x2f00bf00, 
	0xfc52f44b, 0xc32f01bf, 0x146c52f0, 0x4bc36720, 0x0e000000, 0x00000000, 
	0x18a02f80, 0xa310cc42, 0x304bc02e, 0x00bb20fc, 0x02f04fc0, 0x2f0ab300, 
	0xfc5232cd, 0xc02f18bf, 0x007c22f0, 0x49c06200, 0x0e000000, 0x00000000, 
	0x1c080700, 0x13024408, 0x14a14204, 0x08118074, 0x00d0a140, 0x07001100, 
	0x741010c1, 0x4087040f, 0x307420d0, 0x41417102, 0x0c000000, 0x00000000, 
	0x10a02740, 0xc1140402, 0x10084066, 0x808da034, 0x8652086a, 0x23008180, 
	0x34d21848, 0x4823138d, 0x693402d0, 0xc8404080, 0x0e000000, 0x00000000, 
	0x18a82522, 0x9100441a, 0x10094834, 0x80952074, 0x02d80940, 0xa7009100, 
	0x76121409, 0x4037009d, 0x007402d0, 0x09406120, 0x06000000, 0x00000000, 
	0x05a8e704, 0x83004d02, 0x3408c862, 0x409f077c, 0x0e7089cb, 0x27089300, 
	0x7c9a3009, 0xc027b89f, 0x207c82f0, 0x19c01420, 0x04000000, 0x00000000, 
	0x14802510, 0x9f043c42, 0xf009c027, 0x429b097c, 0x12f019c0, 0xe7449f40, 
	0x7c02f009, 0xc0278097, 0x097c02f0, 0x49c85300, 0x04000000, 0x00000000, 
	0x14088504, 0x13814c00, 0x3011c047, 0x081f024c, 0x607091c0, 0x84001301, 
	0x7c68b001, 0xc007041f, 0x004c00f0, 0x01c05020, 0x04000000, 0x00000000, 
	0x14a09804, 0x7102c401, 0x1077409c, 0x005c00c4, 0x09d02740, 0x1c007112, 
	0xf4095005, 0x405f047d, 0x004401d0, 0x05425000, 0x00000000, 0x00000000, 
	0x14a03200, 0xc140240f, 0x101c4433, 0x208d0004, 0x07581c40, 0x3620c100, 
	0x7403900c, 0x46b300c5, 0x090703d0, 0x0d605000, 0x0a000000, 0x00000000, 
	0x05821c60, 0xa100a443, 0x140e5008, 0x00fd0184, 0x03d81b50, 0xaa00a100, 
	0x3603d60e, 0x403b00ed, 0x018623d0, 0x4e601000, 0x02000000, 0x00000000, 
	0x15107800, 0xe301ad87, 0x301ad05b, 0x00af018d, 0x07701ec0, 0x7e40a301, 
	0xbc07b61e, 0xc87b10ef, 0x018c37f0, 0xdcd05000, 0x00000000, 0x00000000, 
	0x10b811c0, 0xdf201c03, 0xf00cd007, 0x008f007c, 0x03f008c0, 0x3d009f40, 
	0x7c01760d, 0xc22700de, 0x207c0bf0, 0x8dc04360, 0x06000000, 0x00000000, 
	0x00a07b00, 0x73818c07, 0x321fe05f, 0x22bf09cc, 0x27f01fc0, 0x48087301, 
	0xcc07109f, 0xc57d40f3, 0x01cd07f0, 0x1fc00800, 0x0e000000, 0x00000000, 
	0x15882900, 0xe1208423, 0x100e400b, 0x22ed0c84, 0x03d00a40, 0x08006140, 
	0xc413b00f, 0x403800ab, 0x008403d0, 0x0e405520, 0x06000000, 0x00000000, 
	0x0000bd00, 0xe1008503, 0x100e409b, 0x22bd10a4, 0x00d88340, 0x2c063100, 
	0xa402580e, 0x411900e1, 0x008403d0, 0x0e400000, 0x04000000, 0x00000000, 
	0x04287340, 0xc1010405, 0x14044003, 0x008c0124, 0x84d00040, 0xa0000100, 
	0x2408d01c, 0x40010099, 0x060403d0, 0x0c401920, 0x0c000000, 0x00000000, 
	0x15a8b101, 0xd3000847, 0x300dc017, 0x049f022d, 0x03d04dc0, 0x40005301, 
	0x6503700f, 0xc03500d1, 0x00cc03f0, 0x5fc05420, 0x06000000, 0x00000000, 
	0x01001700, 0xdf987c13, 0xf00dc007, 0x20df305c, 0x20f021d0, 0x0740df08, 
	0x5c1ba00d, 0x801600d7, 0x037c03f0, 0x0dc00700, 0x0c000000, 0x00000000, 
	0x80081f01, 0xf304cc23, 0xb09fc08f, 0x20bf00fc, 0x0bb03bd0, 0x0c04b308, 
	0xfc03300f, 0xc074007f, 0x20cc0320, 0x0ec00022, 0x0c000000, 0x00000000, 
	0x81205640, 0xc1614407, 0x101d4147, 0x009d0074, 0x00101040, 0xc4249141, 
	0x3488140c, 0x40c4005d, 0x12440310, 0x0d400402, 0x08000000, 0x00000000, 
	0x01a0a400, 0x5100448b, 0x900d4017, 0x009d0074, 0x43900941, 0x44005122, 
	0x7453100d, 0x402402dd, 0x20140350, 0x0d400400, 0x0a000000, 0x00000000, 
	0x10202400, 0xc1000402, 0x100c4003, 0x00cd0076, 0x00100040, 0x04004180, 
	0x3403100d, 0x4000008d, 0x00040350, 0x0c404000, 0x00000000, 0x00000000, 
	0x00b01600, 0xd3004c03, 0xb00dc007, 0x009f007c, 0x00b001c0, 0x04001300, 
	0x7c00320d, 0xd004884f, 0x00cc0374, 0x0ec00040, 0x08000000, 0x00000000, 
	0x05b81f08, 0xef00fd03, 0xf00fc80f, 0x00af00fc, 0x00f002ca, 0x0f402f00, 
	0xfc00f00f, 0xc00f003e, 0x00fc03b0, 0x0fc01760, 0x0e000000, 0x00000000, 
	0x82a00f03, 0x3308cc42, 0x3002c80f, 0x003f00fc, 0x033003c2, 0x0f01af22, 
	0xdc12b303, 0xc4083833, 0x40cc01d1, 0x03400800, 0x0e000000, 0x00000000, 
	0x0318f711, 0xd12d458a, 0x12014027, 0x009d00f4, 0x0b110101, 0x07009140, 
	0x44084041, 0xc0060011, 0x0e5401d0, 0x21400c20, 0x0c000000, 0x00000000, 
	0x11001102, 0xc1000402, 0x50044003, 0x200c0134, 0x23180040, 0x85008504, 
	0x1523d000, 0x01058001, 0x100401d1, 0x80404588, 0x0e000000, 0x00000000, 
	0x06203542, 0xd1284413, 0x50054047, 0x089d4134, 0x03100541, 0x67089100, 
	0x44015265, 0x40474051, 0x045421d1, 0x01420820, 0x02000000, 0x00000000, 
	0x82a82710, 0x13804c07, 0x7239c067, 0x001f817c, 0x033411c8, 0x07009f00, 
	0x1c62f031, 0x80850092, 0x014c99f0, 0x09c08d22, 0x0a000000, 0x00000000, 
	0x07803d00, 0xff00fc03, 0xb03b4027, 0x003f00fc, 0x83f093c0, 0x0f00fd25, 
	0xfc04801b, 0xc00e002f, 0x01fc07f0, 0x2ec01f00, 0x06000000, 0x00000000, 
	0x0a08b510, 0xdf007c03, 0x3011c304, 0x0413047c, 0x13f025c0, 0x6400df00, 
	0x4c0bf001, 0xc4050b93, 0x084c1370, 0x05c00820, 0x04000000, 0x00000000, 
	0x13a03400, 0xdd0e7403, 0x003d4084, 0x109102f4, 0x47d00540, 0x6000dd00, 
	0x6c05d10d, 0x488000db, 0x81440710, 0x3d446c00, 0x02000000, 0x00000000, 
	0x1320b603, 0xdd027403, 0x102c4080, 0x00810034, 0x0fd00040, 0x00209d00, 
	0x0406d001, 0x4002000d, 0x11042810, 0x00151c00, 0x0a000000, 0x00000000, 
	0x0d087a00, 0xed01b406, 0x101f4878, 0x00e1a1b4, 0x07d01750, 0x5800ed21, 
	0xa406d036, 0x404e003d, 0x01c42510, 0x17413400, 0x02000000, 0x00000000, 
	0x1210b209, 0xcf027c03, 0x30044090, 0x08c3083c, 0x03d048c0, 0x0001cf00, 
	0x0cc2f000, 0xc092020f, 0x040c0074, 0x84e44842, 0x00000000, 0x00000000, 
	0x02a83d00, 0xff00fc03, 0xf00fd03f, 0xc2ff28fc, 0x23f00e40, 0x3f00ff08, 
	0xfc02f006, 0xc01c022a, 0x00b481d0, 0x86e20b60, 0x06000000, 0x00000000, 
	0x14287500, 0xd3014c03, 0xf809c027, 0x001f007c, 0x173405c0, 0x03009300, 
	0x4c03f001, 0xc007008f, 0x010c0210, 0x09c25700, 0x0e000000, 0x00000000, 
	0x13093900, 0xc1008403, 0xd00e403b, 0x0067009c, 0x53100640, 0x1b00e100, 
	0x8403f00e, 0x400b002d, 0x00840315, 0x0e404f04, 0x06000000, 0x00000000, 
	0x10007900, 0xe1018407, 0xd032427b, 0x00ed0134, 0x27101641, 0x6b00e103, 
	0xa407d81a, 0x405b00bd, 0x01a40f10, 0x16480720, 0x04000000, 0x00000000, 
	0x06083100, 0xc1000707, 0xd02c41b3, 0x21d50014, 0x03100c48, 0xb300c101, 
	0x2403d00d, 0x4033008d, 0x82240710, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17a89f42, 0x71004c01, 0xf007c01f, 0x387f627c, 0x013007c0, 0x9f005300, 
	0xed01f027, 0xc09b007f, 0x02ad0d30, 0x27c15f20, 0x06000000, 0x00000000, 
	0x12800508, 0x1f007c20, 0xf001ce07, 0x00142074, 0x00f001c0, 0x07401b02, 
	0x5c007031, 0xc047001f, 0x125c0cf0, 0x11c44b00, 0x0c000000, 0x00000000, 
	0x10082500, 0x9f007c02, 0xf009c027, 0x909f304c, 0x06f209c1, 0x23269300, 
	0x4c16f039, 0xc0641193, 0x037c2630, 0x19c44020, 0x0c000000, 0x00000000, 
	0x01202600, 0x9d025802, 0xd0294027, 0x809d0844, 0x02d20940, 0x27008b12, 
	0x4416f009, 0x4025009f, 0x81740610, 0x18c04600, 0x08000000, 0x00000000, 
	0x1ca02400, 0x9d507002, 0xd02d4027, 0x02990044, 0x22d00960, 0x27009100, 
	0x4502d009, 0x40240091, 0x00760a10, 0x89006000, 0x02000000, 0x00000000, 
	0x14286003, 0x8d6c1422, 0xd0284063, 0x018d0605, 0x42d00860, 0x23019902, 
	0x0612508c, 0x4031808d, 0x04748210, 0x48414288, 0x00000000, 0x00000000, 
	0x1fb082a4, 0x1f827c08, 0xd021cc87, 0x205d124c, 0x09d181c8, 0x07001380, 
	0x4440d001, 0xc0040053, 0x0c7c0034, 0x01c0f480, 0x00000000, 0x00000000, 
	0x19a92f01, 0xbf06dc22, 0xf04bc4af, 0x0cbf0074, 0xd2f04bc8, 0xaf00af04, 
	0xfc02f00b, 0xc82f08bf, 0x0cfc02f2, 0x0bc06fa4, 0x0e000000, 0x00000000, 
	0x18a8af20, 0xbf804c82, 0x302bc02f, 0x00bf00fc, 0x02f00980, 0x2f00b300, 
	0xfc13300b, 0xc02c00bf, 0x10fc02f0, 0x4bc06000, 0x0e000000, 0x00000000, 
	0x1c080500, 0x1d404400, 0x10014007, 0x0917c45c, 0x10d04140, 0x17001b14, 
	0x74801045, 0xc006001d, 0x027480d0, 0x21427920, 0x0c000000, 0x00000000, 
	0x1220a3a0, 0x8d16045a, 0x100848a3, 0x848d3234, 0x4ad00841, 0xa3008100, 
	0x740a1009, 0x0320008d, 0x143402d0, 0x88404980, 0x0e000000, 0x00000000, 
	0x19a82528, 0xdd104402, 0x108d40a7, 0x829d0254, 0x02d08943, 0x27009900, 
	0x74021809, 0x6026149d, 0x107403d0, 0x19406120, 0x02000000, 0x00000000, 
	0x05a02700, 0x9f024d22, 0x3469c0e7, 0x809f087c, 0x02f039c0, 0xa7089301, 
	0x7c023099, 0xc0e4009f, 0x097c4af0, 0x19c91520, 0x0e000000, 0x00000000, 
	0x12882509, 0x8f043c06, 0xf019c027, 0x0097005c, 0x02f009c0, 0x27009d23, 
	0x7c12f419, 0xc167029f, 0x217c12f0, 0x08e05b08, 0x06000000, 0x00000000, 
	0x10080540, 0x13807c00, 0xf021c087, 0x0013087c, 0x00f021c0, 0x87801300, 
	0x6c04f001, 0xd044001f, 0x064c9830, 0x41c05320, 0x04000000, 0x00000000, 
	0x14a05c10, 0x71017401, 0xd027401f, 0x007102f4, 0x0dd00540, 0x13007b18, 
	0x840dd026, 0xc19e017d, 0x11c401b2, 0x07445300, 0x02000000, 0x00000000, 
	0x14203200, 0xc9013403, 0xd02c4133, 0x14c94734, 0x6bd00c40, 0x33808103, 
	0x2403d028, 0x407280cd, 0x01040f12, 0x2c005300, 0x0a000000, 0x00000000, 
	0x01086204, 0x6910b4b3, 0xd00a407b, 0x40e900b4, 0x03d04e40, 0x230ca901, 
	0x840ad003, 0x402a00cd, 0x00c40f90, 0x02421700, 0x02000000, 0x00000000, 
	0x11115a00, 0xeb21bc87, 0xd01ec06f, 0x086b01b4, 0x07f01ec0, 0x7b003101, 
	0xac07f016, 0xc07a006f, 0x008c0533, 0x1ec05744, 0x00000000, 0x00000000, 
	0x10a82500, 0x57007c03, 0xf001c027, 0x0057007c, 0x00f08dc0, 0x27001f00, 
	0x7c02f004, 0xc00700de, 0x003c02f0, 0x05c04340, 0x06000000, 0x00000000, 
	0x00217d08, 0xbf01cc07, 0xf01fc07f, 0x08fe09fc, 0x07109fc0, 0x7801f301, 
	0xc805f017, 0xc06f02ef, 0x01ec0530, 0x1fc00004, 0x0e000000, 0x00000000, 
	0x15182900, 0x2d088423, 0x700a403b, 0x00ed18b4, 0x83100e40, 0x2909f108, 
	0x8400d006, 0x40ab00ad, 0x228c0170, 0x8a405420, 0x06000000, 0x00000000, 
	0x00001902, 0xad008403, 0xd00e400b, 0x06ad4836, 0x03100f41, 0x28836100, 
	0x8420d006, 0x402b807d, 0x00a42190, 0x0e400000, 0x04000000, 0x00000000, 
	0x04202009, 0x0d040487, 0xd0714083, 0x008d0734, 0x00107d64, 0x61905101, 
	0x0408d005, 0x400300dd, 0x13061150, 0x3c401020, 0x0c000000, 0x00000000, 
	0x15a87709, 0xdf11cd07, 0xf019c167, 0x029f003c, 0x03342fc0, 0xf400d300, 
	0x4c0bf01d, 0xc037001f, 0x072c1fb0, 0x25d15420, 0x06000000, 0x00000000, 
	0x01801100, 0x9f027c23, 0x7029c007, 0x001e027c, 0x03f00dc2, 0x3702df08, 
	0x7d1af075, 0xc027041f, 0x027c03f0, 0x01c00700, 0x0c000000, 0x00000000, 
	0x8408dd00, 0x7303fc03, 0xe00bc02c, 0x002f80cc, 0x27300fc0, 0x7c067f21, 
	0x8c01b017, 0xc22e0033, 0x00cc0f72, 0x04c10022, 0x0c000000, 0x00000000, 
	0x8520d604, 0x11037403, 0xd01140c4, 0x00191354, 0x08500d40, 0x35005d41, 
	0x46181095, 0x42810215, 0x23540f12, 0x05d00600, 0x08000000, 0x00000000, 
	0x01a02400, 0xd1007403, 0xd0114064, 0x049d0144, 0x08100d40, 0x34205d06, 
	0x4401910d, 0x41060091, 0x01440150, 0x0d450400, 0x02000000, 0x00000000, 
	0x10280000, 0x81003403, 0xd0004200, 0x10090014, 0x00500c40, 0x31004d00, 
	0x04001004, 0x40010085, 0x00540110, 0x08404280, 0x00000000, 0x00000000, 
	0x00b00640, 0x43007c03, 0xf001d004, 0x009f004c, 0x00300dc0, 0x34005f00, 
	0x4400b005, 0xc0060013, 0x004c0172, 0x0dd000c0, 0x0a000000, 0x00000000, 
	0x85a80f00, 0x3f00fc03, 0xf003c20f, 0x003b00fc, 0x00f00ec0, 0x3f007f00, 
	0xfd00f007, 0x400f00bf, 0x00bc01f0, 0x0fc21560, 0x0e000000, 0x00000000, 
	0x03a03f00, 0x3f40cc02, 0x344fc03d, 0x0a7b00fc, 0x33300fc0, 0x3f006300, 
	0x8c00f00f, 0xc43e0033, 0x08cc0bf0, 0x43c00c00, 0x0e000000, 0x00000000, 
	0x0108b723, 0x5d1e4442, 0x102d40bc, 0x03510074, 0x23100540, 0x37005500, 
	0x4400d00d, 0x40370011, 0x06442bd0, 0xe1400420, 0x0c000000, 0x00000000, 
	0x11a0130c, 0x4d204513, 0x108c4831, 0x00090034, 0x13100c40, 0x33005d00, 
	0x0400d00c, 0x40374041, 0x022413d0, 0x00414480, 0x0e000000, 0x00000000, 
	0x03a85520, 0x5d284402, 0x100c4031, 0x00d10074, 0x03000540, 0x37005518, 
	0x4500d18d, 0x41370041, 0x826403d0, 0x01410c20, 0x06000000, 0x00000000, 
	0x02a86704, 0x1f040c02, 0x300dc035, 0x00db007c, 0x033029c0, 0x3780d700, 
	0x4c10f02d, 0xc02300d3, 0x026c03e0, 0x3dd00820, 0x0e000000, 0x00000000, 
	0x07802d0c, 0x7f01fc02, 0xf00dc03e, 0x00ff24bc, 0x83f691c0, 0x3700ff41, 
	0xfca4f01f, 0xc02f00ff, 0x005c03f0, 0x8fc01f00, 0x06000000, 0x00000000, 
	0x0208e500, 0xd30c4d03, 0xb00dc035, 0x00d3007c, 0x03f029d0, 0x34105300, 
	0x4c20302d, 0xc87740d3, 0x004c4334, 0x0cc00920, 0x04000000, 0x00000000, 
	0x13a06408, 0xd1024402, 0x120f003c, 0x00d18af4, 0x03d1a140, 0x3840c100, 
	0x442a103d, 0x407700d1, 0x40c40310, 0x0d404c00, 0x02000000, 0x00000000, 
	0x07a03200, 0x19410402, 0xd00c0231, 0x00410034, 0x03d00c40, 0x30000100, 
	0x240c161c, 0x40330081, 0x80042350, 0x0c401f00, 0x0a000000, 0x00000000, 
	0x0480784a, 0x79018406, 0x101e4c70, 0x006101b4, 0x07d01e40, 0x78022101, 
	0xa504113e, 0x417f00a1, 0x01840750, 0x1e441200, 0x02000000, 0x00000000, 
	0x12103400, 0x4b004c03, 0xf00cc031, 0x0043003c, 0x03f02cc8, 0x30024300, 
	0x2c203088, 0xc83341d3, 0x000c0370, 0x0dc04b40, 0x00000000, 0x00000000, 
	0x02b81d00, 0xe720fc22, 0xf28fc03f, 0x00ff00f8, 0x23f08fc0, 0x3f023f08, 
	0xdc00f083, 0xc01b50ff, 0x00fc63b0, 0x0fc00960, 0x06000000, 0x00000000, 
	0x15a03740, 0x03804c02, 0xf28dc0f7, 0x03cb004c, 0x23f00dc2, 0x70001300, 
	0x7c01700d, 0xc82340d7, 0x407c03f0, 0x0dc05708, 0x0e000000, 0x00000000, 
	0x12883900, 0x21008502, 0xd00e403b, 0x04e10084, 0x13d00e40, 0x38012500, 
	0xb403d00e, 0x402b50e1, 0x00b413d0, 0x0e404b20, 0x06000000, 0x00000000, 
	0x0300e100, 0xe1018407, 0xd05e4873, 0x11fd1185, 0x07d11e40, 0x78026101, 
	0xb407501a, 0x407b40e5, 0x41b407d0, 0x1e400f00, 0x04000000, 0x00000000, 
	0x1228f308, 0xc1010402, 0xd10c4033, 0x00dd0004, 0x03d80d40, 0x30004500, 
	0x3405d108, 0x467300c1, 0x217403d0, 0x8c404b20, 0x0c000000, 0x00000000, 
	0x17a8dd00, 0x73074c01, 0xf005c817, 0x007f034c, 0x01f057d0, 0x14007312, 
	0xfc1d7026, 0xc0df4077, 0x207c01f0, 0x17c05f20, 0x06000000, 0x00000000, 
	0x12008744, 0x1f437c00, 0xf001c007, 0x0012037c, 0x00f001e0, 0x07001f01, 
	0x7c04f131, 0xc0c7020f, 0x097c00f2, 0x11c04b00, 0x0c000000, 0x00000000, 
	0x10086340, 0x83456c82, 0xb009c627, 0x009f030c, 0x023209c0, 0x262a9f20, 
	0x7c02f029, 0xc0644097, 0x004c0234, 0x09004320, 0x0c000000, 0x00000000, 
	0x01202600, 0x91014402, 0xd0294227, 0x009d8045, 0x02100950, 0x24009d43, 
	0x742ad029, 0x58a04391, 0x00440210, 0x09400700, 0x08000000, 0x00000000, 
	0x18a02405, 0x91506482, 0xd0294027, 0x009d0044, 0x02100940, 0x24009d14, 
	0x740ad009, 0x40345095, 0x00460210, 0x09406300, 0x02000000, 0x00000000, 
	0x10202005, 0x81000402, 0xd04840a3, 0x01cd0004, 0x82104841, 0x20058d00, 
	0x3402d00d, 0x4a200081, 0x14055210, 0x48414380, 0x00000000, 0x00000000, 
	0x1db00602, 0x13086c08, 0xf001c187, 0x001f004c, 0x303440c0, 0x06011f00, 
	0x7c00d001, 0xd4040017, 0x044c1030, 0x41c077c0, 0x00000000, 0x00000000, 
	0x19b02f60, 0xbf48fc42, 0xf049c1a7, 0x00bf147c, 0x0af04bc9, 0x2700bf00, 
	0xfc02f10b, 0xd82f05bf, 0x947c52f0, 0x4bc367c0, 0x0e000000, 0x00000000, 
	0x18a02f01, 0xaba64c8a, 0xf04bc0a4, 0x01b3006d, 0x22304bc0, 0x2f01bf00, 
	0xfc02f00b, 0xc02f409b, 0x10ec42f2, 0x69c06000, 0x0e000000, 0x00000000, 
	0x1c088705, 0x1d044410, 0xd0415004, 0x01111454, 0x18104141, 0x87001d40, 
	0x7400d001, 0x42170011, 0x00040070, 0x61407000, 0x08000000, 0x00000000, 
	0x10a02302, 0x89870412, 0xd02841a0, 0x899d8024, 0x0a582842, 0x23028d81, 
	0x3403c008, 0x4023048d, 0x102452d0, 0x284040a0, 0x0e000000, 0x00000000, 
	0x18a82500, 0x9d084402, 0xd0094024, 0x909d0254, 0x02500940, 0x27009d01, 
	0x7402d049, 0x40270195, 0x44440250, 0x09406020, 0x06000000, 0x00000000, 
	0x05a8e703, 0x9b024d06, 0xf0098024, 0x008f026c, 0x027009c0, 0x27009f01, 
	0x7c1af049, 0xc023109f, 0x006c02f2, 0x09d01420, 0x0e000000, 0x00000000, 
	0x14806510, 0x9f007c26, 0xf009c027, 0x0093047c, 0x02b409c0, 0x27009f80, 
	0x7c02f309, 0xc027408b, 0x407c0270, 0x08c05300, 0x06000000, 0x00000000, 
	0x14088560, 0x13204c00, 0xf001c003, 0x001f407c, 0x003001c0, 0x07001700, 
	0x7c8c3211, 0xc4850417, 0x005c4030, 0x01c05020, 0x04000000, 0x00000000, 
	0x14a05c41, 0x71404401, 0xd0776817, 0x207c4474, 0x01142740, 0x17107107, 
	0xdc091127, 0x441f0051, 0x00c40910, 0x05405000, 0x02000000, 0x00000000, 
	0x14a0b259, 0x51240403, 0x907d4033, 0x00cc0174, 0x03805c40, 0x33004504, 
	0x34831014, 0x40b102c5, 0x80140f10, 0x0c525000, 0x0a000000, 0x00000000, 
	0x05807800, 0xe1008433, 0xd00e407b, 0x016d00b4, 0x13902640, 0x7b046100, 
	0xd4071206, 0x493b00c1, 0x04840f10, 0x0e401400, 0x02000000, 0x00000000, 
	0x15107c00, 0xe3018d87, 0xb016403b, 0x04ef01fc, 0x0fb01ec0, 0x7b002701, 
	0xbc06301e, 0xc07900e7, 0x0b9c0734, 0x1cc05400, 0x00000000, 0x00000000, 
	0x10b83500, 0xdf007c03, 0xf005c0b7, 0x03df007c, 0x037005c0, 0x33001f00, 
	0x3c82f40d, 0xc83308df, 0x207c03f0, 0x1dc04320, 0x06000000, 0x00000000, 
	0x00a07f00, 0xf321cd27, 0xf01fc07f, 0x00b301fc, 0x27701fc0, 0x6f00bf01, 
	0xfc07f01f, 0xc07c03ff, 0x01cc07f0, 0x1fc10300, 0x0e000000, 0x00000000, 
	0x15880910, 0xf1008423, 0xd10e423f, 0x402120b4, 0x33100e40, 0x2b00adc0, 
	0xb402d10e, 0x48380ae1, 0x008400d0, 0x0e405720, 0x06000000, 0x00000000, 
	0x00002900, 0xe1008503, 0xd80e403b, 0x00e108b4, 0x03110e40, 0x3b002d00, 
	0xb40ad00e, 0x403801cd, 0x008403d0, 0x0e400300, 0x04000000, 0x00000000, 
	0x04284710, 0xc1400403, 0xd00c4037, 0x00c11034, 0x03112c41, 0x33000d10, 
	0x3402d02c, 0x403000c1, 0x000400d0, 0x0c401320, 0x0c000000, 0x00000000, 
	0x15a8a500, 0xd301cc03, 0xd009c03f, 0x00d310fc, 0x033409c0, 0x37009f02, 
	0x7c03f02c, 0xc03410ff, 0x004503f0, 0x0fc05720, 0x06000000, 0x00000000, 
	0x0100271a, 0x9f137c07, 0xf209c037, 0x005f007c, 0x03f000c0, 0x37009f08, 
	0x7c09f001, 0xd22704df, 0x007c03f0, 0x0dca0700, 0x0c000000, 0x00000000, 
	0x80080704, 0xf340dc03, 0xf003c03f, 0x00f7004c, 0x03f00bc0, 0x38003301, 
	0xfc01f01b, 0xc16c00fb, 0x00fc0334, 0x0e800022, 0x0c000000, 0x00000000, 
	0x81204638, 0xc1054403, 0xd0014037, 0x00d10044, 0x03d89140, 0x34401100, 
	0x7401d019, 0x402400d3, 0x00740310, 0x0d400402, 0x08000000, 0x00000000, 
	0x01a06440, 0xd1015403, 0xd01d4037, 0x00850044, 0x83d00d40, 0x24001108, 
	0x7451d069, 0x403005d9, 0x00340310, 0x0d600500, 0x02000000, 0x00000000, 
	0x10204000, 0x91000503, 0xd00c4033, 0x00018004, 0x03d00c40, 0x20000181, 
	0x3400d000, 0x422000c0, 0x00340010, 0x0c604180, 0x00000000, 0x00000000, 
	0x00b00600, 0xd3005c03, 0xf00dc03f, 0x00d7004c, 0x03d00dd0, 0x34001300, 
	0x7c01f009, 0xc01420fb, 0x407c0330, 0x0dd001c0, 0x0a000000, 0x00000000, 
	0x05b80f00, 0xff00fc03, 0xf00fc03f, 0x00ff00fc, 0x03f00fc0, 0x3f003f00, 
	0xfc00f00a, 0xc00b00f7, 0x00fc00f0, 0x0fc01660, 0x0e000000, 0x00000000, 
	0x03a08f00, 0x3f01cc00, 0x308b820f, 0x08330ccc, 0x00f04fc0, 0x0f007740, 
	0xc4023487, 0xc02d0173, 0x408d2330, 0x03c00c00, 0x0e000000, 0x00000000, 
	0x01087722, 0x17024c00, 0x10494086, 0x44110e45, 0x00d0ad40, 0x07310118, 
	0x442b5045, 0x42840211, 0x10441310, 0x21440420, 0x0c000000, 0x00000000, 
	0x11a01389, 0x8d160453, 0x504040b3, 0x01010006, 0x54d00c40, 0x03445524, 
	0x04521000, 0x40214051, 0x04040312, 0x81444480, 0x0e000000, 0x00000000, 
	0x03a83500, 0x9500e403, 0x10a14036, 0x0a113040, 0x13d00d48, 0x87411100, 
	0x44035061, 0x04444451, 0x4044a300, 0x01600c20, 0x06000000, 0x00000000, 
	0x02a8b701, 0x5f054d03, 0x3439c007, 0x00d3204c, 0x04f00dc0, 0x97005700, 
	0x4d423435, 0x80654053, 0x194c0330, 0x05c60820, 0x0e000000, 0x00000000, 
	0x07803d00, 0x3f09dc03, 0xf01bc40e, 0x00ff14fc, 0x07f00f80, 0x7f007f20, 
	0xbc25a217, 0xc427483f, 0x00f887f0, 0x97d01f00, 0x06000000, 0x00000000, 
	0x02083500, 0xdf003c03, 0xf801d034, 0x20df004c, 0x80f20dc0, 0x07105300, 
	0x4c0a3409, 0xc0a60853, 0x107c4332, 0x15d00820, 0x04000000, 0x00000000, 
	0x13a03401, 0x9d057413, 0xd0014034, 0x00dd0255, 0x03d01f40, 0x1300cb81, 
	0xc4411401, 0x402002c1, 0x82741710, 0x0c404d00, 0x02000000, 0x00000000, 
	0x07a02210, 0x1d813404, 0xd00c4034, 0x00dd0934, 0x00d08c40, 0x53084118, 
	0x05021005, 0x41834001, 0x02740b50, 0x00401e00, 0x0a000000, 0x00000000, 
	0x04807800, 0xed01b404, 0xd01e4078, 0x01ed09b6, 0x04d01e40, 0x5b002901, 
	0x052e1096, 0x40590221, 0x89f40758, 0x92401300, 0x02000000, 0x00000000, 
	0x12103008, 0x0f003c03, 0xd00dc0b0, 0x92cf003c, 0x03f00ce0, 0x07044302, 
	0x0c023001, 0xc0130003, 0x103c2372, 0x00d04a40, 0x00000000, 0x00000000, 
	0x02b83d20, 0xfd88fc03, 0xf00fc03f, 0x0bef00dc, 0x23f18f00, 0x1f20bf00, 
	0xfc43f003, 0xc01e003f, 0x00fc01b0, 0x0ac00960, 0x06000000, 0x00000000, 
	0x15a07780, 0x53204c03, 0xf009c037, 0x20d3804c, 0x07021dc8, 0x36005780, 
	0x4802300d, 0xc0770053, 0x014c83f0, 0x11805400, 0x0e000000, 0x00000000, 
	0x12883100, 0xc1408403, 0xd00a0433, 0x00e100c4, 0x03104e40, 0x3800e100, 
	0x94131406, 0x403840b1, 0x00ac03d0, 0x0ac84a20, 0x06000000, 0x00000000, 
	0x0300f900, 0x61018407, 0xd13a407b, 0x00e101a4, 0x07109c40, 0x4a00e501, 
	0xa486101e, 0x48f18061, 0x018407d0, 0x18400c00, 0x04000000, 0x00000000, 
	0x1228f340, 0xc128043b, 0xd0184433, 0x10c10825, 0x07110c40, 0x10404100, 
	0x344b1014, 0x40f000c1, 0x212406d2, 0x60404a20, 0x0c000000, 0x00000000, 
	0x17a89d02, 0x7141cd0d, 0xf006c01b, 0x407301ec, 0x413405c4, 0xde017705, 
	0xec113177, 0xc0dd0273, 0x46cc49f0, 0x27c05c20, 0x06000000, 0x00000000, 
	0x12000700, 0x1f207c00, 0xf101c007, 0x101f005c, 0x04f801c4, 0xc7001f90, 
	0x1c08f011, 0xc085001f, 0x037c04f0, 0x01c84b00, 0x0c000000, 0x00000000, 
	0x10082700, 0x97004c02, 0x3809c024, 0x0083104c, 0x02f009c4, 0x27c08305, 
	0x4c0a3029, 0x8024009f, 0x037c0220, 0x09c04320, 0x0c000000, 0x00000000, 
	0x0120a610, 0x9d124442, 0x08094024, 0x00910045, 0x02d20940, 0x27009b84, 
	0x544a1019, 0x42240097, 0x017402b2, 0x09420700, 0x08000000, 0x00000000, 
	0x18a02404, 0x8d000482, 0x10094024, 0x08910046, 0x02d00940, 0x23009100, 
	0x44021008, 0x4025009d, 0x00340354, 0x1d406300, 0x02000000, 0x00000000, 
	0x1020200b, 0x8d02055a, 0x10097024, 0x45818406, 0x0ad04841, 0x23008900, 
	0x16521018, 0x40312085, 0xa03402c4, 0x4c414380, 0x00000000, 0x00000000, 
	0x1db08684, 0x1f164c08, 0x1421c084, 0x0003124c, 0x08d001c8, 0x97401106, 
	0x4c083420, 0xd005015f, 0x027c0870, 0x01c077c0, 0x0a000000, 0x00000000, 
	0x19b82f81, 0xbf00fc82, 0xf00bc52f, 0x04bf54fc, 0x12d009c0, 0x2b05af12, 
	0xbc42f00b, 0xc1ae00b7, 0x30fc42b0, 0x0bc06760, 0x0e000000, 0x00000000, 
	0x18802f20, 0xb092fc02, 0xf009c026, 0x01b3064c, 0x02f04bc1, 0xa808a706, 
	0x8c12308b, 0xc22901b3, 0x00fc2235, 0x4fc06000, 0x0e000000, 0x00000000, 
	0x1c080319, 0x11627401, 0xd2014007, 0x4011042d, 0x00d02140, 0x04011104, 
	0x45401201, 0x40040011, 0x04741010, 0x01c47320, 0x0c000000, 0x00000000, 
	0x10a0a304, 0x81003453, 0xd24861a3, 0x05810604, 0x42d00840, 0x64018506, 
	0x050a1008, 0x40211281, 0x34749210, 0x38404080, 0x0e000000, 0x00000000, 
	0x18882512, 0x91027402, 0xd0094927, 0x81d14064, 0x02c00950, 0x24089100, 
	0x44021008, 0x48244291, 0x20741200, 0x09606320, 0x06000000, 0x00000000, 
	0x05a86740, 0x93807c0a, 0xf029c0e6, 0x0483004c, 0x1ef008c0, 0xa0009710, 
	0x4c0234c9, 0x80650093, 0x1b7c1a30, 0x08c01420, 0x0e000000, 0x00000000, 
	0x14802100, 0x9f107c12, 0xd009c063, 0x009f007c, 0x92f009c0, 0x27019f00, 
	0x7d26f119, 0xc023009f, 0x207c02f4, 0x09c05300, 0x06000000, 0x00000000, 
	0x14080504, 0x13807c08, 0x3221c007, 0x001f004c, 0x003401c0, 0x47001b02, 
	0x4c043021, 0xc0464013, 0x027c0030, 0x11c05320, 0x04000000, 0x00000000, 
	0x14a09c00, 0x7143f401, 0x10054017, 0x0077006e, 0x011017c0, 0x9d007103, 
	0x94091087, 0xc1dc007f, 0x07b4cd12, 0x27c05100, 0x02000000, 0x00000000, 
	0x14a0f200, 0xc1223401, 0x180c4033, 0x80cd2104, 0x03d1c840, 0x0300d919, 
	0x2603100c, 0x606302c1, 0x06341b5c, 0x08405300, 0x0a000000, 0x00000000, 
	0x0580b810, 0xe102b604, 0x104e403b, 0x03f50285, 0x37d20e40, 0x1900f100, 
	0xf5011106, 0x4029006d, 0x00b40259, 0x0e401500, 0x02000000, 0x00000000, 
	0x15107840, 0xe321b407, 0x305ec27b, 0x23ef0184, 0x17d01ac0, 0x4b00eb01, 
	0xa506341b, 0xc06b0063, 0x01fc0770, 0x12c05740, 0x00000000, 0x00000000, 
	0x10b83500, 0xdf003c02, 0xf50fc037, 0x08cf007d, 0x1b300dc0, 0x97009f16, 
	0x4c03f401, 0xc0260019, 0x007c02b0, 0x01c24240, 0x06000000, 0x00000000, 
	0x00804f00, 0xff21fc85, 0xf09fc17d, 0x00f301cc, 0x8ff017c8, 0xcf08b301, 
	0xfc07701f, 0xc07c0033, 0x098c0530, 0x1bc00000, 0x0e000000, 0x00000000, 
	0x15880904, 0xed18b420, 0xd88e4838, 0x00a10884, 0x93102640, 0x1b006100, 
	0xcd211006, 0x40180221, 0x00842314, 0x0e405520, 0x06000000, 0x00000000, 
	0x00000900, 0xed00b403, 0xd00f403f, 0x40c900c4, 0x43580640, 0x2b04a108, 
	0x84005027, 0x503c0021, 0x32c40110, 0x0a400000, 0x04000000, 0x00000000, 
	0x04284704, 0xcd003402, 0xd00c6032, 0x00890004, 0x03100440, 0x73008100, 
	0x04011204, 0x40300001, 0x00040f10, 0x28401120, 0x0c000000, 0x00000000, 
	0x15a83520, 0xdf8a7c00, 0xf10fc03f, 0x00db008c, 0x83700cc0, 0xc302d310, 
	0x5c27700c, 0xc0f400c3, 0x800c4b30, 0x2dc25420, 0x06000000, 0x00000000, 
	0x01002780, 0xdf027c00, 0xf00dc035, 0x0057007c, 0x03700dc0, 0x0720df30, 
	0x7c05f005, 0xc0f7015f, 0x807d12f4, 0x0dc00700, 0x0c000000, 0x00000000, 
	0x80081f01, 0xe3008c04, 0x300fe03c, 0x00f300cd, 0x43b02fc0, 0x0c20f300, 
	0x9c80300b, 0xc0784131, 0x00cc0330, 0x13c10322, 0x0c000000, 0x00000000, 
	0x8100c601, 0xdb504400, 0x100cc035, 0x00430244, 0x03313dc0, 0x0650c108, 
	0x7c011001, 0x58b40411, 0x80450210, 0x11420702, 0x08000000, 0x00000000, 
	0x01803400, 0xd1044621, 0x100d4030, 0x00d10045, 0x03d00d40, 0x04029100, 
	0x440b100d, 0x40340015, 0x88508114, 0x4d400700, 0x02000000, 0x00000000, 
	0x10202080, 0x81000604, 0x100d6031, 0x00110044, 0x03520c40, 0x06004100, 
	0x30011405, 0x42302815, 0x00440310, 0x0c404380, 0x00000000, 0x00000000, 
	0x00b01600, 0x51004501, 0x340d403c, 0x00d300cc, 0x03f00dc8, 0x2c08a300, 
	0x4d003405, 0xc4341017, 0x405c0130, 0x09c203c0, 0x0a000000, 0x00000000, 
	0x05b80f00, 0x3f00fc00, 0xf00ec039, 0x003700bc, 0x03300fc0, 0x2b10ff60, 
	0xfc01f006, 0xc03b4029, 0x20fc83f0, 0x0ac21760, 0x0e000000, 0x00000000, 
	0x03a02f01, 0xe300cc03, 0x700fc03c, 0x026300bc, 0x41710fc0, 0x3c00bf04, 
	0xcc023007, 0xc42c002f, 0x00cc0830, 0x0bc00b00, 0x0e000000, 0x00000000, 
	0x0108b704, 0xd100402b, 0x100d4034, 0x41110074, 0x09100d00, 0x3500dd14, 
	0x45411101, 0x4024001d, 0x40140110, 0x09400f20, 0x0c000000, 0x00000000, 
	0x11a03343, 0xd1000483, 0x50004030, 0x41410034, 0x01500c48, 0x3000cd0c, 
	0x0421900c, 0x402000cd, 0x00441110, 0x0c404780, 0x0e000000, 0x00000000, 
	0x03a83500, 0xd1014403, 0x10014034, 0x40910074, 0x0b108d48, 0x3500dd01, 
	0x40099019, 0x442400fd, 0x10542110, 0x0d400b20, 0x06000000, 0x00000000, 
	0x02a82700, 0xd3024c03, 0x700dd034, 0x0053123c, 0x05702cc0, 0x34008f03, 
	0x080eb01c, 0xc8a4001f, 0x034c173c, 0x09c00b22, 0x0e000000, 0x00000000, 
	0x07803500, 0xff003d03, 0xf00ec4af, 0x007f22fc, 0x25f01fc0, 0x3f00ff00, 
	0xfc0f700f, 0xd0af183f, 0x02fc07f0, 0x0bc03f00, 0x06000000, 0x00000000, 
	0x02087500, 0xd3004c03, 0x300dc034, 0x0357004c, 0x29f02dc4, 0x3500db0e, 
	0x4c3b3009, 0xc0a400cf, 0x024c1331, 0x09c02820, 0x04000000, 0x00000000, 
	0x13a03008, 0xc101c403, 0x100d40b4, 0x00d10344, 0x03110de0, 0x7e04d102, 
	0x448b105d, 0x402409dd, 0x132c1f10, 0x0d404c00, 0x02000000, 0x00000000, 
	0x07a02200, 0xc1011503, 0x100c4076, 0x00010114, 0x01d00c40, 0x7100c903, 
	0x150f1004, 0x442004cd, 0x10040310, 0x08441c00, 0x0a000000, 0x00000000, 
	0x04807802, 0x61038407, 0x101c407a, 0x50311395, 0x06101744, 0x7a12e181, 
	0x94a71092, 0x407800ed, 0x01a40710, 0x1a403400, 0x02000000, 0x00000000, 
	0x12103000, 0xc3121403, 0x3000c036, 0x4083041c, 0x01f06c40, 0x3100db00, 
	0x5c03300c, 0xc0b000cf, 0x000c0334, 0x0dd04840, 0x00000000, 0x00000000, 
	0x02b83d48, 0xbf00fc03, 0xf003c03d, 0x00bf00ec, 0x20f00ec4, 0x3b087f00, 
	0xec03f40a, 0xd02f00ff, 0x08fc23f0, 0x0fc00b60, 0x06000000, 0x00000000, 
	0x15a02700, 0xd7205c03, 0x340dd034, 0x0053007c, 0x05301dc0, 0x3600d380, 
	0x7c033419, 0x422410df, 0x007c03f0, 0x09c05700, 0x0e000000, 0x00000000, 
	0x12883900, 0xe100f403, 0x100f4038, 0x006100b4, 0x02100e40, 0x3801e100, 
	0x3403110e, 0x402800ed, 0x40b483d0, 0x0a404f24, 0x06000000, 0x00000000, 
	0x03007140, 0xe501b427, 0x101e407e, 0x00e10134, 0x05901b41, 0x724ae101, 
	0xb4071018, 0x504a00ed, 0x01b407d0, 0x1a400700, 0x04000000, 0x00000000, 
	0x12283300, 0x81007403, 0x101c4432, 0x00c10134, 0x80100840, 0x3000c130, 
	0x340b102c, 0x406201cd, 0x007403d0, 0x9c404b20, 0x0c000000, 0x00000000, 
	0x17a81500, 0x65027c01, 0x3077c856, 0x017321fc, 0x013427d0, 0x160073c2, 
	0xfc093017, 0xc01e047f, 0x00fc1df0, 0x05c05f20, 0x06000000, 0x00000000, 
	0x12000700, 0x1f037c08, 0xf001c985, 0x401f087c, 0x08f031c0, 0x07001f02, 
	0x3c00f4a1, 0xc085201f, 0x027c04f2, 0x01c24b00, 0x0c000000, 0x00000000, 
	0x10082300, 0x9f005c06, 0x30098064, 0x4093404c, 0x16f039c0, 0x27009b01, 
	0x7c463409, 0xc167008f, 0x804c0231, 0x09c04320, 0x0c000000, 0x00000000, 
	0x01202600, 0x9143440e, 0x100940e4, 0x00810144, 0x0ed04940, 0xa300910c, 
	0x74261049, 0x42e7019d, 0x1a440e10, 0x09400700, 0x08000000, 0x00000000, 
	0x18a02400, 0x9d015422, 0x15084021, 0x42910444, 0x42d00940, 0x2704d900, 
	0x74021019, 0x4027019d, 0x00440616, 0x09406300, 0x02000000, 0x00000000, 
	0x10202008, 0xd1000442, 0x10484131, 0x00810104, 0x52d00840, 0x23058114, 
	0x34531048, 0x4523008d, 0x04040610, 0x08404380, 0x00000000, 0x00000000, 
	0x1db00602, 0x1f005c11, 0x3041d005, 0x0013804c, 0x10f001c0, 0x07011b04, 
	0x7c103041, 0xc807001f, 0x044c0030, 0x01c477c0, 0x0a000000, 0x00000000, 
	0x19b82f02, 0xff007c52, 0xf04bc12a, 0x45bf00fd, 0x02f20ac0, 0x2700bf14, 
	0xfcd2f00b, 0xc02f10bf, 0x02fd52f0, 0x4bc16764, 0x0e000000, 0x00000000, 
	0x18a02f00, 0xbf00ed82, 0xf08bc02d, 0x00b340bc, 0x12300bc0, 0x2f01bf06, 
	0xcc12b04b, 0xc32800bf, 0x00fc0230, 0x29c06300, 0x0e000000, 0x00000000, 
	0x1c08870d, 0x1d000490, 0xd1a14400, 0x41110074, 0x28140140, 0x07001d24, 
	0x44101221, 0x4004001d, 0x00341010, 0x01407320, 0x0c000000, 0x00000000, 
	0x10a0a300, 0x9d80244a, 0xd0484021, 0x44810174, 0x06500848, 0xa3808d06, 
	0x04cf9018, 0x7020888d, 0x00344210, 0x08404b80, 0x0e000000, 0x00000000, 
	0x18a82508, 0x9d004402, 0xd0094020, 0x00912074, 0x02508948, 0x27009d30, 
	0x45021009, 0x6034009d, 0x00740710, 0x49406320, 0x06000000, 0x00000000, 
	0x05a82700, 0x9d416c02, 0xf0794065, 0x42930074, 0x0a4049c0, 0x27009f01, 
	0x4c06b409, 0xc024049f, 0x0c7c0234, 0x09c01720, 0x0e000000, 0x00000000, 
	0x14806502, 0x9f497c02, 0xf058c827, 0x009f007c, 0x02b419c0, 0x27008f03, 
	0x3d0ef048, 0xc227019f, 0x007c02f0, 0x09c05b00, 0x06000000, 0x00000000, 
	0x14080500, 0x13034c00, 0x3021c007, 0x0013017c, 0x04b031c0, 0x05101f42, 
	0x4c003081, 0xc0470013, 0x094c1030, 0x01c05320, 0x04000000, 0x00000000, 
	0x14a01404, 0x6152c401, 0x1077405f, 0x407102b4, 0x09107748, 0x9c007d05, 
	0xc4011007, 0x40df0070, 0x02c40910, 0x05405300, 0x02000000, 0x00000000, 
	0x14a07240, 0x81210403, 0x107c40d3, 0x01c10134, 0x05d00c40, 0x3104cd10, 
	0x07c1141c, 0x48730889, 0x00450b14, 0x0c405300, 0x0a000000, 0x00000000, 
	0x05807040, 0xf1008407, 0x100e403b, 0x44e110b4, 0xc1501e42, 0x28006d00, 
	0x0501100a, 0x407b4409, 0x01840310, 0x0e401700, 0x02000000, 0x00000000, 
	0x15107800, 0xa3018d07, 0x341ec06b, 0x00e301bc, 0x04f01ec0, 0x5900ff01, 
	0x8c053412, 0xc07b002b, 0x418c0731, 0x1ec05740, 0x00000000, 0x00000000, 
	0x10b83560, 0x8f007c03, 0xf00dc03f, 0x005f807c, 0x80b00cc0, 0x0700df00, 
	0x7d01f001, 0xc0370017, 0x007c03f0, 0x8dc04360, 0x06000000, 0x00000000, 
	0x00a07f00, 0x7301fc07, 0xf01fc07f, 0x007301bc, 0x247013c0, 0x7f22ef41, 
	0xcc85309e, 0xd04800a3, 0x01cd07f0, 0x1fc00000, 0x0e000000, 0x00000000, 
	0x15882d40, 0x6104b403, 0xd00e403f, 0x006100b4, 0x30108240, 0x2b00ed08, 
	0x8501150e, 0x400800e1, 0x008403d0, 0x0e405420, 0x06000000, 0x00000000, 
	0x00003900, 0xa110b403, 0x908e403b, 0x006100b4, 0x00580e40, 0x3b80fd00, 
	0x24611003, 0x740c0421, 0x008403d0, 0x0f400200, 0x04000000, 0x00000000, 
	0x04286720, 0x81633403, 0xd00d4033, 0x00410234, 0x28182c42, 0x2300dd93, 
	0x648d1084, 0x40c00441, 0x004501d0, 0x0c401220, 0x0c000000, 0x00000000, 
	0x15a87500, 0x91007c00, 0xb001c017, 0x41d38074, 0x0b702dc0, 0x3700df06, 
	0x6c2f3009, 0xd0a40012, 0x004c03d0, 0x1fc15620, 0x06000000, 0x00000000, 
	0x01003702, 0xdf067c00, 0xf101c037, 0x00df017c, 0x42f42dc1, 0x37005f00, 
	0x5c09f029, 0xd007001f, 0x007d04f0, 0x0dd80500, 0x0c000000, 0x00000000, 
	0x80083f00, 0xb308bc03, 0x3483c02c, 0x00f318b4, 0x16b01fc0, 0x5b01f300, 
	0xcc01340b, 0xc07f017b, 0x03fc0234, 0x0fc00322, 0x0c000000, 0x00000000, 
	0x81207602, 0xd102740b, 0x10214030, 0x00514074, 0x4a102d40, 0x5708d181, 
	0x44111009, 0x40230051, 0x00742510, 0x0d480700, 0x08000000, 0x00000000, 
	0x01a03440, 0x5122740c, 0x102d4034, 0x60110074, 0x02904d41, 0x3700d501, 
	0x56851039, 0x42051011, 0x02740310, 0x0d400700, 0x02000000, 0x00000000, 
	0x10203000, 0xc1003400, 0x100c4030, 0x00410034, 0x02100c40, 0x3300c140, 
	0x16011008, 0x42070040, 0x00340018, 0x0c604380, 0x00000000, 0x00000000, 
	0x00b03640, 0xd3207c83, 0x310dc034, 0x0053007c, 0x00b00dc8, 0x3710d300, 
	0x5c013109, 0xc0050853, 0x007c0231, 0x0dc003c0, 0x0a000000, 0x00000000, 
	0x05b83f40, 0xff00fc03, 0xf00fd03f, 0x007f00fc, 0x80f00fc0, 0x3f00bf00, 
	0xed00f60b, 0xc40f007f, 0x00fc01f0, 0x0ec01760, 0x0e000000, 0x00000000, 
	0x03a88f01, 0x3302fc02, 0x30cfd00a, 0x003f03fc, 0x23300bc5, 0x3d426300, 
	0xfc51f007, 0xc00f1133, 0x00cc21f0, 0x6ec40c00, 0x0e000000, 0x00000000, 
	0x05186710, 0xd1097443, 0x102d4004, 0x001d0eb4, 0x1b112540, 0x241211c0, 
	0x7409d305, 0x40071151, 0x846c00d1, 0x6d400520, 0x0c000000, 0x00000000, 
	0x11a01303, 0x41043422, 0x10854800, 0x000d0434, 0x0b140c40, 0x713889c0, 
	0x3401d004, 0x40030601, 0x900410d0, 0x68404480, 0x0e000000, 0x00000000, 
	0x07803540, 0xd1807423, 0x14054104, 0x081d0074, 0x03100d52, 0x64001920, 
	0x7603d005, 0x44174451, 0x006402d3, 0x0d600d20, 0x06000000, 0x00000000, 
	0x00006500, 0x93207c02, 0x309cd084, 0x041f0c7c, 0x033008c0, 0x75005b00, 
	0x7c21e005, 0xc2070053, 0x034c01f2, 0x0dd00020, 0x0e000000, 0x00000000, 
	0x87082501, 0xff003c03, 0xf10fc19d, 0x0c3f01fc, 0x83f00f50, 0x3f4077a0, 
	0xfc85f297, 0xc097207e, 0x03fc00f0, 0x4f801f02, 0x06000000, 0x00000000, 
	0x02083508, 0xd3c06c22, 0x313dc046, 0x00d3000c, 0x03300dc0, 0x34009300, 
	0x4d41b005, 0xc1044453, 0x006c0131, 0x1cd00820, 0x04000000, 0x00000000, 
	0x13203400, 0xd10a4407, 0x142dc0d6, 0x20db00c4, 0x0314fd40, 0x70085131, 
	0x444f101d, 0x409000d1, 0x074403b0, 0x8dc04c00, 0x02000000, 0x00000000, 
	0x07a01620, 0x0102244f, 0x102c4882, 0x80c10005, 0x83100848, 0x7010c100, 
	0x200cd0b0, 0x40400011, 0x33260110, 0x24481e00, 0x0a000000, 0x00000000, 
	0x8680f804, 0xe1858427, 0x141b406a, 0x10e90184, 0x07109740, 0xf8002101, 
	0x24045017, 0x60580471, 0x01840690, 0x1f401800, 0x02000000, 0x00000000, 
	0x12101042, 0x53802c23, 0x310cc202, 0x0213800c, 0x33300cc0, 0x34440108, 
	0x2401f0c4, 0xc8008003, 0x042c0832, 0x4cd04a40, 0x00000000, 0x00000000, 
	0x02b83d08, 0xff04fc23, 0xf40ac02f, 0x0a3f00fc, 0x63f00ec2, 0x3f083f00, 
	0xdc03b086, 0xc01f422e, 0x80bc00f0, 0x0fc00b60, 0x06000000, 0x00000000, 
	0x11a03700, 0x9f01c903, 0x340cc824, 0x00df007c, 0x1bf009c0, 0x3400d300, 
	0x7c00700d, 0xc0470053, 0x403c0130, 0x0c805500, 0x0a000000, 0x00000000, 
	0x12883910, 0xcd00c403, 0x100a5029, 0x00ed00b4, 0xd3d00c40, 0x18086100, 
	0x3400120e, 0x403b1061, 0x00b48210, 0x0e804a20, 0x06000000, 0x00000000, 
	0x83007900, 0xed819407, 0x111f6268, 0x00ed01b4, 0x07d01e40, 0x7900a101, 
	0xb405501e, 0x414b04a9, 0x01b44712, 0x1f400d02, 0x04000000, 0x00000000, 
	0x12283320, 0xcd061483, 0x180940f1, 0x11cd1334, 0x03da6c40, 0xf400c108, 
	0x3403111c, 0x44130099, 0x48340710, 0x6c404a20, 0x0c000000, 0x00000000, 
	0x17a81d00, 0x7f005c01, 0x3127c8dc, 0x007f677c, 0x01f027c0, 0x5d497303, 
	0xfc017036, 0xc89f487b, 0x23bc0d34, 0x67c05d20, 0x06000000, 0x00000000, 
	0x12000720, 0x1f006400, 0xf411c887, 0x0a0f007c, 0x00f121d0, 0x07041f81, 
	0x3c00f031, 0xc2470017, 0x817c04f1, 0x01404b00, 0x0c000000, 0x00000000, 
	0x10082706, 0x9f287c02, 0x3009d064, 0x109f084c, 0x82f008c0, 0x24809300, 
	0x7c06b019, 0xc824009f, 0x80480230, 0x09c84020, 0x0c000000, 0x00000000, 
	0x0120a600, 0x9d037402, 0x101940a4, 0x019d0344, 0x82d02950, 0x64029101, 
	0x740a1219, 0x4064089d, 0x005402b1, 0x48d00601, 0x08000000, 0x00000000, 
	0x18202404, 0x9d503402, 0x14194024, 0x019d5044, 0x02d04954, 0x2400d144, 
	0x742a904d, 0x616410dd, 0x00541212, 0x0d406000, 0x02000000, 0x00000000, 
	0x10202002, 0x8db8341b, 0x10484120, 0x308d8804, 0x12d20849, 0x60488100, 
	0x34121009, 0x40a0808d, 0x02168a90, 0x49504280, 0x00000000, 0x00000000, 
	0x1d108400, 0x1f067c08, 0x3081c804, 0x101f164d, 0x48f045d0, 0x04021100, 
	0x7400b001, 0xd080011f, 0x825c0834, 0x21c074c0, 0x0a000000, 0x00000000, 
	0x19b82f03, 0xbd84fc0a, 0xf40bc42f, 0x08be007c, 0xc2f00fc0, 0x2b42bf00, 
	0xfc0af20b, 0xc0bf01bd, 0x00f802f2, 0x2bc16760, 0x0e000000, 0x00000000, 
	0x19a02f00, 0xbf04bc22, 0x304bc028, 0x00bf0c4c, 0x02f00bc0, 0x2802b300, 
	0xcc52f00a, 0xc02c00a2, 0x20fc0230, 0x4bc06400, 0x0e000000, 0x00000000, 
	0xbc088704, 0x1d527420, 0x14415104, 0x005dcc44, 0x48c00142, 0x04021100, 
	0x4401d001, 0x40841615, 0x00740031, 0x41407122, 0x0c000000, 0x00000000, 
	0x10a02303, 0x8d283402, 0x52c86020, 0x108d0404, 0xb2c08940, 0x24008120, 
	0x0403d008, 0x40200185, 0x14345310, 0x28414080, 0x0e000000, 0x00000000, 
	0x18a82580, 0x9d407402, 0x50294224, 0x008d0844, 0x02d00940, 0x24089103, 
	0x4406d029, 0x50200295, 0x00740e13, 0x09436120, 0x06000000, 0x00000000, 
	0x05286500, 0x9f213c02, 0x7409c024, 0x009f034d, 0x02f808c0, 0x24449301, 
	0x4d02f029, 0xc0e40097, 0x9a7c0a34, 0x29c05420, 0x0e000000, 0x00000000, 
	0x5400a500, 0x9f037c82, 0xb008c067, 0x029f007c, 0x02f059d0, 0x27049f00, 
	0x7c02f029, 0xc027009f, 0x817c0270, 0x39c01301, 0x06000000, 0x00000000, 
	0x14080520, 0x17207c00, 0x3401c044, 0x8013004c, 0x00f031c0, 0x84221301, 
	0x4d043041, 0xc0060813, 0x924c0c30, 0xa1d35021, 0x04000000, 0x00000000, 
	0x14205c00, 0x7701f401, 0x0407409c, 0x00710444, 0x01d06750, 0x18406103, 
	0xc4093036, 0x401c0070, 0x03ac0112, 0x07d05300, 0x02000000, 0x00000000, 
	0x14a17200, 0xc5013483, 0x009c6032, 0x02c10105, 0x03501c40, 0xf0488108, 
	0x0403989c, 0x40a20181, 0x8b040011, 0x3d405004, 0x0a000000, 0x00000000, 
	0x9480180c, 0x6530b402, 0x1007507e, 0x00c16084, 0x13d00250, 0x3c28f100, 
	0x8407100a, 0x4830e071, 0x21e40014, 0x02401702, 0x02000000, 0x00000000, 
	0x14107800, 0xe701bc07, 0x321ad05a, 0x40e1018c, 0x3ff01840, 0x7800e321, 
	0x0487b01e, 0xc06a00a3, 0x018c0432, 0x16d05440, 0x00000000, 0x00000000, 
	0x10982500, 0xdf007c02, 0xf000c835, 0x00df007c, 0x0bf001c0, 0x3700cf00, 
	0x7001f40d, 0xc827005e, 0x003c00f2, 0x00c04360, 0x06000000, 0x00000000, 
	0x02a86f00, 0xfb89cc07, 0x311ec05d, 0x00ff01fc, 0x07b017c0, 0x7c487301, 
	0xfc043017, 0xc44d00f3, 0x09cc0531, 0x1fc00c20, 0x0e000000, 0x00000000, 
	0x15981900, 0x6108c412, 0x12065018, 0x01ed08fc, 0x03108640, 0x38026588, 
	0xb481100a, 0x40b801e1, 0x0cc40150, 0x4a405420, 0x06000000, 0x00000000, 
	0x19002902, 0xa1808403, 0x980b4019, 0x00ad00b4, 0x03100650, 0x3c006902, 
	0xf421100e, 0x400914e9, 0x30840810, 0x0c412000, 0x04000000, 0x00000000, 
	0x06202300, 0x81100406, 0x90104080, 0x028d0034, 0x03112040, 0xf0004948, 
	0x34991038, 0x426000d9, 0x50040050, 0x30461820, 0x0c000000, 0x00000000, 
	0x15a83552, 0x93034d45, 0xb015c901, 0x00df00fc, 0x8330b9c0, 0x5404db03, 
	0x7c01305d, 0xc0e1409b, 0x004d0a30, 0x34c07c00, 0x06000000, 0x00000000, 
	0x09001300, 0x17087c03, 0x7421c027, 0x09df025c, 0x037018d0, 0x371cd7c0, 
	0x7c81f00d, 0xc0370057, 0x407c06f0, 0x01c00700, 0x0c000000, 0x00000000, 
	0x80081f00, 0x5300cc23, 0x3003f02c, 0x007300bc, 0x032859d0, 0x2800f300, 
	0xfe00300f, 0xc92c04b3, 0x00cc02d0, 0x07c12800, 0x0c000000, 0x00000000, 
	0x83018604, 0x510b440b, 0x1450c824, 0x00510264, 0x03107140, 0xf421d192, 
	0x3e49148c, 0xc226405b, 0x80548291, 0x11d00602, 0x08000000, 0x00000000, 
	0x00202488, 0x81020409, 0x14154804, 0x05d15074, 0x03500140, 0x7440d101, 
	0x7484100d, 0x410480d1, 0x004401d2, 0x31400000, 0x02000000, 0x00000000, 
	0x10201000, 0x01800403, 0x14044000, 0x00c1c024, 0x03580c40, 0x30c0c500, 
	0x16011009, 0x481680c9, 0x00140590, 0x08504280, 0x00000000, 0x00000000, 
	0x01900240, 0x13004d03, 0x34014004, 0x401340f4, 0x035005d0, 0x3400d300, 
	0x7400300d, 0xc00008d3, 0x004c00f2, 0x09d004c0, 0x0a000000, 0x00000000, 
	0x04b80f00, 0x3f00fc03, 0xf403c00d, 0x083f00e8, 0x03b003c0, 0x3b00fb00, 
	0xbc01f10a, 0xc00f00e7, 0x00fc00f0, 0x03c01360, 0x0e000000, 0x00000000, 
	0x03a03f00, 0xff80cc03, 0x520bc81c, 0x107704cc, 0xc3f00fc0, 0x3c60b300, 
	0xcc0af007, 0xd02810ff, 0x0ccc1b30, 0x0bc40800, 0x0e000000, 0x00000000, 
	0x01083700, 0xdd000403, 0x10094834, 0x00410040, 0x09d20d40, 0xb4089134, 
	0x448010a5, 0x403500dd, 0x2c441010, 0x09400c20, 0x0c000000, 0x00000000, 
	0x11a03300, 0xcd000483, 0x50084034, 0x00450204, 0x50d00c40, 0x3002d500, 
	0x0413d200, 0x405000cd, 0x04041a10, 0x0d404480, 0x0e000000, 0x00000000, 
	0x03a83504, 0xcd004543, 0x10285034, 0x80511040, 0x46d00d10, 0x34001180, 
	0x45015011, 0x003500dd, 0x00401114, 0x0d400820, 0x06000000, 0x00000000, 
	0x80a08700, 0x1f004c28, 0x7019c064, 0x02d7824c, 0x0df10dc0, 0x3000875b, 
	0x0c0af215, 0x507400df, 0x004d0730, 0x9cd00422, 0x04000000, 0x00000000, 
	0x87880d10, 0x3f00fc04, 0xf09fc13f, 0x00ef047c, 0x01f00ec2, 0x3f00bf20, 
	0xfc24b406, 0xd23f0aef, 0x02bc83f4, 0x0fc63f00, 0x04000000, 0x00000000, 
	0x02089500, 0xdf003c08, 0x3829f064, 0x00df025c, 0x02b00dc0, 0x3704d700, 
	0x4c4b3405, 0xc13401db, 0x244c0334, 0x0dc02b20, 0x04000000, 0x00000000, 
	0x13a01400, 0xdd007400, 0x102d4030, 0x00dd0044, 0x16100f40, 0xff241b01, 
	0x6c1f101d, 0x40b400d1, 0x06440710, 0x0d404f00, 0x00000000, 0x00000000, 
	0x03203000, 0xcd003403, 0x10184000, 0x004d0004, 0x01900c40, 0x7200c109, 
	0x060e1034, 0x423300c9, 0x02140010, 0x0c401f01, 0x0a000000, 0x00000000, 
	0x04087800, 0xed01b407, 0x101241f8, 0x082d0184, 0x0d101e40, 0x7b00f941, 
	0xa6040416, 0x417d00c1, 0x01944610, 0x1e403702, 0x02000000, 0x00000000, 
	0x12103001, 0xcf243c13, 0x10094220, 0x004f040c, 0x03b04cc0, 0x3601c300, 
	0x4c1b3044, 0xc033004b, 0x005d0930, 0x0cc04b40, 0x00000000, 0x00000000, 
	0x02283500, 0xdf007c03, 0xf081d037, 0x001f006d, 0x03f00dc0, 0x3700cf00, 
	0x7c01f400, 0xc43600df, 0x406c03f5, 0x0dc00b60, 0x06000000, 0x00000000, 
	0x10a06708, 0x13014c07, 0x3009c022, 0x00d7004c, 0x01300dc0, 0x3702df00, 
	0x4e83d005, 0xc2740013, 0x004c0310, 0x0dc05700, 0x0e000000, 0x00000000, 
	0x128b2900, 0x01008483, 0x100b4038, 0x00e10084, 0x03144e40, 0x3b01ed20, 
	0x8c03d006, 0x403800c1, 0x00840310, 0x0e404f04, 0x06000000, 0x00000000, 
	0x8400718c, 0xe1110447, 0x101a406c, 0x00e50184, 0x0710de40, 0x7b00ed01, 
	0xa5079017, 0x407c08a1, 0x01858714, 0x1e440702, 0x04000000, 0x00000000, 
	0x16283380, 0xc1000403, 0x18184030, 0x00410144, 0x01100c42, 0x3300dd00, 
	0x0407d054, 0x40b000c1, 0x0a040710, 0x1c404b20, 0x0c000000, 0x00000000, 
	0x17201d40, 0x7300cd01, 0x3426d09c, 0x007703cd, 0x013805c0, 0x17007f00, 
	0xec0df057, 0xd01c2273, 0x01cc4930, 0x15c05f20, 0x06000000, 0x00000000, 
	0x12080500, 0x1f027c08, 0xf091c045, 0x001f097c, 0x04f801c0, 0x07001f42, 
	0x7d24f001, 0xc087601f, 0x107c48f0, 0x81c24b00, 0x0c000000, 0x00000000, 
	0x11082504, 0x9f137c4e, 0xf009c024, 0x4093014c, 0x02b009ca, 0x631a9302, 
	0x4d06f239, 0xc064018f, 0x00480230, 0x09c04320, 0x0c000000, 0x00000000, 
	0x01202400, 0x9d007402, 0xd0094020, 0x00910644, 0x02100940, 0x27109113, 
	0x4412d018, 0x4864009d, 0x01444a10, 0x09404700, 0x08000000, 0x00000000, 
	0x18a02400, 0x95007402, 0xd0096024, 0x01818444, 0x06900940, 0x27009100, 
	0x4622d10d, 0x502400dd, 0x08140210, 0x09406300, 0x00000000, 0x00000000, 
	0x10202005, 0xcd143453, 0xd0094024, 0x00811404, 0x52104849, 0x63058114, 
	0x0482d049, 0x4130008d, 0x14155210, 0x08404320, 0x00000000, 0x00000000, 
	0x1db00601, 0x17047c10, 0xf001c014, 0x2003044d, 0x11b041c0, 0x07411304, 
	0x4c00e241, 0xc004001f, 0x241c1030, 0x01c0f760, 0x08000000, 0x00000000, 
	0x1db92f00, 0xbf14fc52, 0xf04bd12f, 0x40bf14bc, 0x52f009c0, 0x2705af14, 
	0xfc52f00a, 0xc02b00bf, 0x14ec52f4, 0x0bca6f24, 0x0e000000, 0x00000000, 
	0x1ca02700, 0xbf04fe22, 0x300bc03f, 0x10bf0ccd, 0x02700bc4, 0x2f40b312, 
	0xcf02000b, 0xc03880b3, 0x00cc2230, 0x09c06300, 0x0e000000, 0x00000000, 
	0x98088700, 0x5d127420, 0x10414307, 0x805d0c44, 0x4810a160, 0x87021142, 
	0x46811085, 0x42040011, 0x1004a010, 0x0140fb22, 0x0c000000, 0x00000000, 
	0x12002192, 0x8d083402, 0x10484023, 0x008d8404, 0x32d0084e, 0x232d8140, 
	0x44d21008, 0x44240081, 0x08040210, 0x08484b80, 0x0e000000, 0x00000000, 
	0x18282580, 0x9d007402, 0x150940a7, 0x00dd0044, 0x42100946, 0x27009100, 
	0x44021049, 0x48640091, 0x02440210, 0x49406320, 0x06000000, 0x00000000, 
	0x05226508, 0x9fab7482, 0x3009c027, 0x089d024d, 0x2e700940, 0x27009313, 
	0x408a1028, 0xd0644491, 0x004d0630, 0x09c81721, 0x04000000, 0x00000000, 
	0x1608a520, 0x9f013c02, 0xf009c427, 0x048f003d, 0x467909c0, 0x23049f12, 
	0x7c12f409, 0xc027008f, 0x007c52f4, 0x09e05b00, 0x04000000, 0x00000000, 
	0x14080500, 0x13024f80, 0x3001c907, 0x0017024d, 0x20b001c0, 0x07201f02, 
	0x4c00f121, 0xc2c42013, 0x000c0030, 0x01c05321, 0x04000000, 0x00000000, 
	0x10201400, 0x7300c601, 0x1407409f, 0x207100c4, 0x011105c2, 0x9d007d00, 
	0xac05d107, 0x40980071, 0x01c40911, 0x05407300, 0x00000000, 0x00000000, 
	0x10a03200, 0xc1000403, 0x108c6c03, 0x10c50005, 0x0c998840, 0x9300dd00, 
	0x3627d01c, 0x402080c1, 0x01050b14, 0x0c605300, 0x0a000000, 0x00000000, 
	0x04807800, 0xc1018403, 0x1002405b, 0x00e10004, 0x83180a40, 0x2b00ed42, 
	0xb401d02b, 0x5028c0e1, 0x10840310, 0x0e601322, 0x02000000, 0x00000000, 
	0x14107000, 0xe3010487, 0x301e405b, 0x00f7018c, 0x05b01ac0, 0x4b20cf01, 
	0xbd07f01a, 0xc07800c3, 0x018c0730, 0x1ec07344, 0x00000000, 0x00000000, 
	0x10983540, 0xdf007c03, 0xf201c013, 0x00df007c, 0x02f209c0, 0x1500df00, 
	0x6c03f008, 0xc03740d7, 0x007c03f0, 0x0dc04321, 0x06000000, 0x00000000, 
	0x06207d00, 0xff01fc37, 0x709fc048, 0x00e701cc, 0x07309fc0, 0x5f007301, 
	0xcc07b01b, 0xc04c00f3, 0x01cc0730, 0x1fc00b00, 0x0e000000, 0x00000000, 
	0x15083908, 0xed04b423, 0x108e4138, 0x00e10084, 0x23900e40, 0x0b006100, 
	0xd501140a, 0x400804f5, 0x04846310, 0x0e405721, 0x06000000, 0x00000000, 
	0x00003900, 0xed803413, 0x520e021c, 0x02f51884, 0x03940e40, 0x2b00c100, 
	0x842b900b, 0x401800e1, 0x20840110, 0x0e400700, 0x04000000, 0x00000000, 
	0x02283100, 0xdd807403, 0x102c4030, 0x00c00144, 0x0b900c48, 0x1720d001, 
	0x54031838, 0x40d090c5, 0x0b440510, 0x0c401b20, 0x0c000000, 0x00000000, 
	0x15a03500, 0x1f007800, 0x703dd0c4, 0x00170b4d, 0x01100cc0, 0x17605346, 
	0x4e8bb00d, 0xd1240053, 0x004d0e34, 0x0d405720, 0x06000000, 0x00000000, 
	0x05083700, 0x1f007c00, 0xf001c057, 0x001f007c, 0x4a700dc0, 0x37205f00, 
	0x7c0bf021, 0xc12701df, 0x027c13f0, 0x0dc00700, 0x0c000000, 0x00000000, 
	0x80083f00, 0xff01cc07, 0x300fc13f, 0x04ef0944, 0x00351fc0, 0x1400b310, 
	0xcc03320a, 0xc02d0073, 0x10fc1434, 0x0fc00322, 0x0c000000, 0x00000000, 
	0x81203600, 0xdd13444f, 0x100140b7, 0x21dd0044, 0x07109d42, 0x5402d191, 
	0x440f1241, 0x40a00191, 0x83740112, 0x0d400f00, 0x08000000, 0x00000000, 
	0x01a03600, 0x1d044420, 0x100d4005, 0x001d0054, 0x0f100d50, 0x1500d101, 
	0x450f5409, 0x40050111, 0x03744210, 0x0d400700, 0x00000000, 0x00000000, 
	0x10083000, 0x0d000400, 0x100c4033, 0x000d0015, 0x03140c40, 0x1100c100, 
	0x04030200, 0x422000c1, 0x20340314, 0x0c404300, 0x00000000, 0x00000000, 
	0x00103600, 0xdf004d03, 0x340cc035, 0x00df005d, 0x01300dc0, 0x3540d300, 
	0x4c033209, 0xd0050013, 0x003c0231, 0x0de00340, 0x08000000, 0x00000000, 
	0x05a83f00, 0xff00fc03, 0xf00fc03f, 0x00ff80ec, 0x03d00fc2, 0x1e00ff00, 
	0xf002f402, 0xcc0b50ff, 0x00fc03f0, 0x0fc01760, 0x0e000000, 0x00000000, 
	0x03a04f02, 0x3f52cc03, 0x300fc0cf, 0x013f08cc, 0x14300ac2, 0xbc103300, 
	0xcc037003, 0xc03f02ff, 0x0ccc12f0, 0x0fc00c00, 0x0e000000, 0x00000000, 
	0x05088701, 0xdd234403, 0x10ed4807, 0x009d0705, 0x18102948, 0x34011180, 
	0x44035001, 0x403429dd, 0x4e442ad1, 0xad480520, 0x0c000000, 0x00000000, 
	0x11a0b310, 0x0d040483, 0x100c4123, 0x030d0204, 0x49102842, 0x34401100, 
	0x05035001, 0x403300cd, 0x000402d0, 0x0c004480, 0x0e000000, 0x00000000, 
	0x07a83500, 0xdd004403, 0x140d4087, 0x00890044, 0x02100974, 0x34101100, 
	0x440b5421, 0x4014019d, 0x014546d0, 0x0d400d20, 0x02000000, 0x00000000, 
	0x00294500, 0x9f004d03, 0x320dc057, 0x00df214c, 0x083429c8, 0xf0021303, 
	0x0d037091, 0xc03700df, 0x434c8ee0, 0x0dc00820, 0x0a000000, 0x00000000, 
	0x87004d0a, 0xff08fc03, 0xf00f465f, 0x02ff04fc, 0x01f00ac0, 0x3f183f04, 
	0xfc01b007, 0x803f00ef, 0x007c02f0, 0x0e401e00, 0x06000000, 0x00000000, 
	0x02080500, 0x9f047c03, 0xf00dc027, 0x00df003c, 0x09342dc0, 0xb4001302, 
	0x7c2a3001, 0xc02400d3, 0x0e4d0a34, 0x0dcc0b20, 0x04000000, 0x00000000, 
	0x13200400, 0xdd44b603, 0xd00f4087, 0x08dd0074, 0x2b117dc0, 0x3410810a, 
	0x7428105c, 0x403401d1, 0x02454610, 0x1f404f08, 0x02000000, 0x00000000, 
	0x07a00220, 0x5d023403, 0xd00c4483, 0x244d0034, 0x02101849, 0x22000982, 
	0x34071020, 0x417200c1, 0x81144c48, 0x5c401f00, 0x0a000000, 0x00000000, 
	0x06804802, 0xed41b407, 0xd01e446b, 0x82ed01b4, 0x04129a52, 0x6c422901, 
	0xf4079012, 0x407800e1, 0x09960713, 0x1e411300, 0x02000000, 0x00000000, 
	0x1210b006, 0x4f003403, 0xf00cc033, 0x024f003c, 0x0b3000c0, 0xb2024b02, 
	0x3c013200, 0xe03642d3, 0x0a1c0270, 0x0cc04b40, 0x00000000, 0x00000000, 
	0x02b83d22, 0xff00f403, 0xf00fc13f, 0x0aff08fc, 0x22f00bc0, 0x3b027708, 
	0xbc217482, 0xc01f007c, 0x48e523d0, 0x0fc00a60, 0x06000000, 0x00000000, 
	0x11a83700, 0xd3807c03, 0xf00dc015, 0x00d3004c, 0x02f209c2, 0x04601300, 
	0x7c03f108, 0xc03508df, 0x004c0331, 0x0dc25700, 0x0e000000, 0x00000000, 
	0x12983100, 0xe1009c1b, 0xd01f4430, 0x00c10084, 0x01d00a40, 0x0c00a100, 
	0xb401d00a, 0x403808ed, 0x00840311, 0x6e404b20, 0x06000000, 0x00000000, 
	0x83007900, 0xe101b407, 0xd01e4079, 0x00e50384, 0x07d01e41, 0x5a002111, 
	0xa404d01b, 0x507900ed, 0x01a40716, 0x1e400f00, 0x04000000, 0x00000000, 
	0x12203704, 0xc1041403, 0xd00d4074, 0x00d58145, 0x23d17c40, 0x9200c180, 
	0x3480d01c, 0x407402cd, 0x04240312, 0x0c404b20, 0x0c000000, 0x00000000, 
	0x17a8dd41, 0x73007c01, 0xf005c05d, 0x417700cc, 0x05f037c0, 0x9e027343, 
	0xfc4df836, 0xc49d287f, 0x23ec3930, 0x05c45f20, 0x06000000, 0x00000000, 
	0x12000700, 0x0f807c00, 0xf001c487, 0x0019007c, 0x00f101d0, 0x05001f41, 
	0x7e04f0b1, 0xc047201f, 0x0a5f00f0, 0x01c04b00, 0x0c000000, 0x00000000, 
	0x1008e700, 0x93004c26, 0xf009c026, 0x8093904c, 0x063088c0, 0x26109380, 
	0x7c02f239, 0xc4240082, 0x400c0230, 0x09c04320, 0x0c000000, 0x00000000, 
	0x0120e600, 0x91024406, 0xd0094024, 0x819b0a44, 0x02112940, 0x20009500, 
	0x740ef829, 0x40250891, 0x06440210, 0x09400700, 0x08000000, 0x00000000, 
	0x18002400, 0x91024602, 0xd0094026, 0x00911044, 0x52502d40, 0x26009100, 
	0x540ed009, 0x50240a95, 0x004602d4, 0x09416300, 0x02000000, 0x00000000, 
	0x10202040, 0x810c0712, 0xd0684020, 0x00810804, 0x025c4860, 0xa0408500, 
	0x34025009, 0x40218085, 0x04041290, 0x08404380, 0x00000000, 0x00000000, 
	0x1d10142d, 0x13864c50, 0xf041c006, 0x4711024d, 0x507141c2, 0x86205340, 
	0x7c00d005, 0xc0041017, 0x0c4d50f3, 0x01c477c0, 0x08000000, 0x00000000, 
	0x19b82f04, 0xbf0c7c02, 0xf069c02f, 0x00bfacfc, 0x42b08ac8, 0x2f01bf00, 
	0xfc02f00b, 0xc02f64ab, 0x0cbd0274, 0x89c067e0, 0x06000000, 0x00000000, 
	0x19a0af04, 0xbf00cc02, 0xf069c12f, 0x24bf10fc, 0x02f00bc0, 0x2d00b300, 
	0xcc02f00b, 0xc02f02b3, 0x16cc42f0, 0x0bc16300, 0x0e000000, 0x00000000, 
	0x9c081300, 0x1d044400, 0xd0614087, 0x00170074, 0x00d0a140, 0x04405100, 
	0x45007001, 0xc0050011, 0x025408d0, 0x21407320, 0x0c000000, 0x00000000, 
	0x10a02300, 0x8d12040a, 0xd0084023, 0x058d9034, 0x4ad01846, 0x21059100, 
	0x0402d008, 0x40270191, 0x240402d0, 0x08484388, 0x0e000000, 0x00000000, 
	0x18a82501, 0x9d004402, 0xd0094aa7, 0x019d0074, 0x12d01944, 0x20509100, 
	0x4462c049, 0x40a50191, 0x04540ad0, 0x09426320, 0x06000000, 0x00000000, 
	0x5528a500, 0x9f004d02, 0xf009c067, 0x009f007c, 0x12f009c0, 0x65009302, 
	0x4c06f029, 0xc9674083, 0x504e0af2, 0x09c01720, 0x0e000000, 0x00000000, 
	0x14002500, 0x8f107c02, 0xf009c267, 0x1097407c, 0x02f008c0, 0xa7109f04, 
	0x7c027019, 0xc065009f, 0x117c42f0, 0x09405300, 0x06000000, 0x00000000, 
	0x14088540, 0x13007c00, 0x3001c084, 0x001f087c, 0x20f011c0, 0x06011b00, 
	0x4d0cf031, 0xc4070013, 0x024d0032, 0x11c25320, 0x04000000, 0x00000000, 
	0x14a01c00, 0x71017401, 0x1005501c, 0x007d80f4, 0x85d22740, 0xdc006102, 
	0xc40dd137, 0x40db2071, 0x00c40516, 0x27405300, 0x02000000, 0x00000000, 
	0x14a03200, 0xc1033407, 0x100c4830, 0x02cd3034, 0x87d21c40, 0x3200c19b, 
	0x0407d80c, 0x60930441, 0x82040f10, 0x18405300, 0x0a000000, 0x00000000, 
	0x84807800, 0x6110340f, 0x105c4038, 0x00ed00b4, 0x03d00841, 0xbd40f100, 
	0x840bd00a, 0x419b40f1, 0x00044510, 0x0a411708, 0x02000000, 0x00000000, 
	0x14107890, 0xe301bc06, 0x343ec078, 0x00af01bc, 0x07f012c0, 0x7a00e301, 
	0x8c06f012, 0xc05f00e3, 0x018d0730, 0x1ac05740, 0x00000000, 0x00000000, 
	0x10b82500, 0xdf007c02, 0xf01dc817, 0x009f007c, 0x01f001c0, 0x3200cf00, 
	0x7c01d001, 0xc01748cf, 0x007c01f4, 0x01c04360, 0x06000000, 0x00000000, 
	0x02a07f00, 0xb301cc07, 0xf21fc47c, 0x02f301fc, 0x273016c0, 0x7c002301, 
	0xcc257093, 0xc06f40f3, 0x018c0530, 0x1bc40000, 0x0e000000, 0x00000000, 
	0x2588b909, 0x21008403, 0xd10e4038, 0x10e402bc, 0x031002c0, 0x3f002b00, 
	0x84015002, 0x40ab01ef, 0x04ac0010, 0x02425420, 0x06000000, 0x00000000, 
	0x19003908, 0x2100a402, 0xd00e4038, 0x006100b4, 0x82900340, 0x3800b100, 
	0xa400c222, 0x423f20e1, 0x00860150, 0x02400000, 0x04000000, 0x00000000, 
	0x26282300, 0x01102402, 0xd00d4090, 0x00411034, 0x0c902041, 0x33008900, 
	0x24099000, 0x407700cd, 0x08240410, 0x00401020, 0x0c000000, 0x00000000, 
	0x15a83510, 0xd3236d02, 0xf00fc034, 0x4053007c, 0x03b409d0, 0x04004321, 
	0x6f00f011, 0xc0774183, 0x814d3170, 0x05c05420, 0x02000000, 0x00000000, 
	0x09003700, 0x1f085c02, 0xf00dc237, 0x005f025c, 0x337001c0, 0x0710d753, 
	0x5c407019, 0xc2a701df, 0x045c00f4, 0x01c00700, 0x0c000000, 0x00000000, 
	0x80081700, 0xff00fc26, 0xf00dc43a, 0x0623084c, 0x03f012c0, 0x0e10f348, 
	0xcc00f013, 0xc83f0093, 0x04c41530, 0x17c00322, 0x0c000000, 0x00000000, 
	0x83218608, 0x9d017406, 0xd00d4054, 0x001b0244, 0x01901140, 0x8440d300, 
	0x4518d021, 0x40f710db, 0x07040010, 0x21410702, 0x08000000, 0x00000000, 
	0x00003408, 0xdd047403, 0xd00d4026, 0x00900044, 0x03d08540, 0xf2005902, 
	0x4411d041, 0x41676091, 0x00540810, 0x81400700, 0x02000000, 0x00000000, 
	0x10203010, 0x0d003603, 0xd00c4020, 0x108d4005, 0x03d21040, 0x30004100, 
	0x0601d800, 0x402300c9, 0x00550010, 0x00404380, 0x00000000, 0x00000000, 
	0x01901600, 0x4f007c02, 0xd00dc022, 0x0013004c, 0x02d001c0, 0x3600db00, 
	0x4c00f001, 0xc4370093, 0x805c0034, 0x01c003c0, 0x0a000000, 0x00000000, 
	0x04b80f00, 0x3f00f802, 0xf00fc00f, 0x083a00fc, 0x00b10384, 0x3f00ff00, 
	0xac01f003, 0x403b00f7, 0x40ec00f0, 0x02c01760, 0x0e000000, 0x00000000, 
	0x00a102c8, 0x0e023b08, 0xec28a083, 0xc00e023b, 0x10ec20a0, 0x83800e80, 
	0x3b08ec28, 0xa0e3c08e, 0x023b0ae8, 0x40b8038c, 0x00000000, 0x00000000, 
	0x00a122a4, 0x8c803a02, 0xea180823, 0xa08e803a, 0x02ea08a8, 0x23a08e90, 
	0x3202ea18, 0x8823a08e, 0x813a02e8, 0x0828038c, 0x0a000000, 0x00000000, 
	0x00034080, 0x06011204, 0x4800a043, 0x80040112, 0x04481020, 0x41800401, 
	0x1a044810, 0x20438004, 0x01120648, 0x10a00104, 0x00000000, 0x00000000, 
	0x00010080, 0x06001a00, 0x68408901, 0x8006001a, 0x006800a9, 0x01a40610, 
	0x1a006888, 0xa9218486, 0x101a4068, 0x00a80184, 0x00000000, 0x00000000, 
	0x00a312a2, 0x4e803a01, 0xea04a81b, 0x224c80ba, 0x61ca04a8, 0x13a04a0a, 
	0x3a01ea84, 0xa81ba24c, 0x803a05ea, 0x84a8038c, 0x0a000000, 0x00000000, 
	0x00a30200, 0x06001820, 0x60008001, 0x02040018, 0x20408080, 0x01020600, 
	0x18006000, 0x80010204, 0x00180060, 0x0080018c, 0x08000000, 0x00000000, 
	0x00a31220, 0x44801001, 0x42000811, 0x20468010, 0x03620008, 0x01204400, 
	0x10014200, 0x08112046, 0x80100142, 0x0c08018c, 0x00000000, 0x00000000, 
	0x00a2f2a0, 0x42810a05, 0x2a10a050, 0xa04a810a, 0x05aa10a0, 0x4080c283, 
	0x0a052a10, 0xa050a04a, 0x810a052a, 0x34a00088, 0x0a000000, 0x00000000, 
	0x0001b080, 0xc800aa03, 0xa80ca03a, 0x80c000aa, 0x07080ea0, 0x3a80ca02, 
	0x2203a80c, 0xa03a80c0, 0x002a03a8, 0x3c20020c, 0x00000000, 0x00000000, 
	0x00016000, 0x08000800, 0x20048005, 0x01000048, 0x02000480, 0x10008200, 
	0x20002004, 0x80040100, 0x00080022, 0x08008204, 0x00000000, 0x00000000, 
	0x00a30640, 0x18004100, 0x04011104, 0x40100041, 0x00040111, 0x04441010, 
	0x61000401, 0x11044410, 0x10414000, 0x0110828c, 0x0a000000, 0x00000000, 
	0x00a302a0, 0x06809a00, 0x6a00b009, 0xa004809a, 0x006a02b8, 0x09e00600, 
	0x1a006a00, 0xb809a004, 0x801a206a, 0x00a8018c, 0x00000000, 0x00000000, 
	0x00a302c0, 0x06001b00, 0x6c04a003, 0x8006001b, 0x006e04a0, 0x11800600, 
	0x19006c04, 0xa803e006, 0x001b206c, 0x00b0018c, 0x00000000, 0x00000000, 
	0x00a24224, 0x0c813004, 0xc2108841, 0x240c8130, 0x44c21002, 0x43200c91, 
	0x3004c210, 0x8941240c, 0x813024c2, 0x1009038c, 0x0a000000, 0x00000000, 
	0x00000000, 0x0c003020, 0xc0000001, 0x020c0030, 0x20c08000, 0x03020c00, 
	0x3000c000, 0x0001020c, 0x003000c0, 0x00000304, 0x00000000, 0x00000000, 
	0x00014080, 0x0c013204, 0xc8302843, 0x800c0132, 0x04c83028, 0xc3a00c01, 
	0x3204c830, 0x2043800c, 0x013204c8, 0x10200304, 0x00000000, 0x00000000, 
	0x00a242a0, 0x06811a04, 0x6a30a841, 0xa006811a, 0x04e830a8, 0xc1a00681, 
	0x1a046a30, 0xa8418006, 0x811a046a, 0x10a8018c, 0x0a000000, 0x00000000, 
	0x00a34200, 0x04011004, 0x40100043, 0x000c0110, 0x04401000, 0x43000c01, 
	0x10044010, 0x00430004, 0x01100640, 0x1000018c, 0x00000000, 0x00000000, 
	0x00a34a20, 0x06811804, 0x6218084b, 0x20068198, 0x04601008, 0x43202c80, 
	0x1804621a, 0x084b0006, 0x81180462, 0x0288018c, 0x00000000, 0x00000000, 
	0x00a346a0, 0x10806a00, 0xa2012006, 0xa018806a, 0x048a0120, 0x06809880, 
	0x6a00aa01, 0x2806a01a, 0x806a00aa, 0x09a8028c, 0x0a000000, 0x00000000, 
	0x00006480, 0x82010a06, 0x2818a060, 0x808a014a, 0x062818a0, 0x60809201, 
	0x0a062808, 0xa060808a, 0x010a0628, 0x19a00000, 0x00000000, 0x00000000, 
	0x00014880, 0x00010204, 0x08182048, 0x80040182, 0x04081022, 0x40802001, 
	0x02840812, 0x20488000, 0x01020608, 0x12200084, 0x08000000, 0x00000000, 
	0x00a3e2c0, 0x8a012b06, 0xac98b062, 0x408a0103, 0x0eac98a0, 0x62c28a09, 
	0x2b06ac98, 0xb062428a, 0x092b26ac, 0x18b0028c, 0x0a000000, 0x00000000, 
	0x00a26284, 0x8e813a06, 0xea18b863, 0xe48e013a, 0x46e81898, 0x63e08e91, 
	0x3a06ea18, 0xb963848e, 0x813a06ea, 0x18a9038c, 0x00000000, 0x00000000, 
	0x00a262c0, 0x8e013b06, 0xec18a063, 0xc086013b, 0x06ec18a0, 0x63808e01, 
	0x3b06ec18, 0x8063c08e, 0x013b06ec, 0x18b00388, 0x00000000, 0x00000000, 
	0x00a26aa0, 0x8e813a26, 0xea180863, 0xa28c81ba, 0x26ca9888, 0x63a2ac81, 
	0x3206ea18, 0x0863a28e, 0x813a06ea, 0x1aa80388, 0x0a000000, 0x00000000, 
	0x00004080, 0x04011204, 0x4810a043, 0x80040112, 0x04681022, 0x43800601, 
	0x1a044810, 0xa0438004, 0x01120448, 0x10200100, 0x00000000, 0x00000000, 
	0x00006080, 0x86011a06, 0x6818a861, 0x8086011a, 0x066818a8, 0x61a08601, 
	0x1a066818, 0x88610086, 0x011a0668, 0x18a00100, 0x00000000, 0x00000000, 
	0x00a20220, 0x0e803a00, 0xca00a823, 0xa40c803a, 0x10ca0028, 0x03a00c80, 
	0x3a00ea00, 0xa803240c, 0x803a00ea, 0x00a80388, 0x0a000000, 0x00000000, 
	0x00a24200, 0x06011804, 0x40108041, 0x00040118, 0x00401000, 0x41000401, 
	0x18046010, 0x80010000, 0x01180460, 0x10800188, 0x00000000, 0x00000000, 
	0x00a24220, 0x04811004, 0x62100851, 0x20068110, 0x0522108a, 0x41200681, 
	0x10044210, 0x08512006, 0x81100442, 0x10080188, 0x00000000, 0x00000000, 
	0x00a242a0, 0x02810a0c, 0xaa10a0c0, 0xa00a810a, 0x06aa30a0, 0xc2800a81, 
	0x0a042a10, 0xa0e0a00a, 0x810a0422, 0x10a80088, 0x0a000000, 0x00000000, 
	0x00004080, 0x08032a0c, 0xa830a012, 0x800a032a, 0x054830a0, 0xc2800a01, 
	0x220ca830, 0xa052800a, 0x032a0ca8, 0x10200200, 0x00000000, 0x00000000, 
	0x00001000, 0x4c000800, 0x20048000, 0x02460008, 0x20000080, 0x00004200, 
	0x20012004, 0x80000242, 0x00080120, 0x04000200, 0x00000000, 0x00000000, 
	0x00a24244, 0x08010105, 0x04921040, 0x40000101, 0x44041410, 0x50400011, 
	0x21040412, 0x10404004, 0x01011404, 0x10110288, 0x0a000000, 0x00000000, 
	0x00a202a0, 0x06801a00, 0x6a00b801, 0xa006801a, 0x004a00b8, 0x01e00680, 
	0x1a006a00, 0xb901a006, 0x809a006a, 0x00a80188, 0x00000000, 0x00000000, 
	0x00a30280, 0x06001b00, 0x6c00a003, 0xc006001b, 0x006c00a8, 0x03800e00, 
	0x1a006c00, 0xa003c006, 0x001b006c, 0x00b00100, 0x00000000, 0x00000000, 
	0x00000000, 0x0c803000, 0xc2008901, 0x200c8030, 0x10c00088, 0x01200600, 
	0x3000c200, 0x8901000c, 0x80b040c2, 0x80080300, 0x00000000, 0x00000000, 
	0x00000004, 0x0c003000, 0xc0020061, 0x010c0030, 0x00c00200, 0x09002410, 
	0x3000c002, 0x0069002c, 0x00b000c0, 0x00000300, 0x00000000, 0x00000000, 
	0x00002080, 0x8c02320a, 0xc8292823, 0x818c0232, 0x02c82820, 0xa3a08c00, 
	0x320ac829, 0x2823808c, 0x02320ac8, 0x08200300, 0x00000000, 0x00000000, 
	0x0000c4a0, 0x16835a0c, 0x6a11a8c5, 0xa116835a, 0x0c6a31a8, 0xc5a01683, 
	0x5a0c6a11, 0xa8e5a016, 0x835a0c6a, 0x31a80100, 0x00000000, 0x00000000, 
	0x00000000, 0x04001001, 0x40020021, 0x00040010, 0x00400600, 0x19002400, 
	0x10004002, 0x000b0024, 0x00900040, 0x00000100, 0x00000000, 0x00000000, 
	0x00001022, 0x46881820, 0x62840803, 0x22468818, 0x2062808a, 0x01224688, 
	0x18216284, 0x08032646, 0x88182162, 0x84880100, 0x00000000, 0x00000000, 
	0x000000a2, 0x0a882a20, 0xaac0a002, 0xa20a882a, 0xa0aa80a8, 0x02820a88, 
	0x2a20a280, 0x20022a0a, 0x882a20aa, 0x80a80200, 0x00000000, 0x00000000, 
	0x00001084, 0x42100a41, 0x2804a110, 0x8440100a, 0x412804a1, 0x12844218, 
	0x0a412844, 0x81100040, 0x000a0128, 0x04a10000, 0x00000000, 0x00000000, 
	0x00005081, 0x40010205, 0x00942050, 0x80400102, 0x0d081400, 0x50004005, 
	0x02050894, 0x20508040, 0x01020508, 0x54200000, 0x00000000, 0x00000000, 
	0x00003081, 0xca002b03, 0x8c8cb032, 0x40ca002b, 0x43080c12, 0x32c0c804, 
	0x2a03ac4c, 0xb03200ca, 0x002b03ac, 0x4cb00200, 0x00000000, 0x00000000, 
	0x00001062, 0x4e003a01, 0xe204b893, 0xa04e803a, 0x01ea04b8, 0x13e04e90, 
	0x3901ea04, 0xb993a04e, 0x803a01ea, 0x04a90300, 0x00000000, 0x00000000, 
	0x0000c410, 0x1263088c, 0x213182c0, 0x10126308, 0x0c213082, 0xc0081203, 
	0x488c2131, 0x80c00012, 0x23488c20, 0x31840000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xf2ffcbff, 0x2fffbffc, 0xfff2ffcb, 0xff2fffbf, 0xfcfff2ff, 
	0xcbff2fff, 0xbffcfff2, 0xffcbff2f, 0xffbf0000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000b4df, 0xd06c43b3, 0x0dcdbe7c, 0xdbd06c43, 0xfb0dcd36, 0x34dbd0fe, 
	0x4bb30ded, 0xbf7cfbd2, 0xec4bb32f, 0xed370000, 0x00000000, 0x00000000, 
	0x00004c3e, 0x32f3c8cc, 0x23331f9c, 0x3c32f3c8, 0xe423338f, 0xcc3c32f9, 
	0xc1cc2393, 0x1f9c7c30, 0xf3c1cc07, 0x938f0000, 0x00000000, 0x00000000, 
	0x00005c78, 0x72fb49ec, 0x27b70784, 0x7872fb49, 0x8427b187, 0xc41e72e1, 
	0xc1ed2797, 0x07847870, 0xfbc1ed0f, 0x179e0000, 0x00000000, 0x00000000, 
	0x00008040, 0x0e023908, 0xe4289883, 0x600e023b, 0x08e62880, 0xe3208e82, 
	0x3808e428, 0x80a3408e, 0x02390ae4, 0x28b00300, 0x00000000, 0x00000000, 
	0x000020a0, 0x8ea03a02, 0xea08b023, 0xa08ea012, 0x02ee08a8, 0x23e08e80, 
	0x3a02ea08, 0xa823a08e, 0x803a02ea, 0x08280100, 0x00000000, 0x00000000, 
	0x00004080, 0x04011204, 0x48182041, 0x80040112, 0x04481820, 0x01800401, 
	0x12044810, 0x20618084, 0x01120448, 0x10200100, 0x00000000, 0x00000000, 
	0x00000000, 0x06001800, 0x60008101, 0x20060018, 0x00600089, 0x01048610, 
	0x18006008, 0x89410406, 0x10184660, 0x08810100, 0x00000000, 0x00000000, 
	0x00001022, 0x4e803801, 0xe2848893, 0x224e8038, 0x29e20488, 0x13204e88, 
	0x2801e294, 0x8813224e, 0x813801e2, 0x94880300, 0x00000000, 0x00000000, 
	0x00000000, 0x06081820, 0x60908001, 0x02060018, 0x20608080, 0x01020600, 
	0x18006000, 0x80010206, 0x00180060, 0x00800100, 0x00000000, 0x00000000, 
	0x00000020, 0x44801001, 0x42020831, 0x20448010, 0x01421208, 0x09202481, 
	0x10014202, 0x08192064, 0x80900142, 0x06080100, 0x00000000, 0x00000000, 
	0x0000d420, 0x52814805, 0x22198054, 0x00528148, 0x01201180, 0x44009283, 
	0x48052211, 0x80742052, 0x81480522, 0x15880000, 0x00000000, 0x00000000, 
	0x10033000, 0xc8002803, 0xa00c0030, 0x00c00028, 0x03000c80, 0x3200ca00, 
	0x2003a014, 0x803200ca, 0x002803a0, 0x04810208, 0x00000000, 0x00000000, 
	0x10031008, 0x08000800, 0x201a0021, 0x00000008, 0x82000680, 0x1800a281, 
	0x2000200e, 0x80680022, 0x00880020, 0x1280000c, 0x00000000, 0x00000000, 
	0x10031240, 0x08000100, 0x04001900, 0x40000001, 0x00040013, 0x00440010, 
	0x21000480, 0x11084620, 0x10814004, 0x0211000c, 0x00000000, 0x00000000, 
	0x10030210, 0x06801800, 0x60000001, 0x20048018, 0x00420098, 0x01600680, 
	0x18006200, 0x98412006, 0x80180462, 0x0088010c, 0x00000000, 0x00000000, 
	0x08800050, 0x06001900, 0x64009801, 0x40060019, 0x00640480, 0x11200600, 
	0x18006404, 0x80092026, 0x00990064, 0x02904100, 0x00000000, 0x00000000, 
	0x02a2422c, 0x0c813004, 0xc2100143, 0x240ca130, 0x44c21008, 0x43200c91, 
	0x2104c210, 0x0943060c, 0x893014c2, 0x10090288, 0x0a000000, 0x00000000, 
	0x02200000, 0x0c083020, 0xc0840003, 0x020c0030, 0x20c08000, 0x03024c00, 
	0x3000c000, 0x0043220c, 0x003000c0, 0x00000200, 0x00000000, 0x00000000, 
	0x02204000, 0x0c013004, 0xc0340043, 0x000c0130, 0x04c03008, 0xc3004c03, 
	0x3004c030, 0x0843080c, 0x013004c0, 0x10000380, 0x00000000, 0x00000000, 
	0x02a242a0, 0x06811804, 0x62300841, 0x20068118, 0x04223088, 0xc1200683, 
	0x38046230, 0x88410006, 0x81180462, 0x10880188, 0x0a000000, 0x00000000, 
	0x02804000, 0x0c011004, 0x00100040, 0x00040110, 0x04401000, 0x43000c01, 
	0x18044010, 0x00430004, 0x03100440, 0x10000100, 0x00000000, 0x00000000, 
	0x0a804020, 0x0c811804, 0x62100841, 0x20068118, 0x04621008, 0x43200c81, 
	0x10046210, 0x08430006, 0x81180462, 0x18880100, 0x00000000, 0x00000000, 
	0x028202a0, 0x08802800, 0xa2000800, 0x200a8028, 0x00a20000, 0x02200800, 
	0x2000a210, 0x0002000a, 0x802800a2, 0x00884288, 0x0a000000, 0x00000000, 
	0x12006000, 0x82010806, 0x20188060, 0x00820108, 0x06201880, 0x60008201, 
	0x08062018, 0x80602082, 0x01080620, 0x18800000, 0x00000000, 0x00000000, 
	0x12004080, 0x00010204, 0x08102040, 0x80000102, 0x04081020, 0x41800081, 
	0x02040810, 0x20608080, 0x01020608, 0x18220000, 0x00000000, 0x00000000, 
	0x02a262c0, 0x8a013b06, 0xac98b862, 0xc08a012b, 0x06ac98b0, 0x62c28a09, 
	0x2b06acb8, 0xb0e2828a, 0x092b26ac, 0x98b00288, 0x0a000000, 0x00000000, 
	0x00806224, 0x8e813806, 0xe0188963, 0x248e8138, 0x46e01898, 0x63608e91, 
	0x3806e21a, 0x996b348e, 0x813806e2, 0x18890300, 0x00000000, 0x00000000, 
	0x02806200, 0x8e013906, 0xe418b063, 0xc08e0139, 0x06e818a0, 0x63008e81, 
	0x3a06e418, 0xa063408e, 0x013906e4, 0x18b00100, 0x00000000, 0x00000000, 
	0x0aa26220, 0x8e893a26, 0xea980263, 0xa28c813a, 0x26c89888, 0x63228c81, 
	0x3006ea1a, 0x886ba28e, 0x813a06ea, 0x182a4388, 0x0a000000, 0x00000000, 
	0x02004880, 0x0c011204, 0x4812a04b, 0x80060192, 0x046a1020, 0x43802e01, 
	0x1a044812, 0x204b8004, 0x01120448, 0x12200100, 0x00000000, 0x00000000, 
	0x02006080, 0x86011806, 0x6018a061, 0x00860118, 0x06601888, 0x61208681, 
	0x10066018, 0x88610082, 0x01180660, 0x18800100, 0x02000000, 0x00000000, 
	0x00a20628, 0x1e807000, 0xc2010007, 0x201c8078, 0x80c20108, 0x07201c80, 
	0x7800e201, 0x8807201e, 0x807800e2, 0x01880388, 0x0a000000, 0x00000000, 
	0x02804a00, 0x06011004, 0x40120849, 0x00040198, 0x04401000, 0x41002401, 
	0x18046012, 0x80490006, 0x01180460, 0x12800100, 0x00000000, 0x00000000, 
	0x02804220, 0x04811804, 0x62108851, 0x20068110, 0x05221088, 0x41200681, 
	0x10044210, 0x08412004, 0x81100442, 0x10080180, 0x08000000, 0x00000000, 
	0x02a24220, 0x0283280c, 0xa23088c2, 0x200a8108, 0x8ca23080, 0xc2000a01, 
	0x08042210, 0x80402002, 0x81080422, 0x10880088, 0x0a000000, 0x00000000, 
	0x02004000, 0x0a03280c, 0xa0308052, 0x000a0328, 0x05a03080, 0xc2000a01, 
	0x280ca030, 0x80c2000a, 0x03280ca0, 0x30800200, 0x08000000, 0x00000000, 
	0x02001000, 0x06000800, 0x20008200, 0x00420008, 0x00200080, 0x00004280, 
	0x08012004, 0x80100042, 0x00080120, 0x04800080, 0x08000000, 0x00000000, 
	0x02a24240, 0x40010105, 0x04301840, 0x40000101, 0x04001410, 0x50400001, 
	0x01040410, 0x11404600, 0x01010404, 0x10100088, 0x0a000000, 0x00000000, 
	0x02800260, 0x06801800, 0x62008401, 0x20068018, 0x00620098, 0x01600680, 
	0x18006200, 0x98010306, 0x98182062, 0x80880100, 0x08000000, 0x00000000, 
	0x02800240, 0x26009900, 0x64021009, 0x60060099, 0x00600288, 0x0b000e00, 
	0x10006440, 0x800b4306, 0x08190064, 0x80900100, 0x00000000, 0x00000000, 
	0x02a28620, 0x1ca07000, 0xc2010005, 0x201c8070, 0x00c00190, 0x05201680, 
	0x5100c241, 0x8805261c, 0x907040c2, 0x01090388, 0x0a000000, 0x00000000, 
	0x0a008000, 0x8c0b300e, 0xc02800e1, 0x000c0230, 0x1ac2b800, 0xa1000402, 
	0x1008c020, 0x0081000c, 0x023008c0, 0x20000300, 0x00000000, 0x00000000, 
	0x0200a000, 0xac06b01a, 0xc05a002b, 0x218c02b0, 0x16c06a00, 0xeb218c00, 
	0x100ac028, 0x08ab088c, 0x02304ac0, 0x28014300, 0x00000000, 0x00000000, 
	0x0282c220, 0x0687181c, 0x623880e1, 0x01068318, 0x0e627080, 0xe1210683, 
	0x180c6230, 0x88e12006, 0x83180c62, 0x30880188, 0x0a000000, 0x00000000, 
	0x02800000, 0xc4001003, 0x40000801, 0x00040010, 0x00400c00, 0x11000400, 
	0x10004000, 0x00010004, 0x00100040, 0x00000100, 0x00000000, 0x00000000, 
	0x02801222, 0x06801840, 0x62008801, 0x00468818, 0x00620080, 0x01244688, 
	0x18216284, 0x88312046, 0x88182162, 0x84880108, 0x00000000, 0x00000000, 
	0x02a20222, 0x0a882820, 0xa2408902, 0x040a8828, 0x00a28080, 0x02020a04, 
	0x2820a200, 0x8002200a, 0x882820a2, 0x00880288, 0x0a000000, 0x00000000, 
	0x0200100c, 0x42102841, 0x28048012, 0x044a1008, 0x41a08480, 0x12004a00, 
	0x08412044, 0x80100042, 0x00080120, 0x04800008, 0x02000000, 0x00000000, 
	0x00005080, 0x40010205, 0x00942050, 0x81400102, 0x05089408, 0x50864089, 
	0x02050894, 0x20508040, 0x01020508, 0x14200000, 0x00000000, 0x00000000, 
	0x02a2b2c0, 0xca02290b, 0x8c6c98b2, 0x41ca022b, 0x1ba0ac02, 0xb242ca06, 
	0x2b0bacac, 0xb0b2c0ca, 0x022b0bac, 0x2cb00288, 0x0a000000, 0x00000000, 
	0x02801220, 0x4e003a01, 0xe204a913, 0xa44e8038, 0x11ea0488, 0x13e04e90, 
	0x3801e204, 0x9813004e, 0x803801e2, 0x04880300, 0x00000000, 0x00000000, 
	0x0000c410, 0x0263088c, 0x213080c0, 0x10126308, 0x0c213082, 0xc0081203, 
	0x488c2131, 0x80c00012, 0x23488c20, 0x31800000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xf2ffcbff, 0x2fffbffc, 0xfff2ffcb, 0xff2fffbf, 0xfcfff2ff, 
	0xcbff2fff, 0xbffcfff2, 0xffcbff2f, 0xffbf0000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x000034db, 0xf06dc3b7, 0x0dffbffc, 0xdfd06cc3, 0xff0ddfbe, 0x7cfbd2fe, 
	0x4bb30ded, 0xbffcffd2, 0xec4bb32f, 0xedbf0000, 0x00000000, 0x00000000, 
	0x0000cc3c, 0x72f2c8c9, 0x23871f1c, 0x3e32f3c8, 0xe123271f, 0x9c7c30f9, 
	0xc1cc2393, 0x1f1c7e30, 0xf3c1cc07, 0x931f0000, 0x00000000, 0x00000000, 
	0x0000dc78, 0x12fa49e8, 0x27010604, 0x7872fb49, 0x8027a107, 0x841e7061, 
	0xc0ed27d7, 0x071cff70, 0xfbc3ed0f, 0x973f0000, 0x00000000, 0x00000000, 
	0x00004021, 0x00850014, 0x02500840, 0xe10c8533, 0x14cc5030, 0x43210085, 
	0x00140250, 0x0840c10c, 0x85001402, 0x50080000, 0x00000000, 0x00000000, 
	0x00000020, 0x00800000, 0x02000800, 0x20008000, 0x00020008, 0x00200080, 
	0x00000200, 0x08002000, 0x80000002, 0x00080020, 0x01000000, 0x00000000, 
	0x00001021, 0x40840011, 0x02440810, 0x21408400, 0x11024408, 0x10214084, 
	0x00110244, 0x08102140, 0x84001102, 0x44080000, 0x00000000, 0x00000000, 
	0x00000020, 0x00800000, 0x02000800, 0xe00c8033, 0x00020008, 0x00200080, 
	0x00000200, 0x08002000, 0x80000002, 0x00080000, 0x00000000, 0x00000000, 
	0x000010c1, 0x0c040010, 0x00400000, 0x01000400, 0x10004000, 0x00010004, 
	0x33100040, 0x30030100, 0x04001000, 0x40300300, 0x01000000, 0x00000000, 
	0x10004000, 0x00010004, 0x00100040, 0x00000100, 0x04001000, 0x40000001, 
	0x00040010, 0x00400000, 0x01000400, 0x10000000, 0x00000000, 0x00000000, 
	0x10001001, 0x40040011, 0x00440010, 0x01400400, 0x11004400, 0x10014004, 
	0x00110044, 0x00100140, 0x04001100, 0x44004000, 0x00000000, 0x00000000, 
	0x100010c0, 0x4c000001, 0x00040010, 0x00400000, 0x01000400, 0x10004000, 
	0x00010004, 0x30130040, 0x00000100, 0x04304300, 0x00000000, 0x00000000, 
	0x10005021, 0x40850015, 0x02540850, 0x21408500, 0x15025408, 0x50214085, 
	0x00150254, 0x08502140, 0x85001502, 0x54084080, 0x00000000, 0x00000000, 
	0x10001020, 0x40800001, 0x02040810, 0x20408000, 0x01020408, 0x10204080, 
	0x00010204, 0x08102040, 0x80000102, 0x04080000, 0x00000000, 0x00000000, 
	0x10000021, 0x00840010, 0x02400800, 0x21008400, 0x10024008, 0x00210084, 
	0x00100240, 0x08002100, 0x84001002, 0x40084000, 0x00000000, 0x00000000, 
	0x100800e0, 0x0c803300, 0xce003803, 0xe00c8000, 0x00ce0008, 0x00e00c80, 
	0x3300ce00, 0x38032000, 0x803300ce, 0x00384320, 0x00000000, 0x00000000, 
	0x10000021, 0x00840010, 0x02400800, 0xe10c8400, 0x10ce4038, 0x03210084, 
	0x33100240, 0x38032100, 0x84001002, 0x40084000, 0x00000000, 0x00000000, 
	0x00004000, 0x00010004, 0x00100040, 0x20000100, 0x04021008, 0x40000081, 
	0x00040010, 0x08400000, 0x01000400, 0x10000000, 0x00000000, 0x00000000, 
	0x00000001, 0x00040010, 0x00400000, 0x21000400, 0x10024008, 0x00010084, 
	0x00100040, 0x08000100, 0x04001000, 0x40000000, 0x00000000, 0x00000000, 
	0x00080100, 0x00000000, 0x00000000, 0xc00c0000, 0x00cc0030, 0x03000000, 
	0x33000000, 0x30030000, 0x00000000, 0x00000020, 0x0c000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00003080, 0x00000000, 0x00000000, 
	0x3c3c0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00003010, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000048, 0x0f000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x00004021, 0x00850014, 0x02500840, 0x21008500, 0x14025008, 0x40210085, 
	0x00140250, 0x08402100, 0x85001402, 0x50080000, 0x00000000, 0x00000000, 
	0x00000020, 0x00800000, 0x02000800, 0x20008000, 0x00020008, 0x00200080, 
	0x00000200, 0x08002000, 0x80000002, 0x00080000, 0x01000000, 0x00000000, 
	0x00000021, 0x00840010, 0x02400800, 0x21008400, 0x10024008, 0x00210084, 
	0x00100240, 0x08002100, 0x84001002, 0x40080080, 0x00000000, 0x00000000, 
	0x00001020, 0x40800001, 0x02000810, 0x20408000, 0x01020008, 0x00200080, 
	0x00000200, 0x08002000, 0x80000002, 0x00080000, 0x00000000, 0x00000000, 
	0x00000001, 0x00040011, 0x00400000, 0x01000400, 0x10004000, 0x00010004, 
	0x00100040, 0x30030100, 0x04001000, 0x40000000, 0x00000000, 0x00000000, 
	0x10004000, 0x00010004, 0x00100040, 0x00000100, 0x04001000, 0x40000001, 
	0x00040010, 0x00400000, 0x01000400, 0x10004000, 0x00000000, 0x00000000, 
	0x10001001, 0x40040011, 0x00440010, 0x01400400, 0x11004400, 0x10014004, 
	0x00110044, 0x00100140, 0x04001100, 0x44000000, 0x00000000, 0x00000000, 
	0x10001000, 0x40000001, 0x00040010, 0x00400000, 0x01000400, 0x10004000, 
	0x00010004, 0x30130040, 0x00000100, 0x04004000, 0x01000000, 0x00000000, 
	0x10005021, 0x40853315, 0x02543853, 0xe14c8500, 0x15ce5408, 0x50e14c85, 
	0x00150254, 0x08502140, 0x85001502, 0x54084080, 0x00000000, 0x00000000, 
	0x10001020, 0x40800001, 0x02040810, 0x20408000, 0x01020408, 0x10204080, 
	0x00010204, 0x08102040, 0x80000102, 0x04084000, 0x00000000, 0x00000000, 
	0x10000021, 0x00840010, 0x02400800, 0x01008400, 0x10024008, 0x00210084, 
	0x00100240, 0x08002100, 0x84001002, 0x40080000, 0x00000000, 0x00000000, 
	0x100800e0, 0x0c803300, 0xce003803, 0x20008033, 0x00ce0008, 0x00e00c80, 
	0x3300ce00, 0x0800e00c, 0x803300ce, 0x00384320, 0x00000000, 0x00000000, 
	0x10000021, 0x00840010, 0x02400800, 0x21008400, 0x10024008, 0x00210084, 
	0x00100240, 0x08002100, 0x84001002, 0x40084000, 0x00000000, 0x00000000, 
	0x00004000, 0x00010004, 0x00100040, 0x00000100, 0x04001000, 0x40000001, 
	0x00040010, 0x00400000, 0x01000400, 0x10000000, 0x00000000, 0x00000000, 
	0x00000001, 0x00040010, 0x00400000, 0x01000400, 0x10004000, 0x00010004, 
	0x00100040, 0x00000100, 0x04001000, 0x40000000, 0x00000000, 0x00000000, 
	0x00080100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x0c000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00003002, 0x00000000, 0x00000000, 
	0x3c3c0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00003010, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000080, 0x0f000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x0000fcff, 0xffff0300, 0x000000fc, 0xffffff03, 0x00000000, 0xfcffffff, 
	0x03000000, 0x00fcffff, 0xff030000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x0c000480, 0x40000000, 0x0c00c230, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x0c000480, 0x40400000, 0x0c00c200, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x0c000080, 0x000000c2, 0x0c000180, 0x000000c0, 0x0c000230, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0c000180, 
	0x000000a0, 0x0c000580, 0x00008000, 0x0c000080, 0x0000847a, 0x00000000, 
	0x00000000, 0x00000000, 0x00000000, 
};
#define repulse_firmware_size 69900
