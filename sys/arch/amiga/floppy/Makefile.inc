#	$NetBSD: Makefile.inc,v 1.2 1994/10/26 02:05:29 cgd Exp $

LDSTATIC= -static
LDFLAGS+= -N
