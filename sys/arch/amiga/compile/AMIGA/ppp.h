#define NPPP 4
