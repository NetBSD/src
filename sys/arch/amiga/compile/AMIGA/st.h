#define NST	7
