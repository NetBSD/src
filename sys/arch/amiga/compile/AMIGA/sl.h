#define NSL 4
