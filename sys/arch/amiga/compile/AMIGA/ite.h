#define NITE	1
