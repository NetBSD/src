#define NSCSI 1
