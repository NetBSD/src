#define NVN 10
