#define NSD	7
