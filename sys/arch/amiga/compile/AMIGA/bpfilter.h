#define NBPFILTER 16
