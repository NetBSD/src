/*	$NetBSD: locore_machdep.S,v 1.6 2005/12/11 12:17:05 christos Exp $	*/

/* This file intentionally left blank. */
