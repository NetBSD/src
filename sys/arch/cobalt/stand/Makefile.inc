#	$NetBSD: Makefile.inc,v 1.1.180.1 2017/12/03 11:36:00 jdolecek Exp $

NOPIE=	# defined
BINDIR=		/usr/mdec
