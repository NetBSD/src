#	$NetBSD: Makefile.mmeye.inc,v 1.7.32.1 2011/03/05 20:51:14 rmind Exp $

LINKFORMAT=	-N
