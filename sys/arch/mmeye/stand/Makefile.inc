#	$NetBSD: Makefile.inc,v 1.1.186.1 2017/12/03 11:36:30 jdolecek Exp $

NOPIE=	# defined
BINDIR= /usr/mdec
