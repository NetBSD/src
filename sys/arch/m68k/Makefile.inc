#	$NetBSD: Makefile.inc,v 1.2.98.1 2007/02/27 16:51:56 yamt Exp $

SM68K=	${SYSDIR}/arch/m68k/m68k/*.[ch] ${SYSDIR}/arch/m68k/include/*.h
AM68K=	${SYSDIR}/arch/m68k/m68k/*.s
