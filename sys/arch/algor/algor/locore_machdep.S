/*	$NetBSD: locore_machdep.S,v 1.3.40.1 2008/06/03 20:47:13 skrll Exp $	*/

/* This file intentionally left blank. */
