/*	$NetBSD: locore_machdep.S,v 1.3 2005/12/11 12:17:11 christos Exp $	*/

/* This file intentionally left blank. */
