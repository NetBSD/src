/* $NetBSD: locore_machdep.S,v 1.1.1.1.6.2 2017/12/03 11:36:10 jdolecek Exp $ */

/* This file intentionally left blank. */
