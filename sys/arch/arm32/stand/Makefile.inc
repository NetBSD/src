#	$NetBSD: Makefile.inc,v 1.1 2002/02/06 21:30:41 thorpej Exp $

BINDIR=		/usr/mdec

CPPFLAGS+=	-D_STANDALONE
