# $NetBSD: Makefile.inc,v 1.2.180.1 2021/04/17 17:26:13 thorpej Exp $

.include <bsd.own.mk>

BINDIR?=	/usr/mdec

COPTS+=		-fcommon
