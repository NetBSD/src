#	$NetBSD: Makefile.hpcsh.inc,v 1.1.2.2 2001/01/17 05:21:49 itojun Exp $

MACHINE=hpcsh
