#	$NetBSD: Makefile.inc,v 1.2.12.2 2014/05/22 11:39:39 yamt Exp $

BINDIR=		/usr/mdec
MACHINE=	epoc32
