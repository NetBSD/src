/* $NetBSD: locore_machdep.S,v 1.4 2005/12/11 12:18:51 christos Exp $ */

/* This file intentionally left blank. */
