#	$Id: Makefile.inc,v 1.1 1994/04/18 08:47:09 cgd Exp $

LDSTATIC= -static
LDFLAGS+= -N
