# $NetBSD: Makefile.inc,v 1.1.124.1 2017/12/03 11:36:13 jdolecek Exp $

NOPIE=	# defined

BINDIR?=	/usr/mdec
