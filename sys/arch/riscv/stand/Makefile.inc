#	$NetBSD: Makefile.inc,v 1.1 2021/09/30 20:02:55 jmcneill Exp $

BINDIR?=	/usr/mdec
FILESDIR?=	/usr/mdec
