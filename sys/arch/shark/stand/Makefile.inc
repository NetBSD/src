#	$NetBSD: Makefile.inc,v 1.1.14.2 2002/06/23 17:41:36 jdolecek Exp $

BINDIR=		/usr/mdec

CPPFLAGS+=	-D_STANDALONE
