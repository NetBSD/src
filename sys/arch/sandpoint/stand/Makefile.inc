#	$NetBSD: Makefile.inc,v 1.1.20.1 2017/12/03 11:36:40 jdolecek Exp $

NOPIE=	# defined
BINDIR=		/usr/mdec
