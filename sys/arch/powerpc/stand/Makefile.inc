#	$NetBSD: Makefile.inc,v 1.3 1998/05/22 12:56:35 drochner Exp $

BINDIR=		/usr/mdec

CPPFLAGS+=	-D_STANDALONE

CFLAGS+=	-msoft-float
