# $NetBSD: Makefile.inc,v 1.1.48.1 2007/01/12 01:00:45 ad Exp $

CPPFLAGS+= -D__daddr_t=int32_t
CFLAGS+= -Os
