/*	$NetBSD: mips64_subr.S,v 1.3.100.1 2011/03/05 20:51:07 rmind Exp $	*/

#undef MIPS1
#undef MIPS3
#undef MIPS32
/* #undef MIPS64 */
#undef MIPS64_SB1
#undef MIPS64_XLP
#undef MIPS64_XLR
#undef MIPS64_XLS

#include <mips/mips/mipsX_subr.S>
