/*	$NetBSD: mips3_subr.S,v 1.3.108.1 2011/03/05 15:09:50 bouyer Exp $	*/

#undef MIPS1
/* #undef MIPS3 */
#undef MIPS32
#undef MIPS64
#undef MIPS64_SB1
#undef MIPS64_XLP
#undef MIPS64_XLR
#undef MIPS64_XLS

#include <mips/mips/mipsX_subr.S>
