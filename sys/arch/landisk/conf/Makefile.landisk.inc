#	$NetBSD: Makefile.landisk.inc,v 1.4.32.1 2011/03/05 20:50:51 rmind Exp $

LINKFORMAT=	-N
