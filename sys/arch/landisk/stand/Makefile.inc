#	$NetBSD: Makefile.inc,v 1.1.110.1 2017/12/03 11:36:22 jdolecek Exp $

NOPIE=yes
BINDIR?= /usr/mdec
