#	$NetBSD: Makefile.dnard.inc,v 1.1.4.2 2002/01/10 19:41:28 thorpej Exp $

GENASSYM_EXTRAS+=	${THISARM}/dnard/genassym.cf
