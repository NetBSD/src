#	from: @(#)Makefile.inc	5.1 (Berkeley) 5/11/90
#	$NetBSD: Makefile.inc,v 1.4 1997/10/13 11:19:50 lukem Exp $

BINDIR?=	/usr/share
WARNS?=		1
