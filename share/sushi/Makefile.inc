#	$NetBSD: Makefile.inc,v 1.1 2001/04/25 10:31:30 tron Exp $

.include "../Makefile.inc"
