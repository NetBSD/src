#define BUILDING_GCC_MAJOR 10
#define BUILDING_GCC_MINOR 4
#define BUILDING_GCC_PATCHLEVEL 0
#define BUILDING_GCC_VERSION (BUILDING_GCC_MAJOR * 1000 + BUILDING_GCC_MINOR)
