/* option `AHCISATA_EXTRA_DELAY' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_AHCISATA_EXTRA_DELAY
 .global _KERNEL_OPT_AHCISATA_EXTRA_DELAY
 .equiv _KERNEL_OPT_AHCISATA_EXTRA_DELAY,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_AHCISATA_EXTRA_DELAY\n .global _KERNEL_OPT_AHCISATA_EXTRA_DELAY\n .equiv _KERNEL_OPT_AHCISATA_EXTRA_DELAY,0x6e074def\n .endif");
#endif
/* option `AHCISATA_EXTRA_DELAY_MS' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_AHCISATA_EXTRA_DELAY_MS
 .global _KERNEL_OPT_AHCISATA_EXTRA_DELAY_MS
 .equiv _KERNEL_OPT_AHCISATA_EXTRA_DELAY_MS,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_AHCISATA_EXTRA_DELAY_MS\n .global _KERNEL_OPT_AHCISATA_EXTRA_DELAY_MS\n .equiv _KERNEL_OPT_AHCISATA_EXTRA_DELAY_MS,0x6e074def\n .endif");
#endif
