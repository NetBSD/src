#define	NSYSMON_TASKQ	0
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_NSYSMON_TASKQ
 .global _KERNEL_OPT_NSYSMON_TASKQ
 .equiv _KERNEL_OPT_NSYSMON_TASKQ,0x0
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_NSYSMON_TASKQ\n .global _KERNEL_OPT_NSYSMON_TASKQ\n .equiv _KERNEL_OPT_NSYSMON_TASKQ,0x0\n .endif");
#endif
