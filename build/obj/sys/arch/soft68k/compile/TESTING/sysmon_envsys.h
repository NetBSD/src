#define	NSYSMON_ENVSYS	0
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_NSYSMON_ENVSYS
 .global _KERNEL_OPT_NSYSMON_ENVSYS
 .equiv _KERNEL_OPT_NSYSMON_ENVSYS,0x0
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_NSYSMON_ENVSYS\n .global _KERNEL_OPT_NSYSMON_ENVSYS\n .equiv _KERNEL_OPT_NSYSMON_ENVSYS,0x0\n .endif");
#endif
