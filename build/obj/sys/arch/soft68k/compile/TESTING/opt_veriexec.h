/* option `VERIFIED_EXEC_FP_SHA512' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_VERIFIED_EXEC_FP_SHA512
 .global _KERNEL_OPT_VERIFIED_EXEC_FP_SHA512
 .equiv _KERNEL_OPT_VERIFIED_EXEC_FP_SHA512,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_VERIFIED_EXEC_FP_SHA512\n .global _KERNEL_OPT_VERIFIED_EXEC_FP_SHA512\n .equiv _KERNEL_OPT_VERIFIED_EXEC_FP_SHA512,0x6e074def\n .endif");
#endif
/* option `VERIFIED_EXEC_FP_SHA384' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_VERIFIED_EXEC_FP_SHA384
 .global _KERNEL_OPT_VERIFIED_EXEC_FP_SHA384
 .equiv _KERNEL_OPT_VERIFIED_EXEC_FP_SHA384,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_VERIFIED_EXEC_FP_SHA384\n .global _KERNEL_OPT_VERIFIED_EXEC_FP_SHA384\n .equiv _KERNEL_OPT_VERIFIED_EXEC_FP_SHA384,0x6e074def\n .endif");
#endif
/* option `VERIFIED_EXEC_FP_SHA256' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_VERIFIED_EXEC_FP_SHA256
 .global _KERNEL_OPT_VERIFIED_EXEC_FP_SHA256
 .equiv _KERNEL_OPT_VERIFIED_EXEC_FP_SHA256,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_VERIFIED_EXEC_FP_SHA256\n .global _KERNEL_OPT_VERIFIED_EXEC_FP_SHA256\n .equiv _KERNEL_OPT_VERIFIED_EXEC_FP_SHA256,0x6e074def\n .endif");
#endif
