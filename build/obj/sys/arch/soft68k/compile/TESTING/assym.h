#define MMU_68030 -1
#define MMU_68851 1
#define MMU_68040 -2
#define CPU_68020 0
#define CPU_68030 1
#define CPU_68040 2
#define M68030 1
#define M68040 1
#define FPU_NONE 0
#define FPU_68881 1
#define FPU_68882 2
#define FPU_68040 3
#define EC_PHYS -1
#define EC_NONE 0
#define EC_VIRT 1
#define UPAGES 2
#define USPACE 8192
#define PAGE_SIZE 4096
#define PGSHIFT 12
#define USRSTACK -1048576
#define L_PCB 32
#define L_PROC 300
#define L_MD_REGS 36
#define L_MD_FLAGS 40
#define P_FLAG 76
#define P_RASLIST 132
#define P_VMSPACE 48
#define CI_NINTR 400
#define T_BUSERR 0
#define T_ADDRERR 1
#define T_ILLINST 2
#define T_ZERODIV 3
#define T_CHKINST 4
#define T_TRAPVINST 5
#define T_PRIVINST 6
#define T_TRACE 7
#define T_MMUFLT 8
#define T_SSIR 9
#define T_FMTERR 10
#define T_COPERR 12
#define T_FPERR 11
#define T_ASTFLT 13
#define T_TRAP15 15
#define T_FPEMULI 16
#define T_FPEMULD 17
#define PSL_S 8192
#define PSL_IPL7 1792
#define PSL_LOWIPL 8192
#define PSL_HIGHIPL 9984
#define PSL_USER 0
#define PSL_TS 40960
#define SPL1 8448
#define SPL2 8704
#define SPL3 8960
#define SPL4 9216
#define SPL5 9472
#define SPL6 9728
#define FC_USERD 1
#define FC_SUPERD 5
#define DC_FREEZE 512
#define CACHE40_ON -2147450880
#define CACHE_ON 14617
#define CACHE_OFF 2056
#define CACHE_CLR 14617
#define IC_CLEAR 12569
#define DC_CLEAR 14609
#define PG_V 1
#define PG_NV 0
#define PG_RO 4
#define PG_RW 0
#define PG_CI 64
#define PG_PROT 4
#define PG_FRAME -4096
#define SG_V 2
#define SG_NV 0
#define SG_RW 0
#define SG_FRAME -4096
#define SG_ISHIFT 22
#define PCB_PS 2
#define PCB_USP 8
#define PCB_REGS 12
#define PCB_ONFAULT 60
#define PCB_FPCTX 64
#define SIZEOF_PCB 388
#define TF_PC 70
#define FR_SP 60
#define FR_HW 68
#define FR_ADJ 66
#define FR_SIZE 76
#define FPF_REGS 216
#define FPF_FPCR 312
#define SYS_exit 1
#define SYS_execve 59
#define SYS_compat_16___sigreturn14 295
#define SYS_compat_13_sigreturn13 103
#define EFAULT 14
#define ENAMETOOLONG 63
#define COHERENCY_UNIT 64
