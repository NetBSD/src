/* option `INCLUDE_JUST_CONFIG' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_INCLUDE_JUST_CONFIG
 .global _KERNEL_OPT_INCLUDE_JUST_CONFIG
 .equiv _KERNEL_OPT_INCLUDE_JUST_CONFIG,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_INCLUDE_JUST_CONFIG\n .global _KERNEL_OPT_INCLUDE_JUST_CONFIG\n .equiv _KERNEL_OPT_INCLUDE_JUST_CONFIG,0x6e074def\n .endif");
#endif
#define	INCLUDE_CONFIG_FILE	1
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_INCLUDE_CONFIG_FILE
 .global _KERNEL_OPT_INCLUDE_CONFIG_FILE
 .equiv _KERNEL_OPT_INCLUDE_CONFIG_FILE,0x1
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_INCLUDE_CONFIG_FILE\n .global _KERNEL_OPT_INCLUDE_CONFIG_FILE\n .equiv _KERNEL_OPT_INCLUDE_CONFIG_FILE,0x1\n .endif");
#endif
