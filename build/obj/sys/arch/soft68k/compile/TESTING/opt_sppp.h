/* option `SPPP_IFDOWN_RECONNECT' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SPPP_IFDOWN_RECONNECT
 .global _KERNEL_OPT_SPPP_IFDOWN_RECONNECT
 .equiv _KERNEL_OPT_SPPP_IFDOWN_RECONNECT,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SPPP_IFDOWN_RECONNECT\n .global _KERNEL_OPT_SPPP_IFDOWN_RECONNECT\n .equiv _KERNEL_OPT_SPPP_IFDOWN_RECONNECT,0x6e074def\n .endif");
#endif
/* option `SPPP_ALIVE_INTERVAL' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SPPP_ALIVE_INTERVAL
 .global _KERNEL_OPT_SPPP_ALIVE_INTERVAL
 .equiv _KERNEL_OPT_SPPP_ALIVE_INTERVAL,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SPPP_ALIVE_INTERVAL\n .global _KERNEL_OPT_SPPP_ALIVE_INTERVAL\n .equiv _KERNEL_OPT_SPPP_ALIVE_INTERVAL,0x6e074def\n .endif");
#endif
/* option `SPPP_NORECV_TIME' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SPPP_NORECV_TIME
 .global _KERNEL_OPT_SPPP_NORECV_TIME
 .equiv _KERNEL_OPT_SPPP_NORECV_TIME,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SPPP_NORECV_TIME\n .global _KERNEL_OPT_SPPP_NORECV_TIME\n .equiv _KERNEL_OPT_SPPP_NORECV_TIME,0x6e074def\n .endif");
#endif
/* option `SPPP_KEEPALIVE_INTERVAL' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SPPP_KEEPALIVE_INTERVAL
 .global _KERNEL_OPT_SPPP_KEEPALIVE_INTERVAL
 .equiv _KERNEL_OPT_SPPP_KEEPALIVE_INTERVAL,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SPPP_KEEPALIVE_INTERVAL\n .global _KERNEL_OPT_SPPP_KEEPALIVE_INTERVAL\n .equiv _KERNEL_OPT_SPPP_KEEPALIVE_INTERVAL,0x6e074def\n .endif");
#endif
