#include <sys/cdefs.h>

#include "opt_config.h"

/*
 * Add either (or both) of
 *
 *	options INCLUDE_CONFIG_FILE
 *	options INCLUDE_JUST_CONFIG
 *
 * to your kernel config file to embed it in the resulting
 * kernel.  The latter option does not include files that are
 * included (recursively) by your config file.  The embedded
 * data be extracted by using the command:
 *
 *	strings netbsd | sed -n 's/^_CFG_//p' | unvis
 */

#ifdef CONFIG_FILE
#if defined(INCLUDE_CONFIG_FILE) || defined(INCLUDE_JUST_CONFIG)

static const char config[] __used =

#ifdef INCLUDE_CONFIG_FILE

"_CFG_### START CONFIG FILE \"/Users/sidqian/Downloads/summer/L2S/netbsd-src/sys/arch/luna68k/conf/TESTING\"\n"

#endif /* INCLUDE_CONFIG_FILE */

"_CFG_# $NetBSD: GENERIC,v 1.136 2023/02/12 14:50:40 abs Exp $\n"
"_CFG_#\n"
"_CFG_# GENERIC machine description file\n"
"_CFG_# \n"
"_CFG_# This machine description file is used to generate the default NetBSD\n"
"_CFG_# kernel.  The generic kernel does not include all options, subsystems\n"
"_CFG_# and device drivers, but should be useful for most applications.\n"
"_CFG_#\n"
"_CFG_# The machine description file can be customised for your specific\n"
"_CFG_# machine to reduce the kernel size and improve its performance.\n"
"_CFG_#\n"
"_CFG_# For further information on compiling NetBSD kernels, see the config(8)\n"
"_CFG_# man page.\n"
"_CFG_#\n"
"_CFG_# For further information on hardware support for this architecture, see\n"
"_CFG_# the intro(4) man page.  For further information about kernel options\n"
"_CFG_# for this architecture, see the options(4) man page.  For an explanation\n"
"_CFG_# of each device driver in this file see the section 4 man page for the\n"
"_CFG_# device.\n"
"_CFG_\n"
"_CFG_include \\011\"arch/luna68k/conf/std.luna68k\"\n"
"_CFG_\n"
"_CFG_options \\011INCLUDE_CONFIG_FILE\\011# embed config file in kernel binary\n"
"_CFG_\n"
"_CFG_#ident \\011\\011\"GENERIC-$Revision: 1.136 $\"\n"
"_CFG_\n"
"_CFG_makeoptions\\011COPTS=\"-O2 -fno-reorder-blocks -fno-unwind-tables -fno-omit-frame-pointer\"\n"
"_CFG_\\011# See share/mk/sys.mk. -fno-omit-frame-pointer is necessary for\n"
"_CFG_\\011# backtraces in DDB.\n"
"_CFG_\n"
"_CFG_maxusers\\0118\n"
"_CFG_\n"
"_CFG_options \\011M68030\n"
"_CFG_options \\011M68040\n"
"_CFG_options \\011FPSP\\011# on m68040 to emulate some missing FP instructions\n"
"_CFG_\n"
"_CFG_# Needs to be set per system.  i.e change these as you see fit\n"
"_CFG_\n"
"_CFG_# Standard system options\n"
"_CFG_options \\011NTP\\011\\011\\011# NTP phase/frequency locked loop\n"
"_CFG_options \\011KTRACE\n"
"_CFG_options \\011SYSVMSG\\011\\011\\011# System V message queues\n"
"_CFG_options \\011SYSVSEM\\011\\011\\011# System V semaphores\n"
"_CFG_options \\011SYSVSHM\\011\\011\\011# System V shared memory\n"
"_CFG_\n"
"_CFG_options \\011MODULAR\\011\\011\\011# new style module(7) framework\n"
"_CFG_options \\011MODULAR_DEFAULT_AUTOLOAD\n"
"_CFG_\n"
"_CFG_options \\011USERCONF\\011\\011# userconf(4) support\n"
"_CFG_#options\\011PIPE_SOCKETPAIR\\011\\011# smaller, but slower pipe(2)\n"
"_CFG_options \\011SYSCTL_INCLUDE_DESCR\\011# Include sysctl descriptions in kernel\n"
"_CFG_\n"
"_CFG_# Alternate buffer queue strategies for better responsiveness under high\n"
"_CFG_# disk I/O load.\n"
"_CFG_#options \\011BUFQ_READPRIO\n"
"_CFG_#options \\011BUFQ_PRIOCSCAN\n"
"_CFG_\n"
"_CFG_# Debugging options\n"
"_CFG_options \\011DDB\n"
"_CFG_#options \\011DDB_HISTORY_SIZE=100\\011# enable history editing in DDB\n"
"_CFG_#makeoptions\\011COPY_SYMTAB=1\\011# place DDB symbols in data segment\n"
"_CFG_#options \\011DEBUG\\011\\011\\011# extra kernel debugging support\n"
"_CFG_#options \\011DIAGNOSTIC\\011\\011# extra kernel sanity checking\n"
"_CFG_#options \\011SCSIVERBOSE\\011\\011# Verbose SCSI errors\n"
"_CFG_#options \\011SCSIDEBUG\n"
"_CFG_#makeoptions\\011DEBUG=\"-g\"\\011\\011# compile full symbol table\n"
"_CFG_\n"
"_CFG_# Compatibility options\n"
"_CFG_include \\011\"conf/compat_netbsd12.config\"\n"
"_CFG_\n"
"_CFG_options \\011COMPAT_AOUT_M68K # support for NetBSD a.out executables\n"
"_CFG_options \\011EXEC_AOUT\\011# support for a.out executables\n"
"_CFG_\n"
"_CFG_# File systems\n"
"_CFG_file-system \\011FFS\\011\\011# ufs file system\n"
"_CFG_#file-system\\011LFS\\011\\011# log-structured file system\n"
"_CFG_file-system \\011NFS\\011\\011# nfs client support\n"
"_CFG_file-system\\011MFS\n"
"_CFG_file-system \\011CD9660\\011\\011# ISO 9660 + Rock Ridge file system\n"
"_CFG_#file-system\\011MSDOSFS\\011\\011# MS-DOS FAT file system\n"
"_CFG_file-system \\011KERNFS\\011\\011# /kern\n"
"_CFG_file-system \\011PROCFS\\011\\011# /proc\n"
"_CFG_#file-system \\011FDESC\\011\\011# /dev/fd/*\n"
"_CFG_file-system \\011NULLFS\\011\\011# loopback file system\n"
"_CFG_#file-system\\011UMAPFS\\011\\011# NULLFS + uid and gid remapping\n"
"_CFG_#file-system \\011UNION\\011\\011# union file system\n"
"_CFG_#file-system\\011CODA\\011\\011# Coda File System; also needs vcode (below)\n"
"_CFG_file-system\\011PTYFS\\011\\011# /dev/pts/N support\n"
"_CFG_file-system\\011TMPFS\\011\\011# Efficient memory file-system\n"
"_CFG_#file-system\\011UDF\\011\\011# experimental - OSTA UDF CD/DVD file-system\n"
"_CFG_\n"
"_CFG_# File system options\n"
"_CFG_#options \\011FFS_EI\\011\\011# FFS Endian Independent support\n"
"_CFG_#options \\011FFS_NO_SNAPSHOT\\011# No FFS snapshot support\n"
"_CFG_#options \\011QUOTA\\011\\011# legacy UFS quotas\n"
"_CFG_#options \\011QUOTA2\\011\\011# new, in-filesystem UFS quotas\n"
"_CFG_#options \\011UFS_DIRHASH\\011# UFS Large Directory Hashing\n"
"_CFG_#options \\011UFS_EXTATTR\\011# Extended attribute support for UFS1\n"
"_CFG_options \\011WAPBL\\011\\011# File system journaling support\n"
"_CFG_#options \\011NFSSERVER\\011# Network File System server\n"
"_CFG_\n"
"_CFG_# Networking options\n"
"_CFG_options \\011INET\\011\\011# IP protocol stack support\n"
"_CFG_options \\011INET6\\011\\011# IPV6\n"
"_CFG_#options \\011IPSEC\\011\\011# IP security\n"
"_CFG_#options \\011IPSEC_DEBUG\\011# debug for IP security\n"
"_CFG_#options \\011GATEWAY\\011\\011# IP packet forwarding\n"
"_CFG_#options \\011MROUTING\\011# IP multicast routing\n"
"_CFG_#options \\011PIM\\011\\011# Protocol Independent Multicast\n"
"_CFG_#options \\011NETATALK\\011# AppleTalk networking protocols\n"
"_CFG_#options \\011PPP_BSDCOMP\\011# BSD-Compress compression support for PPP\n"
"_CFG_#options \\011PPP_DEFLATE\\011# Deflate compression support for PPP\n"
"_CFG_#options \\011PPP_FILTER\\011# Active filter support for PPP (requires bpf)\n"
"_CFG_options \\011NFS_BOOT_DHCP\\011# superset of BOOTP\n"
"_CFG_#options \\011TCP_DEBUG\\011# Record last TCP_NDEBUG packets with SO_DEBUG\n"
"_CFG_\n"
"_CFG_#options \\011ALTQ\\011\\011# Manipulate network interfaces' output queues\n"
"_CFG_#options \\011ALTQ_BLUE\\011# Stochastic Fair Blue\n"
"_CFG_#options \\011ALTQ_CBQ\\011# Class-Based Queueing\n"
"_CFG_#options \\011ALTQ_CDNR\\011# Diffserv Traffic Conditioner\n"
"_CFG_#options \\011ALTQ_FIFOQ\\011# First-In First-Out Queue\n"
"_CFG_#options \\011ALTQ_FLOWVALVE\\011# RED/flow-valve (red-penalty-box)\n"
"_CFG_#options \\011ALTQ_HFSC\\011# Hierarchical Fair Service Curve\n"
"_CFG_#options \\011ALTQ_LOCALQ\\011# Local queueing discipline\n"
"_CFG_#options \\011ALTQ_PRIQ\\011# Priority Queueing\n"
"_CFG_#options \\011ALTQ_RED\\011# Random Early Detection\n"
"_CFG_#options \\011ALTQ_RIO\\011# RED with IN/OUT\n"
"_CFG_#options \\011ALTQ_WFQ\\011# Weighted Fair Queueing\n"
"_CFG_\n"
"_CFG_# WS console uses SUN or VT100 terminal emulation\n"
"_CFG_options \\011WSEMUL_VT100\n"
"_CFG_options \\011WSDISPLAY_COMPAT_USL\\011\\011# wsconscfg VT handling\n"
"_CFG_options \\011WSDISPLAY_COMPAT_RAWKBD\n"
"_CFG_options \\011WS_KERNEL_FG=WSCOL_GREEN\n"
"_CFG_#options \\011WS_KERNEL_BG=WSCOL_BLACK\n"
"_CFG_\n"
"_CFG_options \\011FONT_OMRON12x20\n"
"_CFG_\n"
"_CFG_config\\011\\011netbsd root on ? type ?\n"
"_CFG_\n"
"_CFG_mainbus0 at root\n"
"_CFG_\n"
"_CFG_clock0\\011at mainbus0\n"
"_CFG_\n"
"_CFG_# LCD on front panel\n"
"_CFG_lcd0\\011at mainbus0\n"
"_CFG_\n"
"_CFG_# uPD7201 SIO\n"
"_CFG_sio0\\011at mainbus0\n"
"_CFG_siotty0\\011at sio0\\011\\011\\011# ttya\n"
"_CFG_ws0\\011at sio0\\011\\011\\011# port for keyboard and mouse\n"
"_CFG_# AM7990 LANCE\n"
"_CFG_le0\\011at mainbus0\n"
"_CFG_# MB89532 SPC\n"
"_CFG_spc0\\011at mainbus0\n"
"_CFG_spc1\\011at mainbus0\\011\\011# 2nd SCSI on LUNA-II\n"
"_CFG_# framebuffer\n"
"_CFG_fb0\\011at mainbus0\\011\\011# 16 or 256 pseudo color\n"
"_CFG_\n"
"_CFG_# HD647180X I/O processor\n"
"_CFG_xpbus0\\011at mainbus0\n"
"_CFG_xp0\\011at xpbus0\n"
"_CFG_\n"
"_CFG_# HD647180X I/O processor as PSG PAM audio\n"
"_CFG_psgpam0\\011at xpbus0\n"
"_CFG_audio*\\011at psgpam?\n"
"_CFG_#spkr*\\011at audio?\n"
"_CFG_#wsbell*\\011at spkr?\n"
"_CFG_\n"
"_CFG_# Workstation Console attachments\n"
"_CFG_wsdisplay*\\011at fb?\n"
"_CFG_wskbd*\\011\\011at ws? console ? mux 1\n"
"_CFG_wsmouse*\\011at ws? mux 0\n"
"_CFG_\n"
"_CFG_# SCSI bus support\n"
"_CFG_scsibus* at spc?\n"
"_CFG_\n"
"_CFG_# SCSI devices\n"
"_CFG_sd* at scsibus? target ? lun ?\\011\\011# SCSI disks\n"
"_CFG_st* at scsibus? target ? lun ?\\011\\011# SCSI tapes\n"
"_CFG_cd* at scsibus? target ? lun ?\\011\\011# SCSI CD-ROMs\n"
"_CFG_#ch* at scsibus? target ? lun ?\\011\\011# SCSI changer devices\n"
"_CFG_#ss* at scsibus? target ? lun ?\\011\\011# SCSI scanners\n"
"_CFG_#uk* at scsibus? target ? lun ?\\011\\011# unknown SCSI devices\n"
"_CFG_\n"
"_CFG_#\n"
"_CFG_# accept filters\n"
"_CFG_#pseudo-device   accf_data\\011\\011# \"dataready\" accept filter\n"
"_CFG_#pseudo-device   accf_http\\011\\011# \"httpready\" accept filter\n"
"_CFG_\n"
"_CFG_pseudo-device\\011bpfilter\\011\\011# Berkeley Packet Filter\n"
"_CFG_#pseudo-device\\011carp\\011\\011\\011# Common Address Redundancy Protocol\n"
"_CFG_#pseudo-device\\011ccd\\011\\011\\011# concatenated and striped disks\n"
"_CFG_#pseudo-device\\011cgd\\011\\011\\011# cryptographic disks\n"
"_CFG_#pseudo-device\\011gre\\011\\011\\011# generic L3 over IP tunnel\n"
"_CFG_#pseudo-device\\011npf\\011\\011\\011# NPF packet filter\n"
"_CFG_pseudo-device\\011loop\\011\\011\\011# loopback interface; required\n"
"_CFG_pseudo-device\\011md\\011\\011\\011# memory disk device\n"
"_CFG_#pseudo-device\\011ppp\\011\\011\\011# PPP interfaces\n"
"_CFG_#pseudo-device\\011pppoe\\011\\011\\011# PPP over Ethernet (RFC 2516)\n"
"_CFG_pseudo-device\\011pty\\011\\011\\011# pseudo-terminals\n"
"_CFG_#pseudo-device\\011raid\\011\\011\\011# RAIDframe disk driver\n"
"_CFG_pseudo-device\\011fss\\011\\011\\011# file system snapshot device\n"
"_CFG_#pseudo-device\\011sl\\011\\011\\011# SLIP interfaces\n"
"_CFG_#pseudo-device\\011tun\\011\\011\\011# Network \"tunnel\" device\n"
"_CFG_#pseudo-device\\011tap\\011\\011\\011# virtual Ethernet\n"
"_CFG_pseudo-device\\011vlan\\011\\011\\011# IEEE 802.1q encapsulation\n"
"_CFG_pseudo-device\\011bridge\\011\\011\\011# simple inter-network bridging\n"
"_CFG_#pseudo-device\\011vether\\011\\011\\011# Virtual Ethernet for bridge\n"
"_CFG_pseudo-device\\011agr\\011\\011\\011# IEEE 802.3ad link aggregation\n"
"_CFG_#pseudo-device\\011vnd\\011\\011\\011# disk-like interface to files\n"
"_CFG_#options \\011VND_COMPRESSION\\011\\011# compressed vnd(4)\n"
"_CFG_pseudo-device\\011clockctl\\011\\011# user control of clock subsystem\n"
"_CFG_pseudo-device\\011drvctl\\011\\011\\011# user control of drive subsystem\n"
"_CFG_pseudo-device\\011ksyms\\011\\011\\011# /dev/ksyms\n"
"_CFG_pseudo-device \\011swwdog\\011\\011\\011# software watchdog timer -- swwdog(4)\n"
"_CFG_\n"
"_CFG_pseudo-device\\011wsmux\\011\\011\\011# mouse & keyboard multiplexsor\n"
"_CFG_\n"
"_CFG_# Veriexec\n"
"_CFG_# include \"dev/veriexec.config\"\n"
"_CFG_\n"
"_CFG_# Pull in optional local configuration - always at end\n"
"_CFG_cinclude\\011\"arch/luna68k/conf/GENERIC.local\"\n"
#ifdef INCLUDE_CONFIG_FILE

"_CFG_### END CONFIG FILE \"/Users/sidqian/Downloads/summer/L2S/netbsd-src/sys/arch/luna68k/conf/TESTING\"\n"
"_CFG_### (included from \"arch/luna68k/conf/std.luna68k\")\n"
"_CFG_###> #\\011$NetBSD: std.luna68k,v 1.8 2010/09/19 02:09:28 tsutsui Exp $\n"
"_CFG_###> \n"
"_CFG_###> machine luna68k m68k\n"
"_CFG_###> include\\011\\011\"conf/std\"\\011\\011\\011# MI standard options\n"
"_CFG_###> include\\011\\011\"arch/m68k/conf/std.m68k\"\\011# m68k standard options\n"
"_CFG_### (end include \"arch/luna68k/conf/std.luna68k\")\n"
"_CFG_### (included from \"conf/std\")\n"
"_CFG_###> # $NetBSD: std,v 1.23 2019/01/27 02:08:41 pgoyette Exp $\n"
"_CFG_###> #\n"
"_CFG_###> # standard MI 'options'\n"
"_CFG_###> #\n"
"_CFG_###> # this file is for options which can't be off-by-default for some reasons.\n"
"_CFG_###> # \"it's commonly used\" is NOT a good reason to enable options here.\n"
"_CFG_###> \n"
"_CFG_###> #\n"
"_CFG_###> # Always include \"kern\" attribute (module).  Other attributes don't need to\n"
"_CFG_###> # depend on \"kern\".\n"
"_CFG_###> #\n"
"_CFG_###> select\\011kern\n"
"_CFG_###> \n"
"_CFG_###> # Always include the \"vfs\" attribute (module).  Although all of the\n"
"_CFG_###> # ufs/xxx file systems depend on the vfs attribute, it is not required\n"
"_CFG_###> # that any file system actually be built-in to the kernel.  (At least\n"
"_CFG_###> # on some architectures, file system modules can be loaded at boot\n"
"_CFG_###> # time.)\n"
"_CFG_###> \n"
"_CFG_###> select vfs\n"
"_CFG_###> \n"
"_CFG_###> select\\011net\\011\\011# XXX Clean up dependency\n"
"_CFG_###> \n"
"_CFG_###> # the following options are on-by-default to keep\n"
"_CFG_###> # kernel config file compatibility.\n"
"_CFG_###> options\\011VMSWAP\\011\\011# Swap device/file support\n"
"_CFG_###> options\\011BUFQ_FCFS\\011# First-come First-serve strategy\n"
"_CFG_###> options\\011BUFQ_DISKSORT\\011# Traditional min seek sort strategy\n"
"_CFG_###> options\\011RFC2292\\011\\011# Previous version of Adv. Sockets API for IPv6 \n"
"_CFG_###> options\\011PTRACE\\011\\011# Include ptrace(2) syscall\n"
"_CFG_###> options\\011PTRACE_HOOKS\\011# Include ptrace hooks\n"
"_CFG_###> options\\011COREDUMP\\011# allow processes to coredump.\n"
"_CFG_###> options\\011AIO\\011\\011# POSIX asynchronous I/O\n"
"_CFG_###> options\\011MQUEUE\\011\\011# POSIX message queues\n"
"_CFG_###> \n"
"_CFG_###> # Common compatibility functions. They happen to be needed even when\n"
"_CFG_###> # no compatibility option is explicitly enabled.\n"
"_CFG_###> #\n"
"_CFG_###> options        COMPAT_UTILS\n"
"_CFG_###> \n"
"_CFG_###> #\n"
"_CFG_###> # Security model.\n"
"_CFG_###> #\n"
"_CFG_###> options\\011secmodel_bsd44\\011# Traditional 4.4BSD security model\n"
"_CFG_###> \n"
"_CFG_###> #\n"
"_CFG_###> # Scheduling algorithm\n"
"_CFG_###> #\n"
"_CFG_###> options\\011SCHED_4BSD\n"
"_CFG_###> \n"
"_CFG_###> pseudo-device\\011cpuctl\n"
"_CFG_###> \n"
"_CFG_###> #\n"
"_CFG_###> # Kernel entropy pool and random-number generator pseudodevice.\n"
"_CFG_###> # The pseudodevice might stop being \"std\" when the two are torn\n"
"_CFG_###> # apart some day but the entropy pool itself never will (they are\n"
"_CFG_###> # presently implemented in the same source file)\n"
"_CFG_###> #\n"
"_CFG_###> pseudo-device\\011rnd\n"
"_CFG_### (end include \"conf/std\")\n"
"_CFG_### (included from \"arch/m68k/conf/std.m68k\")\n"
"_CFG_###> # $NetBSD: std.m68k,v 1.2 2021/06/04 10:46:11 martin Exp $\n"
"_CFG_###> #\n"
"_CFG_###> # standard, required NetBSD/m68k options\n"
"_CFG_###> \n"
"_CFG_###> options \\011EXEC_ELF32\\011\\011# exec ELF binaries\n"
"_CFG_###> options \\011EXEC_SCRIPT\\011\\011# exec #! scripts\n"
"_CFG_###> \n"
"_CFG_###> options \\011CPU_IN_CKSUM\\011\\011# use MD optimized cpu_in_cksum()\n"
"_CFG_###> \n"
"_CFG_###> options\\011\\011VMSWAP_DEFAULT_PLAINTEXT\\011# do not encrypt swap by\n"
"_CFG_###> \\011\\011\\011\\011\\011# default (slow cpu)\n"
"_CFG_### (end include \"arch/m68k/conf/std.m68k\")\n"
"_CFG_### (included from \"conf/compat_netbsd12.config\")\n"
"_CFG_###> #\\011$NetBSD: compat_netbsd12.config,v 1.2 2018/01/15 07:20:10 mrg Exp $\n"
"_CFG_###> \n"
"_CFG_###> # Common fragment for all NetBSD targets wanting NetBSD 1.2 and newer\n"
"_CFG_###> # compatibility support.\n"
"_CFG_###> #\n"
"_CFG_###> # Note that COMPAT_12 implies all newer COMPAT_XX options.\n"
"_CFG_###> \n"
"_CFG_###> include        \"conf/compat_netbsd.config\"\n"
"_CFG_###> options \\011COMPAT_12\\011# NetBSD 1.2 and beyond.\n"
"_CFG_### (end include \"conf/compat_netbsd12.config\")\n"
"_CFG_### (included from \"conf/compat_netbsd.config\")\n"
"_CFG_###> # $NetBSD: compat_netbsd.config,v 1.1 2017/09/14 07:58:44 mrg Exp $\n"
"_CFG_###> \n"
"_CFG_###> # Traditional NetBSD options enabled for most kernels.\n"
"_CFG_###> \n"
"_CFG_###> options \\011COMPAT_43\\011# 4.3BSD system interfaces\n"
"_CFG_###> options \\011COMPAT_44\\011# 4.4BSD system interfaces\n"
"_CFG_###> options \\011COMPAT_BSDPTY\\011# /dev/[pt]ty?? ptys.\n"
"_CFG_### (end include \"conf/compat_netbsd.config\")\n"
#endif /* INCLUDE_CONFIG_FILE */
;
#endif /* INCLUDE_CONFIG_FILE || INCLUDE_JUST_CONFIG */
#endif /* CONFIG_FILE */
