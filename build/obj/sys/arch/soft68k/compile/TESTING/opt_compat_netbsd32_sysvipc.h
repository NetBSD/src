/* option `COMPAT_NETBSD32_SYSVIPC' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_COMPAT_NETBSD32_SYSVIPC
 .global _KERNEL_OPT_COMPAT_NETBSD32_SYSVIPC
 .equiv _KERNEL_OPT_COMPAT_NETBSD32_SYSVIPC,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_COMPAT_NETBSD32_SYSVIPC\n .global _KERNEL_OPT_COMPAT_NETBSD32_SYSVIPC\n .equiv _KERNEL_OPT_COMPAT_NETBSD32_SYSVIPC,0x6e074def\n .endif");
#endif
