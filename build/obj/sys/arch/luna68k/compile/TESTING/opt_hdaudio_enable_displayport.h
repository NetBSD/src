/* option `HDAUDIO_ENABLE_DISPLAYPORT' is obsolete */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_HDAUDIO_ENABLE_DISPLAYPORT
 .global _KERNEL_OPT_HDAUDIO_ENABLE_DISPLAYPORT
 .equiv _KERNEL_OPT_HDAUDIO_ENABLE_DISPLAYPORT,0xdeadbeef
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_HDAUDIO_ENABLE_DISPLAYPORT\n .global _KERNEL_OPT_HDAUDIO_ENABLE_DISPLAYPORT\n .equiv _KERNEL_OPT_HDAUDIO_ENABLE_DISPLAYPORT,0xdeadbeef\n .endif");
#endif
