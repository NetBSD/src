#define	SYSCTL_INCLUDE_DESCR	1
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SYSCTL_INCLUDE_DESCR
 .global _KERNEL_OPT_SYSCTL_INCLUDE_DESCR
 .equiv _KERNEL_OPT_SYSCTL_INCLUDE_DESCR,0x1
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SYSCTL_INCLUDE_DESCR\n .global _KERNEL_OPT_SYSCTL_INCLUDE_DESCR\n .equiv _KERNEL_OPT_SYSCTL_INCLUDE_DESCR,0x1\n .endif");
#endif
/* option `SYSCTL_DEBUG_CREATE' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SYSCTL_DEBUG_CREATE
 .global _KERNEL_OPT_SYSCTL_DEBUG_CREATE
 .equiv _KERNEL_OPT_SYSCTL_DEBUG_CREATE,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SYSCTL_DEBUG_CREATE\n .global _KERNEL_OPT_SYSCTL_DEBUG_CREATE\n .equiv _KERNEL_OPT_SYSCTL_DEBUG_CREATE,0x6e074def\n .endif");
#endif
/* option `SYSCTL_DEBUG_SETUP' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SYSCTL_DEBUG_SETUP
 .global _KERNEL_OPT_SYSCTL_DEBUG_SETUP
 .equiv _KERNEL_OPT_SYSCTL_DEBUG_SETUP,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SYSCTL_DEBUG_SETUP\n .global _KERNEL_OPT_SYSCTL_DEBUG_SETUP\n .equiv _KERNEL_OPT_SYSCTL_DEBUG_SETUP,0x6e074def\n .endif");
#endif
/* option `SYSCTL_DISALLOW_KWRITE' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SYSCTL_DISALLOW_KWRITE
 .global _KERNEL_OPT_SYSCTL_DISALLOW_KWRITE
 .equiv _KERNEL_OPT_SYSCTL_DISALLOW_KWRITE,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SYSCTL_DISALLOW_KWRITE\n .global _KERNEL_OPT_SYSCTL_DISALLOW_KWRITE\n .equiv _KERNEL_OPT_SYSCTL_DISALLOW_KWRITE,0x6e074def\n .endif");
#endif
/* option `SYSCTL_DISALLOW_CREATE' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_SYSCTL_DISALLOW_CREATE
 .global _KERNEL_OPT_SYSCTL_DISALLOW_CREATE
 .equiv _KERNEL_OPT_SYSCTL_DISALLOW_CREATE,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_SYSCTL_DISALLOW_CREATE\n .global _KERNEL_OPT_SYSCTL_DISALLOW_CREATE\n .equiv _KERNEL_OPT_SYSCTL_DISALLOW_CREATE,0x6e074def\n .endif");
#endif
