/* option `FLASH_STATIC_PARTITIONS' not defined */
#ifdef _LOCORE
 .ifndef _KERNEL_OPT_FLASH_STATIC_PARTITIONS
 .global _KERNEL_OPT_FLASH_STATIC_PARTITIONS
 .equiv _KERNEL_OPT_FLASH_STATIC_PARTITIONS,0x6e074def
 .endif
#else
__asm(" .ifndef _KERNEL_OPT_FLASH_STATIC_PARTITIONS\n .global _KERNEL_OPT_FLASH_STATIC_PARTITIONS\n .equiv _KERNEL_OPT_FLASH_STATIC_PARTITIONS,0x6e074def\n .endif");
#endif
