/Users/sidqian/Downloads/summer/L2S/netbsd-src/crypto/external/bsd/heimdal/dist/lib/asn1/der.h