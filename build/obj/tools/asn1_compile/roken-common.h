/Users/sidqian/Downloads/summer/L2S/netbsd-src/crypto/external/bsd/heimdal/dist/lib/roken/roken-common.h