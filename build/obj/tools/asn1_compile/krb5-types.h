/Users/sidqian/Downloads/summer/L2S/netbsd-src/crypto/external/bsd/heimdal/include/krb5-types.h