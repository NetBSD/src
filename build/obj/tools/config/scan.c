#if HAVE_NBTOOL_CONFIG_H
#include "nbtool_config.h"
#endif
#line 1 "scan.c"

#line 3 "scan.c"

#define  YY_INT_ALIGNED short int

/* A lexical scanner generated by flex */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 6
#define YY_FLEX_SUBMINOR_VERSION 4
#if YY_FLEX_SUBMINOR_VERSION > 0
#define FLEX_BETA
#endif

/* First, we deal with  platform-specific or compiler-specific issues. */

/* begin standard C headers. */
#ifdef _LIBC
#include "namespace.h"
#endif
#include <stdio.h>
#include <string.h>
#include <errno.h>
#include <stdlib.h>

/* end standard C headers. */

/*	$NetBSD: flexint.h,v 1.3 2018/12/23 16:27:17 christos Exp $	*/

/* flex integer type definitions */

#ifndef FLEXINT_H
#define FLEXINT_H

/* C99 systems have <inttypes.h>. Non-C99 systems may or may not. */

#if defined (__STDC_VERSION__) && __STDC_VERSION__ >= 199901L

/* C99 says to define __STDC_LIMIT_MACROS before including stdint.h,
 * if you want the limit (max/min) macros for int types. 
 */
#ifndef __STDC_LIMIT_MACROS
#define __STDC_LIMIT_MACROS 1
#endif

#include <inttypes.h>
typedef int8_t flex_int8_t;
typedef uint8_t flex_uint8_t;
typedef int16_t flex_int16_t;
typedef uint16_t flex_uint16_t;
typedef int32_t flex_int32_t;
typedef uint32_t flex_uint32_t;
#else
typedef signed char flex_int8_t;
typedef short int flex_int16_t;
typedef int flex_int32_t;
typedef unsigned char flex_uint8_t; 
typedef unsigned short int flex_uint16_t;
typedef unsigned int flex_uint32_t;

/* Limits of integral types. */
#ifndef INT8_MIN
#define INT8_MIN               (-128)
#endif
#ifndef INT16_MIN
#define INT16_MIN              (-32767-1)
#endif
#ifndef INT32_MIN
#define INT32_MIN              (-2147483647-1)
#endif
#ifndef INT8_MAX
#define INT8_MAX               (127)
#endif
#ifndef INT16_MAX
#define INT16_MAX              (32767)
#endif
#ifndef INT32_MAX
#define INT32_MAX              (2147483647)
#endif
#ifndef UINT8_MAX
#define UINT8_MAX              (255U)
#endif
#ifndef UINT16_MAX
#define UINT16_MAX             (65535U)
#endif
#ifndef UINT32_MAX
#define UINT32_MAX             (4294967295U)
#endif

#ifndef SIZE_MAX
#define SIZE_MAX               (~(size_t)0)
#endif

#endif /* ! C99 */

#endif /* ! FLEXINT_H */

/* begin standard C++ headers. */

/* TODO: this is always defined, so inline it */
#define yyconst const

#if defined(__GNUC__) && __GNUC__ >= 3
#define yynoreturn __attribute__((__noreturn__))
#else
#define yynoreturn
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an
 *   integer in range [0..255] for use as an array index.
 */
#define YY_SC_TO_UI(c) ((YY_CHAR) (c))

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN (yy_start) = 1 + 2 *
/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START (((yy_start) - 1) / 2)
#define YYSTATE YY_START
/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)
/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( yyin  )
#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#ifndef YY_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k.
 * Moreover, YY_BUF_SIZE is 2*YY_READ_BUF_SIZE in the general case.
 * Ditto for the __ia64__ case accordingly.
 */
#define YY_BUF_SIZE 32768
#else
#define YY_BUF_SIZE 16384
#endif /* __ia64__ */
#endif

/* The state buf must be large enough to hold one state per character in the main buffer.
 */
#define YY_STATE_BUF_SIZE   ((YY_BUF_SIZE + 2) * sizeof(yy_state_type))

#ifndef YY_TYPEDEF_YY_BUFFER_STATE
#define YY_TYPEDEF_YY_BUFFER_STATE
typedef struct yy_buffer_state *YY_BUFFER_STATE;
#endif

#ifndef YY_TYPEDEF_YY_SIZE_T
#define YY_TYPEDEF_YY_SIZE_T
typedef size_t yy_size_t;
#endif

extern yy_size_t yyleng;

extern FILE *yyin, *yyout;

#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2
    
    #define YY_LESS_LINENO(n)
    #define YY_LINENO_REWIND_TO(ptr)
    
/* Return all but the first "n" matched characters back to the input stream. */
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		*yy_cp = (yy_hold_char); \
		YY_RESTORE_YY_MORE_OFFSET \
		(yy_c_buf_p) = yy_cp = yy_bp + yyless_macro_arg - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )
#define unput(c) yyunput( c, (yytext_ptr)  )

#ifndef YY_STRUCT_YY_BUFFER_STATE
#define YY_STRUCT_YY_BUFFER_STATE
struct yy_buffer_state
	{
	FILE *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	size_t yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	size_t yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether this is an "interactive" input source; if so, and
	 * if we're using stdio for input, then we want to use getc()
	 * instead of fread(), to make sure we stop fetching input after
	 * each newline.
	 */
	int yy_is_interactive;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

    int yy_bs_lineno; /**< The line count. */
    int yy_bs_column; /**< The column count. */

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;

#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2

	};
#endif /* !YY_STRUCT_YY_BUFFER_STATE */

/* Stack of input buffers. */
static size_t yy_buffer_stack_top = 0; /**< index of top of stack. */
static size_t yy_buffer_stack_max = 0; /**< capacity of stack. */
static YY_BUFFER_STATE * yy_buffer_stack = NULL; /**< Stack as an array. */

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 *
 * Returns the top of the stack, or NULL.
 */
#define YY_CURRENT_BUFFER ( (yy_buffer_stack) \
                          ? (yy_buffer_stack)[(yy_buffer_stack_top)] \
                          : NULL)
/* Same as previous macro, but useful when we know that the buffer stack is not
 * NULL or when we need an lvalue. For internal use only.
 */
#define YY_CURRENT_BUFFER_LVALUE (yy_buffer_stack)[(yy_buffer_stack_top)]

/* yy_hold_char holds the character lost when yytext is formed. */
static char yy_hold_char;
static yy_size_t yy_n_chars;		/* number of characters read into yy_ch_buf */
yy_size_t yyleng;

/* Points to current character in buffer. */
static char *yy_c_buf_p = NULL;
static int yy_init = 0;		/* whether we need to initialize */
static int yy_start = 0;	/* start state number */

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
static int yy_did_buffer_switch_on_eof;

void yyrestart ( FILE *input_file  );
void yy_switch_to_buffer ( YY_BUFFER_STATE new_buffer  );
YY_BUFFER_STATE yy_create_buffer ( FILE *file, yy_size_t size  );
void yy_delete_buffer ( YY_BUFFER_STATE b  );
void yy_flush_buffer ( YY_BUFFER_STATE b  );
void yypush_buffer_state ( YY_BUFFER_STATE new_buffer  );
void yypop_buffer_state ( void );

static void yyensure_buffer_stack ( void );
static void yy_load_buffer_state ( void );
static void yy_init_buffer ( YY_BUFFER_STATE b, FILE *file  );
#define YY_FLUSH_BUFFER yy_flush_buffer( YY_CURRENT_BUFFER )

YY_BUFFER_STATE yy_scan_buffer ( char *base, yy_size_t size  );
YY_BUFFER_STATE yy_scan_string ( const char *yy_str  );
YY_BUFFER_STATE yy_scan_bytes ( const char *bytes, yy_size_t len  );

void *yyalloc ( yy_size_t  );
void *yyrealloc ( void *, yy_size_t  );
void yyfree ( void *  );

#define yy_new_buffer yy_create_buffer
#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){ \
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_is_interactive = is_interactive; \
	}
#define yy_set_bol(at_bol) \
	{ \
	if ( ! YY_CURRENT_BUFFER ){\
        yyensure_buffer_stack (); \
		YY_CURRENT_BUFFER_LVALUE =    \
            yy_create_buffer( yyin, YY_BUF_SIZE ); \
	} \
	YY_CURRENT_BUFFER_LVALUE->yy_at_bol = at_bol; \
	}
#define YY_AT_BOL() (YY_CURRENT_BUFFER_LVALUE->yy_at_bol)

/* Begin user sect3 */

#define yywrap() (/*CONSTCOND*/1)
#define YY_SKIP_YYWRAP
typedef flex_uint8_t YY_CHAR;

FILE *yyin = NULL, *yyout = NULL;

typedef int yy_state_type;

extern int yylineno;
int yylineno = 1;

extern char *yytext;
#ifdef yytext_ptr
#undef yytext_ptr
#endif
#define yytext_ptr yytext

static yy_state_type yy_get_previous_state ( void );
static yy_state_type yy_try_NUL_trans ( yy_state_type current_state  );
static int yy_get_next_buffer ( void );
static void yynoreturn yy_fatal_error ( const char* msg  );

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	(yytext_ptr) = yy_bp; \
	yyleng = (yy_size_t)(yy_cp - yy_bp); \
	(yy_hold_char) = *yy_cp; \
	*yy_cp = '\0'; \
	(yy_c_buf_p) = yy_cp;
#define YY_NUM_RULES 78
#define YY_END_OF_BUFFER 79
/* This struct is not used in this scanner,
   but its presence is necessary. */
struct yy_trans_info
	{
	flex_int32_t yy_verify;
	flex_int32_t yy_nxt;
	};
static const flex_int16_t yy_accept[447] =
    {   0,
        0,    0,    0,    0,   79,   77,   76,   73,   77,   75,
       77,   77,   65,   69,   71,   77,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,   74,   76,   66,   66,   61,   60,   61,
       61,   61,   76,   72,    0,   67,    0,   75,   52,    0,
       65,   65,   69,    0,    0,   71,   53,   66,   66,   66,
        2,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,   66,   34,   66,   38,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   76,    0,    0,   66,   66,   66,    0,    0,    0,

        0,   68,   35,   70,    1,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,    0,    0,    0,    0,
        0,   66,   66,   66,    6,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   20,   66,   66,   66,   66,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,   66,   44,   66,   66,   66,   48,   66,
       66,   51,   66,   66,   66,   66,   66,    0,    0,    0,

        0,    0,   66,    4,    5,   66,   66,   66,   66,    9,
       66,   66,   66,   66,   66,   66,   19,   66,   22,   23,
       66,   66,   66,   66,   27,   66,   66,   66,   31,   66,
       66,   66,   66,   66,   66,   66,   66,   66,   66,   66,
       66,   66,   66,    0,   58,    0,   66,   66,   66,    0,
        0,    0,    0,    0,    3,   66,   66,   66,    8,   66,
       10,   12,   66,   66,   66,   17,   66,   66,   24,   66,
       66,   66,   66,   66,   66,   36,   66,   66,   66,   40,
       66,   45,   46,   47,   49,   66,   66,   66,    0,    0,
       59,    0,    0,   66,    0,    0,    0,   66,   66,   66,

       11,   66,   66,   66,   66,   66,   66,   66,   26,   66,
       66,   66,   66,   66,   66,   39,   66,   66,   50,   66,
       66,    0,    0,    0,    0,    0,   66,   66,   66,   13,
       66,   16,   66,   66,    0,   25,   66,   66,   30,   66,
       66,   37,    0,   66,   66,    0,   66,    0,   54,    0,
        0,    0,    0,   66,    0,   66,   14,   66,   66,    0,
        0,    0,   66,   66,   66,   66,    0,    0,    0,   66,
       66,    0,    0,    0,    0,   55,    0,    0,   66,    0,
        0,    0,   66,   66,   66,   66,    0,    0,    0,    0,
       62,    0,    0,   66,   66,   66,   33,    0,    0,    0,

        0,   64,    0,    0,   66,   66,    0,   56,    0,    0,
        0,    0,   41,    0,    0,    0,    0,   63,    0,    0,
       66,   66,   66,   21,    0,   28,   66,   32,    0,   66,
       43,    0,    0,   57,    0,    0,    0,    7,   15,   18,
       66,   66,    0,   29,   42,    0
    } ;

static const YY_CHAR yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    2,    1,    4,    5,    1,    1,    1,    1,    1,
        1,    1,    6,    1,    7,    8,    8,    9,   10,   10,
       10,   10,   10,   10,   10,   11,   11,   12,    1,    1,
       13,    1,    1,    1,   14,   14,   14,   14,   14,   14,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   16,   15,   15,
        1,   17,    1,    1,   15,    1,   18,   19,   20,   21,

       22,   23,   24,   25,   26,   27,   28,   29,   30,   31,
       32,   33,   15,   34,   35,   36,   37,   38,   39,   40,
       41,   42,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,

        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1
    } ;

static const YY_CHAR yy_meta[44] =
    {   0,
        1,    2,    3,    4,    5,    1,    6,    7,    8,    8,
        8,    1,    1,    9,    9,    9,    1,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
        9,    9,    1
    } ;

static const flex_int16_t yy_base[480] =
    {   0,
        0,   42,  953,   43,  948, 1405,  935,  926,   43,    0,
      897,  873,    0,   40,   43,  886,   50,   54,   59,   66,
       64,   68,   74,   76,   92,   71,  100,  104,  108,  119,
      106,  113,  116, 1405,  126,  129,  136, 1405, 1405,  127,
       58,  873,  882, 1405,  100, 1405,  877,    0, 1405,  845,
        0,    0,  146,  839,  161,  153, 1405,    0,  158,  166,
      169,  178,  181,  183,  185,  187,  189,  191,  195,  201,
      206,  215,  218,  222,  224,  226,  232,  229,  234,  238,
      240,  242,  248,  251,  258,  260,  264,  267,  270,  272,
      274,  261,  101,  822,  286,  277,  292,  289,   99,  818,

      265, 1405, 1405,    0,  294,  300,  309,  312,  317,  319,
      323,  325,  327,  329,  335,  339,  350,  355,  337,  357,
      362,  368,  364,  370,  372,  374,  376,  380,  387,  391,
      393,  400,  396,  403,  405,  407,  417,  421,  427,  429,
      433,  437,  439,  441,  446,  448,  804,  799,  777,  778,
      772,  458,  463,  465,  467,  469,  473,  475,  477,  480,
      482,  485,  487,  489,  497,  500,  506,  510,  514,  516,
      518,  522,  520,  526,  531,  528,  535,  537,  545,  548,
      554,  560,  563,  566,  568,  572,  574,  576,  583,  586,
      590,  592,  594,  602,  604,  606,  612,  307,  619,  751,

      744,  743,  623,  625,  628,  630,  633,  635,  637,  639,
      642,  644,  649,  646,  658,  662,  664,  723,  666,  670,
      674,  678,  680,  682,  684,  686,  689,  692,  696,  698,
      700,  702,  704,  708,  710,  713,  718,  720,  722,  726,
      730,  733,  740,  754, 1405,  750,  761,  744,  763,  727,
      722,  770,  737,  708,  769,  771,  773,  775,  777,  780,
      782,  784,  788,  791,  794,  800,  681,  802,  804,  806,
      808,  810,  812,  815,  439,  818,  824,  826,  828,  830,
      834,  836,  844,  846,  848,  850,  855,  857,  695,  864,
     1405,  676,  673,  866,  640,  638,  656,  863,  868,  875,

      879,  881,  884,  886,  598,  588,  893,  890,  895,  899,
      901,  905,  585,  577,  907,  909,  916,  288,  912,  924,
      926,  585,  933,  583,  564,  541,  934,  937,  520,  939,
      943,  945,  539,  504,  414,  947,  951,  953,  955,  494,
      501,  957,  964,  488,  470,  498,  969,  976, 1405,  476,
      982,  988,  455,  962,  978,  426,  987,  423,  420,  350,
      994,  996,  994,  966,  407,  408,  533, 1004, 1008,  392,
      394, 1012,  418,  388, 1016, 1405,  382, 1021, 1020,  591,
     1027, 1029,  337, 1027,  320,  310,  622, 1036,  311, 1040,
     1405,  302, 1045, 1044, 1046,  261,    0,  855, 1053,  285,

     1059, 1405,  257, 1063,  217,  184, 1067, 1405,  212, 1071,
     1078,  208, 1077,  926, 1084,  203, 1088, 1405,  201, 1092,
      175, 1091,  144,    0,  147, 1093, 1095,    0,  143,   89,
        0,   74, 1102, 1405,   67, 1106,   60,    0, 1105,    0,
     1107,   37,   52, 1109,    0, 1405, 1142, 1151, 1160, 1164,
     1167, 1171, 1175, 1184, 1193, 1201, 1209, 1217, 1225, 1233,
     1241, 1250, 1258, 1266, 1275, 1283, 1292, 1300, 1308, 1316,
     1325, 1334, 1342, 1351, 1360, 1369, 1377, 1386, 1395
    } ;

static const flex_int16_t yy_def[480] =
    {   0,
      446,    1,  447,  447,  446,  446,  446,  446,  448,  449,
      446,  446,  450,  451,  451,  446,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  446,  446,  452,  452,  446,  446,  446,
      446,  446,  446,  446,  448,  446,  448,  449,  446,  446,
      450,  450,  451,  451,  451,  451,  446,  453,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  446,  446,  446,  452,  452,  452,  446,  446,  446,

      446,  446,  446,   55,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  446,  446,  446,  446,
      446,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  446,  446,  446,

      446,  446,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  453,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  446,  446,  454,  452,  452,  452,  446,
      446,  446,  446,  446,  452,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  453,  452,  452,  452,
      452,  452,  452,  452,  453,  452,  452,  452,  452,  452,
      452,  452,  452,  452,  452,  452,  452,  452,  454,  446,
      446,  455,  456,  452,  446,  446,  446,  452,  452,  452,

      452,  452,  452,  452,  453,  453,  452,  452,  452,  452,
      452,  452,  453,  453,  452,  452,  452,  453,  452,  452,
      452,  455,  457,  458,  446,  446,  452,  452,  453,  452,
      452,  452,  453,  453,  459,  452,  452,  452,  452,  453,
      453,  452,  460,  453,  453,  461,  452,  446,  446,  462,
      457,  463,  446,  452,  464,  453,  452,  453,  453,  465,
      466,  459,  452,  452,  453,  453,  467,  468,  460,  453,
      453,  469,  470,  462,  446,  446,  471,  463,  452,  472,
      473,  464,  453,  452,  453,  453,  465,  446,  465,  446,
      446,  474,  466,  452,  452,  453,  453,  467,  446,  467,

      446,  446,  475,  468,  453,  453,  446,  446,  476,  469,
      477,  471,  452,  472,  446,  472,  446,  446,  478,  473,
      453,  452,  453,  453,  474,  452,  452,  453,  475,  453,
      453,  476,  446,  446,  479,  477,  478,  453,  452,  453,
      452,  453,  479,  452,  453,    0,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446
    } ;

static const flex_int16_t yy_nxt[1449] =
    {   0,
        6,    7,    8,    9,   10,   11,   12,   13,   14,   15,
       15,   16,    6,   17,   17,   17,    6,   18,   19,   20,
       21,   17,   22,   17,   17,   23,   17,   17,   24,   25,
       26,   27,   28,   29,   30,   31,   17,   32,   33,   17,
       17,   17,   34,   35,   40,   39,   46,   52,   53,   53,
       52,   56,   56,   56,  434,   55,   58,   52,  445,   47,
       58,   52,  418,   36,   41,   58,   52,   37,   42,  434,
       58,   52,   58,   52,   58,   52,  408,   58,   52,   55,
       58,   52,   58,   52,   60,   67,   99,   62,  100,   61,
       64,   65,   77,   69,   71,   63,   70,   66,   58,   52,

       68,   74,   78,  102,   72,   73,   58,   52,  442,   75,
       58,   52,   58,   52,   58,   52,   47,   76,   79,   58,
       52,   82,   58,   52,  147,   58,   52,   92,   98,   99,
       80,  100,   81,  148,   90,   58,   52,   83,   84,   85,
       86,   91,   58,   52,   87,  402,   89,   93,   93,  391,
       88,   94,   94,   52,   53,   53,   71,   95,   97,   96,
       52,   56,   56,   56,   58,   52,   72,   73,   52,  104,
      104,  104,   58,   52,  104,   58,   52,  440,  104,  104,
      104,  104,  104,  104,   58,   52,  105,   58,   52,   58,
       52,   58,   52,   58,   52,   58,   52,   58,   52,  438,

      109,   58,   52,  418,  106,  446,  108,   58,   52,  107,
      376,  113,   58,   52,  408,  110,  111,  112,  117,  431,
      115,   58,   52,  116,   58,   52,  114,  118,   58,   52,
       58,   52,   58,   52,  119,   58,   52,  120,   58,   52,
       58,   52,  430,  122,   58,   52,   58,   52,   58,   52,
      123,  124,  121,  127,   58,   52,  126,   58,   52,  402,
      128,  131,   92,  125,   58,   52,   58,   52,  129,  132,
       58,   52,  133,   58,   52,  130,   58,   52,   58,   52,
       58,   52,   93,   58,   52,  150,   94,  446,  135,  134,
       98,  139,   58,   52,  136,  151,  428,  144,   58,   52,

       58,   52,  138,  137,  391,  140,   58,   52,  344,  141,
       93,  142,  145,  446,   94,   58,   52,  152,   58,   52,
      143,  345,  146,   58,   52,   58,   52,  250,  153,   58,
       52,   58,   52,   58,   52,   58,   52,  251,  156,  424,
      154,   58,   52,   58,   52,   58,   52,  158,  163,  159,
      155,  423,  160,  388,  164,  157,   58,   52,  161,  162,
      166,   58,   52,   58,   52,  169,  389,  165,   58,   52,
       58,   52,  421,  167,   58,   52,   58,   52,   58,   52,
       58,   52,   58,   52,  376,  168,   58,   52,  170,  171,
      349,  174,  172,   58,   52,  173,  178,   58,   52,   58,

       52,  179,   58,   52,  175,  177,   58,   52,  176,   58,
       52,   58,   52,   58,   52,  335,  181,  360,  180,  373,
      182,  361,  183,   58,   52,  406,  186,   58,   52,  405,
      187,  397,  184,   58,   52,   58,   52,  396,  185,   58,
       52,  386,  189,   58,   52,   58,   52,   58,   52,  385,
      188,  383,   58,   52,   58,   52,  373,  192,  313,  193,
      194,  314,  190,  191,   58,   52,  195,  196,  197,   58,
       52,   58,   52,   58,   52,   58,   52,  203,  349,   58,
       52,   58,   52,   58,   52,  205,   58,   52,   58,   52,
      204,   58,   52,   58,   52,   58,   52,  206,  207,  346,

      208,  371,  213,   58,   52,  209,  218,   52,  216,  370,
      211,  210,   58,   52,  212,  215,   58,   52,  366,  214,
       58,   52,   58,   52,   58,   52,   58,   52,   58,   52,
      365,  217,   58,   52,   58,   52,  399,   58,   52,  359,
      219,   58,   52,   58,   52,  220,  222,  224,  227,  400,
      221,   58,   52,  225,   58,   52,  358,  226,  356,  223,
       58,   52,  228,  353,  231,  346,   58,   52,  229,   58,
       52,  230,   58,   52,   58,   52,  232,  234,   58,   52,
       58,   52,   58,   52,  324,  233,  236,  291,  235,   58,
       52,  237,   58,   52,  415,  239,   58,   52,   58,   52,

       58,   52,  238,  244,  245,  341,  246,  416,   58,   52,
       58,   52,   58,   52,  242,  241,  340,  240,   58,   52,
      244,  245,  334,  246,  243,  388,  247,  333,  248,   58,
       52,   58,   52,  249,   58,   52,   58,   52,  389,   58,
       52,   58,   52,   58,   52,   58,   52,  255,   58,   52,
       58,   52,   58,   52,  260,   58,   52,  324,  259,  326,
      256,  258,  325,  261,   58,   52,  257,  264,   58,   52,
       58,   52,   58,   52,  293,  265,   58,   52,  291,  262,
       58,   52,  263,  266,   58,   52,   58,   52,   58,   52,
       58,   52,   58,   52,  268,   58,   52,  245,   58,   52,

      269,  270,   58,   52,  275,   52,   58,   52,   58,   52,
       58,   52,  271,  274,   58,   52,   58,   52,  272,   58,
       52,  306,  273,  277,   58,   52,   58,   52,   58,   52,
      297,  279,   58,   52,  278,  276,   58,   52,  293,   58,
       52,  283,  296,  284,  281,  293,   58,   52,  295,  280,
       58,   52,  245,  282,  287,  244,  245,  267,  246,  285,
      288,  286,  290,  291,  254,  292,  253,   58,   52,   58,
       52,  290,  291,  252,  292,   58,   52,   58,   52,   58,
       52,   58,   52,   58,   52,  294,   58,   52,   58,   52,
       58,   52,  202,  299,   58,   52,  300,   58,   52,  201,

       58,   52,  200,  301,  298,  302,  305,   52,   58,   52,
       58,   52,   58,   52,   58,   52,   58,   52,   58,   52,
      199,   58,   52,  307,   58,   52,  198,  303,  304,  309,
       58,   52,   58,   52,   58,   52,   58,   52,  149,  308,
      318,   52,   58,   52,  101,  310,   52,  311,  312,  317,
       58,   52,   58,   52,   58,   52,   58,   52,  399,  315,
      316,   58,   52,   58,   52,  290,  291,  324,  292,   58,
       52,  400,   58,   52,   58,   52,  103,  320,  321,  446,
      319,  329,   52,   43,  327,   58,   52,   58,   52,  328,
       58,   52,   58,   52,  335,  101,   58,   52,   57,   58,

       52,   58,   52,   50,  331,   58,   52,   58,   52,   49,
      330,   58,   52,   58,   52,   58,   52,  343,   58,   52,
      332,  336,   58,   52,  337,  346,  338,   44,  342,  415,
       58,   52,   58,   52,  348,  349,   43,  350,  355,  339,
       58,   52,  416,   58,   52,   58,   52,  446,  347,   58,
       52,   58,   52,   58,   52,   39,  354,   58,   52,   58,
       52,   58,   52,   58,   52,  343,  446,  367,   58,   52,
      373,  368,   58,   52,  357,   58,   52,  348,  349,  355,
      350,  380,  363,  348,  349,  381,  350,  379,  364,  375,
      376,  395,  377,   58,   52,  390,  391,  446,  392,  446,

       58,   52,  446,  361,  446,  401,  402,  384,  403,  446,
      446,  446,  446,  407,  408,  368,  409,  375,  376,  446,
      377,  446,  375,  376,  394,  377,   58,   52,  417,  418,
      446,  419,  446,   58,   52,  446,  381,  390,  391,  446,
      392,  390,  391,  446,  392,  446,  390,  391,  422,  392,
       58,   52,   58,   52,  401,  402,  446,  403,  446,  413,
      401,  402,  446,  403,  401,  402,  446,  403,  407,  408,
      446,  409,  407,  408,  446,  409,  446,  427,  426,  433,
      434,  446,  435,   58,   52,  417,  418,  446,  419,  417,
      418,  446,  419,  417,  418,  446,  419,   58,   52,   58,

       52,   58,   52,  433,  434,  446,  435,  433,  434,  446,
      435,   58,   52,   58,   52,   58,   52,  446,  446,  446,
      446,  446,  446,  446,  446,  441,  446,  446,  439,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  444,   38,   38,   38,   38,   38,   38,   38,   38,
       38,   45,   45,   45,   45,   45,   45,   45,   45,   45,
       48,   48,  446,   48,   48,   48,   48,   48,   48,   51,
       51,   51,   51,   54,   54,   54,   59,   59,   59,   59,
       58,  446,   58,   58,  289,  289,  289,  289,  289,  289,
      289,  289,  289,  322,  322,  322,  322,  322,  322,  322,

      322,  322,  323,  446,  446,  446,  446,  446,  446,  323,
      351,  351,  446,  351,  351,  446,  351,  351,  352,  446,
      446,  446,  446,  446,  446,  352,  362,  446,  362,  446,
      446,  362,  362,  362,  369,  446,  369,  446,  446,  369,
      369,  369,  372,  446,  446,  446,  446,  446,  446,  372,
      374,  374,  374,  374,  374,  374,  374,  374,  374,  378,
      378,  446,  378,  378,  446,  378,  378,  382,  446,  382,
      446,  446,  382,  382,  382,  387,  387,  387,  387,  387,
      387,  387,  387,  387,  393,  393,  446,  393,  393,  393,
      393,  393,  398,  398,  398,  398,  398,  398,  398,  398,

      398,  404,  404,  446,  404,  404,  404,  404,  404,  410,
      410,  446,  410,  410,  446,  410,  410,  411,  446,  446,
      446,  446,  446,  446,  411,  412,  412,  412,  412,  412,
      412,  412,  412,  412,  414,  414,  414,  414,  414,  414,
      414,  414,  414,  420,  420,  446,  420,  420,  420,  420,
      420,  425,  425,  425,  425,  425,  425,  425,  425,  425,
      429,  429,  429,  429,  429,  429,  429,  429,  429,  432,
      432,  432,  432,  432,  432,  432,  432,  432,  436,  436,
      446,  436,  436,  446,  436,  436,  437,  437,  437,  437,
      437,  437,  437,  437,  437,  443,  443,  443,  443,  443,

      443,  443,  443,  443,    5,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446
    } ;

static const flex_int16_t yy_chk[1449] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    2,    4,    4,    9,   14,   14,   14,
       15,   15,   15,   15,  443,   14,   17,   17,  442,    9,
       18,   18,  437,    2,    4,   19,   19,    2,    4,  435,
       21,   21,   20,   20,   22,   22,  432,   26,   26,   14,
       23,   23,   24,   24,   18,   21,   41,   19,   41,   18,
       20,   20,   26,   22,   23,   19,   22,   20,   25,   25,

       21,   24,   26,   45,   23,   23,   27,   27,  430,   25,
       28,   28,   31,   31,   29,   29,   45,   25,   27,   32,
       32,   28,   33,   33,   99,   30,   30,   35,   40,   93,
       27,   93,   27,   99,   32,   36,   36,   28,   28,   29,
       30,   33,   37,   37,   30,  429,   31,   35,   40,  425,
       30,   35,   40,   53,   53,   53,   37,   36,   37,   36,
       56,   56,   56,   56,   59,   59,   37,   37,   55,   55,
       55,   55,   60,   60,   55,   61,   61,  423,   55,   55,
       55,   55,   55,   55,   62,   62,   60,   63,   63,   64,
       64,   65,   65,   66,   66,   67,   67,   68,   68,  421,

       64,   69,   69,  419,   61,  416,   63,   70,   70,   62,
      412,   67,   71,   71,  409,   65,   66,   66,   70,  406,
       68,   72,   72,   69,   73,   73,   67,   71,   74,   74,
       75,   75,   76,   76,   72,   78,   78,   73,   77,   77,
       79,   79,  405,   75,   80,   80,   81,   81,   82,   82,
       75,   75,   74,   77,   83,   83,   76,   84,   84,  403,
       79,   82,   92,   75,   85,   85,   86,   86,   79,   83,
       87,   87,   84,   88,   88,   81,   89,   89,   90,   90,
       91,   91,   92,   96,   96,  101,   92,  400,   86,   85,
       98,   90,   95,   95,   87,  101,  396,   96,   97,   97,

      105,  105,   89,   88,  392,   90,  106,  106,  318,   91,
       98,   95,   97,  389,   98,  107,  107,  106,  108,  108,
       95,  318,   97,  109,  109,  110,  110,  198,  107,  111,
      111,  112,  112,  113,  113,  114,  114,  198,  110,  386,
      108,  115,  115,  119,  119,  116,  116,  112,  114,  113,
      109,  385,  113,  360,  114,  111,  117,  117,  113,  113,
      116,  118,  118,  120,  120,  119,  360,  115,  121,  121,
      123,  123,  383,  117,  122,  122,  124,  124,  125,  125,
      126,  126,  127,  127,  377,  118,  128,  128,  120,  121,
      374,  124,  122,  129,  129,  123,  127,  130,  130,  131,

      131,  128,  133,  133,  125,  126,  132,  132,  125,  134,
      134,  135,  135,  136,  136,  335,  130,  335,  129,  373,
      131,  335,  132,  137,  137,  371,  135,  138,  138,  370,
      136,  366,  133,  139,  139,  140,  140,  365,  134,  141,
      141,  359,  138,  142,  142,  143,  143,  144,  144,  358,
      137,  356,  145,  145,  146,  146,  353,  141,  275,  142,
      143,  275,  139,  140,  152,  152,  144,  145,  146,  153,
      153,  154,  154,  155,  155,  156,  156,  152,  350,  157,
      157,  158,  158,  159,  159,  154,  160,  160,  161,  161,
      153,  162,  162,  163,  163,  164,  164,  156,  157,  346,

      158,  345,  162,  165,  165,  159,  166,  166,  164,  344,
      160,  159,  167,  167,  161,  163,  168,  168,  341,  162,
      169,  169,  170,  170,  171,  171,  173,  173,  172,  172,
      340,  165,  174,  174,  176,  176,  367,  175,  175,  334,
      167,  177,  177,  178,  178,  168,  170,  172,  175,  367,
      169,  179,  179,  173,  180,  180,  333,  174,  329,  171,
      181,  181,  176,  326,  179,  325,  182,  182,  177,  183,
      183,  178,  184,  184,  185,  185,  180,  182,  186,  186,
      187,  187,  188,  188,  324,  181,  184,  322,  183,  189,
      189,  186,  190,  190,  380,  188,  191,  191,  192,  192,

      193,  193,  187,  194,  194,  314,  194,  380,  194,  194,
      195,  195,  196,  196,  193,  191,  313,  190,  197,  197,
      199,  199,  306,  199,  193,  387,  195,  305,  196,  203,
      203,  204,  204,  197,  205,  205,  206,  206,  387,  207,
      207,  208,  208,  209,  209,  210,  210,  203,  211,  211,
      212,  212,  214,  214,  209,  213,  213,  297,  208,  296,
      205,  207,  295,  211,  215,  215,  206,  214,  216,  216,
      217,  217,  219,  219,  293,  215,  220,  220,  292,  212,
      221,  221,  213,  216,  222,  222,  223,  223,  224,  224,
      225,  225,  226,  226,  221,  227,  227,  289,  228,  228,

      222,  223,  229,  229,  230,  230,  231,  231,  232,  232,
      233,  233,  224,  228,  234,  234,  235,  235,  226,  236,
      236,  267,  227,  232,  237,  237,  238,  238,  239,  239,
      254,  234,  240,  240,  233,  231,  241,  241,  253,  242,
      242,  238,  251,  239,  236,  248,  243,  243,  250,  235,
      248,  248,  246,  237,  242,  244,  244,  218,  244,  240,
      243,  241,  247,  247,  202,  247,  201,  247,  247,  249,
      249,  252,  252,  200,  252,  255,  255,  256,  256,  257,
      257,  258,  258,  259,  259,  249,  260,  260,  261,  261,
      262,  262,  151,  257,  263,  263,  258,  264,  264,  150,

      265,  265,  149,  260,  256,  263,  266,  266,  268,  268,
      269,  269,  270,  270,  271,  271,  272,  272,  273,  273,
      148,  274,  274,  268,  276,  276,  147,  264,  265,  271,
      277,  277,  278,  278,  279,  279,  280,  280,  100,  270,
      281,  281,  282,  282,   94,  272,   54,  273,  274,  279,
      283,  283,  284,  284,  285,  285,  286,  286,  398,  277,
      278,  287,  287,  288,  288,  290,  290,  294,  290,  298,
      298,  398,  294,  294,  299,  299,   50,  287,  288,   47,
      286,  300,  300,   43,  298,  301,  301,  302,  302,  299,
      303,  303,  304,  304,  307,   42,  308,  308,   16,  307,

      307,  309,  309,   12,  303,  310,  310,  311,  311,   11,
      302,  312,  312,  315,  315,  316,  316,  317,  319,  319,
      304,  308,  317,  317,  310,  320,  311,    8,  315,  414,
      320,  320,  321,  321,  323,  323,    7,  323,  328,  312,
      327,  327,  414,  328,  328,  330,  330,    5,  321,  331,
      331,  332,  332,  336,  336,    3,  327,  337,  337,  338,
      338,  339,  339,  342,  342,  343,    0,  343,  354,  354,
      347,  343,  364,  364,  331,  347,  347,  348,  348,  355,
      348,  355,  337,  351,  351,  355,  351,  354,  338,  352,
      352,  364,  352,  357,  357,  361,  361,  362,  361,  362,

      363,  363,    0,  362,    0,  368,  368,  357,  368,  369,
        0,  369,    0,  372,  372,  369,  372,  375,  375,    0,
      375,    0,  378,  378,  363,  378,  379,  379,  381,  381,
      382,  381,  382,  384,  384,    0,  382,  388,  388,    0,
      388,  390,  390,    0,  390,    0,  393,  393,  384,  393,
      394,  394,  395,  395,  399,  399,    0,  399,    0,  379,
      401,  401,    0,  401,  404,  404,    0,  404,  407,  407,
        0,  407,  410,  410,    0,  410,    0,  395,  394,  411,
      411,    0,  411,  413,  413,  415,  415,    0,  415,  417,
      417,    0,  417,  420,  420,    0,  420,  422,  422,  426,

      426,  427,  427,  433,  433,    0,  433,  436,  436,    0,
      436,  439,  439,  441,  441,  444,  444,    0,    0,    0,
        0,    0,    0,    0,    0,  427,    0,    0,  422,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,  441,  447,  447,  447,  447,  447,  447,  447,  447,
      447,  448,  448,  448,  448,  448,  448,  448,  448,  448,
      449,  449,    0,  449,  449,  449,  449,  449,  449,  450,
      450,  450,  450,  451,  451,  451,  452,  452,  452,  452,
      453,    0,  453,  453,  454,  454,  454,  454,  454,  454,
      454,  454,  454,  455,  455,  455,  455,  455,  455,  455,

      455,  455,  456,    0,    0,    0,    0,    0,    0,  456,
      457,  457,    0,  457,  457,    0,  457,  457,  458,    0,
        0,    0,    0,    0,    0,  458,  459,    0,  459,    0,
        0,  459,  459,  459,  460,    0,  460,    0,    0,  460,
      460,  460,  461,    0,    0,    0,    0,    0,    0,  461,
      462,  462,  462,  462,  462,  462,  462,  462,  462,  463,
      463,    0,  463,  463,    0,  463,  463,  464,    0,  464,
        0,    0,  464,  464,  464,  465,  465,  465,  465,  465,
      465,  465,  465,  465,  466,  466,    0,  466,  466,  466,
      466,  466,  467,  467,  467,  467,  467,  467,  467,  467,

      467,  468,  468,    0,  468,  468,  468,  468,  468,  469,
      469,    0,  469,  469,    0,  469,  469,  470,    0,    0,
        0,    0,    0,    0,  470,  471,  471,  471,  471,  471,
      471,  471,  471,  471,  472,  472,  472,  472,  472,  472,
      472,  472,  472,  473,  473,    0,  473,  473,  473,  473,
      473,  474,  474,  474,  474,  474,  474,  474,  474,  474,
      475,  475,  475,  475,  475,  475,  475,  475,  475,  476,
      476,  476,  476,  476,  476,  476,  476,  476,  477,  477,
        0,  477,  477,    0,  477,  477,  478,  478,  478,  478,
      478,  478,  478,  478,  478,  479,  479,  479,  479,  479,

      479,  479,  479,  479,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446,  446,  446,
      446,  446,  446,  446,  446,  446,  446,  446
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

extern int yy_flex_debug;
int yy_flex_debug = 0;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
#define yymore() yymore_used_but_not_detected
#define YY_MORE_ADJ 0
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#line 1 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
#line 2 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
/*	$NetBSD: scan.l,v 1.34 2021/09/10 21:52:17 rillig Exp $	*/

/*
 * Copyright (c) 1992, 1993
 *	The Regents of the University of California.  All rights reserved.
 *
 * This software was developed by the Computer Systems Engineering group
 * at Lawrence Berkeley Laboratory under DARPA contract BG 91-66 and
 * contributed to Berkeley.
 *
 * All advertising materials mentioning features or use of this software
 * must display the following acknowledgement:
 *	This product includes software developed by the University of
 *	California, Lawrence Berkeley Laboratories.
 *
 * Redistribution and use in source and binary forms, with or without
 * modification, are permitted provided that the following conditions
 * are met:
 * 1. Redistributions of source code must retain the above copyright
 *    notice, this list of conditions and the following disclaimer.
 * 2. Redistributions in binary form must reproduce the above copyright
 *    notice, this list of conditions and the following disclaimer in the
 *    documentation and/or other materials provided with the distribution.
 * 3. Neither the name of the University nor the names of its contributors
 *    may be used to endorse or promote products derived from this software
 *    without specific prior written permission.
 *
 * THIS SOFTWARE IS PROVIDED BY THE REGENTS AND CONTRIBUTORS ``AS IS'' AND
 * ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE
 * IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE
 * ARE DISCLAIMED.  IN NO EVENT SHALL THE REGENTS OR CONTRIBUTORS BE LIABLE
 * FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL
 * DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS
 * OR SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION)
 * HOWEVER CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT
 * LIABILITY, OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY
 * OUT OF THE USE OF THIS SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF
 * SUCH DAMAGE.
 *
 *	from: @(#)scan.l	8.1 (Berkeley) 6/6/93
 */

#include <sys/cdefs.h>
__RCSID("$NetBSD: scan.l,v 1.34 2021/09/10 21:52:17 rillig Exp $");

#include <sys/param.h>
#include <errno.h>
#include <libgen.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <stddef.h>
#include <ctype.h>
#include <util.h>
#undef ECHO
#include "defs.h"
#include "gram.h"

int	yyline;
const char *yyfile;
const char *lastfile;
char curinclpath[PATH_MAX];
uint64_t ifdefstate;
int	 ifdefshift = -1;

/*
 * The state is represented by 3 bits.
 */
#define	IDS_ENABLED	1ll
#define	IDS_MATCH	2ll
#define	IDS_ELIF	4ll
#define	IDS_ELSE	8ll

#define	IDS_BITS	0xf
#define	IDS_SHIFT	4

#define	IDS_ISMATCH(st) (((st) & IDS_MATCH) != 0)
#define	IDS_ISENABLED(st) (((st) & IDS_ENABLED) != 0)
#define	IDS_PARENT_DISABLED \
	(ifdefshift > 0 && !IDS_ISENABLED(ifdefstate >> IDS_SHIFT))
#define IDS_MAX_DEPTH	16 /* 64 / 4 */

#ifdef	IDS_DEBUG
# define IDS_PRINT(s, st, x) \
	do { \
		for (int i = 0; i < ifdefshift + 1; i++) \
			fprintf(stderr, " "); \
		printf("%s%s [%d,%d,%d] %#" PRIx64 "\n", x, # s, \
		    IDS_PARENT_DISABLED, IDS_ISMATCH(st), getcurifdef(), \
		    ifdefstate); \
	} while (0)
#else
# define IDS_PRINT(s, st, x) ((void)0)
#endif

#define	IDS_ENTER(s, st) \
	IDS_PRINT(s, st, ">")
#define	IDS_EXIT(s, st) \
	IDS_PRINT(s, st, "<")

/*
 * Data for returning to previous files from include files.
 */
struct incl {
	struct	incl *in_prev;	/* previous includes in effect, if any */
	YY_BUFFER_STATE in_buf;	/* previous lex state */
	struct where in_where;
	int	in_ateof;	/* token to insert at EOF */
	int	in_interesting;	/* previous value for "interesting" */
	uint64_t	in_ifdefstate;	/* conditional level */
	int	in_ifdefshift;	/* conditional level */
};
static struct incl *incl;
static int endinclude(void);
static int getincludepath(void);
static int getcurifdef(void);

SLIST_HEAD(, prefix)	curdirs;	/* curdir stack */

#line 1040 "scan.c"
#define YY_NO_INPUT 1

#line 1043 "scan.c"

#define INITIAL 0
#define IGNORED 1

#ifndef YY_NO_UNISTD_H
/* Special case for "unistd.h", since it is non-ANSI. We include it way
 * down here because we want the user's section 1 to have been scanned first.
 * The user has a chance to override it with an option.
 */
#include <unistd.h>
#endif

#ifndef YY_EXTRA_TYPE
#define YY_EXTRA_TYPE void *
#endif

static int yy_init_globals ( void );

/* Accessor methods to globals.
   These are made visible to non-reentrant scanners for convenience. */

int yylex_destroy ( void );

int yyget_debug ( void );

void yyset_debug ( int debug_flag  );

YY_EXTRA_TYPE yyget_extra ( void );

void yyset_extra ( YY_EXTRA_TYPE user_defined  );

FILE *yyget_in ( void );

void yyset_in  ( FILE * _in_str  );

FILE *yyget_out ( void );

void yyset_out  ( FILE * _out_str  );

			yy_size_t yyget_leng ( void );

char *yyget_text ( void );

int yyget_lineno ( void );

void yyset_lineno ( int _line_number  );

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap ( void );
#else
extern int yywrap ( void );
#endif
#endif

#ifndef YY_NO_UNPUT
    
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy ( char *, const char *, int );
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen ( const char * );
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int yyinput ( void );
#else
static int input ( void );
#endif

#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#ifdef __ia64__
/* On IA-64, the buffer size is 16k, not 8k */
#define YY_READ_BUF_SIZE 16384
#else
#define YY_READ_BUF_SIZE 8192
#endif /* __ia64__ */
#endif

/* Copy whatever the last rule matched to the standard output. */
#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO do { if (fwrite( yytext, (size_t) yyleng, 1, yyout )) {} } while (0)
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( YY_CURRENT_BUFFER_LVALUE->yy_is_interactive ) \
		{ \
		int c = '*'; \
		yy_size_t n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else \
		{ \
		errno=0; \
		while ( (result = fread(buf, 1, (yy_size_t) max_size, yyin)) == 0 && ferror(yyin)) \
			{ \
			if( errno != EINTR) \
				{ \
				YY_FATAL_ERROR( "input in flex scanner failed" ); \
				break; \
				} \
			errno=0; \
			clearerr(yyin); \
			} \
		}\
\

#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif

/* end tables serialization structures and prototypes */

/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL_IS_OURS 1

extern int yylex (void);

#define YY_DECL int yylex (void)
#endif /* !YY_DECL */

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK /*LINTED*/break;
#endif

#define YY_RULE_SETUP \
	if ( yyleng > 0 ) \
		YY_CURRENT_BUFFER_LVALUE->yy_at_bol = \
				(yytext[yyleng - 1] == '\n'); \
	YY_USER_ACTION

/** The main scanner function which does all the work.
 */
YY_DECL
{
	yy_state_type yy_current_state;
	char *yy_cp, *yy_bp;
	int yy_act;
    
	if ( !(yy_init) )
		{
		(yy_init) = 1;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! (yy_start) )
			(yy_start) = 1;	/* first start state */

		if ( ! yyin )
			yyin = stdin;

		if ( ! yyout )
			yyout = stdout;

		if ( ! YY_CURRENT_BUFFER ) {
			yyensure_buffer_stack ();
			YY_CURRENT_BUFFER_LVALUE =
				yy_create_buffer( yyin, YY_BUF_SIZE );
		}

		yy_load_buffer_state(  );
		}

	{
#line 135 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"

#line 137 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
		/* Local variables for yylex() */
		int tok;

#line 1268 "scan.c"

	while ( /*CONSTCOND*/1 )		/* loops until end-of-file is reached */
		{
		yy_cp = (yy_c_buf_p);

		/* Support of yytext. */
		*yy_cp = (yy_hold_char);

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = (yy_start);
		yy_current_state += YY_AT_BOL();
yy_match:
		do
			{
			YY_CHAR yy_c = yy_ec[YY_SC_TO_UI(*yy_cp)] ;
			if ( yy_accept[yy_current_state] )
				{
				(yy_last_accepting_state) = yy_current_state;
				(yy_last_accepting_cpos) = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 447 )
					yy_c = yy_meta[yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 1405 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;

do_action:	/* This label is used only to access EOF actions. */

		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = (yy_hold_char);
			yy_cp = (yy_last_accepting_cpos);
			yy_current_state = (yy_last_accepting_state);
			goto yy_find_action;

case 1:
YY_RULE_SETUP
#line 140 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return AND;
	YY_BREAK
case 2:
YY_RULE_SETUP
#line 141 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return AT;
	YY_BREAK
case 3:
YY_RULE_SETUP
#line 142 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return ATTACH;
	YY_BREAK
case 4:
YY_RULE_SETUP
#line 143 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return BLOCK;
	YY_BREAK
case 5:
YY_RULE_SETUP
#line 144 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return BUILD;
	YY_BREAK
case 6:
YY_RULE_SETUP
#line 145 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return CHAR;
	YY_BREAK
case 7:
YY_RULE_SETUP
#line 146 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return COMPILE_WITH;
	YY_BREAK
case 8:
YY_RULE_SETUP
#line 147 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return CONFIG;
	YY_BREAK
case 9:
YY_RULE_SETUP
#line 148 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFFS;
	YY_BREAK
case 10:
YY_RULE_SETUP
#line 149 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFINE;
	YY_BREAK
case 11:
YY_RULE_SETUP
#line 150 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFFLAG;
	YY_BREAK
case 12:
YY_RULE_SETUP
#line 151 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFOPT;
	YY_BREAK
case 13:
YY_RULE_SETUP
#line 152 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFPARAM;
	YY_BREAK
case 14:
YY_RULE_SETUP
#line 153 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFPSEUDO;
	YY_BREAK
case 15:
YY_RULE_SETUP
#line 154 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEFPSEUDODEV;
	YY_BREAK
case 16:
YY_RULE_SETUP
#line 155 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEVCLASS;
	YY_BREAK
case 17:
YY_RULE_SETUP
#line 156 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEVICE;
	YY_BREAK
case 18:
YY_RULE_SETUP
#line 157 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DEVICE_MAJOR;
	YY_BREAK
case 19:
YY_RULE_SETUP
#line 158 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return DUMPS;
	YY_BREAK
case 20:
YY_RULE_SETUP
#line 159 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return XFILE;
	YY_BREAK
case 21:
YY_RULE_SETUP
#line 160 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return FILE_SYSTEM;
	YY_BREAK
case 22:
YY_RULE_SETUP
#line 161 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return FLAGS;
	YY_BREAK
case 23:
YY_RULE_SETUP
#line 162 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return IDENT;
	YY_BREAK
case 24:
YY_RULE_SETUP
#line 163 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return IOCONF;
	YY_BREAK
case 25:
YY_RULE_SETUP
#line 164 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return LINKZERO;
	YY_BREAK
case 26:
YY_RULE_SETUP
#line 165 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return XMACHINE;
	YY_BREAK
case 27:
YY_RULE_SETUP
#line 166 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return MAJOR;
	YY_BREAK
case 28:
YY_RULE_SETUP
#line 167 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return MAKEOPTIONS;
	YY_BREAK
case 29:
YY_RULE_SETUP
#line 168 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return MAXPARTITIONS;
	YY_BREAK
case 30:
YY_RULE_SETUP
#line 169 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return MAXUSERS;
	YY_BREAK
case 31:
YY_RULE_SETUP
#line 170 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return MINOR;
	YY_BREAK
case 32:
YY_RULE_SETUP
#line 171 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return NEEDS_COUNT;
	YY_BREAK
case 33:
YY_RULE_SETUP
#line 172 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return NEEDS_FLAG;
	YY_BREAK
case 34:
YY_RULE_SETUP
#line 173 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return NO;
	YY_BREAK
case 35:
YY_RULE_SETUP
#line 174 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return CNO;
	YY_BREAK
case 36:
YY_RULE_SETUP
#line 175 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return XOBJECT;
	YY_BREAK
case 37:
YY_RULE_SETUP
#line 176 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return OBSOLETE;
	YY_BREAK
case 38:
YY_RULE_SETUP
#line 177 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return ON;
	YY_BREAK
case 39:
YY_RULE_SETUP
#line 178 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return OPTIONS;
	YY_BREAK
case 40:
YY_RULE_SETUP
#line 179 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return PREFIX;
	YY_BREAK
case 41:
YY_RULE_SETUP
#line 180 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return BUILDPREFIX;
	YY_BREAK
case 42:
YY_RULE_SETUP
#line 181 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return PSEUDO_DEVICE;
	YY_BREAK
case 43:
YY_RULE_SETUP
#line 182 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return PSEUDO_ROOT;
	YY_BREAK
case 44:
YY_RULE_SETUP
#line 183 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return ROOT;
	YY_BREAK
case 45:
YY_RULE_SETUP
#line 184 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return SELECT;
	YY_BREAK
case 46:
YY_RULE_SETUP
#line 185 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return SINGLE;
	YY_BREAK
case 47:
YY_RULE_SETUP
#line 186 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return SOURCE;
	YY_BREAK
case 48:
YY_RULE_SETUP
#line 187 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return TYPE;
	YY_BREAK
case 49:
YY_RULE_SETUP
#line 188 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return VECTOR;
	YY_BREAK
case 50:
YY_RULE_SETUP
#line 189 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return VERSION;
	YY_BREAK
case 51:
YY_RULE_SETUP
#line 190 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return WITH;
	YY_BREAK
case 52:
YY_RULE_SETUP
#line 192 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return PLUSEQ;
	YY_BREAK
case 53:
YY_RULE_SETUP
#line 193 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
return COLONEQ;
	YY_BREAK
case 54:
/* rule 54 can match eol */
YY_RULE_SETUP
#line 195 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		ifdefstate <<= IDS_SHIFT;
		if (++ifdefshift >= IDS_MAX_DEPTH) {
			yyerror("too many levels of conditional");
		}
		IDS_ENTER(ifdef, 0);
		if (IDS_PARENT_DISABLED || !getcurifdef()) {
			ifdefstate &= (uint64_t)~IDS_ENABLED;
			BEGIN(IGNORED);
		} else {
			ifdefstate |= IDS_MATCH|IDS_ENABLED;
			BEGIN(INITIAL);
		}
		IDS_EXIT(ifdef, 0);
		yyline++;
	}
	YY_BREAK
case 55:
/* rule 55 can match eol */
YY_RULE_SETUP
#line 212 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		ifdefstate <<= IDS_SHIFT;
		if (++ifdefshift >= IDS_MAX_DEPTH) {
			yyerror("too many levels of conditional");
		}
		IDS_ENTER(ifndef, 0);
		if (IDS_PARENT_DISABLED || getcurifdef()) {
			ifdefstate &= (uint64_t)~IDS_ENABLED;
			BEGIN(IGNORED);
		} else {
			ifdefstate |= IDS_MATCH|IDS_ENABLED;
			BEGIN(INITIAL);
		}
		IDS_EXIT(ifndef, 0);
		yyline++;
	}
	YY_BREAK
case 56:
/* rule 56 can match eol */
YY_RULE_SETUP
#line 230 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		int st = ifdefstate & IDS_BITS;
		IDS_ENTER(elifdef, st);
		if (ifdefshift == -1 || (st & IDS_ELSE) != 0) {
			yyerror("mismatched elifdef");
		}
		if (IDS_PARENT_DISABLED || IDS_ISMATCH(st) || !getcurifdef()) {
			ifdefstate &= (uint64_t)~IDS_ENABLED;
			BEGIN(IGNORED);
		} else {
			ifdefstate |= IDS_MATCH|IDS_ENABLED;
			BEGIN(INITIAL);
		}
		ifdefstate |= IDS_ELIF;
		IDS_EXIT(elifdef, st);
		yyline++;
	}
	YY_BREAK
case 57:
/* rule 57 can match eol */
YY_RULE_SETUP
#line 248 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		int st = ifdefstate & IDS_BITS;
		IDS_ENTER(elifndef, st);
		if (ifdefshift == -1 || (st & IDS_ELSE) != 0) {
			yyerror("mismatched elifndef");
		}
		if (IDS_PARENT_DISABLED || IDS_ISMATCH(st) || getcurifdef()) {
			ifdefstate &= (uint64_t)~IDS_ENABLED;
			BEGIN(IGNORED);
		} else {
			ifdefstate |= IDS_MATCH|IDS_ENABLED;
			BEGIN(INITIAL);
		}
		ifdefstate |= IDS_ELIF;
		IDS_EXIT(elifndef, st);
		yyline++;
	}
	YY_BREAK
case 58:
/* rule 58 can match eol */
YY_RULE_SETUP
#line 266 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		int st = ifdefstate & IDS_BITS;
		IDS_ENTER(else, st);
		if (ifdefshift == -1 || (st & IDS_ELSE) != 0) {
			yyerror("mismatched else");
		}
		if (IDS_PARENT_DISABLED || IDS_ISMATCH(st)) {
			ifdefstate &= (uint64_t)~IDS_ENABLED;
			BEGIN(IGNORED);
		} else {
			ifdefstate |= IDS_MATCH|IDS_ENABLED;
			BEGIN(INITIAL);
		}
		ifdefstate |= IDS_ELSE;
		IDS_ENTER(else, st);
		yyline++;
	}
	YY_BREAK
case 59:
/* rule 59 can match eol */
YY_RULE_SETUP
#line 284 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		IDS_ENTER(endif, 0);
		if (ifdefshift == -1) {
			yyerror("mismatched endif");
		}
		if (!IDS_PARENT_DISABLED) {
			BEGIN(INITIAL);
		}
		IDS_EXIT(endif, 0);
		ifdefshift--;
		ifdefstate >>= IDS_SHIFT;
		yyline++;
	}
	YY_BREAK
case 60:
/* rule 60 can match eol */
YY_RULE_SETUP
#line 298 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yyline++;
	}
	YY_BREAK
case 61:
YY_RULE_SETUP
#line 302 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
/* ignore */
	YY_BREAK
case 62:
/* rule 62 can match eol */
YY_RULE_SETUP
#line 304 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yyline++;
		if (getincludepath()) {
			include(curinclpath, 0, 0, 1);
		} else {
			yyerror("bad include path-name");
		}
	}
	YY_BREAK
case 63:
/* rule 63 can match eol */
YY_RULE_SETUP
#line 313 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yyline++;
		if (getincludepath()) {
			include(curinclpath, 0, 1, 1);
		} else {
			yyerror("bad cinclude path-name");
		}
	}
	YY_BREAK
case 64:
/* rule 64 can match eol */
YY_RULE_SETUP
#line 322 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yyline++;
		if (!oktopackage) {
			yyerror("package not allowed here");
		} else if (getincludepath()) {
			package(curinclpath);
		} else {
			yyerror("bad package path-name");
		}
	}
	YY_BREAK
case 65:
YY_RULE_SETUP
#line 333 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yylval.str = intern(yytext);
		return PATHNAME;
	}
	YY_BREAK
case 66:
YY_RULE_SETUP
#line 338 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yylval.str = intern(yytext);
		return WORD;
	}
	YY_BREAK
case 67:
YY_RULE_SETUP
#line 343 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yylval.str = intern("");
		return EMPTYSTRING;
	}
	YY_BREAK
case 68:
/* rule 68 can match eol */
YY_RULE_SETUP
#line 348 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		size_t l = strlen(yytext);
		if (l > 1 && yytext[l - 1] == '"')
			yytext[l - 1] = '\0';

		yylval.str = intern(yytext + 1);
		return QSTRING;
	}
	YY_BREAK
case 69:
YY_RULE_SETUP
#line 356 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yylval.num.fmt = 8;
		yylval.num.val = strtoll(yytext, NULL, 8);
		return NUMBER;
	}
	YY_BREAK
case 70:
YY_RULE_SETUP
#line 361 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yylval.num.fmt = 16;
		yylval.num.val = (long long)strtoull(yytext + 2, NULL, 16);
		return NUMBER;
	}
	YY_BREAK
case 71:
YY_RULE_SETUP
#line 366 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yylval.num.fmt = 10;
		yylval.num.val = strtoll(yytext, NULL, 10);
		return NUMBER;
	}
	YY_BREAK
case 72:
/* rule 72 can match eol */
YY_RULE_SETUP
#line 371 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		/*
		 * Note: newline followed by whitespace is always a
		 * continuation of the previous line, so do NOT
		 * return a token in this case.
		 */
		yyline++;
	}
	YY_BREAK
case 73:
/* rule 73 can match eol */
YY_RULE_SETUP
#line 379 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		yyline++;
		return '\n';
	}
	YY_BREAK
case 74:
YY_RULE_SETUP
#line 383 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		/* Detect NUL characters in the config file and
		 * error out.
		 */
		cfgerror("NUL character detected at line %i", yyline);
	}
	YY_BREAK
case 75:
YY_RULE_SETUP
#line 389 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{ /* ignored (comment) */; }
	YY_BREAK
case 76:
YY_RULE_SETUP
#line 390 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{ /* ignored (white space) */; }
	YY_BREAK
case 77:
YY_RULE_SETUP
#line 391 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{ return yytext[0]; }
	YY_BREAK
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(IGNORED):
#line 392 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
{
		if (ifdefshift > (incl == NULL ? -1 : incl->in_ifdefshift)) {
			yyerror("reached EOF while looking for endif");
		}
		if (incl == NULL)
			return YY_NULL;
		tok = endinclude();
		if (tok)
			return tok;
		/* otherwise continue scanning */
	}
	YY_BREAK
case 78:
YY_RULE_SETUP
#line 404 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"
ECHO;
	YY_BREAK
#line 1902 "scan.c"

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - (yytext_ptr)) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = (yy_hold_char);
		YY_RESTORE_YY_MORE_OFFSET

		if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between YY_CURRENT_BUFFER and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
			YY_CURRENT_BUFFER_LVALUE->yy_input_file = yyin;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( (yy_c_buf_p) <= &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			(yy_c_buf_p) = (yytext_ptr) + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state(  );

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state );

			yy_bp = (yytext_ptr) + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++(yy_c_buf_p);
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = (yy_c_buf_p);
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer(  ) )
			{
			case EOB_ACT_END_OF_FILE:
				{
				(yy_did_buffer_switch_on_eof) = 0;

				if ( yywrap(  ) )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					(yy_c_buf_p) = (yytext_ptr) + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				(yy_c_buf_p) =
					(yytext_ptr) + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				(yy_c_buf_p) =
				&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)];

				yy_current_state = yy_get_previous_state(  );

				yy_cp = (yy_c_buf_p);
				yy_bp = (yytext_ptr) + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of user's declarations */
} /* end of yylex */

/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */
static int yy_get_next_buffer (void)
{
    	char *dest = YY_CURRENT_BUFFER_LVALUE->yy_ch_buf;
	char *source = (yytext_ptr);
	yy_size_t number_to_move, i;
	int ret_val;

	if ( (yy_c_buf_p) > &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( YY_CURRENT_BUFFER_LVALUE->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( (yy_c_buf_p) - (yytext_ptr) - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (yy_size_t) ((yy_c_buf_p) - (yytext_ptr) - 1);

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( YY_CURRENT_BUFFER_LVALUE->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars) = 0;

	else
		{
			yy_size_t num_to_read =
			YY_CURRENT_BUFFER_LVALUE->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = YY_CURRENT_BUFFER_LVALUE;

			int yy_c_buf_p_offset =
				(int) ((yy_c_buf_p) - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				yy_size_t new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yyrealloc( (void *) b->yy_ch_buf,
							 (yy_size_t) (b->yy_buf_size + 2)  );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = NULL;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			(yy_c_buf_p) = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = YY_CURRENT_BUFFER_LVALUE->yy_buf_size -
						number_to_move - 1;

			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[number_to_move]),
			(yy_n_chars), num_to_read );

		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	if ( (yy_n_chars) == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( yyin  );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			YY_CURRENT_BUFFER_LVALUE->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	if (((yy_n_chars) + number_to_move) > YY_CURRENT_BUFFER_LVALUE->yy_buf_size) {
		/* Extend the array by 50%, plus the number we really need. */
		yy_size_t new_size = (yy_n_chars) + number_to_move + ((yy_n_chars) >> 1);
		YY_CURRENT_BUFFER_LVALUE->yy_ch_buf = (char *) yyrealloc(
			(void *) YY_CURRENT_BUFFER_LVALUE->yy_ch_buf, (yy_size_t) new_size  );
		if ( ! YY_CURRENT_BUFFER_LVALUE->yy_ch_buf )
			YY_FATAL_ERROR( "out of dynamic memory in yy_get_next_buffer()" );
		/* "- 2" to take care of EOB's */
		YY_CURRENT_BUFFER_LVALUE->yy_buf_size = (yy_size_t) (new_size - 2);
	}

	(yy_n_chars) += number_to_move;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars) + 1] = YY_END_OF_BUFFER_CHAR;

	(yytext_ptr) = &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[0];

	return ret_val;
}

/* yy_get_previous_state - get the state just before the EOB char was reached */

    static yy_state_type yy_get_previous_state (void)
{
	yy_state_type yy_current_state;
	char *yy_cp;
    
	yy_current_state = (yy_start);
	yy_current_state += YY_AT_BOL();

	for ( yy_cp = (yytext_ptr) + YY_MORE_ADJ; yy_cp < (yy_c_buf_p); ++yy_cp )
		{
		YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 43);
		if ( yy_accept[yy_current_state] )
			{
			(yy_last_accepting_state) = yy_current_state;
			(yy_last_accepting_cpos) = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 447 )
				yy_c = yy_meta[yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
		}

	return yy_current_state;
}

/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */
    static yy_state_type yy_try_NUL_trans  (yy_state_type yy_current_state )
{
	int yy_is_jam;
    	char *yy_cp = (yy_c_buf_p);

	YY_CHAR yy_c = 43;
	if ( yy_accept[yy_current_state] )
		{
		(yy_last_accepting_state) = yy_current_state;
		(yy_last_accepting_cpos) = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 447 )
			yy_c = yy_meta[yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + yy_c];
	yy_is_jam = (yy_current_state == 446);

	return yy_is_jam ? 0 : yy_current_state;
}

#ifndef YY_NO_UNPUT

#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
    static int yyinput (void)
#else
    static int input  (void)
#endif

{
	int c;
    
	*(yy_c_buf_p) = (yy_hold_char);

	if ( *(yy_c_buf_p) == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( (yy_c_buf_p) < &YY_CURRENT_BUFFER_LVALUE->yy_ch_buf[(yy_n_chars)] )
			/* This was really a NUL. */
			*(yy_c_buf_p) = '\0';

		else
			{ /* need more input */
			yy_size_t offset = (int) ((yy_c_buf_p) - (yytext_ptr));
			++(yy_c_buf_p);

			switch ( yy_get_next_buffer(  ) )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( yyin );

					/*FALLTHROUGH*/

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap(  ) )
						return 0;

					if ( ! (yy_did_buffer_switch_on_eof) )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput();
#else
					return input();
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					(yy_c_buf_p) = (yytext_ptr) + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) (yy_c_buf_p);	/* cast for 8-bit char's */
	*(yy_c_buf_p) = '\0';	/* preserve yytext */
	(yy_hold_char) = *++(yy_c_buf_p);

	YY_CURRENT_BUFFER_LVALUE->yy_at_bol = (c == '\n');

	return c;
}
#endif	/* ifndef YY_NO_INPUT */

/** Immediately switch to a different input stream.
 * @param input_file A readable stream.
 * 
 * @note This function does not reset the start condition to @c INITIAL .
 */
    void yyrestart  (FILE * input_file )
{
    
	if ( ! YY_CURRENT_BUFFER ){
        yyensure_buffer_stack ();
		YY_CURRENT_BUFFER_LVALUE =
            yy_create_buffer( yyin, YY_BUF_SIZE );
	}

	yy_init_buffer( YY_CURRENT_BUFFER, input_file );
	yy_load_buffer_state(  );
}

/** Switch to a different input buffer.
 * @param new_buffer The new input buffer.
 * 
 */
    void yy_switch_to_buffer  (YY_BUFFER_STATE  new_buffer )
{
    
	/* TODO. We should be able to replace this entire function body
	 * with
	 *		yypop_buffer_state();
	 *		yypush_buffer_state(new_buffer);
     */
	yyensure_buffer_stack ();
	if ( YY_CURRENT_BUFFER == new_buffer )
		return;

	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	YY_CURRENT_BUFFER_LVALUE = new_buffer;
	yy_load_buffer_state(  );

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	(yy_did_buffer_switch_on_eof) = 1;
}

static void yy_load_buffer_state  (void)
{
    	(yy_n_chars) = YY_CURRENT_BUFFER_LVALUE->yy_n_chars;
	(yytext_ptr) = (yy_c_buf_p) = YY_CURRENT_BUFFER_LVALUE->yy_buf_pos;
	yyin = YY_CURRENT_BUFFER_LVALUE->yy_input_file;
	(yy_hold_char) = *(yy_c_buf_p);
}

/** Allocate and initialize an input buffer state.
 * @param file A readable stream.
 * @param size The character buffer size in bytes. When in doubt, use @c YY_BUF_SIZE.
 * 
 * @return the allocated buffer state.
 */
    YY_BUFFER_STATE yy_create_buffer  (FILE * file, yy_size_t  size )
{
	YY_BUFFER_STATE b;
    
	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yyalloc( (yy_size_t) (b->yy_buf_size + 2)  );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file );

	return b;
}

/** Destroy the buffer.
 * @param b a buffer created with yy_create_buffer()
 * 
 */
    void yy_delete_buffer (YY_BUFFER_STATE  b )
{
    
	if ( ! b )
		return;

	if ( b == YY_CURRENT_BUFFER ) /* Not sure if we should pop here. */
		YY_CURRENT_BUFFER_LVALUE = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yyfree( (void *) b->yy_ch_buf  );

	yyfree( (void *) b  );
}

/* Initializes or reinitializes a buffer.
 * This function is sometimes called more than once on the same buffer,
 * such as during a yyrestart() or at EOF.
 */
    static void yy_init_buffer  (YY_BUFFER_STATE  b, FILE * file )

{
	int oerrno = errno;
    
	yy_flush_buffer( b );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

    /* If b is the current buffer, then yy_init_buffer was _probably_
     * called from yyrestart() or through yy_get_next_buffer.
     * In that case, we don't want to reset the lineno or column.
     */
    if (b != YY_CURRENT_BUFFER){
        b->yy_bs_lineno = 1;
        b->yy_bs_column = 0;
    }

        b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
    
	errno = oerrno;
}

/** Discard all buffered characters. On the next scan, YY_INPUT will be called.
 * @param b the buffer state to be flushed, usually @c YY_CURRENT_BUFFER.
 * 
 */
    void yy_flush_buffer (YY_BUFFER_STATE  b )
{
    	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == YY_CURRENT_BUFFER )
		yy_load_buffer_state(  );
}

/** Pushes the new state onto the stack. The new state becomes
 *  the current state. This function will allocate the stack
 *  if necessary.
 *  @param new_buffer The new state.
 *  
 */
void yypush_buffer_state (YY_BUFFER_STATE new_buffer )
{
    	if (new_buffer == NULL)
		return;

	yyensure_buffer_stack();

	/* This block is copied from yy_switch_to_buffer. */
	if ( YY_CURRENT_BUFFER )
		{
		/* Flush out information for old buffer. */
		*(yy_c_buf_p) = (yy_hold_char);
		YY_CURRENT_BUFFER_LVALUE->yy_buf_pos = (yy_c_buf_p);
		YY_CURRENT_BUFFER_LVALUE->yy_n_chars = (yy_n_chars);
		}

	/* Only push if top exists. Otherwise, replace top. */
	if (YY_CURRENT_BUFFER)
		(yy_buffer_stack_top)++;
	YY_CURRENT_BUFFER_LVALUE = new_buffer;

	/* copied from yy_switch_to_buffer. */
	yy_load_buffer_state(  );
	(yy_did_buffer_switch_on_eof) = 1;
}

/** Removes and deletes the top of the stack, if present.
 *  The next element becomes the new top.
 *  
 */
void yypop_buffer_state (void)
{
    	if (!YY_CURRENT_BUFFER)
		return;

	yy_delete_buffer(YY_CURRENT_BUFFER );
	YY_CURRENT_BUFFER_LVALUE = NULL;
	if ((yy_buffer_stack_top) > 0)
		--(yy_buffer_stack_top);

	if (YY_CURRENT_BUFFER) {
		yy_load_buffer_state(  );
		(yy_did_buffer_switch_on_eof) = 1;
	}
}

/* Allocates the stack if it does not exist.
 *  Guarantees space for at least one push.
 */
static void yyensure_buffer_stack (void)
{
	yy_size_t num_to_alloc;
    
	if (!(yy_buffer_stack)) {

		/* First allocation is just for 2 elements, since we don't know if this
		 * scanner will even need a stack. We use 2 instead of 1 to avoid an
		 * immediate realloc on the next call.
         */
      num_to_alloc = 1; /* After all that talk, this was set to 1 anyways... */
		(yy_buffer_stack) = (struct yy_buffer_state**)yyalloc
								(num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		memset((yy_buffer_stack), 0, num_to_alloc * sizeof(struct yy_buffer_state*));

		(yy_buffer_stack_max) = num_to_alloc;
		(yy_buffer_stack_top) = 0;
		return;
	}

	if ((yy_buffer_stack_top) >= ((yy_buffer_stack_max)) - 1){

		/* Increase the buffer to prepare for a possible push. */
		yy_size_t grow_size = 8 /* arbitrary grow size */;

		num_to_alloc = (yy_buffer_stack_max) + grow_size;
		(yy_buffer_stack) = (struct yy_buffer_state**)yyrealloc
								((yy_buffer_stack),
								num_to_alloc * sizeof(struct yy_buffer_state*)
								);
		if ( ! (yy_buffer_stack) )
			YY_FATAL_ERROR( "out of dynamic memory in yyensure_buffer_stack()" );

		/* zero only the new slots.*/
		memset((yy_buffer_stack) + (yy_buffer_stack_max), 0, grow_size * sizeof(struct yy_buffer_state*));
		(yy_buffer_stack_max) = num_to_alloc;
	}
}

/** Setup the input buffer state to scan directly from a user-specified character buffer.
 * @param base the character buffer
 * @param size the size in bytes of the character buffer
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_buffer  (char * base, yy_size_t  size )
{
	YY_BUFFER_STATE b;
    
	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return NULL;

	b = (YY_BUFFER_STATE) yyalloc( sizeof( struct yy_buffer_state )  );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = (size - 2);	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = NULL;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_is_interactive = 0;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b  );

	return b;
}

/** Setup the input buffer state to scan a string. The next call to yylex() will
 * scan from a @e copy of @a str.
 * @param yystr a NUL-terminated string to scan
 * 
 * @return the newly allocated buffer state object.
 * @note If you want to scan bytes that may contain NUL values, then use
 *       yy_scan_bytes() instead.
 */
YY_BUFFER_STATE yy_scan_string (const char * yystr )
{
    
	return yy_scan_bytes( yystr, strlen(yystr) );
}

/** Setup the input buffer state to scan the given bytes. The next call to yylex() will
 * scan from a @e copy of @a bytes.
 * @param yybytes the byte buffer to scan
 * @param _yybytes_len the number of bytes in the buffer pointed to by @a bytes.
 * 
 * @return the newly allocated buffer state object.
 */
YY_BUFFER_STATE yy_scan_bytes  (const char * yybytes, yy_size_t  _yybytes_len )
{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	yy_size_t i;
    
	/* Get memory for full buffer, including space for trailing EOB's. */
	n = (yy_size_t) (_yybytes_len + 2);
	buf = (char *) yyalloc( n  );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < _yybytes_len; ++i )
		buf[i] = yybytes[i];

	buf[_yybytes_len] = buf[_yybytes_len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n );
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
}

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

static void yynoreturn yy_fatal_error (const char* msg )
{
			fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
}

/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
        int yyless_macro_arg = (n); \
        YY_LESS_LINENO(yyless_macro_arg);\
		yytext[yyleng] = (yy_hold_char); \
		(yy_c_buf_p) = yytext + yyless_macro_arg; \
		(yy_hold_char) = *(yy_c_buf_p); \
		*(yy_c_buf_p) = '\0'; \
		yyleng = yyless_macro_arg; \
		} \
	while ( 0 )

/* Accessor  methods (get/set functions) to struct members. */

/** Get the current line number.
 * 
 */
int yyget_lineno  (void)
{
    
    return yylineno;
}

/** Get the input stream.
 * 
 */
FILE *yyget_in  (void)
{
        return yyin;
}

/** Get the output stream.
 * 
 */
FILE *yyget_out  (void)
{
        return yyout;
}

/** Get the length of the current token.
 * 
 */
yy_size_t yyget_leng  (void)
{
        return yyleng;
}

/** Get the current token.
 * 
 */

char *yyget_text  (void)
{
        return yytext;
}

/** Set the current line number.
 * @param _line_number line number
 * 
 */
void yyset_lineno (int  _line_number )
{
    
    yylineno = _line_number;
}

/** Set the input stream. This does not discard the current
 * input buffer.
 * @param _in_str A readable stream.
 * 
 * @see yy_switch_to_buffer
 */
void yyset_in (FILE *  _in_str )
{
        yyin = _in_str ;
}

void yyset_out (FILE *  _out_str )
{
        yyout = _out_str ;
}

int yyget_debug  (void)
{
        return yy_flex_debug;
}

void yyset_debug (int  _bdebug )
{
        yy_flex_debug = _bdebug ;
}

static int yy_init_globals (void)
{
        /* Initialization is the same as for the non-reentrant scanner.
     * This function is called from yylex_destroy(), so don't allocate here.
     */

    (yy_buffer_stack) = NULL;
    (yy_buffer_stack_top) = 0;
    (yy_buffer_stack_max) = 0;
    (yy_c_buf_p) = NULL;
    (yy_init) = 0;
    (yy_start) = 0;

/* Defined in main.c */
#ifdef YY_STDINIT
    yyin = stdin;
    yyout = stdout;
#else
    yyin = NULL;
    yyout = NULL;
#endif

    /* For future reference: Set errno on error, since we are called by
     * yylex_init()
     */
    return 0;
}

/* yylex_destroy is for both reentrant and non-reentrant scanners. */
int yylex_destroy  (void)
{
    
    /* Pop the buffer stack, destroying each element. */
	while(YY_CURRENT_BUFFER){
		yy_delete_buffer( YY_CURRENT_BUFFER  );
		YY_CURRENT_BUFFER_LVALUE = NULL;
		yypop_buffer_state();
	}

	/* Destroy the stack itself. */
	yyfree((yy_buffer_stack) );
	(yy_buffer_stack) = NULL;

    /* Reset the globals. This is important in a non-reentrant scanner so the next time
     * yylex() is called, initialization will occur. */
    yy_init_globals( );

    return 0;
}

/*
 * Internal utility routines.
 */

#ifndef yytext_ptr
static void yy_flex_strncpy (char* s1, const char * s2, int n )
{
		
	int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
}
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen (const char * s )
{
	int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
}
#endif

void *yyalloc (yy_size_t  size )
{
			return malloc(size);
}

void *yyrealloc  (void * ptr, yy_size_t  size )
{
		
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return realloc(ptr, size);
}

void yyfree (void * ptr )
{
			free( (char *) ptr );	/* see yyrealloc() for (char *) cast */
}

#define YYTABLES_NAME "yytables"

#line 404 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/config/../../usr.bin/config/scan.l"


int interesting = 1;

static int
curdir_push(const char *fname)
{
	struct prefix *pf;
	char *p, *d, *f;

	/* Set up the initial "current directory" for include directives. */
	d = dirname(f = estrdup(fname));
	if (*d == '/')
		p = estrdup(d);
	else {
		char *cwd, buf[PATH_MAX];

		if ((cwd = getcwd(buf, sizeof(buf))) == NULL) {
			free(f);
			return (-1);
		}
		easprintf(&p, "%s/%s", cwd, d);
	}
	free(f);
	pf = ecalloc(1, sizeof(*pf));
	pf->pf_prefix = p;
	SLIST_INSERT_HEAD(&curdirs, pf, pf_next);

	return (0);
}

static void
curdir_pop(void)
{
	struct prefix *pf;

	pf = SLIST_FIRST(&curdirs);
	SLIST_REMOVE_HEAD(&curdirs, pf_next);
	if (SLIST_EMPTY(&curdirs))
		panic("curdirs is empty");
	/* LINTED cast away const (pf_prefix is malloc'd for curdirs) */
	free((void *)__UNCONST(pf->pf_prefix));
	free(pf);
}

/*
 * Open the "main" file (conffile).
 */
int
firstfile(const char *fname)
{

#if defined(__NetBSD__)
	if ((yyin = fopen(fname, "rf")) == NULL)
#else
	if ((yyin = fopen(fname, "r")) == NULL)
#endif
		return (-1);

	if (curdir_push(fname) == -1)
		return (-1);

	yyfile = conffile = fname;
	yyline = 1;
	return (0);
}

/*
 * Add a "package" to the configuration.  This is essentially
 * syntactic sugar around the sequence:
 *
 *	prefix ../some/directory
 *	include "files.package"
 *	prefix
 */
void
package(const char *fname)
{
	char *fname1 = estrdup(fname);
	char *fname2 = estrdup(fname);
	char *dir = dirname(fname1);
	char *file = basename(fname2);

	/*
	 * Push the prefix on to the prefix stack and process the include
	 * file.  When we reach the end of the include file, inserting
	 * the PREFIX token into the input stream will pop the prefix off
	 * of the prefix stack.
	 */
	prefix_push(dir);
	(void) include(file, PREFIX, 0, 1);

	free(fname1);
	free(fname2);
}

int includedepth;

/*
 * Open the named file for inclusion at the current point.  Returns 0 on
 * success (file opened and previous state pushed), nonzero on failure
 * (fopen failed, complaint made).  The `ateof' parameter controls the
 * token to be inserted at the end of the include file (i.e. ENDFILE).
 * If ateof == 0 then nothing is inserted.
 */
int
include(const char *fname, int ateof, int conditional, int direct)
{
	FILE *fp;
	struct incl *in;
	char *s;
	static int havedirs;
	extern int vflag;

	if (havedirs == 0) {
		havedirs = 1;
		setupdirs();
	}

	if (fname[0] == '/')
		s = estrdup(fname);
	else if (fname[0] == '.' && fname[1] == '/') {
		struct prefix *pf = SLIST_FIRST(&curdirs);
		easprintf(&s, "%s/%s", pf->pf_prefix, fname + 2);
	} else
		s = sourcepath(fname);
	if ((fp = fopen(s, "r")) == NULL) {
		if (conditional == 0)
			cfgerror("cannot open %s for reading: %s", s,
			    strerror(errno));
		else if (vflag)
			cfgwarn("cannot open conditional include file %s: %s",
			     s, strerror(errno));
		free(s);
		return (-1);
	}
	if (curdir_push(s) == -1) {
		cfgerror("cannot record current working directory for %s", s);
		fclose(fp);
		free(s);
		return (-1);
	}
	in = ecalloc(1, sizeof *in);
	in->in_prev = incl;
	in->in_buf = YY_CURRENT_BUFFER;
	in->in_where.w_srcfile = yyfile;
	in->in_where.w_srcline = (u_short)yyline;
	in->in_ateof = ateof;
	in->in_interesting = interesting;
	in->in_ifdefstate = ifdefstate;
	in->in_ifdefshift = ifdefshift;
	interesting = direct & interesting;
	if (interesting)
		logconfig_include(fp, fname);
	incl = in;
	CFGDBG(1, "include `%s'", fname);
	yy_switch_to_buffer(yy_create_buffer(fp, YY_BUF_SIZE));
	yyfile = intern(s);
	yyline = 1;
	free(s);
	includedepth++;
	return (0);
}

/*
 * Extract the pathname from a include/cinclude/package into curinclpath
 */
static int
getincludepath(void)
{
	const char *p = yytext;
	ptrdiff_t len;
	const char *e;

	while (*p && isascii((unsigned int)*p) && !isspace((unsigned int)*p))
		p++;
	while (*p && isascii((unsigned int)*p) && isspace((unsigned int)*p))
		p++;
	if (!*p)
		return 0;
	if (*p == '"') {
		p++;
		e = strchr(p, '"');
		if (!e) return 0;
	} else {
		e = p;
		while (*e && isascii((unsigned int)*e)
		    && !isspace((unsigned int)*e))
			e++;
	}

	len = e-p;
	if (len > (ptrdiff_t)sizeof(curinclpath)-1)
		len = sizeof(curinclpath)-1;
	strncpy(curinclpath, p, sizeof(curinclpath));
	curinclpath[len] = '\0';

	return 1;
}

/*
 * Terminate the most recent inclusion.
 */
static int
endinclude(void)
{
	struct incl *in;
	int ateof;

	curdir_pop();
	if ((in = incl) == NULL)
		panic("endinclude");
	incl = in->in_prev;
	lastfile = yyfile;
	yy_delete_buffer(YY_CURRENT_BUFFER);
	(void)fclose(yyin);
	yy_switch_to_buffer(in->in_buf);
	yyfile = in->in_where.w_srcfile;
	yyline = in->in_where.w_srcline;
	ateof  = in->in_ateof;
	interesting = in->in_interesting;
	ifdefstate = in->in_ifdefstate;
	ifdefshift = in->in_ifdefshift;
	free(in);

	includedepth--;

	return (ateof);
}

/*
 * Return the current line number.  If yacc has looked ahead and caused
 * us to consume a newline, we have to subtract one.  yychar is yacc's
 * token lookahead, so we can tell.
 */
u_short
currentline(void)
{
	extern int yychar;

	return (u_short)(yyline - (yychar == '\n'));
}

static int
getcurifdef(void)
{
	char *p = yytext, *q;

	while (*p && isascii((unsigned int)*p) && !isspace((unsigned int)*p))
		p++;
	while (*p && isascii((unsigned int)*p) && isspace((unsigned int)*p))
		p++;
	q = p;
	while (*q && isascii((unsigned int)*q) && !isspace((unsigned int)*q))
		q++;
	*q = '\0';

	return ht_lookup(attrtab, intern(p)) != NULL;
}

