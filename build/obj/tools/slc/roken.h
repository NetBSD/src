/Users/sidqian/Downloads/summer/L2S/netbsd-src/crypto/external/bsd/heimdal/include/roken.h