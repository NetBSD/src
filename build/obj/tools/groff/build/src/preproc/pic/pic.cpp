/* original parser id follows */
/* yysccsid[] = "@(#)yaccpar	1.9 (Berkeley) 02/21/93" */
/* (use YYMAJOR/YYMINOR for ifdefs dependent on parser version) */

#define YYBYACC 1
#define YYMAJOR 2
#define YYMINOR 0

#define YYEMPTY        (-1)
#define yyclearin      (yychar = YYEMPTY)
#define yyerrok        (yyerrflag = 0)
#define YYRECOVERING() (yyerrflag != 0)
#define YYENOMEM       (-2)
#define YYEOF          0
#undef YYBTYACC
#define YYBTYACC 0
#define YYDEBUGSTR YYPREFIX "debug"
#define YYPREFIX "yy"

#define YYPURE 0

#line 23 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
#include "pic.h"
#include "ptable.h"
#include "object.h"

extern int delim_flag;
extern void copy_rest_thru(const char *, const char *);
extern void copy_file_thru(const char *, const char *, const char *);
extern void push_body(const char *);
extern void do_for(char *var, double from, double to,
		   int by_is_multiplicative, double by, char *body);
extern void do_lookahead();

/* Maximum number of characters produced by printf("%g") */
#define GDIGITS 14

int yylex();
void yyerror(const char *);

void reset(const char *nm);
void reset_all();

place *lookup_label(const char *);
void define_label(const char *label, const place *pl);

direction current_direction;
position current_position;

implement_ptable(place)

PTABLE(place) top_table;

PTABLE(place) *current_table = &top_table;
saved_state *current_saved_state = 0;

object_list olist;

const char *ordinal_postfix(int n);
const char *object_type_name(object_type type);
char *format_number(const char *form, double n);
char *do_sprintf(const char *form, const double *v, int nv);

#ifdef YYSTYPE
#undef  YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#endif
#ifndef YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#line 67 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
typedef union {
	char *str;
	int n;
	double x;
	struct { double x, y; } pair;
	struct { double x; char *body; } if_data;
	struct { char *str; const char *filename; int lineno; } lstr;
	struct { double *v; int nv; int maxv; } dv;
	struct { double val; int is_multiplicative; } by;
	place pl;
	object *obj;
	corner crn;
	path *pth;
	object_spec *spec;
	saved_state *pstate;
	graphics_state state;
	object_type obtype;
} YYSTYPE;
#endif /* !YYSTYPE_IS_DECLARED */
#line 91 "y.tab.c"

/* compatibility with bison */
#ifdef YYPARSE_PARAM
/* compatibility with FreeBSD */
# ifdef YYPARSE_PARAM_TYPE
#  define YYPARSE_DECL() yyparse(YYPARSE_PARAM_TYPE YYPARSE_PARAM)
# else
#  define YYPARSE_DECL() yyparse(void *YYPARSE_PARAM)
# endif
#else
# define YYPARSE_DECL() yyparse(void)
#endif

/* Parameters sent to lex. */
#ifdef YYLEX_PARAM
# define YYLEX_DECL() yylex(void *YYLEX_PARAM)
# define YYLEX yylex(YYLEX_PARAM)
#else
# define YYLEX_DECL() yylex(void)
# define YYLEX yylex()
#endif

#if !(defined(yylex) || defined(YYSTATE))
int YYLEX_DECL();
#endif

/* Parameters sent to yyerror. */
#ifndef YYERROR_DECL
#define YYERROR_DECL() yyerror(const char *s)
#endif
#ifndef YYERROR_CALL
#define YYERROR_CALL(msg) yyerror(msg)
#endif

extern int YYPARSE_DECL();

#define LABEL 257
#define VARIABLE 258
#define NUMBER 259
#define TEXT 260
#define COMMAND_LINE 261
#define DELIMITED 262
#define ORDINAL 263
#define TH 264
#define LEFT_ARROW_HEAD 265
#define RIGHT_ARROW_HEAD 266
#define DOUBLE_ARROW_HEAD 267
#define LAST 268
#define UP 269
#define DOWN 270
#define LEFT 271
#define RIGHT 272
#define BOX 273
#define CIRCLE 274
#define ELLIPSE 275
#define ARC 276
#define LINE 277
#define ARROW 278
#define MOVE 279
#define SPLINE 280
#define HEIGHT 281
#define RADIUS 282
#define FIGNAME 283
#define WIDTH 284
#define DIAMETER 285
#define FROM 286
#define TO 287
#define AT 288
#define WITH 289
#define BY 290
#define THEN 291
#define SOLID 292
#define DOTTED 293
#define DASHED 294
#define CHOP 295
#define SAME 296
#define INVISIBLE 297
#define LJUST 298
#define RJUST 299
#define ABOVE 300
#define BELOW 301
#define OF 302
#define THE 303
#define WAY 304
#define BETWEEN 305
#define AND 306
#define HERE 307
#define DOT_N 308
#define DOT_E 309
#define DOT_W 310
#define DOT_S 311
#define DOT_NE 312
#define DOT_SE 313
#define DOT_NW 314
#define DOT_SW 315
#define DOT_C 316
#define DOT_START 317
#define DOT_END 318
#define DOT_X 319
#define DOT_Y 320
#define DOT_HT 321
#define DOT_WID 322
#define DOT_RAD 323
#define SIN 324
#define COS 325
#define ATAN2 326
#define LOG 327
#define EXP 328
#define SQRT 329
#define K_MAX 330
#define K_MIN 331
#define INT 332
#define RAND 333
#define SRAND 334
#define COPY 335
#define THRU 336
#define TOP 337
#define BOTTOM 338
#define UPPER 339
#define LOWER 340
#define SH 341
#define PRINT 342
#define CW 343
#define CCW 344
#define FOR 345
#define DO 346
#define IF 347
#define ELSE 348
#define ANDAND 349
#define OROR 350
#define NOTEQUAL 351
#define EQUALEQUAL 352
#define LESSEQUAL 353
#define GREATEREQUAL 354
#define LEFT_CORNER 355
#define RIGHT_CORNER 356
#define NORTH 357
#define SOUTH 358
#define EAST 359
#define WEST 360
#define CENTER 361
#define END 362
#define START 363
#define RESET 364
#define UNTIL 365
#define PLOT 366
#define THICKNESS 367
#define FILL 368
#define COLORED 369
#define OUTLINED 370
#define SHADED 371
#define ALIGNED 372
#define SPRINTF 373
#define COMMAND 374
#define DEFINE 375
#define UNDEF 376
#define YYERRCODE 256
typedef int YYINT;
static const YYINT yylhs[] = {                           -1,
    0,    0,   16,   17,   17,   29,   29,   30,   30,   31,
   31,   31,   31,   31,   31,   31,   31,   31,   31,   32,
   31,   31,   33,   34,   31,   35,   36,   31,   37,   31,
   31,   38,   31,   31,   31,   23,   23,   39,   39,   39,
   27,   27,   28,   28,   28,   40,    7,   24,   24,    2,
    2,    3,    3,    3,    3,    3,    3,    3,    3,    3,
    4,    4,    4,   15,   15,   15,   15,   41,   43,   15,
   15,   42,   42,   18,   18,   18,   18,   18,   18,   18,
   18,   18,   18,   18,   44,   18,   18,   18,   18,   18,
   18,   18,   18,   18,   18,   18,   18,   18,   18,   18,
   18,   18,   18,   18,   18,   18,   18,   18,   18,   18,
   18,   18,   18,   18,   18,   18,   18,   18,   18,   18,
   18,   18,   18,   18,   18,   18,   18,   18,   18,   18,
   18,   18,   26,   26,   25,   25,   19,   19,   19,    6,
    6,    6,    6,    6,    6,    6,    6,    6,    6,   45,
   45,    5,    5,   13,   13,   13,   13,   13,   14,   14,
   14,   22,   22,   21,   21,    8,    8,   20,   20,   20,
   20,   20,   20,   20,   20,   20,   11,   11,   12,   12,
   12,   10,   10,   10,   10,   10,   10,    9,    9,    9,
    9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
    9,    9,    9,    9,    9,    9,    9,    9,    9,    9,
    9,    9,    9,    9,    9,    9,    9,    9,    9,    1,
    1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
    1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
    1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
    1,    1,    1,    1,    1,
};
static const YYINT yylen[] = {                            2,
    1,    1,    3,    1,    3,    0,    1,    1,    2,    3,
    3,    4,    1,    1,    1,    1,    1,    2,    2,    0,
    3,    2,    0,    0,    7,    0,    0,    6,    0,   10,
    1,    0,    4,    1,    1,    1,    1,    2,    2,    3,
    1,    2,    1,    1,    1,    0,    5,    0,    2,    1,
    1,    3,    3,    3,    3,    3,    3,    3,    3,    2,
    0,    2,    3,    1,    4,    4,    4,    0,    0,    6,
    1,    0,    1,    1,    1,    1,    1,    1,    1,    1,
    1,    1,    2,    3,    0,    4,    3,    3,    3,    3,
    2,    2,    3,    2,    3,    2,    3,    2,    3,    3,
    3,    3,    3,    3,    3,    2,    2,    2,    3,    2,
    3,    2,    3,    3,    3,    3,    2,    3,    2,    2,
    2,    2,    2,    2,    2,    2,    2,    2,    2,    2,
    3,    2,    1,    5,    0,    3,    1,    1,    3,    1,
    3,    5,    3,    5,    5,    5,    7,    6,    8,    1,
    4,    3,    3,    1,    2,    2,    3,    1,    1,    1,
    3,    1,    3,    1,    2,    2,    2,    1,    1,    1,
    1,    1,    1,    1,    2,    1,    2,    3,    1,    1,
    2,    1,    5,    4,    3,    3,    2,    1,    1,    1,
    1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
    1,    1,    2,    2,    2,    2,    1,    1,    2,    2,
    2,    2,    1,    1,    1,    1,    1,    1,    1,    1,
    1,    2,    2,    2,    2,    2,    3,    3,    3,    3,
    3,    3,    2,    3,    4,    4,    6,    4,    4,    4,
    6,    6,    4,    4,    3,    4,    3,    3,    3,    3,
    3,    3,    3,    3,    2,
};
static const YYINT yydefred[] = {                         0,
    8,    0,    2,    0,    0,    0,    0,  133,   17,   13,
   14,   15,   16,   74,   75,   76,   77,   78,   79,   80,
   81,    0,    0,   20,    0,    0,    0,    0,    0,    0,
    0,   85,   68,    0,    4,    0,    0,   82,   71,    0,
    9,    0,    0,    0,    0,    0,   26,    0,  159,  220,
  221,  162,  164,  201,  202,  158,  188,  189,  190,  191,
  192,  193,  194,  195,  196,  197,  198,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  199,  200,
    0,    0,  207,  208,  213,  214,  215,  216,  217,  219,
  218,    0,    0,    0,    0,    0,  140,  137,  160,    0,
    0,    0,    0,    0,    0,   44,    0,   41,    0,    0,
    0,    0,    0,    0,    0,    0,   38,    0,    0,    0,
    0,    0,   32,    3,    0,  121,  122,  123,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  106,  107,    0,    0,    0,  119,  120,  127,  128,
  129,  130,  124,  125,    0,    0,    0,    0,    0,  132,
    0,  126,   39,    0,    0,   11,    0,   37,   36,   10,
   23,    0,   21,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  203,  205,  209,  211,  204,  206,
  210,  212,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  150,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  222,  223,  224,  225,  226,    0,  155,    0,    0,  176,
  168,  169,  170,  171,  172,  173,  174,    0,  167,  165,
  166,   42,    0,    0,   60,    0,    0,    0,   46,    0,
    0,    0,    0,   84,  135,    0,    0,    0,    0,    5,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  103,    0,
  182,    0,    0,    0,  105,    0,    0,    0,    0,    0,
  115,  116,  114,   40,    0,    0,    0,    0,    0,    0,
   65,    0,   12,    0,   27,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  245,    0,    0,    0,    0,  234,
  153,  139,    0,    0,    0,  163,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  161,  141,  143,  175,    0,
    0,   56,    0,    0,    0,    0,    0,   54,    0,    0,
   53,   52,    0,   86,   69,   33,  179,  187,    0,    0,
    0,  177,    0,    0,  181,    0,    0,   24,    0,  235,
  236,    0,  238,  239,  240,    0,    0,  243,  244,  246,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   47,
    0,  134,    0,    0,  186,  185,    0,  178,    0,    0,
   28,    0,    0,    0,    0,    0,  145,  142,  144,  151,
    0,    0,    0,    0,   73,   70,  184,    0,   25,   49,
  237,  241,  242,    0,    0,  148,    0,    0,  183,    0,
  147,    0,    0,   29,  149,    0,    0,   30,
};
#if defined(YYDESTRUCT_CALL) || defined(YYSTYPE_TOSTRING)
static const YYINT yystos[] = {                           0,
   59,  378,  394,  407,  408,  257,  258,  260,  261,  269,
  270,  271,  272,  273,  274,  275,  276,  277,  278,  279,
  280,  283,  335,  341,  342,  345,  347,  364,  366,  373,
  374,   91,  123,  385,  393,  395,  396,  404,  409,  417,
   59,   58,   61,   58,   61,  260,  336,  410,  257,  258,
  259,  263,  268,  271,  272,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,  337,  338,
  339,  340,  355,  356,  357,  358,  359,  360,  361,  362,
  363,   40,   96,   45,   33,  379,  383,  384,  386,  387,
  391,  392,  397,  399,  400,  404,  405,  406,  258,   40,
   33,  379,  380,  381,  391,  404,  258,  379,   40,  405,
  422,  419,  348,  407,  408,  265,  266,  267,  269,  270,
  271,  272,  281,  282,  284,  285,  286,  287,  288,  289,
  290,  291,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,  343,  344,  367,  368,  369,  370,  371,  372,
  379,  404,  258,   44,  407,  380,   61,  257,  258,  401,
  336,  413,  262,   40,   40,   40,   40,   40,   40,   40,
   40,   40,   40,   40,  271,  272,  355,  356,  271,  272,
  355,  356,  379,  380,  383,  391,  397,  380,  379,  379,
  302,  305,  349,  350,  351,  352,  353,  354,   44,   60,
   62,   43,   45,   42,   47,   37,   94,  423,  302,  392,
  319,  320,  321,  322,  323,   46,  387,   43,   45,  260,
  273,  274,  275,  276,  277,  278,  280,   91,  398,  268,
  398,  406,   61,  379,  381,  349,  350,   60,  291,  349,
  350,  351,  352,  404,  260,  394,  407,  394,  416,  393,
  379,  379,  379,  379,  379,  379,  379,  379,  379,  397,
  397,  397,  257,  263,  268,   46,   40,  387,  388,  389,
  390,  397,   40,  379,  383,  379,  379,  379,  379,  379,
  404,  404,  404,  258,  257,  258,  271,  272,  384,  391,
  393,  397,  380,  411,  262,  380,  380,  380,  380,  380,
  380,  380,  380,  380,   41,  380,  380,   60,  423,   41,
   41,   41,   44,   43,   45,  264,  303,  379,  379,  379,
  379,  379,  379,  379,  379,  397,  379,  379,  379,  379,
  379,  379,  379,  397,  392,  257,  383,  383,   93,  379,
  379,  381,  379,  381,  379,  418,  379,  381,  379,  381,
  404,  404,  403,   93,  125,  262,  387,  390,  268,  398,
  398,  257,  390,   46,  387,  379,  383,  262,  414,   41,
   41,   44,   41,   41,   41,   44,   44,   41,   41,   41,
  397,  397,  397,  383,  383,  304,   44,  306,  287,  262,
   44,   41,  421,  398,  390,  390,   44,  257,  412,  365,
  402,  380,  380,  380,   44,  306,   41,   41,   41,  305,
  397,  397,  379,  379,  393,  420,  390,  390,  402,  260,
   41,   41,   41,  397,  397,   62,  290,  382,   41,   62,
   41,   42,  379,  346,   41,  379,  415,  262,
};
#endif /* YYDESTRUCT_CALL || YYSTYPE_TOSTRING */
static const YYINT yydgoto[] = {                          2,
  112,  194,  114,  438,   97,   98,   34,   99,  100,  279,
  280,  281,  115,  102,   35,    3,   36,   37,  103,  239,
  104,  105,  170,  411,  363,  116,  107,  108,  257,    5,
   39,   48,  304,  409,  172,  379,  447,  259,   40,  356,
  122,  426,  403,  121,  218,
};
static const YYINT yysindex[] = {                       -58,
    0,    0,    0, 5077,  -43,  -21,   -2,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   19, -242,    0,12299, -173,12422, -155,13019,   85,
12299,    0,    0, -214,    0,  -58,11880,    0,    0,  -42,
    0,  -58,12422,   76, -160, -195,    0, -118,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  108,  120,  127,
  133,  137,  154,  161,  162,  173,  174,  179,    0,    0,
 -193, -119,    0,    0,    0,    0,    0,    0,    0,    0,
    0,12539,12422,13019,13019,  -34,    0,    0,    0,  -51,
  170,  585,   46,  495,  329,    0,12299,    0,  110,12422,
12422, 1768,  -71, -227,  170, -197,    0,  -22,  -50,12299,
  -58,  -58,    0,    0,13489,    0,    0,    0,13382,13382,
13382,13382,13019,13019,13019,13019,13142,13142,13142,12779,
13259,    0,    0,13382,13382,13382,    0,    0,    0,    0,
    0,    0,    0,    0,13019,13382, -228, -228, -228,    0,
 1792,    0,    0,  -30,11548,    0,12422,    0,    0,    0,
    0,  -28,    0,12422,12422,12422,12422,12422,12422,12422,
12422,12422,11997,12422,    0,    0,    0,    0,    0,    0,
    0,    0, 1315,  194,  198,  -11,  299,  -10,  159,  159,
  -47,    0,13019,13019,13019,13019,13019,13019,13019,13142,
13019,13019,13019,13019,13019,13019,13019,13142,   -8,  211,
    0,    0,    0,    0,    0,    2,    0,13259,13259,    0,
    0,    0,    0,    0,    0,    0,    0,  177,    0,    0,
    0,    0,13019,  159,    0,12422,12422,13019,    0,12422,
12422, -228, -228,    0,    0,  180, 5077,  147,   25,    0,
 1792, 1792, 1792, 1792, 1792, 1792, 1792, 1792,  -34,   46,
   46,   46, 1842,  318,  318,   29,12182,  -51,    0,  525,
    0,   46,12662, 1336,    0, 1792, 1792, 1792, 1792, 1792,
    0,    0,    0,    0,  -21,   -2,    0,    0,    0,  170,
    0,   46,    0,   27,    0,  251,  264,  262,  292,  293,
  295,  301,  304,  308,    0,  312,  313,13142,13142,    0,
    0,    0,13142,13259,13259,    0,   57, 1194,    6, 1166,
 1166,  506,  506, 1792,   -1,  343,  506,  388,  388,  159,
  159,  159,  159,  -16,  211,    0,    0,    0,    0, 3170,
 1194,    0,  394,   14,  506,  103, 1194,    0,  394,   14,
    0,    0,   21,    0,    0,    0,    0,    0,  495,  986,
  986,    0,  324,  118,    0, 1756,  198,    0,   12,    0,
    0,12422,    0,    0,    0,12422,12422,    0,    0,    0,
  389,    7,  131,  351,  353,   79,13142,13142,13019,    0,
13019,    0, 5077,  986,    0,    0,  986,    0,   12,  135,
    0,  361,  363,  365,13142,13142,    0,    0,    0,    0,
   56,   46, 2233, 1792,    0,    0,    0,  367,    0,    0,
    0,    0,    0,  205,  296,    0,12902,   64,    0,  370,
    0,13019, 1792,    0,    0, 1792,  151,    0,
};
static const YYINT yyrindex[] = {                         5,
    0,    0,    0,  424,  200,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   24,    0,    0,
    0,    0,    0,   31,    0,   34,  102,    0,    0,  139,
    0,11744,    0,    0,    0,  639,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,10124,    0,    0,    0,    0,
 4478, 9516,10459,    0,    0,    0,  691,    0,    0,    0,
    0, 1713,    0, 2171,    0,    0,    0,11366,    0,  692,
 5532, 5532,    0,    0,  136,    0,    0,    0,10701,10765,
10277,10580,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,10829,10955,11019,    0,    0,    0,    0,
    0,    0,    0,    0,    0,11083,    0,    0,    0,    0,
 5277,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  385,    0,  421,  441,    0,    0,  356,  697,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0, 3104,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,10627,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
 5394, 5735, 5852, 6193, 6310, 6651, 6768, 7109,    0, 7226,
 7567, 7684, 9818, -213,  169,    0,    0, 9399,    0, 9912,
    0, 8025,    0,    0,    0, 8142, 8483, 8600, 8941, 9058,
    0,    0,    0,    0,11436, 1656, 2507, 2965,  321,  362,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0, 4020, 4361, 3445,
 3562, 2188, 2529, 4936,10001,    0, 2646, 1730, 2071,  814,
 1155, 1272, 1613,    0, 3903,    0,    0,    0,    0,    0,
   33,    0, 4451, 3118, 2987,    0,  326,    0, 3990, 4906,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  385,    0,    0,  701,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  452,  455,    0,    0,    0,    0,    0,
    0,    0,  720,    0,    0,    0,    0,    0,  701,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0, 4819,   92,   32,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  396,    0,    0,    0,    0,  460,
    0,    0,   96,    0,    0,   97,    0,    0,
};
#if YYBTYACC
static const YYINT yycindex[] = {                         0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,
};
#endif
static const YYINT yygindex[] = {                         0,
  -25,  401, -104,    0,  -78,  280,    0,    0, 1852,    0,
    0, -238,  104,  -81, -108,   43,    0,    0, 2253,  -44,
    0,    0,    0,   38,    0,   50,  417,  -36,   22,  414,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  269,
};
#define YYTABLESIZE 13863
static const YYINT yytable[] = {                         96,
    1,  164,  216,  118,    6,   96,  245,  214,  212,  209,
  213,  161,  215,  195,  216,   41,  260,   46,  220,  214,
  212,    4,  213,   35,  215,  210,  228,  211,  229,  322,
   31,    8,  253,    6,  368,  216,   42,  248,  373,  211,
  214,  212,  216,  213,   93,  215,  162,  214,  212,  228,
  213,  229,  215,   38,  162,   44,  301,  124,   43,  217,
  241,  402,  285,  165,  401,  248,  193,  211,  199,  200,
  242,  217,  136,  253,  106,  136,  253,  185,  186,   45,
  106,   96,   35,  242,  109,  244,  162,   93,  228,   31,
  229,  253,  217,   47,   96,    6,  168,  169,  228,  217,
  229,   64,  117,  261,  262,  263,  264,  265,  266,  267,
  268,  269,  269,  269,  269,  284,   35,  436,  286,  287,
  288,  250,  251,   31,  119,  253,    6,    6,  101,  289,
  290,  405,  406,  123,  101,    7,  167,  345,   34,  269,
  171,  352,  354,  173,   30,  358,  360,  174,   35,  347,
  348,  189,  190,  252,  253,   31,  106,  253,    6,  175,
   64,  187,  188,  256,  258,  427,  176,  254,  428,  106,
  243,  417,  177,  228,   38,  229,  178,  328,  329,  330,
  331,  332,  333,  334,  335,  337,  338,  339,  340,  341,
  342,  343,  269,  179,   64,  196,  220,   34,  195,    7,
  180,  181,  284,  284,  377,   49,  291,  292,  293,  255,
  101,   52,  182,  183,   38,  163,   53,  350,  184,  249,
  351,  353,  355,  101,  357,  359,   64,  294,    7,  370,
  371,   34,    7,  305,  320,  191,  192,    8,  321,    7,
  101,  101,  101,  101,    7,  394,  395,  228,   49,  229,
  219,  193,  217,  326,   52,  327,  226,  376,  346,   53,
    7,    6,    6,   34,    6,    6,  440,  201,  300,  349,
  202,  365,  364,    6,    6,    6,    6,    6,    6,    6,
    6,    6,    6,    6,    6,  372,  366,    6,  378,  398,
    7,  380,  335,  269,  425,    7,  253,  269,  284,  284,
  201,  361,  362,  202,  381,  382,   38,  221,  222,  223,
  224,  225,  416,  101,  203,  204,  205,  206,  207,  208,
   66,  101,    7,  253,  404,   55,  203,  204,  205,  206,
  207,  208,  383,  384,  253,  385,  441,  253,  228,    6,
  229,  324,  323,  325,  386,    6,    6,  387,  388,    6,
   30,    6,  389,  390,  203,  233,  205,  206,  207,  208,
  396,   67,  250,  137,  400,  137,   55,  407,    6,   55,
    6,  269,  269,  423,  408,  424,  410,    6,    6,   66,
  196,  253,  253,  420,   55,  228,  397,  229,  233,  269,
  269,  418,  233,  419,  430,  233,  233,  233,  233,  233,
  233,  431,  233,  432,  138,  433,  138,  439,  238,  444,
  445,  443,  448,   66,  233,  233,  446,  233,   55,  238,
   67,  101,  101,    1,  216,   50,  101,  113,  164,  214,
  216,  228,  415,  229,  215,  214,  212,   61,  213,  146,
  215,   62,   63,  166,  299,   66,  429,  120,  233,  125,
   55,  233,   38,  248,   67,  211,    7,    7,    7,    7,
    7,  319,    7,  140,  140,  140,    0,    7,    7,    7,
    7,    7,    7,    7,    7,    7,    7,    7,    7,    7,
  233,  217,    7,  138,  138,  138,   67,  217,  221,  222,
  223,  224,  225,  198,  141,  141,  141,  143,  143,  143,
  101,  101,  148,  148,  148,    0,    7,    7,    7,    7,
    7,    7,    7,    7,    7,    7,    7,    7,  101,  101,
    0,    0,    0,    7,    7,    7,    7,    7,    7,    7,
    7,    7,    7,    7,    7,    0,    7,    7,    7,    7,
    7,    7,  216,    0,    7,    0,    7,  214,  212,    0,
  213,    0,  215,    0,    7,    7,    7,    7,    7,    7,
    7,    7,    7,    7,    0,    7,    0,  303,    0,    0,
  374,    0,    7,    7,  306,  307,  308,  309,  310,  311,
  312,  313,  314,  316,  317,  238,    0,    0,  230,   55,
  231,  232,  233,  234,  235,  236,  240,  237,    0,  217,
    0,  231,  232,  233,  234,  235,  236,    0,  237,    0,
    0,    0,  233,  233,  233,  233,   55,    0,  233,  233,
  233,  233,  233,  233,  233,  233,  233,  233,    0,    0,
  226,    0,    0,    0,    0,    0,  233,  233,   22,  233,
  233,  233,  233,  233,  233,  233,  233,  233,  233,  233,
  233,  233,  233,  233,  233,  233,  233,  233,    0,    0,
  233,  233,  233,  233,  233,  233,  233,  233,  233,  233,
  233,  233,  233,  233,   55,   55,    0,    0,    0,  233,
  233,  233,  233,  233,  233,  233,  233,  233,  233,  233,
   19,   18,  233,  233,  233,  233,  255,   22,  233,  233,
   48,  233,    0,    0,  233,  233,  233,  233,  233,  233,
  233,  233,  233,  233,  233,  233,  233,  233,  233,   72,
    0,    0,  233,  233,  233,  233,  233,  233,  233,  255,
    0,   22,    0,  255,    0,    0,  255,  255,  255,  255,
  255,  255,  246,  255,  205,  206,  207,  208,    0,   19,
   18,    0,    0,    0,  230,  255,  255,    0,  255,   48,
    0,    0,    0,   22,    0,    0,    0,  231,  232,  233,
  234,  235,  236,    0,  237,    0,    0,    0,   72,    0,
    0,    0,  412,   19,   18,    0,  413,  414,    0,  255,
    0,    0,  255,   48,    0,   54,   55,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   72,  229,    0,   19,   18,    0,    0,    0,
    0,  255,    0,    0,    0,   48,    0,    0,    0,    0,
    0,    0,   57,   58,   59,   60,   61,   62,   63,   64,
   65,   66,   67,    0,   72,    0,  229,    0,    0,    0,
  229,    0,    0,  229,  229,  229,  229,  229,  229,    0,
  229,   79,   80,   81,   82,    0,    0,    0,    0,    0,
    0,    0,  229,  229,    0,  229,    0,    0,    0,   83,
   84,   85,   86,   87,   88,   89,   90,   91,    0,    0,
    0,    0,   57,   58,   59,   60,   61,   62,   63,   64,
   65,   66,   67,    0,    0,    0,  229,    0,    0,  229,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   79,   80,   81,   82,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  229,   83,
   84,   85,   86,   87,   88,   89,   90,   91,    0,    0,
    0,    0,    0,  255,  255,  255,  255,    0,    0,  255,
  255,  255,  255,  255,  255,  255,  255,  255,  255,    0,
    0,    0,    0,    0,    0,    0,    0,  255,  255,    0,
  255,  255,  255,  255,  255,  255,  255,  255,  255,  255,
  255,  255,  255,  255,  255,  255,  255,  255,  255,    0,
    0,  255,  255,  255,  255,  255,  255,  255,  255,  255,
  255,  255,  255,  255,  255,    0,    0,    0,    0,    0,
  255,  255,  255,  255,  255,  255,  255,  255,  255,  255,
  255,  276,    0,  255,  255,  255,  255,    0,    0,  255,
  255,    0,  255,    0,    0,  255,  255,  255,  255,  255,
  255,  255,  255,  255,  255,  255,  255,  255,  255,  255,
    0,    0,    0,  255,  255,  255,  255,  255,  255,  255,
  229,  229,  229,  229,    0,    0,  229,  229,  229,  229,
  229,  229,  229,  229,  229,  229,    0,    0,    0,    0,
    0,    0,    0,    0,  229,  229,    0,  229,  229,  229,
  229,  229,  229,  229,  229,  229,  229,  229,  229,  229,
  229,  229,  229,  229,  229,  229,    0,    0,  229,  229,
  229,  229,  229,  229,  229,  229,  229,  229,  229,  229,
  229,  229,    0,    0,    0,    0,    0,  229,  229,  229,
  229,  229,  229,  229,  229,  229,  229,  229,    0,    0,
  229,  229,  229,  229,  230,    0,  229,  229,    0,  229,
    0,    0,  229,  229,  229,  229,  229,  229,  229,  229,
  229,  229,  229,  229,  229,  229,  229,    0,    0,    0,
  229,  229,  229,  229,  229,  229,  229,  230,    0,    0,
    0,  230,    0,    0,  230,  230,  230,  230,  230,  230,
    0,  230,  216,    0,    0,    0,    0,  214,  212,    0,
  213,    0,  215,  230,  230,    0,  230,    0,    0,    0,
    0,    0,    0,    0,    0,  248,    0,  211,    0,    0,
  216,    0,    0,    0,    0,  214,  212,    0,  213,    0,
  215,    0,    0,    0,    0,    0,    0,  230,    0,    0,
  230,    0,    0,  248,    0,  211,   54,   55,    0,  217,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  231,    0,    0,    0,    0,    0,    0,    0,  230,
    0,    0,    0,    0,    0,    0,    0,  217,    0,    0,
    0,    0,    0,   57,   58,   59,   60,   61,   62,   63,
   64,   65,   66,   67,  231,    0,    0,    0,  231,    0,
    0,  231,  231,  231,  231,  231,  231,    0,  231,    0,
    0,    0,   79,   80,   81,   82,    0,    0,    0,    0,
  231,  231,    0,  231,    0,    0,    0,    0,    0,    0,
   83,   84,   85,   86,   87,   88,   89,   90,   91,    0,
    0,  216,    0,    0,    0,    0,  214,  212,  209,  213,
    0,  215,    0,    0,  231,    0,    0,  231,    0,    0,
    0,    0,  216,    0,  318,    0,  211,  214,  212,  209,
  213,    0,  215,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  248,  231,  211,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  217,    0,
    0,  230,  230,  230,  230,    0,    0,  230,  230,  230,
  230,  230,  230,  230,  230,  230,  230,    0,    0,  217,
    0,    0,    0,    0,    0,  230,  230,    0,  230,  230,
  230,  230,  230,  230,  230,  230,  230,  230,  230,  230,
  230,  230,  230,  230,  230,  230,  230,    0,    0,  230,
  230,  230,  230,  230,  230,  230,  230,  230,  230,  230,
  230,  230,  230,    0,    0,    0,    0,    0,  230,  230,
  230,  230,  230,  230,  230,  230,  230,  230,  230,    0,
    0,  230,  230,  230,  230,    0,    0,  230,  230,    0,
  230,    0,    0,  230,  230,  230,  230,  230,  230,  230,
  230,  230,  230,  230,  230,  230,  230,  230,  207,  208,
    0,  230,  230,  230,  230,  230,  230,  230,  231,  231,
  231,  231,    0,    0,  231,  231,  231,  231,  231,  231,
  231,  231,  231,  231,  205,  206,  207,  208,    0,    0,
    0,    0,  231,  231,    0,  231,  231,  231,  231,  231,
  231,  231,  231,  231,  231,  231,  231,  231,  231,  231,
  231,  231,  231,  231,    0,    0,  231,  231,  231,  231,
  231,  231,  231,  231,  231,  231,  231,  231,  231,  231,
    0,    0,    0,    0,    0,  231,  231,  231,  231,  231,
  231,  231,  231,  231,  231,  231,    0,    0,  231,  231,
  231,  231,  232,    0,  231,  231,  201,  231,    0,  202,
  231,  231,  231,  231,  231,  231,  231,  231,  231,  231,
  231,  231,  231,  231,  231,    0,    0,    0,  231,  231,
  231,  231,  231,  231,  231,  232,    0,    0,    0,  232,
    0,    0,  232,  232,  232,  232,  232,  232,    0,  232,
    0,    0,    0,  246,  247,  205,  206,  207,  208,    0,
    0,  232,  232,    0,  232,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  203,  204,  205,  206,  207,  208,
    0,    0,  220,    0,    0,    0,    0,  220,  220,  220,
  220,    0,  220,    0,    0,  232,    0,    0,  232,    0,
    0,    0,   50,    0,    0,  220,    0,  220,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  227,
    0,    0,    0,    0,    0,    0,    0,  232,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  220,
    0,    0,    0,   50,    0,    0,   50,    0,    0,    0,
    0,    0,  227,    0,    0,    0,    0,    0,    0,  227,
  227,   50,  227,  227,  227,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  227,  227,
    0,  227,  216,    0,    0,    0,    0,  214,  212,  209,
  213,    0,  215,    0,  216,   50,    0,    0,    0,  214,
  212,    0,  213,    0,  215,  248,    0,  211,    0,    0,
    0,    0,  227,    0,    0,  227,    0,  248,  216,  211,
    0,    0,    0,  214,  212,    0,  213,   50,  215,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  217,
    0,  248,    0,  211,  227,    0,    0,    0,    0,    0,
    0,  217,    0,    0,    0,    0,    0,    0,    0,  232,
  232,  232,  232,    0,    0,  232,  232,  232,  232,  232,
  232,  232,  232,  232,  232,  217,    0,    0,    0,    0,
    0,    0,    0,  232,  232,    0,  232,  232,  232,  232,
  232,  232,  232,  232,  232,  232,  232,  232,  232,  232,
  232,  232,  232,  232,  232,    0,    0,  232,  232,  232,
  232,  232,  232,  232,  232,  232,  232,  232,  232,  232,
  232,    0,    0,    0,    0,    0,  232,  232,  232,  232,
  232,  232,  232,  232,  232,  232,  232,    0,    0,  232,
  232,  232,  232,  227,    0,  232,  232,  220,  232,    0,
  220,  232,  232,  232,  232,  232,  232,  232,  232,  232,
  232,  232,  232,  232,  232,  232,   50,    0,    0,  232,
  232,  232,  232,  232,  232,  232,  227,  227,  227,  227,
    0,  278,  227,  227,  227,  227,  227,  227,  227,  227,
  227,  227,    0,   50,  220,  220,  220,  220,  220,  220,
  227,  227,    0,  227,  227,  227,  227,  227,  227,  227,
  227,  227,  227,  227,  227,  227,  227,  227,  227,  227,
  227,  227,    0,    0,  227,  227,  227,  227,  227,  227,
  227,  227,  227,  227,  227,  227,  227,  227,    0,    0,
    0,    0,    0,  227,  227,  227,  227,  227,  227,  227,
  227,  227,  227,  227,    0,    0,  227,  227,  227,  227,
  228,    0,  227,  227,    0,  227,    0,    0,  227,  227,
  227,  227,  227,  227,  227,  227,  227,  227,  227,  227,
  227,  227,  227,    0,    0,    0,  227,  227,  227,  227,
  227,  227,  227,  228,  246,  247,  205,  206,  207,  208,
  228,  228,    0,  228,  228,  228,  246,  247,  205,  206,
  207,  208,    0,    0,  367,    0,    0,    0,  278,  228,
  228,  375,  228,    0,    0,    0,    0,    0,    0,    0,
  203,  204,  205,  206,  207,  208,    0,    0,    0,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,  228,    0,    0,  228,    0,    0,    0,
   51,    0,    0,    0,    0,    0,    0,    0,   79,   80,
   81,   82,    0,    0,    0,    0,    0,  248,    0,    0,
    0,    0,    0,    0,    0,  228,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    0,    0,    0,    0,    0,
    0,   51,    0,    0,   51,    0,    0,    0,    0,    0,
  248,  367,  367,    0,    0,    0,    0,  248,  248,   51,
    0,  248,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  248,  248,    0,  248,
    0,    0,    0,    0,    0,  367,    0,    0,  367,    0,
    0,    0,    0,   51,    0,    0,    0,    0,    0,  216,
    0,    0,    0,    0,  214,  212,    0,  213,    0,  215,
  248,    0,    0,  248,    0,    0,    0,    0,    0,    0,
    0,    0,  248,    0,  211,   51,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  248,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  217,  228,  228,  228,
  228,    0,    0,  228,  228,  228,  228,  228,  228,  228,
  228,  228,  228,    0,  197,    0,    0,    0,    0,    0,
    0,  228,  228,    0,  228,  228,  228,  228,  228,  228,
  228,  228,  228,  228,  228,  228,  228,  228,  228,  228,
  228,  228,  228,    0,    0,  228,  228,  228,  228,  228,
  228,  228,  228,  228,  228,  228,  228,  228,  228,  270,
  271,  272,  282,    0,  228,  228,  228,  228,  228,  228,
  228,  228,  228,  228,  228,    0,    0,  228,  228,  228,
  228,    0,    0,  228,  228,    0,  228,  302,    0,  228,
  228,  228,  228,  228,  228,  228,  228,  228,  228,  228,
  228,  228,  228,  228,   51,    0,    0,  228,  228,  228,
  228,  228,  228,  228,  248,  248,  248,  248,    0,    0,
  248,  248,  248,  248,  248,  248,  248,  248,  248,  248,
    0,   51,  336,    0,    0,    0,    0,    0,  248,  248,
  344,  248,  248,  248,  248,  248,  248,  248,  248,  248,
  248,  248,  248,  248,  248,  248,  248,  248,  248,  248,
    0,    0,  248,  248,  248,  248,  248,  248,  248,  248,
  248,  248,  248,  248,  248,  248,   15,    0,    0,    0,
    0,  248,  248,  248,  248,  248,  248,  248,  248,  248,
  248,  248,  437,    0,  248,  248,  248,  248,  250,  197,
  248,  248,    0,  248,    0,    0,  248,  248,  248,  248,
  248,  248,  248,  248,  248,  248,  248,  248,  248,  248,
  248,    0,    0,    0,  248,  248,  248,  248,  248,  248,
  248,  250,    0,    0,    0,   15,    0,    0,  250,  250,
  391,  392,  250,    0,    0,  393,    0,    0,    0,    0,
    0,  203,  204,  205,  206,  207,  208,  250,  250,    0,
  250,    0,    0,    0,    0,    0,    0,    0,    0,   15,
    0,    0,  201,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  250,    0,    0,  250,    0,    0,    0,    0,    0,
    0,   15,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  249,    0,    0,    0,  421,
  422,    0,    0,  250,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  434,  435,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  249,    0,
    0,    0,    0,    0,    0,  249,  249,    0,    0,  249,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  249,  249,    0,  249,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  249,    0,
    0,  249,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  201,    0,    0,    0,    0,    0,  201,
  249,    0,    0,    0,  201,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  250,  250,  250,  250,    0,
    0,  250,  250,  250,  250,  250,  250,  250,  250,  250,
  250,    0,    0,    0,    0,    0,    0,    0,  201,  250,
  250,    0,  250,  250,  250,  250,  250,  250,  250,  250,
  250,  250,  250,  250,  250,  250,  250,  250,  250,  250,
  250,    0,    0,  250,  250,  250,  250,  250,  250,  250,
  250,  250,  250,  250,  250,  250,  250,    0,    0,    0,
    0,    0,  250,  250,  250,  250,  250,  250,  250,  250,
  250,  250,  250,    0,    0,  250,  250,  250,  250,    0,
    0,  250,  250,    0,  250,    0,    0,  250,  250,  250,
  250,  250,  250,  250,  250,  250,  250,  250,  250,  250,
  250,  250,    0,    0,    0,  250,  250,  250,  250,  250,
  250,  250,  249,  249,  249,  249,    0,    0,  249,  249,
  249,  249,  249,  249,  249,  249,  249,  249,    0,    0,
    0,    0,    0,    0,    0,    0,  249,  249,    0,  249,
  249,  249,  249,  249,  249,  249,  249,  249,  249,  249,
  249,  249,  249,  249,  249,  249,  249,  249,    0,    0,
  249,  249,  249,  249,  249,  249,  249,  249,  249,  249,
  249,  249,  249,  249,   16,    0,    0,    0,    0,  249,
  249,  249,  249,  249,  249,  249,  249,  249,  249,  249,
    0,    0,  249,  249,  249,  249,  247,    0,  249,  249,
    0,  249,    0,    0,  249,  249,  249,  249,  249,  249,
  249,  249,  249,  249,  249,  249,  249,  249,  249,    0,
    0,    0,  249,  249,  249,  249,  249,  249,  249,  247,
    0,    0,    0,   16,    0,    0,  247,  247,    0,    0,
  247,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  247,  247,    0,  247,    0,
    0,    0,    0,    0,    0,    0,    0,   16,    0,    0,
  202,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  247,
    0,    0,  247,    0,    0,    0,    0,    0,    0,   16,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  156,    0,    0,    0,    0,    0,    0,
    0,  247,    0,    0,    0,    0,    0,   59,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  156,    0,    0,    0,
    0,    0,    0,  156,  156,    0,  156,  156,  156,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   59,    0,
    0,   59,  156,    0,    0,  156,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   59,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  156,    0,    0,  156,
    0,    0,    0,    0,    0,    0,  216,    0,    0,    0,
   59,  214,  212,    0,  213,    0,  215,    0,    0,    0,
    0,  202,    0,    0,    0,    0,    0,  202,  156,  248,
    0,  211,  202,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   59,  247,  247,  247,  247,    0,    0,  247,
  247,  247,  247,  247,  247,  247,  247,  247,  247,    0,
    0,    0,    0,  217,    0,    0,  202,  247,  247,    0,
  247,  247,  247,  247,  247,  247,  247,  247,  247,  247,
  247,  247,  247,  247,  247,  247,  247,  247,  247,    0,
    0,  247,  247,  247,  247,  247,  247,  247,  247,  247,
  247,  247,  247,  247,  247,    0,    0,    0,    0,    0,
  247,  247,  247,  247,  247,  247,  247,  247,  247,  247,
  247,    0,    0,  247,  247,  247,  247,    0,    0,  247,
  247,    0,  247,    0,    0,  247,  247,  247,  247,  247,
  247,  247,  247,  247,  247,  247,  247,  247,  247,  247,
    0,    0,    0,  247,  247,  247,  247,  247,  247,  247,
  156,  156,  156,  156,    0,    0,  156,    0,  156,  156,
  156,  156,  156,  156,  156,  156,    0,    0,    0,    0,
    0,   59,    0,    0,  156,  156,    0,  156,  156,  156,
  156,  156,  156,  156,  156,  156,  156,  156,  156,  156,
  156,  156,  156,  156,  156,    0,    0,    0,   59,  156,
  156,  156,  156,  156,  156,  156,  156,  156,  156,  156,
  156,  156,  156,  156,  156,  156,  156,  156,  156,  156,
  156,  156,  156,  156,  156,  156,  156,  156,    0,    0,
  156,  156,  156,  156,  252,    0,  156,  156,    0,    0,
    0,    0,    0,    0,    0,    0,  399,    0,  156,  156,
  156,  156,  156,  156,  156,  156,  156,   59,    0,    0,
  156,  156,  156,  156,  156,  156,  156,  252,    0,    0,
    0,    0,    0,    0,  252,  252,    0,    0,  252,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  252,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  203,  204,
  205,  206,  207,  208,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  252,    0,    0,
  252,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  251,    0,    0,    0,    0,    0,    0,    0,  252,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  251,    0,    0,    0,    0,    0,
    0,  251,  251,    0,    0,  251,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  251,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  251,    0,    0,  251,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  251,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  252,  252,  252,  252,    0,    0,  252,  252,  252,
  252,  252,  252,  252,  252,  252,  252,    0,    0,    0,
    0,    0,    0,    0,    0,  252,  252,    0,  252,  252,
  252,  252,  252,  252,  252,  252,  252,  252,  252,  252,
  252,  252,  252,  252,  252,  252,  252,    0,    0,  252,
  252,  252,  252,  252,  252,  252,  252,  252,  252,  252,
  252,  252,  252,    0,    0,    0,    0,    0,  252,  252,
  252,  252,  252,  252,  252,  252,  252,  252,  252,    0,
    0,  252,  252,  252,  252,    0,    0,  252,  252,    0,
  252,    0,    0,  252,  252,  252,  252,    0,    0,  252,
  252,  252,  252,  252,  252,  252,  252,  252,    0,    0,
    0,  252,  252,  252,  252,  252,  252,  252,  251,  251,
  251,  251,    0,    0,  251,  251,  251,  251,  251,  251,
  251,  251,  251,  251,    0,    0,    0,    0,    0,    0,
    0,    0,  251,  251,    0,  251,  251,  251,  251,  251,
  251,  251,  251,  251,  251,  251,  251,  251,  251,  251,
  251,  251,  251,  251,    0,    0,  251,  251,  251,  251,
  251,  251,  251,  251,  251,  251,  251,  251,  251,  251,
    0,    0,    0,    0,    0,  251,  251,  251,  251,  251,
  251,  251,  251,  251,  251,  251,    0,    0,  251,  251,
  251,  251,  157,    0,  251,  251,    0,  251,    0,    0,
  251,  251,  251,  251,    0,    0,  251,  251,  251,  251,
  251,  251,  251,  251,  251,    0,    0,    0,  251,  251,
  251,  251,  251,  251,  251,  157,    0,    0,    0,    0,
    0,    0,  157,  157,    0,  157,  157,  157,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  157,    0,    0,  157,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   58,
    0,    0,    0,    0,    0,  157,    0,    0,  157,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  253,
    0,    0,    0,    0,    0,    0,    0,  157,    0,    0,
   58,    0,    0,   58,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   58,    0,
    0,    0,  253,    0,    0,    0,    0,    0,    0,  253,
  253,    0,    0,  253,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  253,    0,
    0,    0,   58,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  253,    0,   58,  253,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  253,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  157,
  157,  157,  157,    0,    0,  157,    0,  157,  157,  157,
  157,  157,  157,  157,  157,    0,    0,    0,    0,    0,
    0,    0,    0,  157,  157,    0,  157,  157,  157,  157,
  157,  157,  157,  157,  157,  157,  157,  157,  157,  157,
  157,  157,  157,  157,    0,    0,    0,    0,  157,  157,
  157,  157,  157,  157,  157,  157,  157,  157,  157,  157,
  157,  157,  157,  157,  157,  157,  157,  157,  157,  157,
  157,  157,  157,  157,  157,  157,  157,    0,    0,  157,
  157,  157,  157,    0,    0,  157,  157,    0,    0,    0,
    0,    0,    0,   58,    0,    0,    0,  157,  157,  157,
  157,  157,  157,  157,  157,  157,    0,    0,    0,  157,
  157,  157,  157,  157,  157,  157,  253,  253,  253,  253,
   58,    0,  253,  253,  253,  253,  253,  253,  253,  253,
  253,  253,    0,    0,    0,    0,    0,    0,    0,    0,
  253,  253,    0,  253,  253,  253,  253,  253,  253,  253,
  253,  253,  253,  253,  253,  253,  253,  253,  253,  253,
  253,  253,    0,    0,  253,  253,  253,  253,  253,  253,
  253,  253,  253,  253,  253,  253,  253,  253,    0,   58,
    0,    0,    0,  253,  253,  253,  253,  253,  253,  253,
  253,  253,  253,  253,    0,    0,  253,  253,  253,  253,
  254,    0,  253,  253,    0,  253,    0,    0,  253,  253,
    0,    0,    0,    0,  253,  253,  253,  253,  253,  253,
  253,  253,  253,    0,    0,    0,  253,  253,  253,  253,
  253,  253,  253,  254,    0,    0,    0,    0,    0,    0,
  254,  254,    0,    0,  254,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  254,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  254,    0,    0,  254,    0,    0,  254,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  138,    0,    0,
    0,    0,    0,    0,    0,  254,    0,    0,    0,    0,
    0,  254,    0,    0,  254,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  254,
  138,    0,    0,    0,    0,    0,    0,  138,  138,    0,
  138,  138,  138,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  138,    0,    0,  138,
    0,    0,    0,  254,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  138,    0,    0,  138,    0,  254,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  138,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  254,  254,  254,
  254,    0,    0,  254,  254,  254,  254,  254,  254,  254,
  254,  254,  254,    0,    0,    0,    0,    0,    0,    0,
    0,  254,  254,    0,  254,  254,  254,  254,  254,  254,
  254,  254,  254,  254,  254,  254,  254,  254,  254,  254,
  254,  254,  254,    0,    0,  254,  254,  254,  254,  254,
  254,  254,  254,  254,  254,  254,  254,  254,  254,    0,
    0,    0,    0,    0,  254,  254,  254,  254,  254,  254,
  254,  254,  254,  254,  254,    0,    0,  254,  254,  254,
  254,    0,    0,  254,  254,    0,  254,    0,    0,    0,
  254,    0,    0,    0,  254,  254,  254,  254,  254,  254,
  254,  254,  254,  254,    0,    0,    0,  254,  254,  254,
  254,  254,  254,  254,  138,  138,  138,  138,    0,    0,
  138,  254,  138,  138,  138,  138,  138,  138,  138,  138,
    0,    0,  254,    0,    0,  254,    0,    0,  138,  138,
    0,  138,  138,  138,  138,  138,  138,  138,  138,  138,
  138,  138,  138,  138,  138,  138,  138,  138,  138,    0,
    0,    0,    0,  138,  138,  138,  138,  138,  138,  138,
  138,  138,  138,  138,  138,  138,    0,    0,    0,    0,
  254,  138,  138,  138,  138,  138,  138,  138,  138,  138,
  138,  138,    0,    0,  138,  138,  138,  138,  146,    0,
  138,  138,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  138,  138,  138,  138,  138,  138,  138,  138,
  138,    0,    0,    0,  138,  138,  138,  138,  138,  138,
  138,  146,    0,    0,    0,    0,    0,    0,  146,  146,
    0,    0,  146,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  146,    0,    0,
  146,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   57,    0,    0,    0,    0,
    0,  146,    0,    0,  146,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  152,    0,    0,    0,    0,
    0,    0,    0,  146,    0,    0,   57,    0,    0,   57,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   57,    0,    0,    0,  152,    0,
    0,    0,    0,    0,    0,  152,  152,    0,    0,  152,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  152,    0,    0,    0,   57,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  152,    0,
   57,  152,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  152,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  146,  146,  146,  146,    0,
    0,  146,    0,  146,  146,  146,  146,  146,  146,  146,
  146,    0,    0,    0,    0,    0,    0,    0,    0,  146,
  146,    0,  146,  146,  146,  146,  146,  146,  146,  146,
  146,  146,  146,  146,  146,  146,  146,  146,  146,  146,
    0,    0,    0,    0,  146,  146,  146,  146,  146,  146,
  146,  146,  146,  146,  146,  146,  146,    0,    0,    0,
    0,    0,  146,  146,  146,  146,  146,  146,  146,  146,
  146,  146,  146,    0,    0,  146,  146,  146,  146,    0,
    0,  146,  146,    0,    0,    0,    0,   32,    0,   57,
    0,    0,    0,  146,  146,  146,  146,  146,  146,  146,
  146,  146,    0,    0,    0,  146,  146,  146,  146,  146,
  146,  146,  152,  152,  152,  152,   57,    0,  152,   33,
  152,  152,  152,  152,  152,  152,  152,  152,    0,    0,
    0,    0,    0,    0,    0,    0,  152,  152,    0,  152,
  152,  152,  152,  152,  152,  152,  152,  152,  152,  152,
  152,  152,  152,  152,  152,  152,  152,    0,    0,    0,
    0,  152,  152,  152,  152,  152,  152,  152,  152,  152,
  152,  152,  152,  152,    0,   57,    0,    0,    0,  152,
  152,  152,  152,  152,  152,  152,  152,  152,  152,  152,
    0,    0,  152,  152,  152,  152,   91,    0,  152,  152,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  152,  152,  152,  152,  152,  152,  152,  152,  152,    0,
    0,    0,  152,  152,  152,  152,  152,  152,  152,   91,
    0,    0,    0,    0,    0,    0,   91,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    6,    7,   91,    8,    9,    0,    0,
    0,    0,    0,    0,    0,   10,   11,   12,   13,   14,
   15,   16,   17,   18,   19,   20,   21,    0,    0,   22,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   91,
    0,    0,   91,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   93,    0,    0,    0,    0,    0,    0,
    0,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   23,    0,    0,    0,    0,    0,   24,   25,    0,
    0,   26,    0,   27,    0,    0,   93,    0,    0,    0,
    0,    0,    0,   93,    0,    0,    0,    0,    0,    0,
   28,    0,   29,    0,    0,    0,    0,    0,    0,   30,
   31,    0,   93,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   93,    0,    0,   93,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   93,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   91,   91,   91,   91,    0,    0,   91,
    0,   91,   91,   91,   91,   91,   91,   91,   91,    0,
    0,    0,    0,    0,    0,    0,    0,   91,   91,    0,
   91,   91,   91,   91,   91,   91,   91,   91,   91,   91,
   91,   91,   91,   91,   91,   91,   91,   91,    0,    0,
    0,    0,    0,   91,   91,   91,   91,   91,   91,   91,
   91,   91,   91,   91,   91,    0,    0,    0,    0,    0,
   91,   91,   91,   91,   91,   91,   91,   91,   91,   91,
   91,    0,    0,   91,   91,   91,   91,    0,    0,   91,
   91,    0,    6,    0,    0,    0,    0,    0,    0,    0,
    0,   91,   91,   91,   91,   91,   91,   91,   91,   91,
    0,    0,    0,   91,   91,   91,   91,   91,   91,   91,
   93,   93,   93,   93,    6,    0,   93,    0,   93,   93,
   93,   93,   93,   93,   93,   93,    0,    0,    0,    0,
    0,    0,    0,    0,   93,   93,    0,   93,   93,   93,
   93,   93,   93,   93,   93,   93,   93,   93,   93,   93,
   93,   93,   93,   93,   93,    0,    0,    0,    0,    0,
   93,   93,   93,   93,   93,   93,   93,   93,   93,   93,
   93,   93,    0,    0,    0,    0,    0,   93,   93,   93,
   93,   93,   93,   93,   93,   93,   93,   93,    0,    0,
   93,   93,   93,   93,   95,    0,   93,   93,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   93,   93,
   93,   93,   93,   93,   93,   93,   93,    0,    0,    0,
   93,   93,   93,   93,   93,   93,   93,   95,    0,    0,
    0,    0,    0,    0,   95,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    6,    6,
    0,    6,    6,   95,    0,    0,    0,    0,    0,    0,
    6,    6,    6,    6,    6,    6,    6,    6,    6,    6,
    6,    6,    0,    0,    6,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   95,    0,    0,
   95,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   99,    0,    0,    0,    0,    0,    0,    0,   95,
    0,    0,    0,    0,    0,    0,    6,    0,    0,    0,
    0,    0,    6,    6,    0,    0,    6,    0,    6,    0,
    0,    0,    0,    0,   99,    0,    0,    0,    0,    0,
    0,   99,    0,    0,    0,    6,    0,    6,    0,    0,
    0,    0,    0,    0,    6,    6,    0,    0,    0,    0,
   99,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   99,    0,    0,   99,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   99,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   95,   95,   95,   95,    0,    0,   95,    0,   95,
   95,   95,   95,   95,   95,   95,   95,    0,    0,    0,
    0,    0,    0,    0,    0,   95,   95,    0,   95,   95,
   95,   95,   95,   95,   95,   95,   95,   95,   95,   95,
   95,   95,   95,   95,   95,   95,    0,    0,    0,    0,
    0,   95,   95,   95,   95,   95,   95,   95,   95,   95,
   95,   95,   95,    0,    0,    0,    0,    0,   95,   95,
   95,   95,   95,   95,   95,   95,   95,   95,   95,    0,
    0,   95,   95,   95,   95,    0,    0,   95,   95,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   95,
   95,   95,   95,   95,   95,   95,   95,   95,    0,    0,
    0,   95,   95,   95,   95,   95,   95,   95,   99,   99,
   99,   99,    0,    0,   99,    0,   99,   99,   99,   99,
   99,   99,   99,   99,    0,    0,    0,    0,    0,    0,
    0,    0,   99,   99,    0,   99,   99,   99,   99,   99,
   99,   99,   99,   99,   99,   99,   99,   99,   99,   99,
   99,   99,   99,    0,    0,    0,    0,    0,   99,   99,
   99,   99,   99,   99,   99,   99,   99,   99,   99,   99,
    0,    0,    0,    0,    0,   99,   99,   99,   99,   99,
   99,   99,   99,   99,   99,   99,    0,    0,   99,   99,
   99,   99,   97,    0,   99,   99,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   99,   99,   99,   99,
   99,   99,   99,   99,   99,    0,    0,    0,   99,   99,
   99,   99,   99,   99,   99,   97,    0,    0,    0,    0,
    0,    0,   97,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   97,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   97,    0,    0,   97,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   87,
    0,    0,    0,    0,    0,    0,    0,   97,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   87,    0,    0,    0,    0,    0,    0,   87,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   87,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   87,    0,    0,   87,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   87,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   97,
   97,   97,   97,    0,    0,   97,    0,   97,   97,   97,
   97,   97,   97,   97,   97,    0,    0,    0,    0,    0,
    0,    0,    0,   97,   97,    0,   97,   97,   97,   97,
   97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
   97,   97,   97,   97,    0,    0,    0,    0,    0,   97,
   97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
   97,    0,    0,    0,    0,    0,   97,   97,   97,   97,
   97,   97,   97,   97,   97,   97,   97,    0,    0,   97,
   97,   97,   97,    0,    0,   97,   97,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   97,   97,   97,
   97,   97,   97,   97,   97,   97,    0,    0,    0,   97,
   97,   97,   97,   97,   97,   97,   87,   87,   87,   87,
    0,    0,   87,    0,   87,   87,   87,   87,   87,   87,
   87,   87,    0,    0,    0,    0,    0,    0,    0,    0,
   87,   87,    0,   87,   87,   87,   87,   87,   87,   87,
   87,   87,   87,   87,   87,   87,   87,   87,   87,   87,
   87,    0,    0,    0,    0,    0,   87,   87,   87,   87,
   87,   87,   87,   87,   87,   87,   87,   87,    0,    0,
    0,    0,    0,   87,   87,   87,   87,   87,   87,   87,
   87,   87,   87,   87,    0,    0,   87,   87,   87,   87,
   88,    0,   87,   87,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   87,   87,   87,   87,   87,   87,
   87,   87,   87,    0,    0,    0,   87,   87,   87,   87,
   87,   87,   87,   88,    0,    0,    0,    0,    0,    0,
   88,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   88,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   88,    0,    0,   88,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   89,    0,    0,
    0,    0,    0,    0,    0,   88,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   89,    0,    0,    0,    0,    0,    0,   89,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   89,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   89,    0,    0,   89,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   89,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   88,   88,   88,
   88,    0,    0,   88,    0,   88,   88,   88,   88,   88,
   88,   88,   88,    0,    0,    0,    0,    0,    0,    0,
    0,   88,   88,    0,   88,   88,   88,   88,   88,   88,
   88,   88,   88,   88,   88,   88,   88,   88,   88,   88,
   88,   88,    0,    0,    0,    0,    0,   88,   88,   88,
   88,   88,   88,   88,   88,   88,   88,   88,   88,    0,
    0,    0,    0,    0,   88,   88,   88,   88,   88,   88,
   88,   88,   88,   88,   88,    0,    0,   88,   88,   88,
   88,    0,    0,   88,   88,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   88,   88,   88,   88,   88,
   88,   88,   88,   88,    0,    0,    0,   88,   88,   88,
   88,   88,   88,   88,   89,   89,   89,   89,    0,    0,
   89,    0,   89,   89,   89,   89,   89,   89,   89,   89,
    0,    0,    0,    0,    0,    0,    0,    0,   89,   89,
    0,   89,   89,   89,   89,   89,   89,   89,   89,   89,
   89,   89,   89,   89,   89,   89,   89,   89,   89,    0,
    0,    0,    0,    0,   89,   89,   89,   89,   89,   89,
   89,   89,   89,   89,   89,   89,    0,    0,    0,    0,
    0,   89,   89,   89,   89,   89,   89,   89,   89,   89,
   89,   89,    0,    0,   89,   89,   89,   89,   90,    0,
   89,   89,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   89,   89,   89,   89,   89,   89,   89,   89,
   89,    0,    0,    0,   89,   89,   89,   89,   89,   89,
   89,   90,    0,    0,    0,    0,    0,    0,   90,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   90,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   90,    0,    0,   90,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  100,    0,    0,    0,    0,
    0,    0,    0,   90,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  100,    0,
    0,    0,    0,    0,    0,  100,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  100,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  100,    0,
    0,  100,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  100,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   90,   90,   90,   90,    0,
    0,   90,    0,   90,   90,   90,   90,   90,   90,   90,
   90,    0,    0,    0,    0,    0,    0,    0,    0,   90,
   90,    0,   90,   90,   90,   90,   90,   90,   90,   90,
   90,   90,   90,   90,   90,   90,   90,   90,   90,   90,
    0,    0,    0,    0,    0,   90,   90,   90,   90,   90,
   90,   90,   90,   90,   90,   90,   90,    0,    0,    0,
    0,    0,   90,   90,   90,   90,   90,   90,   90,   90,
   90,   90,   90,    0,    0,   90,   90,   90,   90,    0,
    0,   90,   90,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   90,   90,   90,   90,   90,   90,   90,
   90,   90,    0,    0,    0,   90,   90,   90,   90,   90,
   90,   90,  100,  100,  100,  100,    0,    0,  100,    0,
  100,  100,  100,  100,  100,  100,  100,  100,    0,    0,
    0,    0,    0,    0,    0,    0,  100,  100,    0,  100,
  100,  100,  100,  100,  100,  100,  100,  100,  100,  100,
  100,  100,  100,  100,  100,  100,  100,    0,    0,    0,
    0,    0,  100,  100,  100,  100,  100,  100,  100,  100,
  100,  100,  100,  100,    0,    0,    0,    0,    0,  100,
  100,  100,  100,  100,  100,  100,  100,  100,  100,  100,
    0,    0,  100,  100,  100,  100,  101,    0,  100,  100,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  100,  100,  100,  100,  100,  100,  100,  100,  100,    0,
    0,    0,  100,  100,  100,  100,  100,  100,  100,  101,
    0,    0,    0,    0,    0,    0,  101,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  101,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  101,
    0,    0,  101,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  102,    0,    0,    0,    0,    0,    0,
    0,  101,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  102,    0,    0,    0,
    0,    0,    0,  102,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  102,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  102,    0,    0,  102,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  102,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  101,  101,  101,  101,    0,    0,  101,
    0,  101,  101,  101,  101,  101,  101,  101,  101,    0,
    0,    0,    0,    0,    0,    0,    0,  101,  101,    0,
  101,  101,  101,  101,  101,  101,  101,  101,  101,  101,
  101,  101,  101,  101,  101,  101,  101,  101,    0,    0,
    0,    0,    0,  101,  101,  101,  101,  101,  101,  101,
  101,  101,  101,  101,  101,    0,    0,    0,    0,    0,
  101,  101,  101,  101,  101,  101,  101,  101,  101,  101,
  101,    0,    0,  101,  101,  101,  101,    0,    0,  101,
  101,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  101,  101,  101,  101,  101,  101,  101,  101,  101,
    0,    0,    0,  101,  101,  101,  101,  101,  101,  101,
  102,  102,  102,  102,    0,    0,  102,    0,  102,  102,
  102,  102,  102,  102,  102,  102,    0,    0,    0,    0,
    0,    0,    0,    0,  102,  102,    0,  102,  102,  102,
  102,  102,  102,  102,  102,  102,  102,  102,  102,  102,
  102,  102,  102,  102,  102,    0,    0,    0,    0,    0,
  102,  102,  102,  102,  102,  102,  102,  102,  102,  102,
  102,  102,    0,    0,    0,    0,    0,  102,  102,  102,
  102,  102,  102,  102,  102,  102,  102,  102,    0,    0,
  102,  102,  102,  102,  104,    0,  102,  102,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  102,  102,
  102,  102,  102,  102,  102,  102,  102,    0,    0,    0,
  102,  102,  102,  102,  102,  102,  102,  104,    0,    0,
    0,    0,    0,    0,  104,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  104,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  104,    0,    0,
  104,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  109,    0,    0,    0,    0,    0,    0,    0,  104,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  109,    0,    0,    0,    0,    0,
    0,  109,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  109,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  109,    0,    0,  109,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  109,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  104,  104,  104,  104,    0,    0,  104,    0,  104,
  104,  104,  104,  104,  104,  104,  104,    0,    0,    0,
    0,    0,    0,    0,    0,  104,  104,    0,  104,  104,
  104,  104,  104,  104,  104,  104,  104,  104,  104,  104,
  104,  104,  104,  104,  104,  104,    0,    0,    0,    0,
    0,  104,  104,  104,  104,  104,  104,  104,  104,  104,
  104,  104,  104,    0,    0,    0,    0,    0,  104,  104,
  104,  104,  104,  104,  104,  104,  104,  104,  104,    0,
    0,  104,  104,  104,  104,    0,    0,  104,  104,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  104,
  104,  104,  104,  104,  104,  104,  104,  104,    0,    0,
    0,  104,  104,  104,  104,  104,  104,  104,  109,  109,
  109,  109,    0,    0,  109,    0,  109,  109,  109,  109,
  109,  109,  109,  109,    0,    0,    0,    0,    0,    0,
    0,    0,  109,  109,    0,  109,  109,  109,  109,  109,
  109,  109,  109,  109,  109,  109,  109,  109,  109,  109,
  109,  109,  109,    0,    0,    0,    0,    0,  109,  109,
  109,  109,  109,  109,  109,  109,  109,  109,  109,  109,
    0,    0,    0,    0,    0,  109,  109,  109,  109,  109,
  109,  109,  109,  109,  109,  109,    0,    0,  109,  109,
  109,  109,  111,    0,  109,  109,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  109,  109,  109,  109,
  109,  109,  109,  109,  109,    0,    0,    0,  109,  109,
  109,  109,  109,  109,  109,  111,    0,    0,    0,    0,
    0,    0,  111,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  111,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  111,    0,    0,  111,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  118,
    0,    0,    0,    0,    0,    0,    0,  111,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  118,    0,    0,    0,    0,    0,    0,  118,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  118,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  118,    0,    0,  118,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  118,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  111,
  111,  111,  111,    0,    0,  111,    0,  111,  111,  111,
  111,  111,  111,  111,  111,    0,    0,    0,    0,    0,
    0,    0,    0,  111,  111,    0,  111,  111,  111,  111,
  111,  111,  111,  111,  111,  111,  111,  111,  111,  111,
  111,  111,  111,  111,    0,    0,    0,    0,    0,  111,
  111,  111,  111,  111,  111,  111,  111,  111,  111,  111,
  111,    0,    0,    0,    0,    0,  111,  111,  111,  111,
  111,  111,  111,  111,  111,  111,  111,    0,    0,  111,
  111,  111,  111,    0,    0,  111,  111,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  111,  111,  111,
  111,  111,  111,  111,  111,  111,    0,    0,    0,  111,
  111,  111,  111,  111,  111,  111,  118,  118,  118,  118,
    0,    0,  118,    0,  118,  118,  118,  118,  118,  118,
  118,  118,    0,    0,    0,    0,    0,    0,    0,    0,
  118,  118,    0,  118,  118,  118,  118,  118,  118,  118,
  118,  118,  118,  118,  118,  118,  118,  118,  118,  118,
  118,    0,    0,    0,    0,    0,  118,  118,  118,  118,
  118,  118,  118,  118,  118,  118,  118,  118,    0,    0,
    0,    0,    0,  118,  118,  118,  118,  118,  118,  118,
  118,  118,  118,  118,    0,    0,  118,  118,  118,  118,
  131,    0,  118,  118,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  118,  118,  118,  118,  118,  118,
  118,  118,  118,    0,    0,    0,  118,  118,  118,  118,
  118,  118,  118,  131,    0,    0,    0,    0,    0,    0,
  131,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  131,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  131,    0,    0,  131,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  113,    0,    0,
    0,    0,    0,    0,    0,  131,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  113,    0,    0,    0,    0,    0,    0,  113,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  113,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  113,    0,    0,  113,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  113,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  131,  131,  131,
  131,    0,    0,  131,    0,  131,  131,  131,  131,  131,
  131,  131,  131,    0,    0,    0,    0,    0,    0,    0,
    0,  131,  131,    0,  131,  131,  131,  131,  131,  131,
  131,  131,  131,  131,  131,  131,  131,  131,  131,  131,
  131,  131,    0,    0,    0,    0,    0,  131,  131,  131,
  131,  131,  131,  131,  131,  131,  131,  131,  131,    0,
    0,    0,    0,    0,  131,  131,  131,  131,  131,  131,
  131,  131,  131,  131,  131,    0,    0,  131,  131,  131,
  131,    0,    0,  131,  131,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  131,  131,  131,  131,  131,
  131,  131,  131,  131,    0,    0,    0,  131,  131,  131,
  131,  131,  131,  131,  113,  113,  113,  113,    0,    0,
  113,    0,  113,  113,  113,  113,  113,  113,  113,  113,
    0,    0,    0,    0,    0,    0,    0,    0,  113,  113,
    0,  113,  113,  113,  113,  113,  113,  113,  113,  113,
  113,  113,  113,  113,  113,  113,  113,  113,  113,    0,
    0,    0,    0,    0,  113,  113,  113,  113,  113,  113,
  113,  113,  113,  113,  113,  113,    0,    0,    0,    0,
    0,  113,  113,  113,  113,  113,  113,  113,  113,  113,
  113,  113,    0,    0,  113,  113,  113,  113,  179,    0,
  113,  113,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  113,  113,  113,  113,  113,  113,  113,  113,
  113,    0,    0,    0,  113,  113,  113,  113,  113,  113,
  113,  179,    0,    0,    0,    0,    0,    0,  179,    0,
    0,    0,  179,  179,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  179,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  179,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  154,    0,    0,    0,    0,
    0,    0,    0,  179,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  154,    0,
    0,    0,    0,    0,    0,  154,  154,    0,  154,  154,
  154,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  154,    0,    0,  154,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  154,    0,
    0,  154,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  154,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  179,  179,  179,    0,
    0,    0,    0,  179,  179,  179,    0,  179,  179,  179,
  179,    0,    0,    0,    0,    0,    0,    0,    0,  179,
  179,    0,  179,  179,  179,  179,  179,  179,  179,  179,
  179,  179,  179,  179,  179,  179,  179,  179,  179,  179,
    0,    0,    0,    0,    0,  179,  179,  179,  179,  179,
  179,  179,  179,  179,  179,  179,  179,    0,    0,    0,
    0,    0,  179,  179,  179,  179,  179,  179,  179,  179,
  179,  179,  179,    0,    0,  179,  179,  179,  179,    0,
    0,  179,  179,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  179,  179,  179,  179,  179,  179,  179,
  179,  179,    0,    0,    0,  179,  179,  179,  179,  179,
  179,  179,  154,  154,  154,  154,    0,    0,  154,    0,
  154,  154,  154,  154,  154,  154,  154,  154,    0,    0,
    0,    0,    0,    0,    0,    0,  154,  154,    0,  154,
  154,  154,  154,  154,  154,  154,  154,  154,  154,  154,
  154,  154,  154,  154,  154,  154,  154,  159,    0,    0,
    0,  154,  154,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  154,  154,  154,  154,  154,  154,
  154,  154,  154,  154,  154,  154,  154,  154,  154,  154,
  159,    0,    0,    0,    0,    0,    0,  159,  154,  154,
  159,    0,  159,  159,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  159,    0,    0,    0,
    0,    0,  154,  154,  154,  154,  154,  154,  154,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  159,  180,    0,  159,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  159,    0,  180,    0,    0,    0,    0,    0,
    0,  180,  180,    0,    0,  180,  180,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  180,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  247,    0,    0,    0,  180,    0,    0,  180,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  247,    0,    0,  180,    0,    0,    0,
  247,  247,    0,    0,  247,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  247,
  247,    0,  247,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  159,  159,  159,  159,    0,    0,
  159,    0,  159,  159,  159,  159,  159,  159,  159,  159,
    0,    0,    0,  247,    0,    0,  247,    0,  159,  159,
    0,  159,  159,  159,  159,  159,  159,  159,  159,  159,
  159,  159,  159,  159,  159,  159,  159,  159,  159,    0,
    0,    0,    0,   43,  159,  247,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  159,  159,  159,  159,
  159,  159,  159,  159,  159,  159,  159,  159,  159,  159,
  159,  159,    0,    0,    0,    0,   43,    0,    0,    0,
  159,  159,    0,   43,    0,    0,    0,    0,  180,  180,
  180,  180,    0,    0,  180,    0,  180,  180,  180,  180,
  180,  180,   43,    0,  159,  159,  159,  159,  159,  159,
  159,    0,  180,  180,    0,  180,  180,  180,  180,  180,
  180,  180,  180,  180,  180,  180,  180,  180,  180,  180,
  180,  180,  180,    0,    0,    0,   43,    0,  180,   43,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  180,  180,  180,  180,  180,
  180,  180,  180,  180,  180,  180,    0,    0,   43,    0,
    0,    0,    0,    0,  180,  180,    0,  247,  247,  247,
  247,    0,    0,  247,    0,    0,    0,    0,  247,    0,
    0,  247,  247,    0,    0,    0,   98,    0,  180,  180,
  180,  180,  180,  180,  180,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  247,  247,  247,
  247,  247,  247,  247,  247,  247,  247,  247,  247,    0,
    0,    0,    0,    0,  247,  247,  247,  247,  247,  247,
  247,  247,  247,  247,  247,   98,    0,  247,  247,  247,
  247,    0,    0,    0,    0,    0,    0,    0,    0,  247,
  247,  247,  247,  247,  247,  247,  247,  247,  247,  247,
  247,  247,  247,  247,    0,    0,    0,    0,    0,   98,
    0,    0,    0,  247,    0,    0,    0,    0,    0,    0,
   43,   43,   43,   43,    0,    0,   43,    0,    0,    0,
    0,   43,    0,    0,   43,   43,    0,    0,    0,    0,
    0,   98,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   43,   43,   43,   43,   43,   43,   43,   43,   43,   43,
   43,   43,    0,    0,    0,    0,    0,   43,   43,   43,
   43,   43,   43,   43,   43,   43,   43,   43,   45,    0,
   43,   43,   43,   43,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   43,   43,
   43,   43,   43,   43,   43,   43,   43,    0,    0,    0,
    0,   45,    0,    0,    0,    0,   43,    0,   45,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   45,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   98,    0,    0,    0,
    0,   98,   98,   98,    0,   98,   98,   98,   98,    0,
    0,   45,    0,    0,   45,    0,    0,   98,   98,    0,
   98,   98,   98,   98,   98,   98,   98,   98,   98,   98,
   98,   98,   98,   98,   98,   98,   98,   98,  201,   96,
    0,    0,    0,   45,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   98,
   98,    0,    0,    0,    0,    0,  255,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   96,    0,
    0,    0,    0,   98,   98,   98,   98,   98,   98,   98,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  255,    0,    0,    0,  255,  255,  255,
  255,  255,   96,  255,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  255,  255,    0,  255,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   92,    0,    0,    0,   96,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   45,   45,   45,   45,  255,
    0,   45,    0,    0,    0,    0,   45,    0,    0,   45,
   45,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  255,    0,    0,    0,    0,    0,    0,    0,   92,
    0,    0,    0,    0,   94,   45,   45,   45,   45,   45,
   45,   45,   45,   45,   45,   45,   45,    0,    0,    0,
    0,    0,   45,   45,   45,   45,   45,   45,   45,   45,
   45,   45,   45,   92,    0,   45,   45,   45,   45,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   45,   45,   45,   45,   45,   45,   45,
   45,   45,    0,   94,    0,   92,    0,    0,  108,    0,
    0,   45,    0,    0,    0,    0,    0,    0,    0,   96,
    0,    0,    0,    0,   96,   96,   96,    0,   96,   96,
   96,   96,    0,    0,    0,    0,    0,   94,    0,    0,
   96,   96,    0,   96,   96,   96,   96,   96,   96,   96,
   96,   96,   96,   96,   96,   96,   96,   96,   96,   96,
   96,  202,    0,    0,    0,    0,    0,  108,    0,   94,
  255,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  255,    0,    0,
    0,  108,   96,   96,    0,    0,    0,    0,  255,    0,
    0,  255,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   96,   96,   96,   96,
   96,   96,   96,  108,  110,    0,    0,    0,    0,    0,
   92,    0,    0,    0,    0,   92,   92,   92,    0,   92,
   92,   92,   92,    0,    0,  255,  255,  255,  255,  255,
  255,   92,   92,    0,   92,   92,   92,   92,   92,   92,
   92,   92,   92,   92,   92,   92,   92,   92,   92,   92,
   92,   92,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  110,    0,    0,    0,    0,  117,    0,
    0,    0,    0,    0,   94,    0,    0,    0,    0,   94,
   94,   94,    0,   94,   94,   94,   94,    0,    0,    0,
    0,    0,    0,   92,   92,   94,   94,  110,   94,   94,
   94,   94,   94,   94,   94,   94,   94,   94,   94,   94,
   94,   94,   94,   94,   94,   94,    0,   92,   92,   92,
   92,   92,   92,   92,    0,    0,    0,  117,    0,  110,
    0,    0,  112,    0,    0,    0,    0,    0,  108,    0,
    0,    0,    0,  108,  108,  108,    0,  108,  108,  108,
  108,    0,    0,    0,    0,    0,    0,   94,   94,  108,
  108,  117,  108,  108,  108,  108,  108,  108,  108,  108,
  108,  108,  108,  108,  108,  108,  108,  108,  108,  108,
    0,   94,   94,   94,   94,   94,   94,   94,    0,    0,
    0,  112,    0,  117,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  108,  108,    0,    0,  112,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  108,  108,  108,  108,  108,
  108,  108,    0,    0,    0,    0,    0,  112,    0,    0,
    0,    0,    0,    0,  110,    0,    0,    0,    0,  110,
  110,  110,    0,  110,  110,  110,  110,    0,    0,    0,
    0,    0,    0,    0,    0,  110,  110,    0,  110,  110,
  110,  110,  110,  110,  110,  110,  110,  110,  110,  110,
  110,  110,  110,  110,  110,  110,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  117,    0,
    0,    0,    0,  117,  117,  117,    0,  117,  117,  117,
  117,    0,    0,    0,    0,    0,    0,  110,  110,  117,
  117,    0,  117,  117,  117,  117,  117,  117,  117,  117,
  117,  117,  117,  117,  117,  117,  117,  117,  117,  117,
    0,  110,  110,  110,  110,  110,  110,  110,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  112,    0,    0,    0,    0,  112,  112,  112,
    0,  112,  112,  112,  112,    0,    0,    0,    0,    0,
    0,  117,  117,  112,  112,   83,  112,  112,  112,  112,
  112,  112,  112,  112,  112,  112,  112,  112,  112,  112,
  112,  112,  112,  112,    0,  117,  117,  117,  117,  117,
  117,  117,    0,    0,    0,    0,    0,    0,   83,    0,
    0,    0,    0,    0,    0,   83,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   83,  112,  112,    0,    0,    0,
    0,    0,    0,    0,    0,  159,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  112,
  112,  112,  112,  112,  112,  112,    0,    0,   83,    0,
    0,   83,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  159,    0,
  159,  159,    0,    0,    0,    0,    0,    0,    0,    0,
   83,    0,    0,    0,  159,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  159,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  159,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   95,    0,    0,    0,    0,    0,    0,   92,    0,    0,
    0,    0,   94,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   83,   83,   83,    0,    0,    0,   83,    0,
   83,   83,   83,   83,   83,   83,   83,   83,   32,    0,
    0,    0,    0,   93,    0,    0,   83,   83,    0,   83,
   83,   83,   83,   83,   83,   83,   83,   83,   83,   83,
   83,   83,   83,   83,   83,   83,   83,    0,    0,    0,
   33,    0,   83,   83,   83,   83,   83,   83,   83,   83,
   83,   83,   83,   83,    0,    0,    0,    0,    0,   83,
   83,   83,   83,   83,   83,   83,   83,   83,   83,   83,
    0,    0,   83,   83,   83,   83,  159,  159,   83,   83,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   83,   83,   83,   83,   83,   83,   83,   83,   83,    0,
    0,    0,   83,   83,   83,   83,   83,   83,    0,    0,
    0,    0,    0,  159,  159,  159,  159,  159,  159,  159,
  159,  159,  159,  159,  159,  159,  159,  159,  159,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  159,  159,  159,  159,    6,    0,    0,    0,
    0,    0,    0,    6,    0,    0,    0,    0,    6,    0,
  159,  159,  159,  159,  159,  159,  159,  159,  159,    0,
    0,    0,    0,    0,  295,  296,   51,    8,    9,    0,
   52,    0,    0,    0,    0,   53,   10,   11,  297,  298,
   14,   15,   16,   17,   18,   19,   20,   21,    0,    0,
   22,    0,    0,    0,    6,    0,    0,    0,    0,    6,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   56,   57,   58,   59,   60,   61,
   62,   63,   64,   65,   66,   67,    6,    0,    0,    0,
    0,   68,   69,   70,   71,   72,   73,   74,   75,   76,
   77,   78,   23,    0,   79,   80,   81,   82,   24,   25,
    0,    0,   26,    0,   27,    0,    0,    0,    0,    0,
    0,    0,   83,   84,   85,   86,   87,   88,   89,   90,
   91,   28,   95,   29,    0,    0,    0,    0,    0,  110,
   30,   31,    0,    0,   94,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   93,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    6,    6,    6,    6,    6,    0,    6,    0,    0,    0,
    0,    6,    6,    6,    6,    6,    6,    6,    6,    6,
    6,    6,    6,    6,    0,    0,    6,    0,    0,  111,
    0,    0,    0,    0,    0,    0,  110,  315,    0,    0,
    0,   94,    0,    0,    0,    0,    0,    0,    0,    0,
    6,    6,    6,    6,    6,    6,    6,    6,    6,    6,
    6,    6,    0,    0,    0,    0,    0,    6,    6,    6,
    6,    6,    6,    6,    6,    6,    6,    6,    6,    0,
    6,    6,    6,    6,    6,    6,    0,    0,    6,    0,
    6,    0,   93,    0,    0,    0,    0,    0,    6,    6,
    6,    6,    6,    6,    6,    6,    6,    6,    0,    6,
    0,    0,    0,    0,    0,    0,    6,    6,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   49,   50,   51,    8,
    0,    0,   52,    0,  126,  127,  128,   53,  129,  130,
  131,  132,    0,    0,    0,    0,    0,    0,    0,    0,
  133,  134,    0,  135,  136,  137,  138,  139,  140,  141,
  142,  143,  144,  145,  146,  147,  148,  149,  150,  151,
  152,    0,    0,    0,    0,    0,   56,   57,   58,   59,
   60,   61,   62,   63,   64,   65,   66,   67,    0,    0,
    0,    0,    0,   68,   69,   70,   71,   72,   73,   74,
   75,   76,   77,   78,  111,    0,   79,   80,   81,   82,
    0,   92,  153,  154,    0,    0,   94,  276,    0,    0,
    0,    0,    0,    0,   83,   84,   85,   86,   87,   88,
   89,   90,   91,    0,    0,    0,  155,  156,  157,  158,
  159,  160,   30,   49,   50,   51,    8,    0,    0,   52,
    0,    0,    0,    0,   53,    0,    0,   54,   55,    0,
    0,    0,    0,    0,    0,    0,    0,   93,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   56,   57,   58,   59,   60,   61,   62,
   63,   64,   65,   66,   67,    0,    0,    0,    0,    0,
   68,   69,   70,   71,   72,   73,   74,   75,   76,   77,
   78,   95,    0,   79,   80,   81,   82,    0,   92,    0,
    0,    0,    0,   94,    0,    0,    0,    0,    0,    0,
    0,   83,   84,   85,   86,   87,   88,   89,   90,   91,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   30,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   93,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   49,   50,
   51,    8,    0,    0,   52,    0,    0,    0,    0,   53,
    0,    0,   54,   55,  111,    0,    0,    0,    0,    0,
    0,  110,    0,    0,    0,    0,   94,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   56,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,    0,    0,   68,   69,   70,   71,   72,
   73,   74,   75,   76,   77,   78,    0,   93,   79,   80,
   81,   82,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   30,   49,   50,   51,    8,    0,
    0,   52,    0,    0,    0,    0,   53,    0,    0,   54,
   55,  111,    0,    0,    0,    0,    0,    0,   92,    0,
    0,    0,    0,   94,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   56,   57,   58,   59,   60,
   61,   62,   63,   64,   65,   66,   67,    0,    0,    0,
    0,    0,   68,   69,   70,   71,   72,   73,   74,   75,
   76,   77,   78,    0,   93,   79,   80,   81,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   83,   84,   85,   86,   87,   88,   89,
   90,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   30,    0,    0,    0,    0,    0,    0,   49,   50,
   51,    8,    0,    0,   52,    0,    0,    0,    0,   53,
    0,    0,   54,   55,  111,    0,    0,    0,    0,    0,
    0,  283,    0,    0,    0,    0,   94,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   56,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,    0,    0,   68,   69,   70,   71,   72,
   73,   74,   75,   76,   77,   78,    0,   93,   79,   80,
   81,   82,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   30,   49,   50,   51,    8,    0,
    0,   52,    0,    0,    0,    0,   53,    0,    0,   54,
   55,   95,    0,    0,    0,    0,    0,    0,  277,    0,
    0,    0,    0,   94,  276,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   56,   57,   58,   59,   60,
   61,   62,   63,   64,   65,   66,   67,    0,    0,    0,
    0,    0,   68,   69,   70,   71,   72,   73,   74,   75,
   76,   77,   78,    0,   93,   79,   80,   81,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   83,   84,   85,   86,   87,   88,   89,
   90,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   30,    0,    0,    0,    0,    0,    0,   49,   50,
   51,    8,    0,    0,   52,    0,    0,    0,    0,   53,
    0,    0,   54,   55,   95,    0,    0,    0,    0,    0,
    0,  110,    0,  442,    0,    0,   94,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   56,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,    0,    0,   68,   69,   70,   71,   72,
   73,   74,   75,   76,   77,   78,    0,   93,   79,   80,
   81,   82,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   30,  273,   50,   51,    0,    0,
    0,  274,    0,    0,    0,    0,  275,    0,    0,   54,
   55,   95,    0,    0,    0,    0,    0,    0,  110,    0,
    0,    0,    0,   94,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   56,   57,   58,   59,   60,
   61,   62,   63,   64,   65,   66,   67,    0,    0,    0,
    0,    0,   68,   69,   70,   71,   72,   73,   74,   75,
   76,   77,   78,    0,   93,   79,   80,   81,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   83,   84,   85,   86,   87,   88,   89,
   90,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   49,   50,
   51,    0,    0,    0,   52,    0,    0,    0,    0,   53,
    0,    0,   54,   55,   95,    0,    0,    0,    0,    0,
    0,   92,    0,    0,    0,    0,   94,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   56,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,    0,    0,   68,   69,   70,   71,   72,
   73,   74,   75,   76,   77,   78,    0,   93,   79,   80,
   81,   82,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   49,   50,   51,    0,    0,
    0,   52,    0,    0,    0,    0,   53,    0,    0,   54,
   55,   95,    0,    0,    0,    0,    0,    0,  283,    0,
    0,    0,    0,   94,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   56,   57,   58,   59,   60,
   61,   62,   63,   64,   65,   66,   67,    0,    0,    0,
    0,    0,   68,   69,   70,   71,   72,   73,   74,   75,
   76,   77,   78,    0,   93,   79,   80,   81,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   83,   84,   85,   86,   87,   88,   89,
   90,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   49,   50,
   51,    0,    0,    0,   52,    0,    0,    0,    0,   53,
    0,    0,   54,   55,   95,    0,    0,    0,    0,    0,
    0,  110,    0,    0,    0,    0,   94,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   56,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,    0,    0,   68,   69,   70,   71,   72,
   73,   74,   75,   76,   77,   78,    0,   93,   79,   80,
   81,   82,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   49,   50,   51,    0,    0,
    0,   52,    0,    0,    0,    0,   53,    0,    0,   54,
   55,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   41,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   56,   57,   58,   59,   60,
   61,   62,   63,   64,   65,   66,   67,    0,    0,   32,
    0,    0,   68,   69,   70,   71,   72,   73,   74,   75,
   76,   77,   78,    0,    0,   79,   80,   81,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   33,    0,   83,   84,   85,   86,   87,   88,   89,
   90,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   49,   50,
   51,    0,    0,    0,   52,    0,    0,    0,    0,   53,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   56,   57,
   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,
    0,    0,    0,    0,    0,   68,   69,   70,   71,   72,
   73,   74,   75,   76,   77,   78,    0,    0,   79,   80,
   81,   82,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,   85,   86,
   87,   88,   89,   90,   91,    6,    7,    0,    8,    9,
    0,    0,    0,    0,    0,    0,    0,   10,   11,   12,
   13,   14,   15,   16,   17,   18,   19,   20,   21,    0,
    0,   22,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   23,    0,    0,    0,    0,    0,   24,
   25,    0,    0,   26,    0,   27,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   28,    0,   29,    0,    0,    0,    0,    0,
    0,   30,   31,
};
static const YYINT yycheck[] = {                         25,
   59,   44,   37,   29,    0,   31,  111,   42,   43,   44,
   45,   37,   47,   92,   37,   59,  125,  260,  100,   42,
   43,    0,   45,    0,   47,   60,   43,   62,   45,   41,
    0,  260,    0,    0,  273,   37,   58,   60,  277,   62,
   42,   43,   37,   45,   96,   47,  260,   42,   43,   43,
   45,   45,   47,    4,  268,   58,  165,   36,   61,   94,
  105,   41,  141,   42,   44,   60,   92,   62,   94,   95,
  107,   94,   41,   41,   25,   44,   44,  271,  272,   61,
   31,  107,   59,  120,  258,  111,   37,   96,   43,   59,
   45,   59,   94,  336,  120,   91,  257,  258,   43,   94,
   45,    0,  258,  129,  130,  131,  132,  133,  134,  135,
  136,  137,  138,  139,  140,  141,   93,   62,  144,  145,
  146,  349,  350,   93,   40,   93,   93,  123,   25,  155,
  156,  370,  371,  348,   31,    0,   61,  219,    0,  165,
  336,  246,  247,  262,  373,  250,  251,   40,  125,  228,
  229,  271,  272,  351,  352,  125,  107,  125,  125,   40,
   59,  355,  356,  121,  122,  404,   40,  118,  407,  120,
   61,   41,   40,   43,  125,   45,   40,  203,  204,  205,
  206,  207,  208,  209,  210,  211,  212,  213,  214,  215,
  216,  217,  218,   40,   93,   92,  278,   59,  277,    0,
   40,   40,  228,  229,  283,  257,  157,  158,  159,  260,
  107,  263,   40,   40,  165,  258,  268,  243,   40,  291,
  246,  247,  248,  120,  250,  251,  125,  258,   93,  274,
  275,   93,   33,  262,   41,  355,  356,  260,   41,   40,
  137,  138,  139,  140,   45,  324,  325,   43,  257,   45,
  302,  277,   94,  264,  263,  303,   46,  283,  257,  268,
  125,  257,  258,  125,  260,  261,   62,  302,  165,   93,
  305,  125,   93,  269,  270,  271,  272,  273,  274,  275,
  276,  277,  278,  279,  280,  257,  262,  283,  262,  306,
   91,   41,  318,  319,  403,   96,  264,  323,  324,  325,
  302,  252,  253,  305,   41,   44,  257,  319,  320,  321,
  322,  323,  306,  210,  349,  350,  351,  352,  353,  354,
    0,  218,  123,  291,  369,    0,  349,  350,  351,  352,
  353,  354,   41,   41,  302,   41,   41,  305,   43,  335,
   45,   43,   44,   45,   44,  341,  342,   44,   41,  345,
  373,  347,   41,   41,  349,    0,  351,  352,  353,  354,
  304,    0,  349,   43,  262,   45,   41,   44,  364,   44,
  366,  397,  398,  399,  257,  401,  365,  373,  374,   59,
  277,  349,  350,  305,   59,   43,   44,   45,   33,  415,
  416,   41,   37,   41,  260,   40,   41,   42,   43,   44,
   45,   41,   47,   41,   43,   41,   45,   41,   91,  346,
   41,  437,  262,   93,   59,   60,  442,   62,   93,   91,
   59,  318,  319,    0,   37,   41,  323,   27,  260,   42,
   37,   43,   44,   45,   47,   42,   43,  346,   45,   44,
   47,  346,  346,   43,  165,  125,  409,   31,   93,   36,
  125,   96,  403,   60,   93,   62,  257,  258,  259,  260,
  261,  193,  263,   43,   44,   45,   -1,  268,  269,  270,
  271,  272,  273,  274,  275,  276,  277,  278,  279,  280,
  125,   94,  283,   43,   44,   45,  125,   94,  319,  320,
  321,  322,  323,   93,   43,   44,   45,   43,   44,   45,
  397,  398,   43,   44,   45,   -1,  307,  308,  309,  310,
  311,  312,  313,  314,  315,  316,  317,  318,  415,  416,
   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,  330,
  331,  332,  333,  334,  335,   -1,  337,  338,  339,  340,
  341,  342,   37,   -1,  345,   -1,  347,   42,   43,   -1,
   45,   -1,   47,   -1,  355,  356,  357,  358,  359,  360,
  361,  362,  363,  364,   -1,  366,   -1,  167,   -1,   -1,
   46,   -1,  373,  374,  174,  175,  176,  177,  178,  179,
  180,  181,  182,  183,  184,   91,   -1,   -1,  260,  264,
  273,  274,  275,  276,  277,  278,  268,  280,   -1,   94,
   -1,  273,  274,  275,  276,  277,  278,   -1,  280,   -1,
   -1,   -1,  257,  258,  259,  260,  291,   -1,  263,  264,
  265,  266,  267,  268,  269,  270,  271,  272,   -1,   -1,
   46,   -1,   -1,   -1,   -1,   -1,  281,  282,    0,  284,
  285,  286,  287,  288,  289,  290,  291,  292,  293,  294,
  295,  296,  297,  298,  299,  300,  301,  302,   -1,   -1,
  305,  306,  307,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,  349,  350,   -1,   -1,   -1,  324,
  325,  326,  327,  328,  329,  330,  331,  332,  333,  334,
    0,    0,  337,  338,  339,  340,    0,   59,  343,  344,
    0,  346,   -1,   -1,  349,  350,  351,  352,  353,  354,
  355,  356,  357,  358,  359,  360,  361,  362,  363,    0,
   -1,   -1,  367,  368,  369,  370,  371,  372,  373,   33,
   -1,   93,   -1,   37,   -1,   -1,   40,   41,   42,   43,
   44,   45,  349,   47,  351,  352,  353,  354,   -1,   59,
   59,   -1,   -1,   -1,  260,   59,   60,   -1,   62,   59,
   -1,   -1,   -1,  125,   -1,   -1,   -1,  273,  274,  275,
  276,  277,  278,   -1,  280,   -1,   -1,   -1,   59,   -1,
   -1,   -1,  382,   93,   93,   -1,  386,  387,   -1,   93,
   -1,   -1,   96,   93,   -1,  271,  272,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   93,    0,   -1,  125,  125,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,
   -1,   -1,  308,  309,  310,  311,  312,  313,  314,  315,
  316,  317,  318,   -1,  125,   -1,   33,   -1,   -1,   -1,
   37,   -1,   -1,   40,   41,   42,   43,   44,   45,   -1,
   47,  337,  338,  339,  340,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   59,   60,   -1,   62,   -1,   -1,   -1,  355,
  356,  357,  358,  359,  360,  361,  362,  363,   -1,   -1,
   -1,   -1,  308,  309,  310,  311,  312,  313,  314,  315,
  316,  317,  318,   -1,   -1,   -1,   93,   -1,   -1,   96,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  337,  338,  339,  340,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,  355,
  356,  357,  358,  359,  360,  361,  362,  363,   -1,   -1,
   -1,   -1,   -1,  257,  258,  259,  260,   -1,   -1,  263,
  264,  265,  266,  267,  268,  269,  270,  271,  272,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,
  284,  285,  286,  287,  288,  289,  290,  291,  292,  293,
  294,  295,  296,  297,  298,  299,  300,  301,  302,   -1,
   -1,  305,  306,  307,  308,  309,  310,  311,  312,  313,
  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,
  324,  325,  326,  327,  328,  329,  330,  331,  332,  333,
  334,   46,   -1,  337,  338,  339,  340,   -1,   -1,  343,
  344,   -1,  346,   -1,   -1,  349,  350,  351,  352,  353,
  354,  355,  356,  357,  358,  359,  360,  361,  362,  363,
   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,  373,
  257,  258,  259,  260,   -1,   -1,  263,  264,  265,  266,
  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,
  287,  288,  289,  290,  291,  292,  293,  294,  295,  296,
  297,  298,  299,  300,  301,  302,   -1,   -1,  305,  306,
  307,  308,  309,  310,  311,  312,  313,  314,  315,  316,
  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,   -1,   -1,
  337,  338,  339,  340,    0,   -1,  343,  344,   -1,  346,
   -1,   -1,  349,  350,  351,  352,  353,  354,  355,  356,
  357,  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,
  367,  368,  369,  370,  371,  372,  373,   33,   -1,   -1,
   -1,   37,   -1,   -1,   40,   41,   42,   43,   44,   45,
   -1,   47,   37,   -1,   -1,   -1,   -1,   42,   43,   -1,
   45,   -1,   47,   59,   60,   -1,   62,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   60,   -1,   62,   -1,   -1,
   37,   -1,   -1,   -1,   -1,   42,   43,   -1,   45,   -1,
   47,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,
   96,   -1,   -1,   60,   -1,   62,  271,  272,   -1,   94,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   94,   -1,   -1,
   -1,   -1,   -1,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,   33,   -1,   -1,   -1,   37,   -1,
   -1,   40,   41,   42,   43,   44,   45,   -1,   47,   -1,
   -1,   -1,  337,  338,  339,  340,   -1,   -1,   -1,   -1,
   59,   60,   -1,   62,   -1,   -1,   -1,   -1,   -1,   -1,
  355,  356,  357,  358,  359,  360,  361,  362,  363,   -1,
   -1,   37,   -1,   -1,   -1,   -1,   42,   43,   44,   45,
   -1,   47,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,
   -1,   -1,   37,   -1,   60,   -1,   62,   42,   43,   44,
   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   60,  125,   62,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   94,   -1,
   -1,  257,  258,  259,  260,   -1,   -1,  263,  264,  265,
  266,  267,  268,  269,  270,  271,  272,   -1,   -1,   94,
   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,
  286,  287,  288,  289,  290,  291,  292,  293,  294,  295,
  296,  297,  298,  299,  300,  301,  302,   -1,   -1,  305,
  306,  307,  308,  309,  310,  311,  312,  313,  314,  315,
  316,  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,
  326,  327,  328,  329,  330,  331,  332,  333,  334,   -1,
   -1,  337,  338,  339,  340,   -1,   -1,  343,  344,   -1,
  346,   -1,   -1,  349,  350,  351,  352,  353,  354,  355,
  356,  357,  358,  359,  360,  361,  362,  363,  353,  354,
   -1,  367,  368,  369,  370,  371,  372,  373,  257,  258,
  259,  260,   -1,   -1,  263,  264,  265,  266,  267,  268,
  269,  270,  271,  272,  351,  352,  353,  354,   -1,   -1,
   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,  288,
  289,  290,  291,  292,  293,  294,  295,  296,  297,  298,
  299,  300,  301,  302,   -1,   -1,  305,  306,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   -1,  337,  338,
  339,  340,    0,   -1,  343,  344,  302,  346,   -1,  305,
  349,  350,  351,  352,  353,  354,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,
  369,  370,  371,  372,  373,   33,   -1,   -1,   -1,   37,
   -1,   -1,   40,   41,   42,   43,   44,   45,   -1,   47,
   -1,   -1,   -1,  349,  350,  351,  352,  353,  354,   -1,
   -1,   59,   60,   -1,   62,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  349,  350,  351,  352,  353,  354,
   -1,   -1,   37,   -1,   -1,   -1,   -1,   42,   43,   44,
   45,   -1,   47,   -1,   -1,   93,   -1,   -1,   96,   -1,
   -1,   -1,    0,   -1,   -1,   60,   -1,   62,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   94,
   -1,   -1,   -1,   41,   -1,   -1,   44,   -1,   -1,   -1,
   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,
   41,   59,   43,   44,   45,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   60,
   -1,   62,   37,   -1,   -1,   -1,   -1,   42,   43,   44,
   45,   -1,   47,   -1,   37,   93,   -1,   -1,   -1,   42,
   43,   -1,   45,   -1,   47,   60,   -1,   62,   -1,   -1,
   -1,   -1,   93,   -1,   -1,   96,   -1,   60,   37,   62,
   -1,   -1,   -1,   42,   43,   -1,   45,  125,   47,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   94,
   -1,   60,   -1,   62,  125,   -1,   -1,   -1,   -1,   -1,
   -1,   94,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,
  258,  259,  260,   -1,   -1,  263,  264,  265,  266,  267,
  268,  269,  270,  271,  272,   94,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,
  288,  289,  290,  291,  292,  293,  294,  295,  296,  297,
  298,  299,  300,  301,  302,   -1,   -1,  305,  306,  307,
  308,  309,  310,  311,  312,  313,  314,  315,  316,  317,
  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,
  328,  329,  330,  331,  332,  333,  334,   -1,   -1,  337,
  338,  339,  340,  102,   -1,  343,  344,  302,  346,   -1,
  305,  349,  350,  351,  352,  353,  354,  355,  356,  357,
  358,  359,  360,  361,  362,  363,  264,   -1,   -1,  367,
  368,  369,  370,  371,  372,  373,  257,  258,  259,  260,
   -1,  140,  263,  264,  265,  266,  267,  268,  269,  270,
  271,  272,   -1,  291,  349,  350,  351,  352,  353,  354,
  281,  282,   -1,  284,  285,  286,  287,  288,  289,  290,
  291,  292,  293,  294,  295,  296,  297,  298,  299,  300,
  301,  302,   -1,   -1,  305,  306,  307,  308,  309,  310,
  311,  312,  313,  314,  315,  316,  317,  318,   -1,   -1,
   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,  330,
  331,  332,  333,  334,   -1,   -1,  337,  338,  339,  340,
    0,   -1,  343,  344,   -1,  346,   -1,   -1,  349,  350,
  351,  352,  353,  354,  355,  356,  357,  358,  359,  360,
  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,
  371,  372,  373,   33,  349,  350,  351,  352,  353,  354,
   40,   41,   -1,   43,   44,   45,  349,  350,  351,  352,
  353,  354,   -1,   -1,  273,   -1,   -1,   -1,  277,   59,
   60,  280,   62,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  349,  350,  351,  352,  353,  354,   -1,   -1,   -1,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,
    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  125,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,
   -1,   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,
   33,  370,  371,   -1,   -1,   -1,   -1,   40,   41,   59,
   -1,   44,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,   60,   -1,   62,
   -1,   -1,   -1,   -1,   -1,  404,   -1,   -1,  407,   -1,
   -1,   -1,   -1,   93,   -1,   -1,   -1,   -1,   -1,   37,
   -1,   -1,   -1,   -1,   42,   43,   -1,   45,   -1,   47,
   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   60,   -1,   62,  125,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   94,  257,  258,  259,
  260,   -1,   -1,  263,  264,  265,  266,  267,  268,  269,
  270,  271,  272,   -1,   92,   -1,   -1,   -1,   -1,   -1,
   -1,  281,  282,   -1,  284,  285,  286,  287,  288,  289,
  290,  291,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,  302,   -1,   -1,  305,  306,  307,  308,  309,
  310,  311,  312,  313,  314,  315,  316,  317,  318,  137,
  138,  139,  140,   -1,  324,  325,  326,  327,  328,  329,
  330,  331,  332,  333,  334,   -1,   -1,  337,  338,  339,
  340,   -1,   -1,  343,  344,   -1,  346,  165,   -1,  349,
  350,  351,  352,  353,  354,  355,  356,  357,  358,  359,
  360,  361,  362,  363,  264,   -1,   -1,  367,  368,  369,
  370,  371,  372,  373,  257,  258,  259,  260,   -1,   -1,
  263,  264,  265,  266,  267,  268,  269,  270,  271,  272,
   -1,  291,  210,   -1,   -1,   -1,   -1,   -1,  281,  282,
  218,  284,  285,  286,  287,  288,  289,  290,  291,  292,
  293,  294,  295,  296,  297,  298,  299,  300,  301,  302,
   -1,   -1,  305,  306,  307,  308,  309,  310,  311,  312,
  313,  314,  315,  316,  317,  318,    0,   -1,   -1,   -1,
   -1,  324,  325,  326,  327,  328,  329,  330,  331,  332,
  333,  334,  290,   -1,  337,  338,  339,  340,    0,  277,
  343,  344,   -1,  346,   -1,   -1,  349,  350,  351,  352,
  353,  354,  355,  356,  357,  358,  359,  360,  361,  362,
  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,
  373,   33,   -1,   -1,   -1,   59,   -1,   -1,   40,   41,
  318,  319,   44,   -1,   -1,  323,   -1,   -1,   -1,   -1,
   -1,  349,  350,  351,  352,  353,  354,   59,   60,   -1,
   62,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,
   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,  397,
  398,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  415,  416,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   33,   -1,
   -1,   -1,   -1,   -1,   -1,   40,   41,   -1,   -1,   44,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   59,   60,   -1,   62,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  257,   -1,   -1,   -1,   -1,   -1,  263,
  125,   -1,   -1,   -1,  268,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  257,  258,  259,  260,   -1,
   -1,  263,  264,  265,  266,  267,  268,  269,  270,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  302,  281,
  282,   -1,  284,  285,  286,  287,  288,  289,  290,  291,
  292,  293,  294,  295,  296,  297,  298,  299,  300,  301,
  302,   -1,   -1,  305,  306,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   -1,  337,  338,  339,  340,   -1,
   -1,  343,  344,   -1,  346,   -1,   -1,  349,  350,  351,
  352,  353,  354,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,
  372,  373,  257,  258,  259,  260,   -1,   -1,  263,  264,
  265,  266,  267,  268,  269,  270,  271,  272,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,
  285,  286,  287,  288,  289,  290,  291,  292,  293,  294,
  295,  296,  297,  298,  299,  300,  301,  302,   -1,   -1,
  305,  306,  307,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,    0,   -1,   -1,   -1,   -1,  324,
  325,  326,  327,  328,  329,  330,  331,  332,  333,  334,
   -1,   -1,  337,  338,  339,  340,    0,   -1,  343,  344,
   -1,  346,   -1,   -1,  349,  350,  351,  352,  353,  354,
  355,  356,  357,  358,  359,  360,  361,  362,  363,   -1,
   -1,   -1,  367,  368,  369,  370,  371,  372,  373,   33,
   -1,   -1,   -1,   59,   -1,   -1,   40,   41,   -1,   -1,
   44,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   59,   60,   -1,   62,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,
   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,
   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,  125,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   33,   -1,   -1,   -1,
   -1,   -1,   -1,   40,   41,   -1,   43,   44,   45,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   41,   -1,
   -1,   44,   59,   -1,   -1,   62,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,
   -1,   -1,   -1,   -1,   -1,   -1,   37,   -1,   -1,   -1,
   93,   42,   43,   -1,   45,   -1,   47,   -1,   -1,   -1,
   -1,  257,   -1,   -1,   -1,   -1,   -1,  263,  125,   60,
   -1,   62,  268,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  125,  257,  258,  259,  260,   -1,   -1,  263,
  264,  265,  266,  267,  268,  269,  270,  271,  272,   -1,
   -1,   -1,   -1,   94,   -1,   -1,  302,  281,  282,   -1,
  284,  285,  286,  287,  288,  289,  290,  291,  292,  293,
  294,  295,  296,  297,  298,  299,  300,  301,  302,   -1,
   -1,  305,  306,  307,  308,  309,  310,  311,  312,  313,
  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,
  324,  325,  326,  327,  328,  329,  330,  331,  332,  333,
  334,   -1,   -1,  337,  338,  339,  340,   -1,   -1,  343,
  344,   -1,  346,   -1,   -1,  349,  350,  351,  352,  353,
  354,  355,  356,  357,  358,  359,  360,  361,  362,  363,
   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,  373,
  257,  258,  259,  260,   -1,   -1,  263,   -1,  265,  266,
  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,
   -1,  264,   -1,   -1,  281,  282,   -1,  284,  285,  286,
  287,  288,  289,  290,  291,  292,  293,  294,  295,  296,
  297,  298,  299,  300,  301,   -1,   -1,   -1,  291,  306,
  307,  308,  309,  310,  311,  312,  313,  314,  315,  316,
  317,  318,  319,  320,  321,  322,  323,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,   -1,   -1,
  337,  338,  339,  340,    0,   -1,  343,  344,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  287,   -1,  355,  356,
  357,  358,  359,  360,  361,  362,  363,  350,   -1,   -1,
  367,  368,  369,  370,  371,  372,  373,   33,   -1,   -1,
   -1,   -1,   -1,   -1,   40,   41,   -1,   -1,   44,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  349,  350,
  351,  352,  353,  354,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,
   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  257,  258,  259,  260,   -1,   -1,  263,  264,  265,
  266,  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,
  286,  287,  288,  289,  290,  291,  292,  293,  294,  295,
  296,  297,  298,  299,  300,  301,  302,   -1,   -1,  305,
  306,  307,  308,  309,  310,  311,  312,  313,  314,  315,
  316,  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,
  326,  327,  328,  329,  330,  331,  332,  333,  334,   -1,
   -1,  337,  338,  339,  340,   -1,   -1,  343,  344,   -1,
  346,   -1,   -1,  349,  350,  351,  352,   -1,   -1,  355,
  356,  357,  358,  359,  360,  361,  362,  363,   -1,   -1,
   -1,  367,  368,  369,  370,  371,  372,  373,  257,  258,
  259,  260,   -1,   -1,  263,  264,  265,  266,  267,  268,
  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,  288,
  289,  290,  291,  292,  293,  294,  295,  296,  297,  298,
  299,  300,  301,  302,   -1,   -1,  305,  306,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   -1,  337,  338,
  339,  340,    0,   -1,  343,  344,   -1,  346,   -1,   -1,
  349,  350,  351,  352,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,
  369,  370,  371,  372,  373,   33,   -1,   -1,   -1,   -1,
   -1,   -1,   40,   41,   -1,   43,   44,   45,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   59,   -1,   -1,   62,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,
   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,
   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,
   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,
   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,
   -1,   -1,   93,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   93,   -1,  125,   96,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,
  258,  259,  260,   -1,   -1,  263,   -1,  265,  266,  267,
  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,
  288,  289,  290,  291,  292,  293,  294,  295,  296,  297,
  298,  299,  300,  301,   -1,   -1,   -1,   -1,  306,  307,
  308,  309,  310,  311,  312,  313,  314,  315,  316,  317,
  318,  319,  320,  321,  322,  323,  324,  325,  326,  327,
  328,  329,  330,  331,  332,  333,  334,   -1,   -1,  337,
  338,  339,  340,   -1,   -1,  343,  344,   -1,   -1,   -1,
   -1,   -1,   -1,  264,   -1,   -1,   -1,  355,  356,  357,
  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,
  368,  369,  370,  371,  372,  373,  257,  258,  259,  260,
  291,   -1,  263,  264,  265,  266,  267,  268,  269,  270,
  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  281,  282,   -1,  284,  285,  286,  287,  288,  289,  290,
  291,  292,  293,  294,  295,  296,  297,  298,  299,  300,
  301,  302,   -1,   -1,  305,  306,  307,  308,  309,  310,
  311,  312,  313,  314,  315,  316,  317,  318,   -1,  350,
   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,  330,
  331,  332,  333,  334,   -1,   -1,  337,  338,  339,  340,
    0,   -1,  343,  344,   -1,  346,   -1,   -1,  349,  350,
   -1,   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,
  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,
  371,  372,  373,   33,   -1,   -1,   -1,   -1,   -1,   -1,
   40,   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
    0,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,
   -1,   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   41,   -1,
   43,   44,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,   62,
   -1,   -1,   -1,   93,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   93,   -1,   -1,   96,   -1,  125,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,  259,
  260,   -1,   -1,  263,  264,  265,  266,  267,  268,  269,
  270,  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  281,  282,   -1,  284,  285,  286,  287,  288,  289,
  290,  291,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,  302,   -1,   -1,  305,  306,  307,  308,  309,
  310,  311,  312,  313,  314,  315,  316,  317,  318,   -1,
   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,
  330,  331,  332,  333,  334,   -1,   -1,  337,  338,  339,
  340,   -1,   -1,  343,  344,   -1,  346,   -1,   -1,   -1,
  350,   -1,   -1,   -1,  264,  355,  356,  357,  358,  359,
  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,
  370,  371,  372,  373,  257,  258,  259,  260,   -1,   -1,
  263,  291,  265,  266,  267,  268,  269,  270,  271,  272,
   -1,   -1,  302,   -1,   -1,  305,   -1,   -1,  281,  282,
   -1,  284,  285,  286,  287,  288,  289,  290,  291,  292,
  293,  294,  295,  296,  297,  298,  299,  300,  301,   -1,
   -1,   -1,   -1,  306,  307,  308,  309,  310,  311,  312,
  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,
  350,  324,  325,  326,  327,  328,  329,  330,  331,  332,
  333,  334,   -1,   -1,  337,  338,  339,  340,    0,   -1,
  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  355,  356,  357,  358,  359,  360,  361,  362,
  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,
  373,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   41,
   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,
   62,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  125,   -1,   -1,   41,   -1,   -1,   44,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,   33,   -1,
   -1,   -1,   -1,   -1,   -1,   40,   41,   -1,   -1,   44,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,   93,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
  125,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  257,  258,  259,  260,   -1,
   -1,  263,   -1,  265,  266,  267,  268,  269,  270,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,
  282,   -1,  284,  285,  286,  287,  288,  289,  290,  291,
  292,  293,  294,  295,  296,  297,  298,  299,  300,  301,
   -1,   -1,   -1,   -1,  306,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   -1,  337,  338,  339,  340,   -1,
   -1,  343,  344,   -1,   -1,   -1,   -1,   91,   -1,  264,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,
  372,  373,  257,  258,  259,  260,  291,   -1,  263,  123,
  265,  266,  267,  268,  269,  270,  271,  272,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,
  285,  286,  287,  288,  289,  290,  291,  292,  293,  294,
  295,  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,
   -1,  306,  307,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,   -1,  350,   -1,   -1,   -1,  324,
  325,  326,  327,  328,  329,  330,  331,  332,  333,  334,
   -1,   -1,  337,  338,  339,  340,    0,   -1,  343,  344,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  355,  356,  357,  358,  359,  360,  361,  362,  363,   -1,
   -1,   -1,  367,  368,  369,  370,  371,  372,  373,   33,
   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  257,  258,   59,  260,  261,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  269,  270,  271,  272,  273,
  274,  275,  276,  277,  278,  279,  280,   -1,   -1,  283,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,
   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  335,   -1,   -1,   -1,   -1,   -1,  341,  342,   -1,
   -1,  345,   -1,  347,   -1,   -1,   33,   -1,   -1,   -1,
   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,   -1,   -1,
  364,   -1,  366,   -1,   -1,   -1,   -1,   -1,   -1,  373,
  374,   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  257,  258,  259,  260,   -1,   -1,  263,
   -1,  265,  266,  267,  268,  269,  270,  271,  272,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,
  284,  285,  286,  287,  288,  289,  290,  291,  292,  293,
  294,  295,  296,  297,  298,  299,  300,  301,   -1,   -1,
   -1,   -1,   -1,  307,  308,  309,  310,  311,  312,  313,
  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,
  324,  325,  326,  327,  328,  329,  330,  331,  332,  333,
  334,   -1,   -1,  337,  338,  339,  340,   -1,   -1,  343,
  344,   -1,   91,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  355,  356,  357,  358,  359,  360,  361,  362,  363,
   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,  373,
  257,  258,  259,  260,  123,   -1,  263,   -1,  265,  266,
  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,
  287,  288,  289,  290,  291,  292,  293,  294,  295,  296,
  297,  298,  299,  300,  301,   -1,   -1,   -1,   -1,   -1,
  307,  308,  309,  310,  311,  312,  313,  314,  315,  316,
  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,   -1,   -1,
  337,  338,  339,  340,    0,   -1,  343,  344,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,
  357,  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,
  367,  368,  369,  370,  371,  372,  373,   33,   -1,   -1,
   -1,   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
   -1,  260,  261,   59,   -1,   -1,   -1,   -1,   -1,   -1,
  269,  270,  271,  272,  273,  274,  275,  276,  277,  278,
  279,  280,   -1,   -1,  283,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,
   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,
   -1,   -1,   -1,   -1,   -1,   -1,  335,   -1,   -1,   -1,
   -1,   -1,  341,  342,   -1,   -1,  345,   -1,  347,   -1,
   -1,   -1,   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   -1,  364,   -1,  366,   -1,   -1,
   -1,   -1,   -1,   -1,  373,  374,   -1,   -1,   -1,   -1,
   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  257,  258,  259,  260,   -1,   -1,  263,   -1,  265,
  266,  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,
  286,  287,  288,  289,  290,  291,  292,  293,  294,  295,
  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,   -1,
   -1,  307,  308,  309,  310,  311,  312,  313,  314,  315,
  316,  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,
  326,  327,  328,  329,  330,  331,  332,  333,  334,   -1,
   -1,  337,  338,  339,  340,   -1,   -1,  343,  344,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,
  356,  357,  358,  359,  360,  361,  362,  363,   -1,   -1,
   -1,  367,  368,  369,  370,  371,  372,  373,  257,  258,
  259,  260,   -1,   -1,  263,   -1,  265,  266,  267,  268,
  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,  288,
  289,  290,  291,  292,  293,  294,  295,  296,  297,  298,
  299,  300,  301,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   -1,  337,  338,
  339,  340,    0,   -1,  343,  344,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,
  369,  370,  371,  372,  373,   33,   -1,   -1,   -1,   -1,
   -1,   -1,   40,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,
  258,  259,  260,   -1,   -1,  263,   -1,  265,  266,  267,
  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,
  288,  289,  290,  291,  292,  293,  294,  295,  296,  297,
  298,  299,  300,  301,   -1,   -1,   -1,   -1,   -1,  307,
  308,  309,  310,  311,  312,  313,  314,  315,  316,  317,
  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,
  328,  329,  330,  331,  332,  333,  334,   -1,   -1,  337,
  338,  339,  340,   -1,   -1,  343,  344,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,
  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,
  368,  369,  370,  371,  372,  373,  257,  258,  259,  260,
   -1,   -1,  263,   -1,  265,  266,  267,  268,  269,  270,
  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  281,  282,   -1,  284,  285,  286,  287,  288,  289,  290,
  291,  292,  293,  294,  295,  296,  297,  298,  299,  300,
  301,   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,
  311,  312,  313,  314,  315,  316,  317,  318,   -1,   -1,
   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,  330,
  331,  332,  333,  334,   -1,   -1,  337,  338,  339,  340,
    0,   -1,  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,
  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,
  371,  372,  373,   33,   -1,   -1,   -1,   -1,   -1,   -1,
   40,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,  259,
  260,   -1,   -1,  263,   -1,  265,  266,  267,  268,  269,
  270,  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  281,  282,   -1,  284,  285,  286,  287,  288,  289,
  290,  291,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,   -1,   -1,   -1,   -1,   -1,  307,  308,  309,
  310,  311,  312,  313,  314,  315,  316,  317,  318,   -1,
   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,
  330,  331,  332,  333,  334,   -1,   -1,  337,  338,  339,
  340,   -1,   -1,  343,  344,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,  359,
  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,
  370,  371,  372,  373,  257,  258,  259,  260,   -1,   -1,
  263,   -1,  265,  266,  267,  268,  269,  270,  271,  272,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,
   -1,  284,  285,  286,  287,  288,  289,  290,  291,  292,
  293,  294,  295,  296,  297,  298,  299,  300,  301,   -1,
   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,  312,
  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,
   -1,  324,  325,  326,  327,  328,  329,  330,  331,  332,
  333,  334,   -1,   -1,  337,  338,  339,  340,    0,   -1,
  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  355,  356,  357,  358,  359,  360,  361,  362,
  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,
  373,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   33,   -1,
   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  257,  258,  259,  260,   -1,
   -1,  263,   -1,  265,  266,  267,  268,  269,  270,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,
  282,   -1,  284,  285,  286,  287,  288,  289,  290,  291,
  292,  293,  294,  295,  296,  297,  298,  299,  300,  301,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   -1,  337,  338,  339,  340,   -1,
   -1,  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,
  372,  373,  257,  258,  259,  260,   -1,   -1,  263,   -1,
  265,  266,  267,  268,  269,  270,  271,  272,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,
  285,  286,  287,  288,  289,  290,  291,  292,  293,  294,
  295,  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,
   -1,   -1,  307,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,  324,
  325,  326,  327,  328,  329,  330,  331,  332,  333,  334,
   -1,   -1,  337,  338,  339,  340,    0,   -1,  343,  344,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  355,  356,  357,  358,  359,  360,  361,  362,  363,   -1,
   -1,   -1,  367,  368,  369,  370,  371,  372,  373,   33,
   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,
   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   33,   -1,   -1,   -1,
   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  257,  258,  259,  260,   -1,   -1,  263,
   -1,  265,  266,  267,  268,  269,  270,  271,  272,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,
  284,  285,  286,  287,  288,  289,  290,  291,  292,  293,
  294,  295,  296,  297,  298,  299,  300,  301,   -1,   -1,
   -1,   -1,   -1,  307,  308,  309,  310,  311,  312,  313,
  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,
  324,  325,  326,  327,  328,  329,  330,  331,  332,  333,
  334,   -1,   -1,  337,  338,  339,  340,   -1,   -1,  343,
  344,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  355,  356,  357,  358,  359,  360,  361,  362,  363,
   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,  373,
  257,  258,  259,  260,   -1,   -1,  263,   -1,  265,  266,
  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,
  287,  288,  289,  290,  291,  292,  293,  294,  295,  296,
  297,  298,  299,  300,  301,   -1,   -1,   -1,   -1,   -1,
  307,  308,  309,  310,  311,  312,  313,  314,  315,  316,
  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,   -1,   -1,
  337,  338,  339,  340,    0,   -1,  343,  344,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,
  357,  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,
  367,  368,  369,  370,  371,  372,  373,   33,   -1,   -1,
   -1,   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,
   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  257,  258,  259,  260,   -1,   -1,  263,   -1,  265,
  266,  267,  268,  269,  270,  271,  272,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,
  286,  287,  288,  289,  290,  291,  292,  293,  294,  295,
  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,   -1,
   -1,  307,  308,  309,  310,  311,  312,  313,  314,  315,
  316,  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,
  326,  327,  328,  329,  330,  331,  332,  333,  334,   -1,
   -1,  337,  338,  339,  340,   -1,   -1,  343,  344,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,
  356,  357,  358,  359,  360,  361,  362,  363,   -1,   -1,
   -1,  367,  368,  369,  370,  371,  372,  373,  257,  258,
  259,  260,   -1,   -1,  263,   -1,  265,  266,  267,  268,
  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,  288,
  289,  290,  291,  292,  293,  294,  295,  296,  297,  298,
  299,  300,  301,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   -1,  337,  338,
  339,  340,    0,   -1,  343,  344,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,
  369,  370,  371,  372,  373,   33,   -1,   -1,   -1,   -1,
   -1,   -1,   40,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,
  258,  259,  260,   -1,   -1,  263,   -1,  265,  266,  267,
  268,  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  281,  282,   -1,  284,  285,  286,  287,
  288,  289,  290,  291,  292,  293,  294,  295,  296,  297,
  298,  299,  300,  301,   -1,   -1,   -1,   -1,   -1,  307,
  308,  309,  310,  311,  312,  313,  314,  315,  316,  317,
  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,
  328,  329,  330,  331,  332,  333,  334,   -1,   -1,  337,
  338,  339,  340,   -1,   -1,  343,  344,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,
  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,  367,
  368,  369,  370,  371,  372,  373,  257,  258,  259,  260,
   -1,   -1,  263,   -1,  265,  266,  267,  268,  269,  270,
  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  281,  282,   -1,  284,  285,  286,  287,  288,  289,  290,
  291,  292,  293,  294,  295,  296,  297,  298,  299,  300,
  301,   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,
  311,  312,  313,  314,  315,  316,  317,  318,   -1,   -1,
   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,  330,
  331,  332,  333,  334,   -1,   -1,  337,  338,  339,  340,
    0,   -1,  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,
  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,
  371,  372,  373,   33,   -1,   -1,   -1,   -1,   -1,   -1,
   40,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   93,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,  259,
  260,   -1,   -1,  263,   -1,  265,  266,  267,  268,  269,
  270,  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  281,  282,   -1,  284,  285,  286,  287,  288,  289,
  290,  291,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,   -1,   -1,   -1,   -1,   -1,  307,  308,  309,
  310,  311,  312,  313,  314,  315,  316,  317,  318,   -1,
   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,
  330,  331,  332,  333,  334,   -1,   -1,  337,  338,  339,
  340,   -1,   -1,  343,  344,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,  359,
  360,  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,
  370,  371,  372,  373,  257,  258,  259,  260,   -1,   -1,
  263,   -1,  265,  266,  267,  268,  269,  270,  271,  272,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,
   -1,  284,  285,  286,  287,  288,  289,  290,  291,  292,
  293,  294,  295,  296,  297,  298,  299,  300,  301,   -1,
   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,  312,
  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,
   -1,  324,  325,  326,  327,  328,  329,  330,  331,  332,
  333,  334,   -1,   -1,  337,  338,  339,  340,    0,   -1,
  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  355,  356,  357,  358,  359,  360,  361,  362,
  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,
  373,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   -1,   44,   45,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   93,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   33,   -1,
   -1,   -1,   -1,   -1,   -1,   40,   41,   -1,   43,   44,
   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   59,   -1,   -1,   62,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  258,  259,  260,   -1,
   -1,   -1,   -1,  265,  266,  267,   -1,  269,  270,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  281,
  282,   -1,  284,  285,  286,  287,  288,  289,  290,  291,
  292,  293,  294,  295,  296,  297,  298,  299,  300,  301,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   -1,  337,  338,  339,  340,   -1,
   -1,  343,  344,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,  371,
  372,  373,  257,  258,  259,  260,   -1,   -1,  263,   -1,
  265,  266,  267,  268,  269,  270,  271,  272,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,
  285,  286,  287,  288,  289,  290,  291,  292,  293,  294,
  295,  296,  297,  298,  299,  300,  301,    0,   -1,   -1,
   -1,  306,  307,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  319,  320,  321,  322,  323,  324,
  325,  326,  327,  328,  329,  330,  331,  332,  333,  334,
   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,  343,  344,
   43,   -1,   45,   46,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,
   -1,   -1,  367,  368,  369,  370,  371,  372,  373,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   93,    0,   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  125,   -1,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   41,   -1,   -1,   44,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
    0,   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   33,   -1,   -1,  125,   -1,   -1,   -1,
   40,   41,   -1,   -1,   44,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   60,   -1,   62,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  257,  258,  259,  260,   -1,   -1,
  263,   -1,  265,  266,  267,  268,  269,  270,  271,  272,
   -1,   -1,   -1,   93,   -1,   -1,   96,   -1,  281,  282,
   -1,  284,  285,  286,  287,  288,  289,  290,  291,  292,
  293,  294,  295,  296,  297,  298,  299,  300,  301,   -1,
   -1,   -1,   -1,    0,  307,  125,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  319,  320,  321,  322,
  323,  324,  325,  326,  327,  328,  329,  330,  331,  332,
  333,  334,   -1,   -1,   -1,   -1,   33,   -1,   -1,   -1,
  343,  344,   -1,   40,   -1,   -1,   -1,   -1,  257,  258,
  259,  260,   -1,   -1,  263,   -1,  265,  266,  267,  268,
  269,  270,   59,   -1,  367,  368,  369,  370,  371,  372,
  373,   -1,  281,  282,   -1,  284,  285,  286,  287,  288,
  289,  290,  291,  292,  293,  294,  295,  296,  297,  298,
  299,  300,  301,   -1,   -1,   -1,   93,   -1,  307,   96,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   -1,  125,   -1,
   -1,   -1,   -1,   -1,  343,  344,   -1,  257,  258,  259,
  260,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,
   -1,  271,  272,   -1,   -1,   -1,    0,   -1,  367,  368,
  369,  370,  371,  372,  373,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,  309,
  310,  311,  312,  313,  314,  315,  316,  317,  318,   -1,
   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,
  330,  331,  332,  333,  334,   59,   -1,  337,  338,  339,
  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  349,
  350,  351,  352,  353,  354,  355,  356,  357,  358,  359,
  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,   93,
   -1,   -1,   -1,  373,   -1,   -1,   -1,   -1,   -1,   -1,
  257,  258,  259,  260,   -1,   -1,  263,   -1,   -1,   -1,
   -1,  268,   -1,   -1,  271,  272,   -1,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  307,  308,  309,  310,  311,  312,  313,  314,  315,  316,
  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,    0,   -1,
  337,  338,  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,
  357,  358,  359,  360,  361,  362,  363,   -1,   -1,   -1,
   -1,   33,   -1,   -1,   -1,   -1,  373,   -1,   40,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  260,   -1,   -1,   -1,
   -1,  265,  266,  267,   -1,  269,  270,  271,  272,   -1,
   -1,   93,   -1,   -1,   96,   -1,   -1,  281,  282,   -1,
  284,  285,  286,  287,  288,  289,  290,  291,  292,  293,
  294,  295,  296,  297,  298,  299,  300,  301,  302,    0,
   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  343,
  344,   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,
   -1,   -1,   -1,  367,  368,  369,  370,  371,  372,  373,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   37,   -1,   -1,   -1,   41,   42,   43,
   44,   45,   93,   47,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   59,   60,   -1,   62,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
    0,   -1,   -1,   -1,  125,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  257,  258,  259,  260,   93,
   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   -1,   -1,   -1,   -1,    0,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   93,   -1,  337,  338,  339,  340,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   59,   -1,  125,   -1,   -1,    0,   -1,
   -1,  373,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  260,
   -1,   -1,   -1,   -1,  265,  266,  267,   -1,  269,  270,
  271,  272,   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,
  281,  282,   -1,  284,  285,  286,  287,  288,  289,  290,
  291,  292,  293,  294,  295,  296,  297,  298,  299,  300,
  301,  302,   -1,   -1,   -1,   -1,   -1,   59,   -1,  125,
  264,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  291,   -1,   -1,
   -1,   93,  343,  344,   -1,   -1,   -1,   -1,  302,   -1,
   -1,  305,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  367,  368,  369,  370,
  371,  372,  373,  125,    0,   -1,   -1,   -1,   -1,   -1,
  260,   -1,   -1,   -1,   -1,  265,  266,  267,   -1,  269,
  270,  271,  272,   -1,   -1,  349,  350,  351,  352,  353,
  354,  281,  282,   -1,  284,  285,  286,  287,  288,  289,
  290,  291,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,    0,   -1,
   -1,   -1,   -1,   -1,  260,   -1,   -1,   -1,   -1,  265,
  266,  267,   -1,  269,  270,  271,  272,   -1,   -1,   -1,
   -1,   -1,   -1,  343,  344,  281,  282,   93,  284,  285,
  286,  287,  288,  289,  290,  291,  292,  293,  294,  295,
  296,  297,  298,  299,  300,  301,   -1,  367,  368,  369,
  370,  371,  372,  373,   -1,   -1,   -1,   59,   -1,  125,
   -1,   -1,    0,   -1,   -1,   -1,   -1,   -1,  260,   -1,
   -1,   -1,   -1,  265,  266,  267,   -1,  269,  270,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,  343,  344,  281,
  282,   93,  284,  285,  286,  287,  288,  289,  290,  291,
  292,  293,  294,  295,  296,  297,  298,  299,  300,  301,
   -1,  367,  368,  369,  370,  371,  372,  373,   -1,   -1,
   -1,   59,   -1,  125,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  343,  344,   -1,   -1,   93,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  367,  368,  369,  370,  371,
  372,  373,   -1,   -1,   -1,   -1,   -1,  125,   -1,   -1,
   -1,   -1,   -1,   -1,  260,   -1,   -1,   -1,   -1,  265,
  266,  267,   -1,  269,  270,  271,  272,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  281,  282,   -1,  284,  285,
  286,  287,  288,  289,  290,  291,  292,  293,  294,  295,
  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  260,   -1,
   -1,   -1,   -1,  265,  266,  267,   -1,  269,  270,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,  343,  344,  281,
  282,   -1,  284,  285,  286,  287,  288,  289,  290,  291,
  292,  293,  294,  295,  296,  297,  298,  299,  300,  301,
   -1,  367,  368,  369,  370,  371,  372,  373,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  260,   -1,   -1,   -1,   -1,  265,  266,  267,
   -1,  269,  270,  271,  272,   -1,   -1,   -1,   -1,   -1,
   -1,  343,  344,  281,  282,    0,  284,  285,  286,  287,
  288,  289,  290,  291,  292,  293,  294,  295,  296,  297,
  298,  299,  300,  301,   -1,  367,  368,  369,  370,  371,
  372,  373,   -1,   -1,   -1,   -1,   -1,   -1,   33,   -1,
   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   59,  343,  344,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  367,
  368,  369,  370,  371,  372,  373,   -1,   -1,   93,   -1,
   -1,   96,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   43,   -1,
   45,   46,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  125,   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,
   -1,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  257,  258,  259,   -1,   -1,   -1,  263,   -1,
  265,  266,  267,  268,  269,  270,  271,  272,   91,   -1,
   -1,   -1,   -1,   96,   -1,   -1,  281,  282,   -1,  284,
  285,  286,  287,  288,  289,  290,  291,  292,  293,  294,
  295,  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,
  123,   -1,  307,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,  324,
  325,  326,  327,  328,  329,  330,  331,  332,  333,  334,
   -1,   -1,  337,  338,  339,  340,  271,  272,  343,  344,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  355,  356,  357,  358,  359,  360,  361,  362,  363,   -1,
   -1,   -1,  367,  368,  369,  370,  371,  372,   -1,   -1,
   -1,   -1,   -1,  308,  309,  310,  311,  312,  313,  314,
  315,  316,  317,  318,  319,  320,  321,  322,  323,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  337,  338,  339,  340,   33,   -1,   -1,   -1,
   -1,   -1,   -1,   40,   -1,   -1,   -1,   -1,   45,   -1,
  355,  356,  357,  358,  359,  360,  361,  362,  363,   -1,
   -1,   -1,   -1,   -1,  257,  258,  259,  260,  261,   -1,
  263,   -1,   -1,   -1,   -1,  268,  269,  270,  271,  272,
  273,  274,  275,  276,  277,  278,  279,  280,   -1,   -1,
  283,   -1,   -1,   -1,   91,   -1,   -1,   -1,   -1,   96,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,  312,
  313,  314,  315,  316,  317,  318,  123,   -1,   -1,   -1,
   -1,  324,  325,  326,  327,  328,  329,  330,  331,  332,
  333,  334,  335,   -1,  337,  338,  339,  340,  341,  342,
   -1,   -1,  345,   -1,  347,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  355,  356,  357,  358,  359,  360,  361,  362,
  363,  364,   33,  366,   -1,   -1,   -1,   -1,   -1,   40,
  373,  374,   -1,   -1,   45,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   96,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  257,  258,  259,  260,  261,   -1,  263,   -1,   -1,   -1,
   -1,  268,  269,  270,  271,  272,  273,  274,  275,  276,
  277,  278,  279,  280,   -1,   -1,  283,   -1,   -1,   33,
   -1,   -1,   -1,   -1,   -1,   -1,   40,   41,   -1,   -1,
   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  307,  308,  309,  310,  311,  312,  313,  314,  315,  316,
  317,  318,   -1,   -1,   -1,   -1,   -1,  324,  325,  326,
  327,  328,  329,  330,  331,  332,  333,  334,  335,   -1,
  337,  338,  339,  340,  341,  342,   -1,   -1,  345,   -1,
  347,   -1,   96,   -1,   -1,   -1,   -1,   -1,  355,  356,
  357,  358,  359,  360,  361,  362,  363,  364,   -1,  366,
   -1,   -1,   -1,   -1,   -1,   -1,  373,  374,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,  259,  260,
   -1,   -1,  263,   -1,  265,  266,  267,  268,  269,  270,
  271,  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  281,  282,   -1,  284,  285,  286,  287,  288,  289,  290,
  291,  292,  293,  294,  295,  296,  297,  298,  299,  300,
  301,   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,
  311,  312,  313,  314,  315,  316,  317,  318,   -1,   -1,
   -1,   -1,   -1,  324,  325,  326,  327,  328,  329,  330,
  331,  332,  333,  334,   33,   -1,  337,  338,  339,  340,
   -1,   40,  343,  344,   -1,   -1,   45,   46,   -1,   -1,
   -1,   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,
  361,  362,  363,   -1,   -1,   -1,  367,  368,  369,  370,
  371,  372,  373,  257,  258,  259,  260,   -1,   -1,  263,
   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,  272,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   96,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  307,  308,  309,  310,  311,  312,  313,
  314,  315,  316,  317,  318,   -1,   -1,   -1,   -1,   -1,
  324,  325,  326,  327,  328,  329,  330,  331,  332,  333,
  334,   33,   -1,  337,  338,  339,  340,   -1,   40,   -1,
   -1,   -1,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  355,  356,  357,  358,  359,  360,  361,  362,  363,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  373,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   96,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
  259,  260,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,
   -1,   -1,  271,  272,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   -1,   -1,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   96,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  373,  257,  258,  259,  260,   -1,
   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,
  272,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   -1,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   96,  337,  338,  339,  340,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  373,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
  259,  260,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,
   -1,   -1,  271,  272,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   -1,   -1,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   96,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  373,  257,  258,  259,  260,   -1,
   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,
  272,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   -1,   -1,   45,   46,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   96,  337,  338,  339,  340,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  373,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
  259,  260,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,
   -1,   -1,  271,  272,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   42,   -1,   -1,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   96,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  373,  257,  258,  259,   -1,   -1,
   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,
  272,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   -1,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   96,  337,  338,  339,  340,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
  259,   -1,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,
   -1,   -1,  271,  272,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   -1,   -1,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   96,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  257,  258,  259,   -1,   -1,
   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,
  272,   33,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   -1,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   -1,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   96,  337,  338,  339,  340,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
  259,   -1,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,
   -1,   -1,  271,  272,   33,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   -1,   -1,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   96,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  257,  258,  259,   -1,   -1,
   -1,  263,   -1,   -1,   -1,   -1,  268,   -1,   -1,  271,
  272,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  307,  308,  309,  310,  311,
  312,  313,  314,  315,  316,  317,  318,   -1,   -1,   91,
   -1,   -1,  324,  325,  326,  327,  328,  329,  330,  331,
  332,  333,  334,   -1,   -1,  337,  338,  339,  340,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  123,   -1,  355,  356,  357,  358,  359,  360,  361,
  362,  363,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  257,  258,
  259,   -1,   -1,   -1,  263,   -1,   -1,   -1,   -1,  268,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  307,  308,
  309,  310,  311,  312,  313,  314,  315,  316,  317,  318,
   -1,   -1,   -1,   -1,   -1,  324,  325,  326,  327,  328,
  329,  330,  331,  332,  333,  334,   -1,   -1,  337,  338,
  339,  340,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  355,  356,  357,  358,
  359,  360,  361,  362,  363,  257,  258,   -1,  260,  261,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  269,  270,  271,
  272,  273,  274,  275,  276,  277,  278,  279,  280,   -1,
   -1,  283,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  335,   -1,   -1,   -1,   -1,   -1,  341,
  342,   -1,   -1,  345,   -1,  347,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  364,   -1,  366,   -1,   -1,   -1,   -1,   -1,
   -1,  373,  374,
};
#if YYBTYACC
static const YYINT yyctable[] = {                        -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,
};
#endif
#define YYFINAL 2
#ifndef YYDEBUG
#define YYDEBUG 0
#endif
#define YYMAXTOKEN 376
#define YYUNDFTOKEN 424
#define YYTRANSLATE(a) ((a) > YYMAXTOKEN ? YYUNDFTOKEN : (a))
#if YYDEBUG
static const char *const yyname[] = {

"$end",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,"'!'",0,
0,0,"'%'",0,0,"'('","')'","'*'","'+'","','","'-'","'.'","'/'",0,0,0,0,0,0,0,0,0,
0,"':'","';'","'<'","'='","'>'",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,"'['",0,"']'","'^'",0,"'`'",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,"'{'",0,"'}'",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,"error","LABEL","VARIABLE","NUMBER",
"TEXT","COMMAND_LINE","DELIMITED","ORDINAL","TH","LEFT_ARROW_HEAD",
"RIGHT_ARROW_HEAD","DOUBLE_ARROW_HEAD","LAST","UP","DOWN","LEFT","RIGHT","BOX",
"CIRCLE","ELLIPSE","ARC","LINE","ARROW","MOVE","SPLINE","HEIGHT","RADIUS",
"FIGNAME","WIDTH","DIAMETER","FROM","TO","AT","WITH","BY","THEN","SOLID",
"DOTTED","DASHED","CHOP","SAME","INVISIBLE","LJUST","RJUST","ABOVE","BELOW",
"OF","THE","WAY","BETWEEN","AND","HERE","DOT_N","DOT_E","DOT_W","DOT_S",
"DOT_NE","DOT_SE","DOT_NW","DOT_SW","DOT_C","DOT_START","DOT_END","DOT_X",
"DOT_Y","DOT_HT","DOT_WID","DOT_RAD","SIN","COS","ATAN2","LOG","EXP","SQRT",
"K_MAX","K_MIN","INT","RAND","SRAND","COPY","THRU","TOP","BOTTOM","UPPER",
"LOWER","SH","PRINT","CW","CCW","FOR","DO","IF","ELSE","ANDAND","OROR",
"NOTEQUAL","EQUALEQUAL","LESSEQUAL","GREATEREQUAL","LEFT_CORNER","RIGHT_CORNER",
"NORTH","SOUTH","EAST","WEST","CENTER","END","START","RESET","UNTIL","PLOT",
"THICKNESS","FILL","COLORED","OUTLINED","SHADED","ALIGNED","SPRINTF","COMMAND",
"DEFINE","UNDEF","$accept","top","expr","any_expr","text_expr","optional_by",
"expr_pair","position_not_place","simple_if","nth_primitive","corner","path",
"label_path","relative_path","place","label","element","element_list",
"middle_element_list","object_spec","position","object_type",
"optional_ordinal_last","ordinal","macro_name","until","sprintf_args","text",
"print_args","print_arg","optional_separator","separator","placeless_element",
"$$1","$$2","$$3","$$4","$$5","$$6","$$7","reset_variables","$$8","$$9",
"optional_element","$$10","$$11","between","illegal-symbol",
};
static const char *const yyrule[] = {
"$accept : top",
"top : optional_separator",
"top : element_list",
"element_list : optional_separator middle_element_list optional_separator",
"middle_element_list : element",
"middle_element_list : middle_element_list separator element",
"optional_separator :",
"optional_separator : separator",
"separator : ';'",
"separator : separator ';'",
"placeless_element : FIGNAME '=' macro_name",
"placeless_element : VARIABLE '=' any_expr",
"placeless_element : VARIABLE ':' '=' any_expr",
"placeless_element : UP",
"placeless_element : DOWN",
"placeless_element : LEFT",
"placeless_element : RIGHT",
"placeless_element : COMMAND_LINE",
"placeless_element : COMMAND print_args",
"placeless_element : PRINT print_args",
"$$1 :",
"placeless_element : SH $$1 DELIMITED",
"placeless_element : COPY TEXT",
"$$2 :",
"$$3 :",
"placeless_element : COPY TEXT THRU $$2 DELIMITED $$3 until",
"$$4 :",
"$$5 :",
"placeless_element : COPY THRU $$4 DELIMITED $$5 until",
"$$6 :",
"placeless_element : FOR VARIABLE '=' expr TO expr optional_by DO $$6 DELIMITED",
"placeless_element : simple_if",
"$$7 :",
"placeless_element : simple_if ELSE $$7 DELIMITED",
"placeless_element : reset_variables",
"placeless_element : RESET",
"macro_name : VARIABLE",
"macro_name : LABEL",
"reset_variables : RESET VARIABLE",
"reset_variables : reset_variables VARIABLE",
"reset_variables : reset_variables ',' VARIABLE",
"print_args : print_arg",
"print_args : print_args print_arg",
"print_arg : expr",
"print_arg : text",
"print_arg : position",
"$$8 :",
"simple_if : IF any_expr THEN $$8 DELIMITED",
"until :",
"until : UNTIL TEXT",
"any_expr : expr",
"any_expr : text_expr",
"text_expr : text EQUALEQUAL text",
"text_expr : text NOTEQUAL text",
"text_expr : text_expr ANDAND text_expr",
"text_expr : text_expr ANDAND expr",
"text_expr : expr ANDAND text_expr",
"text_expr : text_expr OROR text_expr",
"text_expr : text_expr OROR expr",
"text_expr : expr OROR text_expr",
"text_expr : '!' text_expr",
"optional_by :",
"optional_by : BY expr",
"optional_by : BY '*' expr",
"element : object_spec",
"element : LABEL ':' optional_separator element",
"element : LABEL ':' optional_separator position_not_place",
"element : LABEL ':' optional_separator place",
"$$9 :",
"$$10 :",
"element : '{' $$9 element_list '}' $$10 optional_element",
"element : placeless_element",
"optional_element :",
"optional_element : element",
"object_spec : BOX",
"object_spec : CIRCLE",
"object_spec : ELLIPSE",
"object_spec : ARC",
"object_spec : LINE",
"object_spec : ARROW",
"object_spec : MOVE",
"object_spec : SPLINE",
"object_spec : text",
"object_spec : PLOT expr",
"object_spec : PLOT expr text",
"$$11 :",
"object_spec : '[' $$11 element_list ']'",
"object_spec : object_spec HEIGHT expr",
"object_spec : object_spec RADIUS expr",
"object_spec : object_spec WIDTH expr",
"object_spec : object_spec DIAMETER expr",
"object_spec : object_spec expr",
"object_spec : object_spec UP",
"object_spec : object_spec UP expr",
"object_spec : object_spec DOWN",
"object_spec : object_spec DOWN expr",
"object_spec : object_spec RIGHT",
"object_spec : object_spec RIGHT expr",
"object_spec : object_spec LEFT",
"object_spec : object_spec LEFT expr",
"object_spec : object_spec FROM position",
"object_spec : object_spec TO position",
"object_spec : object_spec AT position",
"object_spec : object_spec WITH path",
"object_spec : object_spec WITH position",
"object_spec : object_spec BY expr_pair",
"object_spec : object_spec THEN",
"object_spec : object_spec SOLID",
"object_spec : object_spec DOTTED",
"object_spec : object_spec DOTTED expr",
"object_spec : object_spec DASHED",
"object_spec : object_spec DASHED expr",
"object_spec : object_spec FILL",
"object_spec : object_spec FILL expr",
"object_spec : object_spec SHADED text",
"object_spec : object_spec COLORED text",
"object_spec : object_spec OUTLINED text",
"object_spec : object_spec CHOP",
"object_spec : object_spec CHOP expr",
"object_spec : object_spec SAME",
"object_spec : object_spec INVISIBLE",
"object_spec : object_spec LEFT_ARROW_HEAD",
"object_spec : object_spec RIGHT_ARROW_HEAD",
"object_spec : object_spec DOUBLE_ARROW_HEAD",
"object_spec : object_spec CW",
"object_spec : object_spec CCW",
"object_spec : object_spec text",
"object_spec : object_spec LJUST",
"object_spec : object_spec RJUST",
"object_spec : object_spec ABOVE",
"object_spec : object_spec BELOW",
"object_spec : object_spec THICKNESS expr",
"object_spec : object_spec ALIGNED",
"text : TEXT",
"text : SPRINTF '(' TEXT sprintf_args ')'",
"sprintf_args :",
"sprintf_args : sprintf_args ',' expr",
"position : position_not_place",
"position : place",
"position : '(' place ')'",
"position_not_place : expr_pair",
"position_not_place : position '+' expr_pair",
"position_not_place : '(' position '+' expr_pair ')'",
"position_not_place : position '-' expr_pair",
"position_not_place : '(' position '-' expr_pair ')'",
"position_not_place : '(' position ',' position ')'",
"position_not_place : expr between position AND position",
"position_not_place : '(' expr between position AND position ')'",
"position_not_place : expr '<' position ',' position '>'",
"position_not_place : '(' expr '<' position ',' position '>' ')'",
"between : BETWEEN",
"between : OF THE WAY BETWEEN",
"expr_pair : expr ',' expr",
"expr_pair : '(' expr_pair ')'",
"place : label",
"place : label corner",
"place : corner label",
"place : corner OF label",
"place : HERE",
"label : LABEL",
"label : nth_primitive",
"label : label '.' LABEL",
"ordinal : ORDINAL",
"ordinal : '`' any_expr TH",
"optional_ordinal_last : LAST",
"optional_ordinal_last : ordinal LAST",
"nth_primitive : ordinal object_type",
"nth_primitive : optional_ordinal_last object_type",
"object_type : BOX",
"object_type : CIRCLE",
"object_type : ELLIPSE",
"object_type : ARC",
"object_type : LINE",
"object_type : ARROW",
"object_type : SPLINE",
"object_type : '[' ']'",
"object_type : TEXT",
"label_path : '.' LABEL",
"label_path : label_path '.' LABEL",
"relative_path : corner",
"relative_path : label_path",
"relative_path : label_path corner",
"path : relative_path",
"path : '(' relative_path ',' relative_path ')'",
"path : ORDINAL LAST object_type relative_path",
"path : LAST object_type relative_path",
"path : ORDINAL object_type relative_path",
"path : LABEL relative_path",
"corner : DOT_N",
"corner : DOT_E",
"corner : DOT_W",
"corner : DOT_S",
"corner : DOT_NE",
"corner : DOT_SE",
"corner : DOT_NW",
"corner : DOT_SW",
"corner : DOT_C",
"corner : DOT_START",
"corner : DOT_END",
"corner : TOP",
"corner : BOTTOM",
"corner : LEFT",
"corner : RIGHT",
"corner : UPPER LEFT",
"corner : LOWER LEFT",
"corner : UPPER RIGHT",
"corner : LOWER RIGHT",
"corner : LEFT_CORNER",
"corner : RIGHT_CORNER",
"corner : UPPER LEFT_CORNER",
"corner : LOWER LEFT_CORNER",
"corner : UPPER RIGHT_CORNER",
"corner : LOWER RIGHT_CORNER",
"corner : NORTH",
"corner : SOUTH",
"corner : EAST",
"corner : WEST",
"corner : CENTER",
"corner : START",
"corner : END",
"expr : VARIABLE",
"expr : NUMBER",
"expr : place DOT_X",
"expr : place DOT_Y",
"expr : place DOT_HT",
"expr : place DOT_WID",
"expr : place DOT_RAD",
"expr : expr '+' expr",
"expr : expr '-' expr",
"expr : expr '*' expr",
"expr : expr '/' expr",
"expr : expr '%' expr",
"expr : expr '^' expr",
"expr : '-' expr",
"expr : '(' any_expr ')'",
"expr : SIN '(' any_expr ')'",
"expr : COS '(' any_expr ')'",
"expr : ATAN2 '(' any_expr ',' any_expr ')'",
"expr : LOG '(' any_expr ')'",
"expr : EXP '(' any_expr ')'",
"expr : SQRT '(' any_expr ')'",
"expr : K_MAX '(' any_expr ',' any_expr ')'",
"expr : K_MIN '(' any_expr ',' any_expr ')'",
"expr : INT '(' any_expr ')'",
"expr : RAND '(' any_expr ')'",
"expr : RAND '(' ')'",
"expr : SRAND '(' any_expr ')'",
"expr : expr '<' expr",
"expr : expr LESSEQUAL expr",
"expr : expr '>' expr",
"expr : expr GREATEREQUAL expr",
"expr : expr EQUALEQUAL expr",
"expr : expr NOTEQUAL expr",
"expr : expr ANDAND expr",
"expr : expr OROR expr",
"expr : '!' expr",

};
#endif

#if YYDEBUG
int      yydebug;
#endif

int      yyerrflag;
int      yychar;
YYSTYPE  yyval;
YYSTYPE  yylval;
int      yynerrs;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
YYLTYPE  yyloc; /* position returned by actions */
YYLTYPE  yylloc; /* position from the lexer */
#endif

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
#ifndef YYLLOC_DEFAULT
#define YYLLOC_DEFAULT(loc, rhs, n) \
do \
{ \
    if (n == 0) \
    { \
        (loc).first_line   = YYRHSLOC(rhs, 0).last_line; \
        (loc).first_column = YYRHSLOC(rhs, 0).last_column; \
        (loc).last_line    = YYRHSLOC(rhs, 0).last_line; \
        (loc).last_column  = YYRHSLOC(rhs, 0).last_column; \
    } \
    else \
    { \
        (loc).first_line   = YYRHSLOC(rhs, 1).first_line; \
        (loc).first_column = YYRHSLOC(rhs, 1).first_column; \
        (loc).last_line    = YYRHSLOC(rhs, n).last_line; \
        (loc).last_column  = YYRHSLOC(rhs, n).last_column; \
    } \
} while (0)
#endif /* YYLLOC_DEFAULT */
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#if YYBTYACC

#ifndef YYLVQUEUEGROWTH
#define YYLVQUEUEGROWTH 32
#endif
#endif /* YYBTYACC */

/* define the initial stack-sizes */
#ifdef YYSTACKSIZE
#undef YYMAXDEPTH
#define YYMAXDEPTH  YYSTACKSIZE
#else
#ifdef YYMAXDEPTH
#define YYSTACKSIZE YYMAXDEPTH
#else
#define YYSTACKSIZE 10000
#define YYMAXDEPTH  10000
#endif
#endif

#ifndef YYINITSTACKSIZE
#define YYINITSTACKSIZE 200
#endif

typedef struct {
    unsigned stacksize;
    YYINT    *s_base;
    YYINT    *s_mark;
    YYINT    *s_last;
    YYSTYPE  *l_base;
    YYSTYPE  *l_mark;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE  *p_base;
    YYLTYPE  *p_mark;
#endif
} YYSTACKDATA;
#if YYBTYACC

struct YYParseState_s
{
    struct YYParseState_s *save;    /* Previously saved parser state */
    YYSTACKDATA            yystack; /* saved parser stack */
    int                    state;   /* saved parser state */
    int                    errflag; /* saved error recovery status */
    int                    lexeme;  /* saved index of the conflict lexeme in the lexical queue */
    YYINT                  ctry;    /* saved index in yyctable[] for this conflict */
};
typedef struct YYParseState_s YYParseState;
#endif /* YYBTYACC */
/* variables for the parser stack */
static YYSTACKDATA yystack;
#if YYBTYACC

/* Current parser state */
static YYParseState *yyps = 0;

/* yypath != NULL: do the full parse, starting at *yypath parser state. */
static YYParseState *yypath = 0;

/* Base of the lexical value queue */
static YYSTYPE *yylvals = 0;

/* Current position at lexical value queue */
static YYSTYPE *yylvp = 0;

/* End position of lexical value queue */
static YYSTYPE *yylve = 0;

/* The last allocated position at the lexical value queue */
static YYSTYPE *yylvlim = 0;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
/* Base of the lexical position queue */
static YYLTYPE *yylpsns = 0;

/* Current position at lexical position queue */
static YYLTYPE *yylpp = 0;

/* End position of lexical position queue */
static YYLTYPE *yylpe = 0;

/* The last allocated position at the lexical position queue */
static YYLTYPE *yylplim = 0;
#endif

/* Current position at lexical token queue */
static YYINT  *yylexp = 0;

static YYINT  *yylexemes = 0;
#endif /* YYBTYACC */
#line 1645 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"

/* bison defines const to be empty unless __STDC__ is defined, which it
isn't under cfront */

#ifdef const
#undef const
#endif

static struct {
  const char *name;
  double val;
  int scaled;		     // non-zero if val should be multiplied by scale
} defaults_table[] = {
  { "arcrad", .25, 1 },
  { "arrowht", .1, 1 },
  { "arrowwid", .05, 1 },
  { "circlerad", .25, 1 },
  { "boxht", .5, 1 },
  { "boxwid", .75, 1 },
  { "boxrad", 0.0, 1 },
  { "dashwid", .05, 1 },
  { "ellipseht", .5, 1 },
  { "ellipsewid", .75, 1 },
  { "moveht", .5, 1 },
  { "movewid", .5, 1 },
  { "lineht", .5, 1 },
  { "linewid", .5, 1 },
  { "textht", 0.0, 1 },
  { "textwid", 0.0, 1 },
  { "scale", 1.0, 0 },
  { "linethick", -1.0, 0 },		// in points
  { "fillval", .5, 0 },
  { "arrowhead", 1.0, 0 },
  { "maxpswid", 8.5, 0 },
  { "maxpsht", 11.0, 0 },
};

place *lookup_label(const char *label)
{
  saved_state *state = current_saved_state;
  PTABLE(place) *tbl = current_table;
  for (;;) {
    place *pl = tbl->lookup(label);
    if (pl)
      return pl;
    if (!state)
      return 0;
    tbl = state->tbl;
    state = state->prev;
  }
}

void define_label(const char *label, const place *pl)
{
  place *p = new place[1];
  *p = *pl;
  current_table->define(label, p);
}

int lookup_variable(const char *name, double *val)
{
  place *pl = lookup_label(name);
  if (pl) {
    *val = pl->x;
    return 1;
  }
  return 0;
}

void define_variable(const char *name, double val)
{
  place *p = new place[1];
  p->obj = 0;
  p->x = val;
  p->y = 0.0;
  current_table->define(name, p);
  if (strcmp(name, "scale") == 0) {
    // When the scale changes, reset all scaled pre-defined variables to
    // their default values.
    for (unsigned int i = 0;
	 i < sizeof(defaults_table)/sizeof(defaults_table[0]); i++) 
      if (defaults_table[i].scaled)
	define_variable(defaults_table[i].name, val*defaults_table[i].val);
  }
}

// called once only (not once per parse)

void parse_init()
{
  current_direction = RIGHT_DIRECTION;
  current_position.x = 0.0;
  current_position.y = 0.0;
  // This resets everything to its default value.
  reset_all();
}

void reset(const char *nm)
{
  for (unsigned int i = 0;
       i < sizeof(defaults_table)/sizeof(defaults_table[0]); i++)
    if (strcmp(nm, defaults_table[i].name) == 0) {
      double val = defaults_table[i].val;
      if (defaults_table[i].scaled) {
	double scale;
	lookup_variable("scale", &scale);
	val *= scale;
      }
      define_variable(defaults_table[i].name, val);
      return;
    }
  lex_error("`%1' is not a predefined variable", nm);
}

void reset_all()
{
  // We only have to explicitly reset the pre-defined variables that
  // aren't scaled because `scale' is not scaled, and changing the
  // value of `scale' will reset all the pre-defined variables that
  // are scaled.
  for (unsigned int i = 0;
       i < sizeof(defaults_table)/sizeof(defaults_table[0]); i++)
    if (!defaults_table[i].scaled)
      define_variable(defaults_table[i].name, defaults_table[i].val);
}

// called after each parse

void parse_cleanup()
{
  while (current_saved_state != 0) {
    delete current_table;
    current_table = current_saved_state->tbl;
    saved_state *tem = current_saved_state;
    current_saved_state = current_saved_state->prev;
    delete tem;
  }
  assert(current_table == &top_table);
  PTABLE_ITERATOR(place) iter(current_table);
  const char *key;
  place *pl;
  while (iter.next(&key, &pl))
    if (pl->obj != 0) {
      position pos = pl->obj->origin();
      pl->obj = 0;
      pl->x = pos.x;
      pl->y = pos.y;
    }
  while (olist.head != 0) {
    object *tem = olist.head;
    olist.head = olist.head->next;
    delete tem;
  }
  olist.tail = 0;
  current_direction = RIGHT_DIRECTION;
  current_position.x = 0.0;
  current_position.y = 0.0;
}

const char *ordinal_postfix(int n)
{
  if (n < 10 || n > 20)
    switch (n % 10) {
    case 1:
      return "st";
    case 2:
      return "nd";
    case 3:
      return "rd";
    }
  return "th";
}

const char *object_type_name(object_type type)
{
  switch (type) {
  case BOX_OBJECT:
    return "box";
  case CIRCLE_OBJECT:
    return "circle";
  case ELLIPSE_OBJECT:
    return "ellipse";
  case ARC_OBJECT:
    return "arc";
  case SPLINE_OBJECT:
    return "spline";
  case LINE_OBJECT:
    return "line";
  case ARROW_OBJECT:
    return "arrow";
  case MOVE_OBJECT:
    return "move";
  case TEXT_OBJECT:
    return "\"\"";
  case BLOCK_OBJECT:
    return "[]";
  case OTHER_OBJECT:
  case MARK_OBJECT:
  default:
    break;
  }
  return "object";
}

static char sprintf_buf[1024];

char *format_number(const char *form, double n)
{
  if (form == 0)
    form = "%g";
  return do_sprintf(form, &n, 1);
}

char *do_sprintf(const char *form, const double *v, int nv)
{
  string result;
  int i = 0;
  string one_format;
  while (*form) {
    if (*form == '%') {
      one_format += *form++;
      for (; *form != '\0' && strchr("#-+ 0123456789.", *form) != 0; form++)
	one_format += *form;
      if (*form == '\0' || strchr("eEfgG%", *form) == 0) {
	lex_error("bad sprintf format");
	result += one_format;
	result += form;
	break;
      }
      if (*form == '%') {
	one_format += *form++;
	one_format += '\0';
	snprintf(sprintf_buf, sizeof(sprintf_buf),
		 "%s", one_format.contents());
      }
      else {
	if (i >= nv) {
	  lex_error("too few arguments to snprintf");
	  result += one_format;
	  result += form;
	  break;
	}
	one_format += *form++;
	one_format += '\0';
	snprintf(sprintf_buf, sizeof(sprintf_buf),
		 one_format.contents(), v[i++]);
      }
      one_format.clear();
      result += sprintf_buf;
    }
    else
      result += *form++;
  }
  result += '\0';
  return strsave(result.contents());
}
#line 5414 "y.tab.c"

/* For use in generated program */
#define yydepth (int)(yystack.s_mark - yystack.s_base)
#if YYBTYACC
#define yytrial (yyps->save)
#endif /* YYBTYACC */

#if YYDEBUG
#include <stdio.h>	/* needed for printf */
#endif

#include <stdlib.h>	/* needed for malloc, etc */
#include <string.h>	/* needed for memset */

/* allocate initial stack or double stack size, up to YYMAXDEPTH */
static int yygrowstack(YYSTACKDATA *data)
{
    int i;
    unsigned newsize;
    YYINT *newss;
    YYSTYPE *newvs;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE *newps;
#endif

    if ((newsize = data->stacksize) == 0)
        newsize = YYINITSTACKSIZE;
    else if (newsize >= YYMAXDEPTH)
        return YYENOMEM;
    else if ((newsize *= 2) > YYMAXDEPTH)
        newsize = YYMAXDEPTH;

    i = (int) (data->s_mark - data->s_base);
    newss = (YYINT *)realloc(data->s_base, newsize * sizeof(*newss));
    if (newss == 0)
        return YYENOMEM;

    data->s_base = newss;
    data->s_mark = newss + i;

    newvs = (YYSTYPE *)realloc(data->l_base, newsize * sizeof(*newvs));
    if (newvs == 0)
        return YYENOMEM;

    data->l_base = newvs;
    data->l_mark = newvs + i;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    newps = (YYLTYPE *)realloc(data->p_base, newsize * sizeof(*newps));
    if (newps == 0)
        return YYENOMEM;

    data->p_base = newps;
    data->p_mark = newps + i;
#endif

    data->stacksize = newsize;
    data->s_last = data->s_base + newsize - 1;

#if YYDEBUG
    if (yydebug)
        fprintf(stderr, "%sdebug: stack size increased to %d\n", YYPREFIX, newsize);
#endif
    return 0;
}

#if YYPURE || defined(YY_NO_LEAKS)
static void yyfreestack(YYSTACKDATA *data)
{
    free(data->s_base);
    free(data->l_base);
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    free(data->p_base);
#endif
    memset(data, 0, sizeof(*data));
}
#else
#define yyfreestack(data) /* nothing */
#endif /* YYPURE || defined(YY_NO_LEAKS) */
#if YYBTYACC

static YYParseState *
yyNewState(unsigned size)
{
    YYParseState *p = (YYParseState *) malloc(sizeof(YYParseState));
    if (p == NULL) return NULL;

    p->yystack.stacksize = size;
    if (size == 0)
    {
        p->yystack.s_base = NULL;
        p->yystack.l_base = NULL;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        p->yystack.p_base = NULL;
#endif
        return p;
    }
    p->yystack.s_base    = (YYINT *) malloc(size * sizeof(YYINT));
    if (p->yystack.s_base == NULL) return NULL;
    p->yystack.l_base    = (YYSTYPE *) malloc(size * sizeof(YYSTYPE));
    if (p->yystack.l_base == NULL) return NULL;
    memset(p->yystack.l_base, 0, size * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    p->yystack.p_base    = (YYLTYPE *) malloc(size * sizeof(YYLTYPE));
    if (p->yystack.p_base == NULL) return NULL;
    memset(p->yystack.p_base, 0, size * sizeof(YYLTYPE));
#endif

    return p;
}

static void
yyFreeState(YYParseState *p)
{
    yyfreestack(&p->yystack);
    free(p);
}
#endif /* YYBTYACC */

#define YYABORT  goto yyabort
#define YYREJECT goto yyabort
#define YYACCEPT goto yyaccept
#define YYERROR  goto yyerrlab
#if YYBTYACC
#define YYVALID        do { if (yyps->save)            goto yyvalid; } while(0)
#define YYVALID_NESTED do { if (yyps->save && \
                                yyps->save->save == 0) goto yyvalid; } while(0)
#endif /* YYBTYACC */

int
YYPARSE_DECL()
{
    int yym, yyn, yystate, yyresult;
#if YYBTYACC
    int yynewerrflag;
    YYParseState *yyerrctx = NULL;
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE  yyerror_loc_range[3]; /* position of error start/end (0 unused) */
#endif
#if YYDEBUG
    const char *yys;

    if ((yys = getenv("YYDEBUG")) != 0)
    {
        yyn = *yys;
        if (yyn >= '0' && yyn <= '9')
            yydebug = yyn - '0';
    }
    if (yydebug)
        fprintf(stderr, "%sdebug[<# of symbols on state stack>]\n", YYPREFIX);
#endif
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    memset(yyerror_loc_range, 0, sizeof(yyerror_loc_range));
#endif

#if YYBTYACC
    yyps = yyNewState(0); if (yyps == 0) goto yyenomem;
    yyps->save = 0;
#endif /* YYBTYACC */
    yym = 0;
    yyn = 0;
    yynerrs = 0;
    yyerrflag = 0;
    yychar = YYEMPTY;
    yystate = 0;

#if YYPURE
    memset(&yystack, 0, sizeof(yystack));
#endif

    if (yystack.s_base == NULL && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
    yystack.s_mark = yystack.s_base;
    yystack.l_mark = yystack.l_base;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark = yystack.p_base;
#endif
    yystate = 0;
    *yystack.s_mark = 0;

yyloop:
    if ((yyn = yydefred[yystate]) != 0) goto yyreduce;
    if (yychar < 0)
    {
#if YYBTYACC
        do {
        if (yylvp < yylve)
        {
            /* we're currently re-reading tokens */
            yylval = *yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylloc = *yylpp++;
#endif
            yychar = *yylexp++;
            break;
        }
        if (yyps->save)
        {
            /* in trial mode; save scanner results for future parse attempts */
            if (yylvp == yylvlim)
            {   /* Enlarge lexical value queue */
                size_t p = (size_t) (yylvp - yylvals);
                size_t s = (size_t) (yylvlim - yylvals);

                s += YYLVQUEUEGROWTH;
                if ((yylexemes = (YYINT *)realloc(yylexemes, s * sizeof(YYINT))) == NULL) goto yyenomem;
                if ((yylvals   = (YYSTYPE *)realloc(yylvals, s * sizeof(YYSTYPE))) == NULL) goto yyenomem;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                if ((yylpsns   = (YYLTYPE *)realloc(yylpsns, s * sizeof(YYLTYPE))) == NULL) goto yyenomem;
#endif
                yylvp   = yylve = yylvals + p;
                yylvlim = yylvals + s;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp   = yylpe = yylpsns + p;
                yylplim = yylpsns + s;
#endif
                yylexp  = yylexemes + p;
            }
            *yylexp = (YYINT) YYLEX;
            *yylvp++ = yylval;
            yylve++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            *yylpp++ = yylloc;
            yylpe++;
#endif
            yychar = *yylexp++;
            break;
        }
        /* normal operation, no conflict encountered */
#endif /* YYBTYACC */
        yychar = YYLEX;
#if YYBTYACC
        } while (0);
#endif /* YYBTYACC */
        if (yychar < 0) yychar = YYEOF;
#if YYDEBUG
        if (yydebug)
        {
            if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
            fprintf(stderr, "%s[%d]: state %d, reading token %d (%s)",
                            YYDEBUGSTR, yydepth, yystate, yychar, yys);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
            if (!yytrial)
#endif /* YYBTYACC */
                fprintf(stderr, " <%s>", YYSTYPE_TOSTRING(yychar, yylval));
#endif
            fputc('\n', stderr);
        }
#endif
    }
#if YYBTYACC

    /* Do we have a conflict? */
    if (((yyn = yycindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
        yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
        YYINT ctry;

        if (yypath)
        {
            YYParseState *save;
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%s[%d]: CONFLICT in state %d: following successful trial parse\n",
                                YYDEBUGSTR, yydepth, yystate);
#endif
            /* Switch to the next conflict context */
            save = yypath;
            yypath = save->save;
            save->save = NULL;
            ctry = save->ctry;
            if (save->state != yystate) YYABORT;
            yyFreeState(save);

        }
        else
        {

            /* Unresolved conflict - start/continue trial parse */
            YYParseState *save;
#if YYDEBUG
            if (yydebug)
            {
                fprintf(stderr, "%s[%d]: CONFLICT in state %d. ", YYDEBUGSTR, yydepth, yystate);
                if (yyps->save)
                    fputs("ALREADY in conflict, continuing trial parse.\n", stderr);
                else
                    fputs("Starting trial parse.\n", stderr);
            }
#endif
            save                  = yyNewState((unsigned)(yystack.s_mark - yystack.s_base + 1));
            if (save == NULL) goto yyenomem;
            save->save            = yyps->save;
            save->state           = yystate;
            save->errflag         = yyerrflag;
            save->yystack.s_mark  = save->yystack.s_base + (yystack.s_mark - yystack.s_base);
            memcpy (save->yystack.s_base, yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            save->yystack.l_mark  = save->yystack.l_base + (yystack.l_mark - yystack.l_base);
            memcpy (save->yystack.l_base, yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            save->yystack.p_mark  = save->yystack.p_base + (yystack.p_mark - yystack.p_base);
            memcpy (save->yystack.p_base, yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            ctry                  = yytable[yyn];
            if (yyctable[ctry] == -1)
            {
#if YYDEBUG
                if (yydebug && yychar >= YYEOF)
                    fprintf(stderr, "%s[%d]: backtracking 1 token\n", YYDEBUGSTR, yydepth);
#endif
                ctry++;
            }
            save->ctry = ctry;
            if (yyps->save == NULL)
            {
                /* If this is a first conflict in the stack, start saving lexemes */
                if (!yylexemes)
                {
                    yylexemes = (YYINT *) malloc((YYLVQUEUEGROWTH) * sizeof(YYINT));
                    if (yylexemes == NULL) goto yyenomem;
                    yylvals   = (YYSTYPE *) malloc((YYLVQUEUEGROWTH) * sizeof(YYSTYPE));
                    if (yylvals == NULL) goto yyenomem;
                    yylvlim   = yylvals + YYLVQUEUEGROWTH;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpsns   = (YYLTYPE *) malloc((YYLVQUEUEGROWTH) * sizeof(YYLTYPE));
                    if (yylpsns == NULL) goto yyenomem;
                    yylplim   = yylpsns + YYLVQUEUEGROWTH;
#endif
                }
                if (yylvp == yylve)
                {
                    yylvp  = yylve = yylvals;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpp  = yylpe = yylpsns;
#endif
                    yylexp = yylexemes;
                    if (yychar >= YYEOF)
                    {
                        *yylve++ = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                        *yylpe++ = yylloc;
#endif
                        *yylexp  = (YYINT) yychar;
                        yychar   = YYEMPTY;
                    }
                }
            }
            if (yychar >= YYEOF)
            {
                yylvp--;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp--;
#endif
                yylexp--;
                yychar = YYEMPTY;
            }
            save->lexeme = (int) (yylvp - yylvals);
            yyps->save   = save;
        }
        if (yytable[yyn] == ctry)
        {
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%s[%d]: state %d, shifting to state %d\n",
                                YYDEBUGSTR, yydepth, yystate, yyctable[ctry]);
#endif
            if (yychar < 0)
            {
                yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp++;
#endif
                yylexp++;
            }
            if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM)
                goto yyoverflow;
            yystate = yyctable[ctry];
            *++yystack.s_mark = (YYINT) yystate;
            *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            *++yystack.p_mark = yylloc;
#endif
            yychar  = YYEMPTY;
            if (yyerrflag > 0) --yyerrflag;
            goto yyloop;
        }
        else
        {
            yyn = yyctable[ctry];
            goto yyreduce;
        }
    } /* End of code dealing with conflicts */
#endif /* YYBTYACC */
    if (((yyn = yysindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
#if YYDEBUG
        if (yydebug)
            fprintf(stderr, "%s[%d]: state %d, shifting to state %d\n",
                            YYDEBUGSTR, yydepth, yystate, yytable[yyn]);
#endif
        if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
        yystate = yytable[yyn];
        *++yystack.s_mark = yytable[yyn];
        *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        *++yystack.p_mark = yylloc;
#endif
        yychar = YYEMPTY;
        if (yyerrflag > 0)  --yyerrflag;
        goto yyloop;
    }
    if (((yyn = yyrindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
        yyn = yytable[yyn];
        goto yyreduce;
    }
    if (yyerrflag != 0) goto yyinrecovery;
#if YYBTYACC

    yynewerrflag = 1;
    goto yyerrhandler;
    goto yyerrlab; /* redundant goto avoids 'unused label' warning */

yyerrlab:
    /* explicit YYERROR from an action -- pop the rhs of the rule reduced
     * before looking for error recovery */
    yystack.s_mark -= yym;
    yystate = *yystack.s_mark;
    yystack.l_mark -= yym;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark -= yym;
#endif

    yynewerrflag = 0;
yyerrhandler:
    while (yyps->save)
    {
        int ctry;
        YYParseState *save = yyps->save;
#if YYDEBUG
        if (yydebug)
            fprintf(stderr, "%s[%d]: ERROR in state %d, CONFLICT BACKTRACKING to state %d, %d tokens\n",
                            YYDEBUGSTR, yydepth, yystate, yyps->save->state,
                    (int)(yylvp - yylvals - yyps->save->lexeme));
#endif
        /* Memorize most forward-looking error state in case it's really an error. */
        if (yyerrctx == NULL || yyerrctx->lexeme < yylvp - yylvals)
        {
            /* Free old saved error context state */
            if (yyerrctx) yyFreeState(yyerrctx);
            /* Create and fill out new saved error context state */
            yyerrctx                 = yyNewState((unsigned)(yystack.s_mark - yystack.s_base + 1));
            if (yyerrctx == NULL) goto yyenomem;
            yyerrctx->save           = yyps->save;
            yyerrctx->state          = yystate;
            yyerrctx->errflag        = yyerrflag;
            yyerrctx->yystack.s_mark = yyerrctx->yystack.s_base + (yystack.s_mark - yystack.s_base);
            memcpy (yyerrctx->yystack.s_base, yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            yyerrctx->yystack.l_mark = yyerrctx->yystack.l_base + (yystack.l_mark - yystack.l_base);
            memcpy (yyerrctx->yystack.l_base, yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yyerrctx->yystack.p_mark = yyerrctx->yystack.p_base + (yystack.p_mark - yystack.p_base);
            memcpy (yyerrctx->yystack.p_base, yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            yyerrctx->lexeme         = (int) (yylvp - yylvals);
        }
        yylvp          = yylvals   + save->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        yylpp          = yylpsns   + save->lexeme;
#endif
        yylexp         = yylexemes + save->lexeme;
        yychar         = YYEMPTY;
        yystack.s_mark = yystack.s_base + (save->yystack.s_mark - save->yystack.s_base);
        memcpy (yystack.s_base, save->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
        yystack.l_mark = yystack.l_base + (save->yystack.l_mark - save->yystack.l_base);
        memcpy (yystack.l_base, save->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        yystack.p_mark = yystack.p_base + (save->yystack.p_mark - save->yystack.p_base);
        memcpy (yystack.p_base, save->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
        ctry           = ++save->ctry;
        yystate        = save->state;
        /* We tried shift, try reduce now */
        if ((yyn = yyctable[ctry]) >= 0) goto yyreduce;
        yyps->save     = save->save;
        save->save     = NULL;
        yyFreeState(save);

        /* Nothing left on the stack -- error */
        if (!yyps->save)
        {
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%sdebug[%d,trial]: trial parse FAILED, entering ERROR mode\n",
                                YYPREFIX, yydepth);
#endif
            /* Restore state as it was in the most forward-advanced error */
            yylvp          = yylvals   + yyerrctx->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylpp          = yylpsns   + yyerrctx->lexeme;
#endif
            yylexp         = yylexemes + yyerrctx->lexeme;
            yychar         = yylexp[-1];
            yylval         = yylvp[-1];
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylloc         = yylpp[-1];
#endif
            yystack.s_mark = yystack.s_base + (yyerrctx->yystack.s_mark - yyerrctx->yystack.s_base);
            memcpy (yystack.s_base, yyerrctx->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            yystack.l_mark = yystack.l_base + (yyerrctx->yystack.l_mark - yyerrctx->yystack.l_base);
            memcpy (yystack.l_base, yyerrctx->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yystack.p_mark = yystack.p_base + (yyerrctx->yystack.p_mark - yyerrctx->yystack.p_base);
            memcpy (yystack.p_base, yyerrctx->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            yystate        = yyerrctx->state;
            yyFreeState(yyerrctx);
            yyerrctx       = NULL;
        }
        yynewerrflag = 1;
    }
    if (yynewerrflag == 0) goto yyinrecovery;
#endif /* YYBTYACC */

    YYERROR_CALL("syntax error");
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yyerror_loc_range[1] = yylloc; /* lookahead position is error start position */
#endif

#if !YYBTYACC
    goto yyerrlab; /* redundant goto avoids 'unused label' warning */
yyerrlab:
#endif
    ++yynerrs;

yyinrecovery:
    if (yyerrflag < 3)
    {
        yyerrflag = 3;
        for (;;)
        {
            if (((yyn = yysindex[*yystack.s_mark]) != 0) && (yyn += YYERRCODE) >= 0 &&
                    yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) YYERRCODE)
            {
#if YYDEBUG
                if (yydebug)
                    fprintf(stderr, "%s[%d]: state %d, error recovery shifting to state %d\n",
                                    YYDEBUGSTR, yydepth, *yystack.s_mark, yytable[yyn]);
#endif
                if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
                yystate = yytable[yyn];
                *++yystack.s_mark = yytable[yyn];
                *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                /* lookahead position is error end position */
                yyerror_loc_range[2] = yylloc;
                YYLLOC_DEFAULT(yyloc, yyerror_loc_range, 2); /* position of error span */
                *++yystack.p_mark = yyloc;
#endif
                goto yyloop;
            }
            else
            {
#if YYDEBUG
                if (yydebug)
                    fprintf(stderr, "%s[%d]: error recovery discarding state %d\n",
                                    YYDEBUGSTR, yydepth, *yystack.s_mark);
#endif
                if (yystack.s_mark <= yystack.s_base) goto yyabort;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                /* the current TOS position is the error start position */
                yyerror_loc_range[1] = *yystack.p_mark;
#endif
#if defined(YYDESTRUCT_CALL)
#if YYBTYACC
                if (!yytrial)
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    YYDESTRUCT_CALL("error: discarding state",
                                    yystos[*yystack.s_mark], yystack.l_mark, yystack.p_mark);
#else
                    YYDESTRUCT_CALL("error: discarding state",
                                    yystos[*yystack.s_mark], yystack.l_mark);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#endif /* defined(YYDESTRUCT_CALL) */
                --yystack.s_mark;
                --yystack.l_mark;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                --yystack.p_mark;
#endif
            }
        }
    }
    else
    {
        if (yychar == YYEOF) goto yyabort;
#if YYDEBUG
        if (yydebug)
        {
            if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
            fprintf(stderr, "%s[%d]: state %d, error recovery discarding token %d (%s)\n",
                            YYDEBUGSTR, yydepth, yystate, yychar, yys);
        }
#endif
#if defined(YYDESTRUCT_CALL)
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            YYDESTRUCT_CALL("error: discarding token", yychar, &yylval, &yylloc);
#else
            YYDESTRUCT_CALL("error: discarding token", yychar, &yylval);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#endif /* defined(YYDESTRUCT_CALL) */
        yychar = YYEMPTY;
        goto yyloop;
    }

yyreduce:
    yym = yylen[yyn];
#if YYDEBUG
    if (yydebug)
    {
        fprintf(stderr, "%s[%d]: state %d, reducing by rule %d (%s)",
                        YYDEBUGSTR, yydepth, yystate, yyn, yyrule[yyn]);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
            if (yym > 0)
            {
                int i;
                fputc('<', stderr);
                for (i = yym; i > 0; i--)
                {
                    if (i != yym) fputs(", ", stderr);
                    fputs(YYSTYPE_TOSTRING(yystos[yystack.s_mark[1-i]],
                                           yystack.l_mark[1-i]), stderr);
                }
                fputc('>', stderr);
            }
#endif
        fputc('\n', stderr);
    }
#endif
    if (yym > 0)
        yyval = yystack.l_mark[1-yym];
    else
        memset(&yyval, 0, sizeof yyval);
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)

    /* Perform position reduction */
    memset(&yyloc, 0, sizeof(yyloc));
#if YYBTYACC
    if (!yytrial)
#endif /* YYBTYACC */
    {
        YYLLOC_DEFAULT(yyloc, &yystack.p_mark[-yym], yym);
        /* just in case YYERROR is invoked within the action, save
           the start of the rhs as the error start position */
        yyerror_loc_range[1] = yystack.p_mark[1-yym];
    }
#endif

    switch (yyn)
    {
case 2:
#line 280 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (olist.head)
		    print_picture(olist.head);
		}
#line 1 ""
break;
case 3:
#line 289 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pl = yystack.l_mark[-1].pl; }
#line 1 ""
break;
case 4:
#line 294 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pl = yystack.l_mark[0].pl; }
#line 1 ""
break;
case 5:
#line 296 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pl = yystack.l_mark[-2].pl; }
#line 1 ""
break;
case 10:
#line 311 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  a_delete graphname;
		  graphname = new char[strlen(yystack.l_mark[0].str) + 1];
		  strcpy(graphname, yystack.l_mark[0].str);
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 11:
#line 319 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  define_variable(yystack.l_mark[-2].str, yystack.l_mark[0].x);
		  a_delete yystack.l_mark[-2].str;
		}
#line 1 ""
break;
case 12:
#line 324 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  place *p = lookup_label(yystack.l_mark[-3].str);
		  if (!p) {
		    lex_error("variable `%1' not defined", yystack.l_mark[-3].str);
		    YYABORT;
		  }
		  p->obj = 0;
		  p->x = yystack.l_mark[0].x;
		  p->y = 0.0;
		  a_delete yystack.l_mark[-3].str;
		}
#line 1 ""
break;
case 13:
#line 336 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ current_direction = UP_DIRECTION; }
#line 1 ""
break;
case 14:
#line 338 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ current_direction = DOWN_DIRECTION; }
#line 1 ""
break;
case 15:
#line 340 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ current_direction = LEFT_DIRECTION; }
#line 1 ""
break;
case 16:
#line 342 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ current_direction = RIGHT_DIRECTION; }
#line 1 ""
break;
case 17:
#line 344 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  olist.append(make_command_object(yystack.l_mark[0].lstr.str, yystack.l_mark[0].lstr.filename,
						   yystack.l_mark[0].lstr.lineno));
		}
#line 1 ""
break;
case 18:
#line 349 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  olist.append(make_command_object(yystack.l_mark[0].lstr.str, yystack.l_mark[0].lstr.filename,
						   yystack.l_mark[0].lstr.lineno));
		}
#line 1 ""
break;
case 19:
#line 354 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  fprintf(stderr, "%s\n", yystack.l_mark[0].lstr.str);
		  a_delete yystack.l_mark[0].lstr.str;
		  fflush(stderr);
		}
#line 1 ""
break;
case 20:
#line 360 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 1; }
#line 1 ""
break;
case 21:
#line 362 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  delim_flag = 0;
		  if (safer_flag)
		    lex_error("unsafe to run command `%1'", yystack.l_mark[0].str);
		  else
		    system(yystack.l_mark[0].str);
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 22:
#line 371 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yychar < 0)
		    do_lookahead();
		  do_copy(yystack.l_mark[0].lstr.str);
		  /* do not delete the filename*/
		}
#line 1 ""
break;
case 23:
#line 378 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 2; }
#line 1 ""
break;
case 24:
#line 380 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 0; }
#line 1 ""
break;
case 25:
#line 382 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yychar < 0)
		    do_lookahead();
		  copy_file_thru(yystack.l_mark[-5].lstr.str, yystack.l_mark[-2].str, yystack.l_mark[0].str);
		  /* do not delete the filename*/
		  a_delete yystack.l_mark[-2].str;
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 26:
#line 391 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 2; }
#line 1 ""
break;
case 27:
#line 393 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 0; }
#line 1 ""
break;
case 28:
#line 395 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yychar < 0)
		    do_lookahead();
		  copy_rest_thru(yystack.l_mark[-2].str, yystack.l_mark[0].str);
		  a_delete yystack.l_mark[-2].str;
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 29:
#line 403 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 1; }
#line 1 ""
break;
case 30:
#line 405 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  delim_flag = 0;
		  if (yychar < 0)
		    do_lookahead();
		  do_for(yystack.l_mark[-8].str, yystack.l_mark[-6].x, yystack.l_mark[-4].x, yystack.l_mark[-3].by.is_multiplicative, yystack.l_mark[-3].by.val, yystack.l_mark[0].str); 
		}
#line 1 ""
break;
case 31:
#line 412 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yychar < 0)
		    do_lookahead();
		  if (yystack.l_mark[0].if_data.x != 0.0)
		    push_body(yystack.l_mark[0].if_data.body);
		  a_delete yystack.l_mark[0].if_data.body;
		}
#line 1 ""
break;
case 32:
#line 420 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 1; }
#line 1 ""
break;
case 33:
#line 422 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  delim_flag = 0;
		  if (yychar < 0)
		    do_lookahead();
		  if (yystack.l_mark[-3].if_data.x != 0.0)
		    push_body(yystack.l_mark[-3].if_data.body);
		  else
		    push_body(yystack.l_mark[0].str);
		  a_delete yystack.l_mark[-3].if_data.body;
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 35:
#line 435 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ define_variable("scale", 1.0); }
#line 1 ""
break;
case 38:
#line 445 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  reset(yystack.l_mark[0].str);
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 39:
#line 450 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  reset(yystack.l_mark[0].str);
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 40:
#line 455 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  reset(yystack.l_mark[0].str);
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 41:
#line 463 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.lstr = yystack.l_mark[0].lstr; }
#line 1 ""
break;
case 42:
#line 465 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.lstr.str = new char[strlen(yystack.l_mark[-1].lstr.str) + strlen(yystack.l_mark[0].lstr.str) + 1];
		  strcpy(yyval.lstr.str, yystack.l_mark[-1].lstr.str);
		  strcat(yyval.lstr.str, yystack.l_mark[0].lstr.str);
		  a_delete yystack.l_mark[-1].lstr.str;
		  a_delete yystack.l_mark[0].lstr.str;
		  if (yystack.l_mark[-1].lstr.filename) {
		    yyval.lstr.filename = yystack.l_mark[-1].lstr.filename;
		    yyval.lstr.lineno = yystack.l_mark[-1].lstr.lineno;
		  }
		  else if (yystack.l_mark[0].lstr.filename) {
		    yyval.lstr.filename = yystack.l_mark[0].lstr.filename;
		    yyval.lstr.lineno = yystack.l_mark[0].lstr.lineno;
		  }
		}
#line 1 ""
break;
case 43:
#line 484 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.lstr.str = new char[GDIGITS + 1];
		  sprintf(yyval.lstr.str, "%g", yystack.l_mark[0].x);
		  yyval.lstr.filename = 0;
		  yyval.lstr.lineno = 0;
		}
#line 1 ""
break;
case 44:
#line 491 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.lstr = yystack.l_mark[0].lstr; }
#line 1 ""
break;
case 45:
#line 493 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.lstr.str = new char[GDIGITS + 2 + GDIGITS + 1];
		  sprintf(yyval.lstr.str, "%g, %g", yystack.l_mark[0].pair.x, yystack.l_mark[0].pair.y);
		  yyval.lstr.filename = 0;
		  yyval.lstr.lineno = 0;
		}
#line 1 ""
break;
case 46:
#line 503 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ delim_flag = 1; }
#line 1 ""
break;
case 47:
#line 505 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  delim_flag = 0;
		  yyval.if_data.x = yystack.l_mark[-3].x;
		  yyval.if_data.body = yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 48:
#line 514 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.str = 0; }
#line 1 ""
break;
case 49:
#line 516 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.str = yystack.l_mark[0].lstr.str; }
#line 1 ""
break;
case 50:
#line 521 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[0].x; }
#line 1 ""
break;
case 51:
#line 523 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[0].x; }
#line 1 ""
break;
case 52:
#line 528 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.x = strcmp(yystack.l_mark[-2].lstr.str, yystack.l_mark[0].lstr.str) == 0;
		  a_delete yystack.l_mark[-2].lstr.str;
		  a_delete yystack.l_mark[0].lstr.str;
		}
#line 1 ""
break;
case 53:
#line 534 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.x = strcmp(yystack.l_mark[-2].lstr.str, yystack.l_mark[0].lstr.str) != 0;
		  a_delete yystack.l_mark[-2].lstr.str;
		  a_delete yystack.l_mark[0].lstr.str;
		}
#line 1 ""
break;
case 54:
#line 540 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 && yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 55:
#line 542 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 && yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 56:
#line 544 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 && yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 57:
#line 546 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 || yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 58:
#line 548 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 || yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 59:
#line 550 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 || yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 60:
#line 552 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[0].x == 0.0); }
#line 1 ""
break;
case 61:
#line 558 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.by.val = 1.0;
		  yyval.by.is_multiplicative = 0;
		}
#line 1 ""
break;
case 62:
#line 563 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.by.val = yystack.l_mark[0].x;
		  yyval.by.is_multiplicative = 0;
		}
#line 1 ""
break;
case 63:
#line 568 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.by.val = yystack.l_mark[0].x;
		  yyval.by.is_multiplicative = 1;
		}
#line 1 ""
break;
case 64:
#line 576 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl.obj = yystack.l_mark[0].spec->make_object(&current_position,
					   &current_direction);
		  if (yyval.pl.obj == 0)
		    YYABORT;
		  delete yystack.l_mark[0].spec;
		  if (yyval.pl.obj)
		    olist.append(yyval.pl.obj);
		  else {
		    yyval.pl.x = current_position.x;
		    yyval.pl.y = current_position.y;
		  }
		}
#line 1 ""
break;
case 65:
#line 590 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl = yystack.l_mark[0].pl;
		  define_label(yystack.l_mark[-3].str, & yyval.pl);
		  a_delete yystack.l_mark[-3].str;
		}
#line 1 ""
break;
case 66:
#line 596 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl.obj = 0;
		  yyval.pl.x = yystack.l_mark[0].pair.x;
		  yyval.pl.y = yystack.l_mark[0].pair.y;
		  define_label(yystack.l_mark[-3].str, & yyval.pl);
		  a_delete yystack.l_mark[-3].str;
		}
#line 1 ""
break;
case 67:
#line 604 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl = yystack.l_mark[0].pl;
		  define_label(yystack.l_mark[-3].str, & yyval.pl);
		  a_delete yystack.l_mark[-3].str;
		}
#line 1 ""
break;
case 68:
#line 610 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.state.x = current_position.x;
		  yyval.state.y = current_position.y;
		  yyval.state.dir = current_direction;
		}
#line 1 ""
break;
case 69:
#line 616 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  current_position.x = yystack.l_mark[-2].state.x;
		  current_position.y = yystack.l_mark[-2].state.y;
		  current_direction = yystack.l_mark[-2].state.dir;
		}
#line 1 ""
break;
case 70:
#line 622 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl = yystack.l_mark[-3].pl;
		}
#line 1 ""
break;
case 71:
#line 626 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl.obj = 0;
		  yyval.pl.x = current_position.x;
		  yyval.pl.y = current_position.y;
		}
#line 1 ""
break;
case 72:
#line 635 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{}
#line 1 ""
break;
case 73:
#line 637 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{}
#line 1 ""
break;
case 74:
#line 642 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.spec = new object_spec(BOX_OBJECT); }
#line 1 ""
break;
case 75:
#line 644 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.spec = new object_spec(CIRCLE_OBJECT); }
#line 1 ""
break;
case 76:
#line 646 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.spec = new object_spec(ELLIPSE_OBJECT); }
#line 1 ""
break;
case 77:
#line 648 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(ARC_OBJECT);
		  yyval.spec->dir = current_direction;
		}
#line 1 ""
break;
case 78:
#line 653 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(LINE_OBJECT);
		  lookup_variable("lineht", & yyval.spec->segment_height);
		  lookup_variable("linewid", & yyval.spec->segment_width);
		  yyval.spec->dir = current_direction;
		}
#line 1 ""
break;
case 79:
#line 660 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(ARROW_OBJECT);
		  lookup_variable("lineht", & yyval.spec->segment_height);
		  lookup_variable("linewid", & yyval.spec->segment_width);
		  yyval.spec->dir = current_direction;
		}
#line 1 ""
break;
case 80:
#line 667 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(MOVE_OBJECT);
		  lookup_variable("moveht", & yyval.spec->segment_height);
		  lookup_variable("movewid", & yyval.spec->segment_width);
		  yyval.spec->dir = current_direction;
		}
#line 1 ""
break;
case 81:
#line 674 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(SPLINE_OBJECT);
		  lookup_variable("lineht", & yyval.spec->segment_height);
		  lookup_variable("linewid", & yyval.spec->segment_width);
		  yyval.spec->dir = current_direction;
		}
#line 1 ""
break;
case 82:
#line 681 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(TEXT_OBJECT);
		  yyval.spec->text = new text_item(yystack.l_mark[0].lstr.str, yystack.l_mark[0].lstr.filename, yystack.l_mark[0].lstr.lineno);
		}
#line 1 ""
break;
case 83:
#line 686 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(TEXT_OBJECT);
		  yyval.spec->text = new text_item(format_number(0, yystack.l_mark[0].x), 0, -1);
		}
#line 1 ""
break;
case 84:
#line 691 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = new object_spec(TEXT_OBJECT);
		  yyval.spec->text = new text_item(format_number(yystack.l_mark[0].lstr.str, yystack.l_mark[-1].x),
					   yystack.l_mark[0].lstr.filename, yystack.l_mark[0].lstr.lineno);
		  a_delete yystack.l_mark[0].lstr.str;
		}
#line 1 ""
break;
case 85:
#line 698 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  saved_state *p = new saved_state;
		  yyval.pstate = p;
		  p->x = current_position.x;
		  p->y = current_position.y;
		  p->dir = current_direction;
		  p->tbl = current_table;
		  p->prev = current_saved_state;
		  current_position.x = 0.0;
		  current_position.y = 0.0;
		  current_table = new PTABLE(place);
		  current_saved_state = p;
		  olist.append(make_mark_object());
		}
#line 1 ""
break;
case 86:
#line 713 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  current_position.x = yystack.l_mark[-2].pstate->x;
		  current_position.y = yystack.l_mark[-2].pstate->y;
		  current_direction = yystack.l_mark[-2].pstate->dir;
		  yyval.spec = new object_spec(BLOCK_OBJECT);
		  olist.wrap_up_block(& yyval.spec->oblist);
		  yyval.spec->tbl = current_table;
		  current_table = yystack.l_mark[-2].pstate->tbl;
		  current_saved_state = yystack.l_mark[-2].pstate->prev;
		  delete yystack.l_mark[-2].pstate;
		}
#line 1 ""
break;
case 87:
#line 725 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->height = yystack.l_mark[0].x;
		  yyval.spec->flags |= HAS_HEIGHT;
		}
#line 1 ""
break;
case 88:
#line 731 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->radius = yystack.l_mark[0].x;
		  yyval.spec->flags |= HAS_RADIUS;
		}
#line 1 ""
break;
case 89:
#line 737 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->width = yystack.l_mark[0].x;
		  yyval.spec->flags |= HAS_WIDTH;
		}
#line 1 ""
break;
case 90:
#line 743 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->radius = yystack.l_mark[0].x/2.0;
		  yyval.spec->flags |= HAS_RADIUS;
		}
#line 1 ""
break;
case 91:
#line 749 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= HAS_SEGMENT;
		  switch (yyval.spec->dir) {
		  case UP_DIRECTION:
		    yyval.spec->segment_pos.y += yystack.l_mark[0].x;
		    break;
		  case DOWN_DIRECTION:
		    yyval.spec->segment_pos.y -= yystack.l_mark[0].x;
		    break;
		  case RIGHT_DIRECTION:
		    yyval.spec->segment_pos.x += yystack.l_mark[0].x;
		    break;
		  case LEFT_DIRECTION:
		    yyval.spec->segment_pos.x -= yystack.l_mark[0].x;
		    break;
		  }
		}
#line 1 ""
break;
case 92:
#line 768 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->dir = UP_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.y += yyval.spec->segment_height;
		}
#line 1 ""
break;
case 93:
#line 775 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->dir = UP_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.y += yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 94:
#line 782 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->dir = DOWN_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.y -= yyval.spec->segment_height;
		}
#line 1 ""
break;
case 95:
#line 789 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->dir = DOWN_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.y -= yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 96:
#line 796 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->dir = RIGHT_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.x += yyval.spec->segment_width;
		}
#line 1 ""
break;
case 97:
#line 803 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->dir = RIGHT_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.x += yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 98:
#line 810 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->dir = LEFT_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.x -= yyval.spec->segment_width;
		}
#line 1 ""
break;
case 99:
#line 817 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->dir = LEFT_DIRECTION;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.x -= yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 100:
#line 824 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= HAS_FROM;
		  yyval.spec->from.x = yystack.l_mark[0].pair.x;
		  yyval.spec->from.y = yystack.l_mark[0].pair.y;
		}
#line 1 ""
break;
case 101:
#line 831 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  if (yyval.spec->flags & HAS_SEGMENT)
		    yyval.spec->segment_list = new segment(yyval.spec->segment_pos,
						   yyval.spec->segment_is_absolute,
						   yyval.spec->segment_list);
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.x = yystack.l_mark[0].pair.x;
		  yyval.spec->segment_pos.y = yystack.l_mark[0].pair.y;
		  yyval.spec->segment_is_absolute = 1;
		  yyval.spec->flags |= HAS_TO;
		  yyval.spec->to.x = yystack.l_mark[0].pair.x;
		  yyval.spec->to.y = yystack.l_mark[0].pair.y;
		}
#line 1 ""
break;
case 102:
#line 846 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= HAS_AT;
		  yyval.spec->at.x = yystack.l_mark[0].pair.x;
		  yyval.spec->at.y = yystack.l_mark[0].pair.y;
		  if (yyval.spec->type != ARC_OBJECT) {
		    yyval.spec->flags |= HAS_FROM;
		    yyval.spec->from.x = yystack.l_mark[0].pair.x;
		    yyval.spec->from.y = yystack.l_mark[0].pair.y;
		  }
		}
#line 1 ""
break;
case 103:
#line 858 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= HAS_WITH;
		  yyval.spec->with = yystack.l_mark[0].pth;
		}
#line 1 ""
break;
case 104:
#line 864 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= HAS_WITH;
		  position pos;
		  pos.x = yystack.l_mark[0].pair.x;
		  pos.y = yystack.l_mark[0].pair.y;
		  yyval.spec->with = new path(pos);
		}
#line 1 ""
break;
case 105:
#line 873 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= HAS_SEGMENT;
		  yyval.spec->segment_pos.x += yystack.l_mark[0].pair.x;
		  yyval.spec->segment_pos.y += yystack.l_mark[0].pair.y;
		}
#line 1 ""
break;
case 106:
#line 880 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  if (yyval.spec->flags & HAS_SEGMENT) {
		    yyval.spec->segment_list = new segment(yyval.spec->segment_pos,
						   yyval.spec->segment_is_absolute,
						   yyval.spec->segment_list);
		    yyval.spec->flags &= ~HAS_SEGMENT;
		    yyval.spec->segment_pos.x = yyval.spec->segment_pos.y = 0.0;
		    yyval.spec->segment_is_absolute = 0;
		  }
		}
#line 1 ""
break;
case 107:
#line 892 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;	/* nothing*/
		}
#line 1 ""
break;
case 108:
#line 896 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_DOTTED;
		  lookup_variable("dashwid", & yyval.spec->dash_width);
		}
#line 1 ""
break;
case 109:
#line 902 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= IS_DOTTED;
		  yyval.spec->dash_width = yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 110:
#line 908 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_DASHED;
		  lookup_variable("dashwid", & yyval.spec->dash_width);
		}
#line 1 ""
break;
case 111:
#line 914 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= IS_DASHED;
		  yyval.spec->dash_width = yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 112:
#line 920 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_DEFAULT_FILLED;
		}
#line 1 ""
break;
case 113:
#line 925 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= IS_FILLED;
		  yyval.spec->fill = yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 114:
#line 931 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= (IS_SHADED | IS_FILLED);
		  yyval.spec->shaded = new char[strlen(yystack.l_mark[0].lstr.str)+1];
		  strcpy(yyval.spec->shaded, yystack.l_mark[0].lstr.str);
		}
#line 1 ""
break;
case 115:
#line 938 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= (IS_SHADED | IS_OUTLINED | IS_FILLED);
		  yyval.spec->shaded = new char[strlen(yystack.l_mark[0].lstr.str)+1];
		  strcpy(yyval.spec->shaded, yystack.l_mark[0].lstr.str);
		  yyval.spec->outlined = new char[strlen(yystack.l_mark[0].lstr.str)+1];
		  strcpy(yyval.spec->outlined, yystack.l_mark[0].lstr.str);
		}
#line 1 ""
break;
case 116:
#line 947 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= IS_OUTLINED;
		  yyval.spec->outlined = new char[strlen(yystack.l_mark[0].lstr.str)+1];
		  strcpy(yyval.spec->outlined, yystack.l_mark[0].lstr.str);
		}
#line 1 ""
break;
case 117:
#line 954 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  /* line chop chop means line chop 0 chop 0*/
		  if (yyval.spec->flags & IS_DEFAULT_CHOPPED) {
		    yyval.spec->flags |= IS_CHOPPED;
		    yyval.spec->flags &= ~IS_DEFAULT_CHOPPED;
		    yyval.spec->start_chop = yyval.spec->end_chop = 0.0;
		  }
		  else if (yyval.spec->flags & IS_CHOPPED) {
		    yyval.spec->end_chop = 0.0;
		  }
		  else {
		    yyval.spec->flags |= IS_DEFAULT_CHOPPED;
		  }
		}
#line 1 ""
break;
case 118:
#line 970 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  if (yyval.spec->flags & IS_DEFAULT_CHOPPED) {
		    yyval.spec->flags |= IS_CHOPPED;
		    yyval.spec->flags &= ~IS_DEFAULT_CHOPPED;
		    yyval.spec->start_chop = 0.0;
		    yyval.spec->end_chop = yystack.l_mark[0].x;
		  }
		  else if (yyval.spec->flags & IS_CHOPPED) {
		    yyval.spec->end_chop = yystack.l_mark[0].x;
		  }
		  else {
		    yyval.spec->start_chop = yyval.spec->end_chop = yystack.l_mark[0].x;
		    yyval.spec->flags |= IS_CHOPPED;
		  }
		}
#line 1 ""
break;
case 119:
#line 987 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_SAME;
		}
#line 1 ""
break;
case 120:
#line 992 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_INVISIBLE;
		}
#line 1 ""
break;
case 121:
#line 997 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= HAS_LEFT_ARROW_HEAD;
		}
#line 1 ""
break;
case 122:
#line 1002 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= HAS_RIGHT_ARROW_HEAD;
		}
#line 1 ""
break;
case 123:
#line 1007 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= (HAS_LEFT_ARROW_HEAD|HAS_RIGHT_ARROW_HEAD);
		}
#line 1 ""
break;
case 124:
#line 1012 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_CLOCKWISE;
		}
#line 1 ""
break;
case 125:
#line 1017 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags &= ~IS_CLOCKWISE;
		}
#line 1 ""
break;
case 126:
#line 1022 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  text_item **p;
		  for (p = & yyval.spec->text; *p; p = &(*p)->next)
		    ;
		  *p = new text_item(yystack.l_mark[0].lstr.str, yystack.l_mark[0].lstr.filename, yystack.l_mark[0].lstr.lineno);
		}
#line 1 ""
break;
case 127:
#line 1030 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  if (yyval.spec->text) {
		    text_item *p;
		    for (p = yyval.spec->text; p->next; p = p->next)
		      ;
		    p->adj.h = LEFT_ADJUST;
		  }
		}
#line 1 ""
break;
case 128:
#line 1040 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  if (yyval.spec->text) {
		    text_item *p;
		    for (p = yyval.spec->text; p->next; p = p->next)
		      ;
		    p->adj.h = RIGHT_ADJUST;
		  }
		}
#line 1 ""
break;
case 129:
#line 1050 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  if (yyval.spec->text) {
		    text_item *p;
		    for (p = yyval.spec->text; p->next; p = p->next)
		      ;
		    p->adj.v = ABOVE_ADJUST;
		  }
		}
#line 1 ""
break;
case 130:
#line 1060 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  if (yyval.spec->text) {
		    text_item *p;
		    for (p = yyval.spec->text; p->next; p = p->next)
		      ;
		    p->adj.v = BELOW_ADJUST;
		  }
		}
#line 1 ""
break;
case 131:
#line 1070 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-2].spec;
		  yyval.spec->flags |= HAS_THICKNESS;
		  yyval.spec->thickness = yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 132:
#line 1076 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.spec = yystack.l_mark[-1].spec;
		  yyval.spec->flags |= IS_ALIGNED;
		}
#line 1 ""
break;
case 133:
#line 1084 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.lstr = yystack.l_mark[0].lstr; }
#line 1 ""
break;
case 134:
#line 1086 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.lstr.filename = yystack.l_mark[-2].lstr.filename;
		  yyval.lstr.lineno = yystack.l_mark[-2].lstr.lineno;
		  yyval.lstr.str = do_sprintf(yystack.l_mark[-2].lstr.str, yystack.l_mark[-1].dv.v, yystack.l_mark[-1].dv.nv);
		  a_delete yystack.l_mark[-1].dv.v;
		  a_delete yystack.l_mark[-2].lstr.str;
		}
#line 1 ""
break;
case 135:
#line 1097 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.dv.v = 0;
		  yyval.dv.nv = 0;
		  yyval.dv.maxv = 0;
		}
#line 1 ""
break;
case 136:
#line 1103 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.dv = yystack.l_mark[-2].dv;
		  if (yyval.dv.nv >= yyval.dv.maxv) {
		    if (yyval.dv.nv == 0) {
		      yyval.dv.v = new double[4];
		      yyval.dv.maxv = 4;
		    }
		    else {
		      double *oldv = yyval.dv.v;
		      yyval.dv.maxv *= 2;
#if 0
		      yyval.dv.v = new double[yyval.dv.maxv];
		      memcpy(yyval.dv.v, oldv, yyval.dv.nv*sizeof(double));
#else
		      /* workaround for bug in Compaq C++ V6.5-033*/
		      /* for Compaq Tru64 UNIX V5.1A (Rev. 1885)*/
		      double *foo = new double[yyval.dv.maxv];
		      memcpy(foo, oldv, yyval.dv.nv*sizeof(double));
		      yyval.dv.v = foo;
#endif
		      a_delete oldv;
		    }
		  }
		  yyval.dv.v[yyval.dv.nv] = yystack.l_mark[0].x;
		  yyval.dv.nv += 1;
		}
#line 1 ""
break;
case 137:
#line 1133 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pair = yystack.l_mark[0].pair; }
#line 1 ""
break;
case 138:
#line 1135 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  position pos = yystack.l_mark[0].pl;
		  yyval.pair.x = pos.x;
		  yyval.pair.y = pos.y;
		}
#line 1 ""
break;
case 139:
#line 1141 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  position pos = yystack.l_mark[-1].pl;
		  yyval.pair.x = pos.x;
		  yyval.pair.y = pos.y;
		}
#line 1 ""
break;
case 140:
#line 1150 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pair = yystack.l_mark[0].pair; }
#line 1 ""
break;
case 141:
#line 1152 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = yystack.l_mark[-2].pair.x + yystack.l_mark[0].pair.x;
		  yyval.pair.y = yystack.l_mark[-2].pair.y + yystack.l_mark[0].pair.y;
		}
#line 1 ""
break;
case 142:
#line 1157 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = yystack.l_mark[-3].pair.x + yystack.l_mark[-1].pair.x;
		  yyval.pair.y = yystack.l_mark[-3].pair.y + yystack.l_mark[-1].pair.y;
		}
#line 1 ""
break;
case 143:
#line 1162 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = yystack.l_mark[-2].pair.x - yystack.l_mark[0].pair.x;
		  yyval.pair.y = yystack.l_mark[-2].pair.y - yystack.l_mark[0].pair.y;
		}
#line 1 ""
break;
case 144:
#line 1167 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = yystack.l_mark[-3].pair.x - yystack.l_mark[-1].pair.x;
		  yyval.pair.y = yystack.l_mark[-3].pair.y - yystack.l_mark[-1].pair.y;
		}
#line 1 ""
break;
case 145:
#line 1172 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = yystack.l_mark[-3].pair.x;
		  yyval.pair.y = yystack.l_mark[-1].pair.y;
		}
#line 1 ""
break;
case 146:
#line 1177 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = (1.0 - yystack.l_mark[-4].x)*yystack.l_mark[-2].pair.x + yystack.l_mark[-4].x*yystack.l_mark[0].pair.x;
		  yyval.pair.y = (1.0 - yystack.l_mark[-4].x)*yystack.l_mark[-2].pair.y + yystack.l_mark[-4].x*yystack.l_mark[0].pair.y;
		}
#line 1 ""
break;
case 147:
#line 1182 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = (1.0 - yystack.l_mark[-5].x)*yystack.l_mark[-3].pair.x + yystack.l_mark[-5].x*yystack.l_mark[-1].pair.x;
		  yyval.pair.y = (1.0 - yystack.l_mark[-5].x)*yystack.l_mark[-3].pair.y + yystack.l_mark[-5].x*yystack.l_mark[-1].pair.y;
		}
#line 1 ""
break;
case 148:
#line 1187 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = (1.0 - yystack.l_mark[-5].x)*yystack.l_mark[-3].pair.x + yystack.l_mark[-5].x*yystack.l_mark[-1].pair.x;
		  yyval.pair.y = (1.0 - yystack.l_mark[-5].x)*yystack.l_mark[-3].pair.y + yystack.l_mark[-5].x*yystack.l_mark[-1].pair.y;
		}
#line 1 ""
break;
case 149:
#line 1192 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = (1.0 - yystack.l_mark[-6].x)*yystack.l_mark[-4].pair.x + yystack.l_mark[-6].x*yystack.l_mark[-2].pair.x;
		  yyval.pair.y = (1.0 - yystack.l_mark[-6].x)*yystack.l_mark[-4].pair.y + yystack.l_mark[-6].x*yystack.l_mark[-2].pair.y;
		}
#line 1 ""
break;
case 152:
#line 1205 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pair.x = yystack.l_mark[-2].x;
		  yyval.pair.y = yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 153:
#line 1210 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pair = yystack.l_mark[-1].pair; }
#line 1 ""
break;
case 154:
#line 1216 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pl = yystack.l_mark[0].pl; }
#line 1 ""
break;
case 155:
#line 1218 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  path pth(yystack.l_mark[0].crn);
		  if (!pth.follow(yystack.l_mark[-1].pl, & yyval.pl))
		    YYABORT;
		}
#line 1 ""
break;
case 156:
#line 1224 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  path pth(yystack.l_mark[-1].crn);
		  if (!pth.follow(yystack.l_mark[0].pl, & yyval.pl))
		    YYABORT;
		}
#line 1 ""
break;
case 157:
#line 1230 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  path pth(yystack.l_mark[-2].crn);
		  if (!pth.follow(yystack.l_mark[0].pl, & yyval.pl))
		    YYABORT;
		}
#line 1 ""
break;
case 158:
#line 1236 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pl.x = current_position.x;
		  yyval.pl.y = current_position.y;
		  yyval.pl.obj = 0;
		}
#line 1 ""
break;
case 159:
#line 1245 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  place *p = lookup_label(yystack.l_mark[0].str);
		  if (!p) {
		    lex_error("there is no place `%1'", yystack.l_mark[0].str);
		    YYABORT;
		  }
		  yyval.pl = *p;
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 160:
#line 1255 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pl.obj = yystack.l_mark[0].obj; }
#line 1 ""
break;
case 161:
#line 1257 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  path pth(yystack.l_mark[0].str);
		  if (!pth.follow(yystack.l_mark[-2].pl, & yyval.pl))
		    YYABORT;
		}
#line 1 ""
break;
case 162:
#line 1266 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.n = yystack.l_mark[0].n; }
#line 1 ""
break;
case 163:
#line 1268 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  /* XXX Check for overflow (and non-integers?).*/
		  yyval.n = (int)yystack.l_mark[-1].x;
		}
#line 1 ""
break;
case 164:
#line 1276 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.n = 1; }
#line 1 ""
break;
case 165:
#line 1278 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.n = yystack.l_mark[-1].n; }
#line 1 ""
break;
case 166:
#line 1283 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  int count = 0;
		  object *p;
		  for (p = olist.head; p != 0; p = p->next)
		    if (p->type() == yystack.l_mark[0].obtype && ++count == yystack.l_mark[-1].n) {
		      yyval.obj = p;
		      break;
		    }
		  if (p == 0) {
		    lex_error("there is no %1%2 %3", yystack.l_mark[-1].n, ordinal_postfix(yystack.l_mark[-1].n),
			      object_type_name(yystack.l_mark[0].obtype));
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 167:
#line 1298 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  int count = 0;
		  object *p;
		  for (p = olist.tail; p != 0; p = p->prev)
		    if (p->type() == yystack.l_mark[0].obtype && ++count == yystack.l_mark[-1].n) {
		      yyval.obj = p;
		      break;
		    }
		  if (p == 0) {
		    lex_error("there is no %1%2 last %3", yystack.l_mark[-1].n,
			      ordinal_postfix(yystack.l_mark[-1].n), object_type_name(yystack.l_mark[0].obtype));
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 168:
#line 1316 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = BOX_OBJECT; }
#line 1 ""
break;
case 169:
#line 1318 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = CIRCLE_OBJECT; }
#line 1 ""
break;
case 170:
#line 1320 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = ELLIPSE_OBJECT; }
#line 1 ""
break;
case 171:
#line 1322 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = ARC_OBJECT; }
#line 1 ""
break;
case 172:
#line 1324 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = LINE_OBJECT; }
#line 1 ""
break;
case 173:
#line 1326 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = ARROW_OBJECT; }
#line 1 ""
break;
case 174:
#line 1328 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = SPLINE_OBJECT; }
#line 1 ""
break;
case 175:
#line 1330 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = BLOCK_OBJECT; }
#line 1 ""
break;
case 176:
#line 1332 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.obtype = TEXT_OBJECT; }
#line 1 ""
break;
case 177:
#line 1337 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pth = new path(yystack.l_mark[0].str); }
#line 1 ""
break;
case 178:
#line 1339 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pth = yystack.l_mark[-2].pth;
		  yyval.pth->append(yystack.l_mark[0].str);
		}
#line 1 ""
break;
case 179:
#line 1347 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pth = new path(yystack.l_mark[0].crn); }
#line 1 ""
break;
case 180:
#line 1351 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pth = yystack.l_mark[0].pth; }
#line 1 ""
break;
case 181:
#line 1353 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pth = yystack.l_mark[-1].pth;
		  yyval.pth->append(yystack.l_mark[0].crn);
		}
#line 1 ""
break;
case 182:
#line 1361 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.pth = yystack.l_mark[0].pth; }
#line 1 ""
break;
case 183:
#line 1363 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.pth = yystack.l_mark[-3].pth;
		  yyval.pth->set_ypath(yystack.l_mark[-1].pth);
		}
#line 1 ""
break;
case 184:
#line 1369 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  lex_warning("`%1%2 last %3' in `with' argument ignored",
			      yystack.l_mark[-3].n, ordinal_postfix(yystack.l_mark[-3].n), object_type_name(yystack.l_mark[-1].obtype));
		  yyval.pth = yystack.l_mark[0].pth;
		}
#line 1 ""
break;
case 185:
#line 1375 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  lex_warning("`last %1' in `with' argument ignored",
			      object_type_name(yystack.l_mark[-1].obtype));
		  yyval.pth = yystack.l_mark[0].pth;
		}
#line 1 ""
break;
case 186:
#line 1381 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  lex_warning("`%1%2 %3' in `with' argument ignored",
			      yystack.l_mark[-2].n, ordinal_postfix(yystack.l_mark[-2].n), object_type_name(yystack.l_mark[-1].obtype));
		  yyval.pth = yystack.l_mark[0].pth;
		}
#line 1 ""
break;
case 187:
#line 1387 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  lex_warning("initial `%1' in `with' argument ignored", yystack.l_mark[-1].str);
		  a_delete yystack.l_mark[-1].str;
		  yyval.pth = yystack.l_mark[0].pth;
		}
#line 1 ""
break;
case 188:
#line 1396 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north; }
#line 1 ""
break;
case 189:
#line 1398 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::east; }
#line 1 ""
break;
case 190:
#line 1400 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::west; }
#line 1 ""
break;
case 191:
#line 1402 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south; }
#line 1 ""
break;
case 192:
#line 1404 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north_east; }
#line 1 ""
break;
case 193:
#line 1406 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object:: south_east; }
#line 1 ""
break;
case 194:
#line 1408 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north_west; }
#line 1 ""
break;
case 195:
#line 1410 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south_west; }
#line 1 ""
break;
case 196:
#line 1412 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::center; }
#line 1 ""
break;
case 197:
#line 1414 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::start; }
#line 1 ""
break;
case 198:
#line 1416 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::end; }
#line 1 ""
break;
case 199:
#line 1418 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north; }
#line 1 ""
break;
case 200:
#line 1420 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south; }
#line 1 ""
break;
case 201:
#line 1422 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::west; }
#line 1 ""
break;
case 202:
#line 1424 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::east; }
#line 1 ""
break;
case 203:
#line 1426 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north_west; }
#line 1 ""
break;
case 204:
#line 1428 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south_west; }
#line 1 ""
break;
case 205:
#line 1430 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north_east; }
#line 1 ""
break;
case 206:
#line 1432 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south_east; }
#line 1 ""
break;
case 207:
#line 1434 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::west; }
#line 1 ""
break;
case 208:
#line 1436 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::east; }
#line 1 ""
break;
case 209:
#line 1438 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north_west; }
#line 1 ""
break;
case 210:
#line 1440 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south_west; }
#line 1 ""
break;
case 211:
#line 1442 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north_east; }
#line 1 ""
break;
case 212:
#line 1444 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south_east; }
#line 1 ""
break;
case 213:
#line 1446 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::north; }
#line 1 ""
break;
case 214:
#line 1448 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::south; }
#line 1 ""
break;
case 215:
#line 1450 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::east; }
#line 1 ""
break;
case 216:
#line 1452 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::west; }
#line 1 ""
break;
case 217:
#line 1454 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::center; }
#line 1 ""
break;
case 218:
#line 1456 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::start; }
#line 1 ""
break;
case 219:
#line 1458 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.crn = &object::end; }
#line 1 ""
break;
case 220:
#line 1463 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (!lookup_variable(yystack.l_mark[0].str, & yyval.x)) {
		    lex_error("there is no variable `%1'", yystack.l_mark[0].str);
		    YYABORT;
		  }
		  a_delete yystack.l_mark[0].str;
		}
#line 1 ""
break;
case 221:
#line 1471 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[0].x; }
#line 1 ""
break;
case 222:
#line 1473 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[-1].pl.obj != 0)
		    yyval.x = yystack.l_mark[-1].pl.obj->origin().x;
		  else
		    yyval.x = yystack.l_mark[-1].pl.x;
		}
#line 1 ""
break;
case 223:
#line 1480 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[-1].pl.obj != 0)
		    yyval.x = yystack.l_mark[-1].pl.obj->origin().y;
		  else
		    yyval.x = yystack.l_mark[-1].pl.y;
		}
#line 1 ""
break;
case 224:
#line 1487 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[-1].pl.obj != 0)
		    yyval.x = yystack.l_mark[-1].pl.obj->height();
		  else
		    yyval.x = 0.0;
		}
#line 1 ""
break;
case 225:
#line 1494 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[-1].pl.obj != 0)
		    yyval.x = yystack.l_mark[-1].pl.obj->width();
		  else
		    yyval.x = 0.0;
		}
#line 1 ""
break;
case 226:
#line 1501 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[-1].pl.obj != 0)
		    yyval.x = yystack.l_mark[-1].pl.obj->radius();
		  else
		    yyval.x = 0.0;
		}
#line 1 ""
break;
case 227:
#line 1508 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[-2].x + yystack.l_mark[0].x; }
#line 1 ""
break;
case 228:
#line 1510 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[-2].x - yystack.l_mark[0].x; }
#line 1 ""
break;
case 229:
#line 1512 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[-2].x * yystack.l_mark[0].x; }
#line 1 ""
break;
case 230:
#line 1514 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[0].x == 0.0) {
		    lex_error("division by zero");
		    YYABORT;
		  }
		  yyval.x = yystack.l_mark[-2].x/yystack.l_mark[0].x;
		}
#line 1 ""
break;
case 231:
#line 1522 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  if (yystack.l_mark[0].x == 0.0) {
		    lex_error("modulus by zero");
		    YYABORT;
		  }
		  yyval.x = fmod(yystack.l_mark[-2].x, yystack.l_mark[0].x);
		}
#line 1 ""
break;
case 232:
#line 1530 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = pow(yystack.l_mark[-2].x, yystack.l_mark[0].x);
		  if (errno == EDOM) {
		    lex_error("arguments to `^' operator out of domain");
		    YYABORT;
		  }
		  if (errno == ERANGE) {
		    lex_error("result of `^' operator out of range");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 233:
#line 1543 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = -yystack.l_mark[0].x; }
#line 1 ""
break;
case 234:
#line 1545 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[-1].x; }
#line 1 ""
break;
case 235:
#line 1547 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = sin(yystack.l_mark[-1].x);
		  if (errno == ERANGE) {
		    lex_error("sin result out of range");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 236:
#line 1556 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = cos(yystack.l_mark[-1].x);
		  if (errno == ERANGE) {
		    lex_error("cos result out of range");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 237:
#line 1565 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = atan2(yystack.l_mark[-3].x, yystack.l_mark[-1].x);
		  if (errno == EDOM) {
		    lex_error("atan2 argument out of domain");
		    YYABORT;
		  }
		  if (errno == ERANGE) {
		    lex_error("atan2 result out of range");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 238:
#line 1578 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = log10(yystack.l_mark[-1].x);
		  if (errno == ERANGE) {
		    lex_error("log result out of range");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 239:
#line 1587 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = pow(10.0, yystack.l_mark[-1].x);
		  if (errno == ERANGE) {
		    lex_error("exp result out of range");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 240:
#line 1596 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  errno = 0;
		  yyval.x = sqrt(yystack.l_mark[-1].x);
		  if (errno == EDOM) {
		    lex_error("sqrt argument out of domain");
		    YYABORT;
		  }
		}
#line 1 ""
break;
case 241:
#line 1605 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[-3].x > yystack.l_mark[-1].x ? yystack.l_mark[-3].x : yystack.l_mark[-1].x; }
#line 1 ""
break;
case 242:
#line 1607 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = yystack.l_mark[-3].x < yystack.l_mark[-1].x ? yystack.l_mark[-3].x : yystack.l_mark[-1].x; }
#line 1 ""
break;
case 243:
#line 1609 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = floor(yystack.l_mark[-1].x); }
#line 1 ""
break;
case 244:
#line 1611 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = 1.0 + floor(((rand()&0x7fff)/double(0x7fff))*yystack.l_mark[-1].x); }
#line 1 ""
break;
case 245:
#line 1613 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  /* return a random number in the range [0,1) */
		  /* portable, but not very random */
		  yyval.x = (rand() & 0x7fff) / double(0x8000);
		}
#line 1 ""
break;
case 246:
#line 1619 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{
		  yyval.x = 0;
		  srand((unsigned int)yystack.l_mark[-1].x);
		}
#line 1 ""
break;
case 247:
#line 1624 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x < yystack.l_mark[0].x); }
#line 1 ""
break;
case 248:
#line 1626 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x <= yystack.l_mark[0].x); }
#line 1 ""
break;
case 249:
#line 1628 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x > yystack.l_mark[0].x); }
#line 1 ""
break;
case 250:
#line 1630 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x >= yystack.l_mark[0].x); }
#line 1 ""
break;
case 251:
#line 1632 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x == yystack.l_mark[0].x); }
#line 1 ""
break;
case 252:
#line 1634 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != yystack.l_mark[0].x); }
#line 1 ""
break;
case 253:
#line 1636 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 && yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 254:
#line 1638 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[-2].x != 0.0 || yystack.l_mark[0].x != 0.0); }
#line 1 ""
break;
case 255:
#line 1640 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/external/gpl2/groff/dist/src/preproc/pic/pic.y"
	{ yyval.x = (yystack.l_mark[0].x == 0.0); }
#line 1 ""
break;
#line 8063 "y.tab.c"
    default:
        break;
    }
    yystack.s_mark -= yym;
    yystate = *yystack.s_mark;
    yystack.l_mark -= yym;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark -= yym;
#endif
    yym = yylhs[yyn];
    if (yystate == 0 && yym == 0)
    {
#if YYDEBUG
        if (yydebug)
        {
            fprintf(stderr, "%s[%d]: after reduction, ", YYDEBUGSTR, yydepth);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
            if (!yytrial)
#endif /* YYBTYACC */
                fprintf(stderr, "result is <%s>, ", YYSTYPE_TOSTRING(yystos[YYFINAL], yyval));
#endif
            fprintf(stderr, "shifting from state 0 to final state %d\n", YYFINAL);
        }
#endif
        yystate = YYFINAL;
        *++yystack.s_mark = YYFINAL;
        *++yystack.l_mark = yyval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        *++yystack.p_mark = yyloc;
#endif
        if (yychar < 0)
        {
#if YYBTYACC
            do {
            if (yylvp < yylve)
            {
                /* we're currently re-reading tokens */
                yylval = *yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylloc = *yylpp++;
#endif
                yychar = *yylexp++;
                break;
            }
            if (yyps->save)
            {
                /* in trial mode; save scanner results for future parse attempts */
                if (yylvp == yylvlim)
                {   /* Enlarge lexical value queue */
                    size_t p = (size_t) (yylvp - yylvals);
                    size_t s = (size_t) (yylvlim - yylvals);

                    s += YYLVQUEUEGROWTH;
                    if ((yylexemes = (YYINT *)realloc(yylexemes, s * sizeof(YYINT))) == NULL)
                        goto yyenomem;
                    if ((yylvals   = (YYSTYPE *)realloc(yylvals, s * sizeof(YYSTYPE))) == NULL)
                        goto yyenomem;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    if ((yylpsns   = (YYLTYPE *)realloc(yylpsns, s * sizeof(YYLTYPE))) == NULL)
                        goto yyenomem;
#endif
                    yylvp   = yylve = yylvals + p;
                    yylvlim = yylvals + s;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpp   = yylpe = yylpsns + p;
                    yylplim = yylpsns + s;
#endif
                    yylexp  = yylexemes + p;
                }
                *yylexp = (YYINT) YYLEX;
                *yylvp++ = yylval;
                yylve++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                *yylpp++ = yylloc;
                yylpe++;
#endif
                yychar = *yylexp++;
                break;
            }
            /* normal operation, no conflict encountered */
#endif /* YYBTYACC */
            yychar = YYLEX;
#if YYBTYACC
            } while (0);
#endif /* YYBTYACC */
            if (yychar < 0) yychar = YYEOF;
#if YYDEBUG
            if (yydebug)
            {
                if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
                fprintf(stderr, "%s[%d]: state %d, reading token %d (%s)\n",
                                YYDEBUGSTR, yydepth, YYFINAL, yychar, yys);
            }
#endif
        }
        if (yychar == YYEOF) goto yyaccept;
        goto yyloop;
    }
    if (((yyn = yygindex[yym]) != 0) && (yyn += yystate) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yystate)
        yystate = yytable[yyn];
    else
        yystate = yydgoto[yym];
#if YYDEBUG
    if (yydebug)
    {
        fprintf(stderr, "%s[%d]: after reduction, ", YYDEBUGSTR, yydepth);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
            fprintf(stderr, "result is <%s>, ", YYSTYPE_TOSTRING(yystos[yystate], yyval));
#endif
        fprintf(stderr, "shifting from state %d to state %d\n", *yystack.s_mark, yystate);
    }
#endif
    if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
    *++yystack.s_mark = (YYINT) yystate;
    *++yystack.l_mark = yyval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    *++yystack.p_mark = yyloc;
#endif
    goto yyloop;
#if YYBTYACC

    /* Reduction declares that this path is valid. Set yypath and do a full parse */
yyvalid:
    if (yypath) YYABORT;
    while (yyps->save)
    {
        YYParseState *save = yyps->save;
        yyps->save = save->save;
        save->save = yypath;
        yypath = save;
    }
#if YYDEBUG
    if (yydebug)
        fprintf(stderr, "%s[%d]: state %d, CONFLICT trial successful, backtracking to state %d, %d tokens\n",
                        YYDEBUGSTR, yydepth, yystate, yypath->state, (int)(yylvp - yylvals - yypath->lexeme));
#endif
    if (yyerrctx)
    {
        yyFreeState(yyerrctx);
        yyerrctx = NULL;
    }
    yylvp          = yylvals + yypath->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yylpp          = yylpsns + yypath->lexeme;
#endif
    yylexp         = yylexemes + yypath->lexeme;
    yychar         = YYEMPTY;
    yystack.s_mark = yystack.s_base + (yypath->yystack.s_mark - yypath->yystack.s_base);
    memcpy (yystack.s_base, yypath->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
    yystack.l_mark = yystack.l_base + (yypath->yystack.l_mark - yypath->yystack.l_base);
    memcpy (yystack.l_base, yypath->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark = yystack.p_base + (yypath->yystack.p_mark - yypath->yystack.p_base);
    memcpy (yystack.p_base, yypath->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
    yystate        = yypath->state;
    goto yyloop;
#endif /* YYBTYACC */

yyoverflow:
    YYERROR_CALL("yacc stack overflow");
#if YYBTYACC
    goto yyabort_nomem;
yyenomem:
    YYERROR_CALL("memory exhausted");
yyabort_nomem:
#endif /* YYBTYACC */
    yyresult = 2;
    goto yyreturn;

yyabort:
    yyresult = 1;
    goto yyreturn;

yyaccept:
#if YYBTYACC
    if (yyps->save) goto yyvalid;
#endif /* YYBTYACC */
    yyresult = 0;

yyreturn:
#if defined(YYDESTRUCT_CALL)
    if (yychar != YYEOF && yychar != YYEMPTY)
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        YYDESTRUCT_CALL("cleanup: discarding token", yychar, &yylval, &yylloc);
#else
        YYDESTRUCT_CALL("cleanup: discarding token", yychar, &yylval);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */

    {
        YYSTYPE *pv;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        YYLTYPE *pp;

        for (pv = yystack.l_base, pp = yystack.p_base; pv <= yystack.l_mark; ++pv, ++pp)
             YYDESTRUCT_CALL("cleanup: discarding state",
                             yystos[*(yystack.s_base + (pv - yystack.l_base))], pv, pp);
#else
        for (pv = yystack.l_base; pv <= yystack.l_mark; ++pv)
             YYDESTRUCT_CALL("cleanup: discarding state",
                             yystos[*(yystack.s_base + (pv - yystack.l_base))], pv);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
    }
#endif /* defined(YYDESTRUCT_CALL) */

#if YYBTYACC
    if (yyerrctx)
    {
        yyFreeState(yyerrctx);
        yyerrctx = NULL;
    }
    while (yyps)
    {
        YYParseState *save = yyps;
        yyps = save->save;
        save->save = NULL;
        yyFreeState(save);
    }
    while (yypath)
    {
        YYParseState *save = yypath;
        yypath = save->save;
        save->save = NULL;
        yyFreeState(save);
    }
#endif /* YYBTYACC */
    yyfreestack(&yystack);
    return (yyresult);
}
