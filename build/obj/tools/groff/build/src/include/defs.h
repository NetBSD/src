#define PROG_PREFIX ""
#define DEVICE "ps"
#define INSTALLPATH "/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64"
#define BINPATH "/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/lib/groff"
#define FONTPATH "/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/share/groff/site-font:/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/share/groff/font"
#define MACROPATH "/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/lib/groff/site-tmac:/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/share/groff/site-tmac:/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/share/groff/tmac"
#define INDEX_SUFFIX ".i"
#define COMMON_WORDS_FILE "/Users/sidqian/Downloads/summer/L2S/netbsd-src/build/obj/tooldir.Darwin-22.1.0-x86_64/share/groff/eign"
#define DEFAULT_INDEX_DIR "/usr/dict/papers"
#define DEFAULT_INDEX_NAME "Ind"
#define DEFAULT_INDEX "/usr/dict/papers/Ind"
