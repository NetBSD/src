/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_m68kelfnbsd_emulation;

#define EMULATION_LIST \
  &ld_m68kelfnbsd_emulation, \
  0
