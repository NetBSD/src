#include "config.h"
#include "system.h"
EXPORTED_CONST unsigned char executable_checksum[16] = { 0x62, 0x91, 0x12, 0xe5, 0x3b, 0xbb, 0x26, 0xfe, 0xb4, 0xdf, 0x90, 0xb6, 0x3a, 0x3f, 0x97, 0x9b };
