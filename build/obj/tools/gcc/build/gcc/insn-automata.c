/* Generated automatically by the program `genautomata'
   from the machine description file `md'.  */

#define IN_TARGET_CODE 1
#include "config.h"
#include "system.h"
#include "coretypes.h"
#include "tm.h"
#include "alias.h"
#include "tree.h"
#include "varasm.h"
#include "stor-layout.h"
#include "calls.h"
#include "rtl.h"
#include "memmodel.h"
#include "tm_p.h"
#include "insn-config.h"
#include "recog.h"
#include "regs.h"
#include "output.h"
#include "insn-attr.h"
#include "diagnostic-core.h"
#include "flags.h"
#include "function.h"
#include "emit-rtl.h"

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv123_ib_translate[] ATTRIBUTE_UNUSED = {
    0,     1,     2,     3,     1,     2,     3,     1,     2,     3,
    1,     2,     3,     1,     2,     3,     1,     2,     3,     1,
    2,     3,     2,     3,     2,     3,     2,     3,     2,     3,
    2,     3,     2,     3,     1,     2,     3,     1,     2,     3,
    2,     3,     2,     3,     1,     2,     3,     1,     2,     3,
    1,     2,     3,     1,     2,     3,     1,     2,     3,     1,
    2,     3,     2,     3,     2,     3,     2,     3,     2,     3,
    2,     3,     2,     3,     2,     3,     2,     3,     2,     3,
    2,     3,     2,     3,     2,     3,     1,     2,     3,     2,
    3,     1,     2,     3,     1,     2,     3,     2,     3,     2,
    3,     1,     2,     3,     1,     2,     3,     1,     2,     3,
    1,     2,     3,     1,     2,     3,     1,     2,     3,     2,
    3,     2,     3,     1,     2,     3,     1,     2,     3,     1,
    2,     3,     1,     2,     3,     1,     2,     3,     1,     2,
    3,     2,     3,     2,     3,     1,     2,     3,     1,     2,
    3,     1,     2,     3,     1,     2,     3,     1,     2,     3,
    2,     3,     2,     3,     1,     1,     1,     2,     3,     1,
    2,     3,     1,     2,     3,     1,     2,     3,     1,     2,
    3,     1,     2,     3,     1,     2,     3,     1,     2,     3,
    1,     1,     3,     4,     4,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     4,     4,     4,     5};

/* Vector for state transitions.  */
static const unsigned char cfv123_ib_transitions[] ATTRIBUTE_UNUSED = {
    4,     3,     2,     1,     0,     0,     6,     6,     6,     6,
    1,     0,     1,     6,     6,     6,     2,     0,     2,     6,
    6,     6,     3,     0,     5,     2,     1,     6,     4,     0,
    1,     1,     6,     6,     5,     0};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv123_ib_min_issue_delay[] ATTRIBUTE_UNUSED = {
    3,   199,    28,    16,   192};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv123_ib_reserved_units[] = {
    0,     0,     0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv123_oep_translate[] ATTRIBUTE_UNUSED = {
    0,     1,     1,     1,     2,     2,     2,     3,     3,     3,
    2,     2,     2,     3,     3,     3,     4,     4,     4,     5,
    5,     5,     6,     6,     7,     7,     6,     6,     7,     7,
    8,     8,     9,     9,    10,    10,    10,    10,    10,    10,
   11,    11,    11,    11,     2,     2,     2,     3,     3,     3,
    2,     2,     2,     3,     3,     3,     4,     4,     4,     5,
    5,     5,     6,     6,     7,     7,     6,     6,     7,     7,
    8,     8,     9,     9,    12,    12,     5,     5,    12,    12,
    5,     5,    13,    13,    14,    14,     1,     1,     1,    15,
   15,    15,    15,    15,    15,    15,    15,    16,    16,    16,
   16,    17,    17,    17,    18,    18,    18,    19,    19,    19,
   20,    20,    20,    21,    21,    21,    22,    22,    22,    23,
   23,    24,    24,     1,     1,     1,     1,     1,     1,     2,
    2,     2,     4,     4,     4,     2,     2,     2,     4,     4,
    4,     6,     6,     8,     8,     1,     1,     1,     2,     2,
    2,     4,     4,     4,     2,     2,     2,     4,     4,     4,
    6,     6,     8,     8,     2,     4,    25,    25,    25,    26,
   26,    26,     1,     1,     1,     1,     1,     1,    10,    10,
   10,    10,    10,    10,    27,    27,    27,    28,    28,    28,
    2,     4,    10,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,    29};

/* Comb vector for state transitions.  */
static const unsigned char cfv123_oep_transitions[] ATTRIBUTE_UNUSED = {
    0,    12,    49,    11,     9,    24,    48,    49,    47,     9,
    5,    12,    44,    42,    23,    11,    24,    32,    18,    40,
   29,    27,    15,    26,    14,    55,     6,     3,     1,     0,
   13,    12,    49,     1,     9,    66,    48,     2,    47,    66,
   66,    66,    44,    42,    66,    11,    24,    32,    18,    40,
   29,    27,    15,    26,    14,     3,    50,    11,    24,     0,
   23,    66,     2,    57,    48,    23,     3,    66,    23,    22,
   23,    66,    66,    48,    48,    39,    46,    25,    38,    66,
   56,    63,    66,    62,     4,    12,    22,    66,    66,     5,
   65,    63,    49,     7,    52,    62,    51,    66,    66,    21,
    8,    47,    22,    54,    52,    60,    58,    22,    51,    57,
   47,    47,    22,    10,    24,    66,    43,    23,     0,    23,
   66,    22,     8,    66,    22,     4,    45,    24,    24,     9,
   23,    23,    53,    47,    22,    66,    38,    37,    66,    22,
   37,    66,    11,    66,    22,    24,    46,     6,    38,    59,
   21,     9,    61,    22,     5,    11,    16,    25,    11,    21,
   21,     9,    22,    22,    30,    39,    64,    48,    23,    28,
   17,    25,    41,    31,    12,    14,     7,    15,    22,    39,
   10,    23,    17,    18,    19,    17,    20,    12,    21,    22,
   23,    24,    25,    31,    26,    49,    27,    29,    18,    31,
   32,    32,    33,    13,    15,    34,    16,    35,    36,    37,
   38,    18,    19,    20,    39,    21,    40,    22,    23,    24,
   11,    17,    42,    27,    44,    28,    30,    46,    32,    33,
   47,    34,    48,    49,    35,    51,    36,    37,    38,    25,
   52,    54,    55,    31,    58,    41,    60,    62,    63,    65,
   66,    43,    66,    45,    66,    66,    39,    66,    66,     9,
   66,    49,    50,    66,    47,    66,    66,    66,    66,    53,
    8,    56,    66,    59,    66,    61,    48,    64,    57};

/* Check vector for state transitions.  */
static const unsigned char cfv123_oep_check[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
   13,    13,    13,     1,    13,    66,    13,     2,    13,    66,
   66,    66,    13,    13,    66,    13,    13,    13,    13,    13,
   13,    13,    13,    13,    13,     3,    50,    50,    50,    13,
   50,    66,     1,    57,    57,    57,     2,    66,    50,    50,
   57,    66,    66,    57,    57,    50,    50,    50,    50,    66,
   56,    56,    66,    56,     3,    50,    56,    66,    66,     5,
   56,    56,    57,     7,     7,    56,     7,    66,    66,     7,
    8,     8,     8,     7,     7,    56,    56,     8,     7,    56,
    8,     8,     8,    10,    10,    66,    43,    43,     5,    10,
   66,    10,     7,    66,    43,     4,    45,    45,    10,     8,
   45,    43,    53,    53,    53,    66,    10,    10,    66,    45,
   43,    66,    10,    66,    53,    43,    45,     6,    45,    59,
   59,     9,    61,    61,     4,    45,    16,    16,    11,    59,
   59,    53,    61,    61,    30,    30,    64,    64,    64,    28,
   28,    16,    41,    41,    12,    14,     6,    15,    59,    30,
    9,    61,    17,    18,    19,    16,    20,    11,    21,    22,
   23,    24,    25,    30,    26,    64,    27,    29,    28,    31,
   32,    41,    33,    12,    14,    34,    15,    35,    36,    37,
   38,    17,    18,    19,    39,    20,    40,    21,    22,    23,
   24,    25,    42,    26,    44,    27,    29,    46,    31,    32,
   47,    33,    48,    49,    34,    51,    35,    36,    37,    38,
   52,    54,    55,    39,    58,    40,    60,    62,    63,    65,
   66,    42,    66,    44,    66,    66,    46,    66,    66,    47,
   66,    48,    49,    66,    51,    66,    66,    66,    66,    52,
   54,    55,    66,    58,    66,    60,    62,    63,    65};

/* Base vector for state transitions.  */
static const unsigned char cfv123_oep_base[] = {
    0,    33,    37,    55,   125,    89,   147,    93,   100,   151,
  113,   158,   174,    30,   175,   177,   156,   182,   183,   184,
  186,   188,   189,   190,   191,   192,   194,   196,   169,   197,
  164,   199,   200,   202,   205,   207,   208,   209,   210,   214,
  216,   172,   222,   116,   224,   126,   227,   230,   232,   233,
   56,   235,   240,   132,   241,   242,    80,    63,   244,   149,
  246,   152,   247,   248,   166,   249};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv123_oep_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     5,     5,     5,     5,     5,     5,     5,     5,     5,
    5,     5,     5,     5,     5,     5,     5,     5,     5,     5,
    5,     5,     5,     5,     5,     5,     5,     5,     5,     0,
    0,     4,     4,     4,     4,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     4,     4,     4,     4,     0,
    0,     3,     3,     3,     3,     3,     3,     3,     3,     3,
    3,     3,     3,     3,     3,     3,     3,     3,     3,     3,
    3,     3,     3,     3,     3,     3,     3,     3,     3,     0,
    0,     2,     2,     2,     2,     2,     2,     2,     2,     2,
    2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
    2,     2,     2,     2,     2,     2,     2,     2,     2,     0,
    0,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     0,
    0,     1,     2,     1,     7,     8,     1,     2,     4,     8,
    1,     1,     2,     7,     8,     1,     7,     7,     7,     7,
    7,     7,     7,     4,     4,     8,     8,     8,     8,     0,
    0,     0,     1,     0,     6,     7,     0,     1,     3,     7,
    0,     0,     1,     6,     7,     0,     6,     6,     6,     6,
    6,     6,     6,     3,     3,     7,     7,     7,     7,     0,
    0,     0,     0,     6,     5,     6,     2,     0,     2,     6,
    0,     0,     0,     5,     6,     2,     5,     5,     5,     5,
    5,     5,     5,     2,     2,     6,     6,     6,     6,     0,
    0,     1,     4,     5,     4,     5,     1,     5,     1,     5,
    5,     5,     4,     4,     5,     1,     4,     4,     4,     4,
    4,     4,     4,     1,     1,     5,     5,     5,     5,     0,
    0,     0,     3,     4,     3,     4,     0,     4,     0,     4,
    4,     4,     3,     3,     4,     0,     3,     3,     3,     3,
    3,     3,     3,     0,     0,     4,     4,     4,     4,     0,
    0,     2,     2,     3,     2,     3,     2,     3,     2,     3,
    3,     3,     2,     2,     3,     2,     2,     2,     2,     2,
    2,     2,     2,     2,     2,     3,     3,     3,     3,     0,
    0,     1,     1,     2,     1,     2,     1,     2,     1,     2,
    2,     2,     1,     1,     2,     1,     1,     1,     1,     1,
    1,     1,     1,     1,     1,     2,     2,     2,     2,     0,
    0,     0,     0,     1,     0,     1,     0,     1,     0,     1,
    1,     1,     0,     0,     1,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     1,     1,     1,     1,     0,
    0,     2,    13,    14,    13,    14,    13,    14,    13,    14,
   14,    14,    13,    13,    14,     2,    13,    13,    13,    13,
   13,    13,    13,    13,    13,    14,    14,    14,    14,     0,
    0,     1,    12,    13,    12,    13,    12,    13,    12,    13,
   13,    13,    12,    12,    13,     1,    12,    12,    12,    12,
   12,    12,    12,    12,    12,    13,    13,    13,    13,     0,
    0,     0,    11,    12,    11,    12,    11,    12,    11,    12,
   12,    12,    11,    11,    12,     0,    11,    11,    11,    11,
   11,    11,    11,    11,    11,    12,    12,    12,    12,     0,
    0,    10,    10,    11,    10,    11,    10,    11,    10,    11,
   11,    11,    10,    10,    11,    10,    10,    10,    10,    10,
   10,    10,    10,    10,    10,    11,    11,    11,    11,     0,
    0,     9,     9,    10,     9,    10,     9,    10,     9,    10,
   10,    10,     9,     9,    10,     9,     9,     9,     9,     9,
    9,     9,     9,     9,     9,    10,    10,    10,    10,     0,
    0,     8,     8,     9,     8,     9,     8,     9,     8,     9,
    9,     9,     8,     8,     9,     8,     8,     8,     8,     8,
    8,     8,     8,     8,     8,     9,     9,     9,     9,     0,
    0,     7,     7,     8,     7,     8,     7,     8,     7,     8,
    8,     8,     7,     7,     8,     7,     7,     7,     7,     7,
    7,     7,     7,     7,     7,     8,     8,     8,     8,     0,
    0,     6,     6,     7,     6,     7,     6,     7,     6,     7,
    7,     7,     6,     6,     7,     6,     6,     6,     6,     6,
    6,     6,     6,     6,     6,     7,     7,     7,     7,     0,
    0,     5,     5,     6,     5,     6,     5,     6,     5,     6,
    6,     6,     5,     5,     6,     5,     5,     5,     5,     5,
    5,     5,     5,     5,     5,     6,     6,     6,     6,     0,
    0,     4,     4,     5,     4,     5,     4,     5,     4,     5,
    5,     5,     4,     4,     5,     4,     4,     4,     4,     4,
    4,     4,     4,     4,     4,     5,     5,     5,     5,     0,
    0,     3,     3,     4,     3,     4,     3,     4,     3,     4,
    4,     4,     3,     3,     4,     3,     3,     3,     3,     3,
    3,     3,     3,     3,     3,     4,     4,     4,     4,     0,
    0,    11,    11,    12,    11,    12,    11,    12,    11,    12,
   12,    12,    11,    11,    12,    11,    11,    11,    11,    11,
   11,    11,    11,    11,    11,    12,    12,    12,    12,     0,
    0,     2,    12,    13,    12,    13,    12,    13,    12,    13,
   13,    13,    12,    12,    13,    12,    12,    12,    12,    12,
   12,    12,    12,    12,    12,    13,    13,    13,    13,     0,
    0,     1,    11,    12,    11,    12,    11,    12,    11,    12,
   12,    12,    11,    11,    12,    11,    11,    11,    11,    11,
   11,    11,    11,    11,    11,    12,    12,    12,    12,     0,
    0,     0,    10,    11,    10,    11,    10,    11,    10,    11,
   11,    11,    10,    10,    11,    10,    10,    10,    10,    10,
   10,    10,    10,    10,    10,    11,    11,    11,    11,     0,
    0,     1,    21,    22,    21,    22,    21,    22,    21,    22,
   22,    22,    21,    21,    22,     1,    21,    21,    21,    21,
   21,    21,    21,    21,    21,    22,    22,    22,    22,     0,
    0,     0,    20,    21,    20,    21,    20,    21,    20,    21,
   21,    21,    20,    20,    21,     0,    20,    20,    20,    20,
   20,    20,    20,    20,    20,    21,    21,    21,    21,     0,
    0,    19,    19,    20,    19,    20,    19,    20,    19,    20,
   20,    20,    19,    19,    20,    19,    19,    19,    19,    19,
   19,    19,    19,    19,    19,    20,    20,    20,    20,     0,
    0,    18,    18,    19,    18,    19,    18,    19,    18,    19,
   19,    19,    18,    18,    19,    18,    18,    18,    18,    18,
   18,    18,    18,    18,    18,    19,    19,    19,    19,     0,
    0,    17,    17,    18,    17,    18,    17,    18,    17,    18,
   18,    18,    17,    17,    18,    17,    17,    17,    17,    17,
   17,    17,    17,    17,    17,    18,    18,    18,    18,     0,
    0,    16,    16,    17,    16,    17,    16,    17,    16,    17,
   17,    17,    16,    16,    17,    16,    16,    16,    16,    16,
   16,    16,    16,    16,    16,    17,    17,    17,    17,     0,
    0,    15,    15,    16,    15,    16,    15,    16,    15,    16,
   16,    16,    15,    15,    16,    15,    15,    15,    15,    15,
   15,    15,    15,    15,    15,    16,    16,    16,    16,     0,
    0,    14,    14,    15,    14,    15,    14,    15,    14,    15,
   15,    15,    14,    14,    15,    14,    14,    14,    14,    14,
   14,    14,    14,    14,    14,    15,    15,    15,    15,     0,
    0,    13,    13,    14,    13,    14,    13,    14,    13,    14,
   14,    14,    13,    13,    14,    13,    13,    13,    13,    13,
   13,    13,    13,    13,    13,    14,    14,    14,    14,     0,
    0,    12,    12,    13,    12,    13,    12,    13,    12,    13,
   13,    13,    12,    12,    13,    12,    12,    12,    12,    12,
   12,    12,    12,    12,    12,    13,    13,    13,    13,     0,
    0,    20,    20,    21,    20,    21,    20,    21,    20,    21,
   21,    21,    20,    20,    21,    20,    20,    20,    20,    20,
   20,    20,    20,    20,    20,    21,    21,    21,    21,     0,
    0,     1,    20,    21,    20,    21,    20,    21,    20,    21,
   21,    21,    20,    20,    21,    20,    20,    20,    20,    20,
   20,    20,    20,    20,    20,    21,    21,    21,    21,     0,
    0,     0,    19,    20,    19,    20,    19,    20,    19,    20,
   20,    20,    19,    19,    20,    19,    19,    19,    19,    19,
   19,    19,    19,    19,    19,    20,    20,    20,    20,     0,
    0,     1,     5,     6,     5,     6,     5,     6,     1,     6,
    6,     6,     5,     5,     6,     1,     5,     5,     5,     5,
    5,     5,     5,     5,     1,     6,     6,     6,     6,     0,
    0,     0,     4,     5,     4,     5,     4,     5,     0,     5,
    5,     5,     4,     4,     5,     0,     4,     4,     4,     4,
    4,     4,     4,     4,     0,     5,     5,     5,     5,     0,
    0,     1,     4,     5,     1,     5,     4,     5,     4,     5,
    5,     5,     4,     1,     5,     4,     4,     4,     4,     4,
    1,     4,     1,     4,     4,     5,     5,     5,     5,     0,
    0,     0,     3,     4,     0,     4,     3,     4,     3,     4,
    4,     4,     3,     0,     4,     3,     3,     3,     3,     3,
    0,     3,     0,     3,     3,     4,     4,     4,     4,     0,
    0,    21,    21,    22,    21,    22,    21,    22,    21,    22,
   22,    22,    21,    21,    22,    21,    21,    21,    21,    21,
   21,    21,    21,    21,    21,    22,    22,    22,    22,     0,
    0,     2,     5,     6,     5,     6,     2,     6,     2,     6,
    6,     6,     5,     5,     6,     2,     5,     5,     5,     5,
    5,     5,     5,     2,     2,     6,     6,     6,     6,     0,
    0,     2,     2,     5,     2,     5,     4,     5,     4,     5,
    5,     5,     2,     2,     5,     4,     4,     4,     4,     2,
    2,     2,     2,     4,     4,     5,     5,     5,     5,     0,
    0,     1,     1,     4,     1,     4,     3,     4,     3,     4,
    4,     4,     1,     1,     4,     3,     3,     3,     3,     1,
    1,     1,     1,     3,     3,     4,     4,     4,     4,     0,
    0,     0,     0,     3,     0,     3,     2,     3,     2,     3,
    3,     3,     0,     0,     3,     2,     2,     2,     2,     0,
    0,     0,     0,     2,     2,     3,     3,     3,     3,     0,
    0,     3,     6,     7,     6,     7,     3,     7,     3,     7,
    7,     7,     6,     6,     7,     3,     6,     6,     6,     6,
    6,     6,     6,     3,     3,     7,     7,     7,     7,     0,
    0,     1,     1,     7,     6,     7,     3,     7,     3,     7,
    7,     7,     1,     6,     7,     3,     6,     6,     6,     6,
    6,     6,     6,     3,     3,     7,     7,     7,     7,     0,
    0,     0,     0,     6,     5,     6,     2,     6,     2,     6,
    6,     6,     0,     5,     6,     2,     5,     5,     5,     5,
    5,     5,     5,     2,     2,     6,     6,     6,     6,     0,
    0,     1,     1,     7,     6,     7,     3,     1,     3,     7,
    1,     1,     1,     6,     7,     3,     6,     6,     6,     6,
    6,     6,     6,     3,     3,     7,     7,     7,     7,     0,
    0,     1,     2,     1,     4,     7,     1,     2,     6,     7,
    1,     1,     4,     4,     7,     1,     6,     6,     6,     4,
    4,     4,     4,     6,     6,     1,     1,     7,     7,     0,
    0,     0,     1,     0,     3,     6,     0,     1,     5,     6,
    0,     0,     3,     3,     6,     0,     5,     5,     5,     3,
    3,     3,     3,     5,     5,     0,     0,     6,     6,     0,
    0,     0,     0,     5,     2,     5,     4,     0,     4,     5,
    0,     0,     2,     2,     5,     4,     4,     4,     4,     2,
    2,     2,     2,     4,     4,     5,     5,     5,     5,     0,
    0,     1,     7,     8,     7,     8,     7,     8,     7,     8,
    1,     1,     7,     7,     8,     7,     7,     7,     7,     7,
    7,     7,     7,     7,     7,     8,     8,     8,     8,     0,
    0,     0,     6,     7,     6,     7,     6,     7,     6,     7,
    0,     0,     6,     6,     7,     6,     6,     6,     6,     6,
    6,     6,     6,     6,     6,     7,     7,     7,     7,     0,
    0,     1,     6,     7,     6,     7,     6,     7,     6,     7,
    1,     1,     6,     6,     7,     6,     6,     6,     6,     6,
    6,     6,     6,     6,     6,     7,     7,     7,     7,     0,
    0,     0,     5,     6,     5,     6,     5,     6,     5,     6,
    0,     0,     5,     5,     6,     5,     5,     5,     5,     5,
    5,     5,     5,     5,     5,     6,     6,     6,     6,     0,
    0,     3,     3,     6,     3,     6,     5,     6,     5,     6,
    6,     6,     3,     3,     6,     5,     5,     5,     5,     3,
    3,     3,     3,     5,     5,     6,     6,     6,     6,     0,
    0,     1,     1,     6,     3,     6,     5,     6,     5,     6,
    6,     6,     3,     3,     6,     5,     5,     5,     5,     3,
    3,     3,     3,     5,     5,     6,     6,     6,     6,     0,
    0,     0,     0,     5,     2,     5,     4,     5,     4,     5,
    5,     5,     2,     2,     5,     4,     4,     4,     4,     2,
    2,     2,     2,     4,     4,     5,     5,     5,     5,     0,
    0,     1,     1,     6,     3,     6,     5,     1,     5,     6,
    1,     1,     3,     3,     6,     5,     5,     5,     5,     3,
    3,     3,     3,     5,     5,     6,     6,     6,     6,     0,
};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv123_oep_reserved_units[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv123_chr_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     1,     1,     1,     1,     1,     1,
    2,     2,     2,     2,     3,     3,     3,     4,     4,     4,
    3,     3,     3,     4,     4,     4,     5,     5,     5,     3,
    3,     3,     5,     5,     3,     3,     5,     5,     3,     3,
    6,     6,     5,     5,     5,     5,     3,     3,     5,     5,
    3,     3,     6,     6,     5,     5,     0,     0,     0,     0,
    0,     4,     4,     4,     4,     4,     4,     3,     3,     3,
    3,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     1,     1,     1,     1,
    1,     1,     0,     0,     0,     0,     0,     0,     1,     1,
    1,     1,     1,     1,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     7};

/* Vector for state transitions.  */
static const unsigned char cfv123_chr_transitions[] ATTRIBUTE_UNUSED = {
    0,     9,     8,     3,     4,     2,     1,     0,     1,     5,
    5,    15,     5,    15,    15,     2,     2,     6,     6,    15,
   15,    15,    15,     3,     3,     7,    15,    15,    15,    15,
   15,     4,     4,    15,    15,    15,    15,    15,     5,     8,
    5,    15,    15,    15,    15,    15,    15,     6,     6,    15,
   15,    15,    15,    15,    15,     7,     7,    15,    15,    15,
   15,    15,    15,     4,     8,    15,    15,    15,    15,     6,
    5,     9,     9,    15,    15,     7,    15,     6,     5,    10,
   10,    15,    15,     7,     4,     6,    14,    11,    11,    15,
    8,     7,     4,    13,    12,     0,    12,    15,     5,    15,
    5,    15,    15,     2,    13,    15,     6,    15,    15,    15,
   15,     3,    14,    15,    15,    15,     5,    15,    15,    13,
};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv123_chr_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     5,     4,    48,     0,     4,
   83,    32,     0,    83,    66,    16,     5,    66,    49,     0,
    8,   117,   100,    48,     7,   100,    83,    32,     6,    83,
   66,    16,     4,    49,    32,     0,     3,    32,    16,     0,
    2,    16,     0,     0,     1,     0,     0,     0,     1,     5,
    4,    48,     1,     4,    83,    32,     2,    21,     4,    48,
};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv123_chr_reserved_units[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv123_mem_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     1,     1,     1,     2,     2,     2,
    1,     1,     1,     2,     2,     2,     3,     3,     3,     4,
    4,     4,     5,     5,     1,     1,     5,     5,     1,     1,
    6,     6,     3,     3,     2,     2,     2,     4,     4,     4,
    1,     1,     3,     3,     7,     7,     7,     8,     8,     8,
    7,     7,     7,     8,     8,     8,     9,     9,     9,    10,
   10,    10,    11,    11,     7,     7,    11,    11,     7,     7,
   12,    12,     9,     9,    13,    13,    14,    14,    13,    13,
   14,    14,    15,    15,    16,    16,     0,     0,     0,     0,
    0,     5,     5,     5,     6,     6,     6,    17,    17,    18,
   18,     0,     0,     0,     0,     0,     0,     1,     1,     1,
    3,     3,     3,     1,     1,     1,     3,     3,     3,     5,
    5,     6,     6,     0,     0,     0,     0,     0,     0,     1,
    1,     1,     3,     3,     3,     1,     1,     1,     3,     3,
    3,     5,     5,     6,     6,     0,     0,     0,     1,     1,
    1,     3,     3,     3,     1,     1,     1,     3,     3,     3,
    5,     5,     6,     6,     1,     3,    19,    19,    19,    16,
   16,    16,     0,     0,     0,     0,     0,     0,     2,     2,
    2,     4,     4,     4,     0,     0,     0,     0,     0,     0,
    1,     3,    20,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,    21};

/* Comb vector for state transitions.  */
static const unsigned short cfv123_mem_transitions[] ATTRIBUTE_UNUSED = {
    0,     5,     6,    10,    11,     4,   484,   529,    32,   523,
  317,   599,   598,   596,   517,   595,   508,   591,   588,   583,
    1,     0,     1,    33,     7,    22,    44,    29,     9,    31,
   40,   316,    45,   582,   581,   579,    28,   578,   289,     3,
  575,     2,   600,     0,    13,    26,    79,    47,    59,   364,
   74,   403,   198,   397,    60,   528,   522,   516,   276,   507,
  386,   500,   483,    14,   600,     0,    12,    78,   600,    65,
   71,    25,    46,   340,   600,   426,   149,   539,   538,   536,
  600,   535,   420,   531,   290,    72,    96,    13,    58,    87,
  232,    89,   197,    61,   265,    88,   402,   396,   394,   158,
  385,   253,   363,    73,     6,    18,    13,    43,   600,    32,
  445,   378,   600,   453,    62,   561,   560,   558,   600,   557,
  600,   517,   554,   600,     7,     1,   591,   529,   517,   549,
  540,   567,   600,    39,   462,   526,   600,   594,   191,   593,
  600,   592,   512,   600,   287,   584,     3,     4,     3,    31,
   28,    76,    24,    16,    40,   600,    36,   332,   600,   572,
  244,   571,   188,   570,   311,     7,    19,   568,   175,     4,
   40,    21,    39,   600,   336,   600,    30,   553,    34,   201,
  552,   245,    28,     8,   600,   600,     1,     4,    17,    32,
  444,    77,    20,   600,   479,   442,   370,   327,   190,   600,
  565,   462,   450,   502,   567,   566,   561,    29,     5,    79,
   52,   445,   120,   600,   198,    98,   211,   213,   205,   600,
  339,   315,    27,   192,   288,   600,   276,    80,   600,   214,
    1,   484,   366,   445,   349,   431,   600,    56,    57,   600,
  497,   326,   252,   600,   495,   600,   494,   493,   110,   488,
  485,     9,    10,   500,   403,   276,   432,   414,   372,   250,
  229,   200,   400,   253,   506,   593,   505,   519,   501,   390,
  530,   600,    15,   379,     4,   588,   562,   554,   548,   317,
  566,   488,   600,   461,   524,   571,   462,   590,   600,   600,
  589,   509,     5,   600,    18,   575,   484,    17,   366,   600,
  245,   600,   512,   565,   564,   356,   378,   504,    38,   529,
  562,   558,    33,     6,    10,   600,    43,   513,    92,   600,
  349,   600,   311,   307,   213,   287,   494,   600,   360,    39,
  355,   549,   548,   546,    22,    11,     9,    42,    21,   100,
  122,   600,    31,   600,    39,   273,   123,   286,    55,   496,
  191,   474,    82,   460,   489,   486,   600,    10,    29,    37,
   40,    35,   142,    32,   155,   286,   275,   137,   143,    56,
  600,   459,    36,   134,   278,    16,   465,    30,   600,     5,
   74,   234,    98,    91,    64,   156,   403,    35,   211,   301,
  262,   244,   287,   359,   188,   354,   297,   374,   348,    75,
  600,    10,   364,   240,   198,   284,   380,    32,    36,   244,
  383,   203,   267,   600,   251,   377,   200,    77,   376,   372,
  365,   339,   600,     5,   483,   467,    80,   430,    60,   365,
  348,   244,   199,   398,   345,   327,   499,   142,    78,   498,
  387,   600,   600,    36,   191,   484,   575,   444,     8,   472,
   45,   465,   489,   160,    41,   328,   287,   114,   577,   402,
  210,   576,   308,   269,    37,   600,   203,   484,   598,   564,
  560,   494,   544,   600,   159,   600,   383,   527,   320,   600,
  403,   597,   272,    54,   515,   139,   590,   587,   581,   523,
   11,   207,   516,    92,    27,    77,   431,   377,   359,   355,
  202,   545,   544,   273,   521,   543,   284,   540,   317,   505,
   44,    12,    22,   517,   175,   562,    93,   475,   100,   600,
  478,   369,    56,   246,   474,   600,   179,   563,   148,    76,
  472,    23,    26,    11,    52,   444,   445,   240,   234,   600,
  184,   600,   600,   377,   469,   600,   211,   600,   600,   403,
  467,    27,    33,     6,    19,   600,   600,    37,    42,   544,
  189,   600,   216,   459,   452,   600,    39,   600,   357,    31,
  444,    34,    47,     6,   120,   600,    70,   320,    91,   436,
  426,   366,   157,   242,   354,   600,   141,    85,   223,   432,
  430,    48,   600,    11,   522,   469,   315,   354,   425,   369,
  367,    42,    43,   401,   413,   159,    62,   521,    86,   125,
  393,   600,   499,   482,   600,   523,   581,   452,   553,   474,
  436,   133,   600,   600,   294,   334,   322,    63,   600,   580,
   21,   186,   314,   181,   577,   574,   595,   523,   557,    55,
  543,   260,   494,   368,   154,   180,   318,    42,   447,   186,
  518,    22,   514,   592,   589,   586,   578,   508,    44,   256,
  600,    93,   261,   142,   122,   370,   368,   148,    43,   437,
  436,   600,   600,   434,   600,    24,    45,    46,   144,    12,
  124,    57,   600,   600,   534,   341,   321,   161,   406,   600,
  433,    59,   412,    62,    70,   306,   380,    64,    47,   505,
  223,   284,   429,   425,   374,   244,   419,   201,   414,    60,
   73,    97,    12,    63,    88,   233,    90,    49,    71,   261,
  462,    86,   362,    95,    57,   361,   254,   131,   600,   409,
  408,    74,   234,   407,   174,   404,   149,    87,    50,    72,
  107,   600,   170,   109,   600,   600,   111,   600,   269,   264,
  235,   194,   252,    43,   231,    88,    89,   119,    72,    69,
  109,   600,   197,   600,   600,   156,    68,   183,   565,   228,
  463,   222,   151,   203,    90,   290,   279,    47,    66,   149,
  307,   306,   379,   198,   304,   530,   600,   300,   459,   378,
  296,   291,   600,   103,   363,   197,    74,   384,   231,   239,
  600,   600,   507,   266,   288,   383,   419,   382,   354,   381,
  257,   192,    61,   104,    86,   364,   277,   104,   392,   501,
  498,   481,   523,   508,   453,   430,   355,   121,   497,   157,
  511,   218,   324,   323,   527,   105,   456,   353,    86,   526,
  524,   224,   316,   317,   531,   340,   431,   411,   404,   470,
  310,   305,   578,   427,   552,   534,   434,   533,   474,   532,
  421,    83,   319,   600,   129,   364,   466,   600,   313,   570,
  576,   573,   600,   508,   583,   558,   164,   546,   600,   561,
  485,   519,    84,    50,   300,   280,   587,   299,   155,   586,
  600,   584,   600,   303,     2,     3,     2,    34,   600,    23,
  293,    30,   486,    35,    51,   301,   600,   600,   574,    14,
   27,   573,    48,   568,   339,    75,   284,     3,    25,    51,
  600,   482,    95,   600,   481,   342,    15,   452,   162,   458,
    3,   344,   600,   600,   416,   470,   307,   232,   172,    26,
  600,   170,   600,   600,   183,   450,   443,   118,   453,   152,
  210,   600,   114,   249,   239,   233,   600,   316,    26,   336,
  467,   148,    53,   273,   113,   241,   235,   163,   185,   334,
  153,   333,   468,   600,   332,   328,   396,   204,   317,   222,
  264,   445,   600,    41,   190,   268,   230,   600,    54,   395,
   28,    39,   260,   179,   362,    36,   397,   397,   205,   333,
  223,   464,   301,    35,    42,   466,   224,   600,   401,    55,
  208,    29,   600,   400,   398,   600,   600,   317,   488,   369,
  446,   351,   326,   315,   338,   508,   147,   492,   355,   600,
  502,   493,   209,   491,   490,   600,   337,   515,   489,   349,
  514,   272,   512,   509,   316,   289,   290,   517,   378,   600,
  360,   600,   462,   506,   374,   285,   456,   418,   520,   472,
  519,   176,   518,    56,   600,   102,   600,    28,    29,   538,
  343,   473,   412,   408,   479,   163,   199,   185,   428,   155,
  431,   600,   537,   554,   475,   424,   439,   300,   461,   446,
  397,   469,   454,   338,   596,   556,   558,    42,   555,   565,
  495,   600,   463,     8,     9,   235,   597,   182,   519,   468,
  337,   593,   453,    94,   579,   517,     8,    20,    18,   176,
  600,    41,   447,   245,   242,   331,   236,   600,   551,   463,
  477,   550,   600,   106,    95,   378,   475,     9,    19,     7,
   58,   261,   600,    27,   107,   112,    69,   160,   202,   194,
  108,   127,   222,   263,   107,   337,   111,   384,    63,    65,
  284,    59,   262,    86,    28,   124,   600,    15,   284,   136,
   49,   412,   285,   600,   192,   131,   411,    66,    80,    53,
   59,   121,   480,   199,    99,   600,   253,   206,    16,   111,
  272,   249,   151,    81,   105,   106,   600,   600,   260,     9,
  600,   259,   600,   257,   254,   276,   211,    73,   141,   600,
  200,   600,    24,   600,   208,    94,   285,    50,   284,   289,
  277,   165,   148,   438,   278,    82,    29,   435,   599,   565,
  561,   314,   545,    25,   313,   530,   311,   308,   317,   110,
  290,   213,   520,   327,   326,   594,   600,   324,   582,   529,
  320,   600,   349,   318,   236,   600,   103,   168,    45,    46,
  111,   600,   192,   600,   600,   365,   241,   199,   352,   267,
  351,   350,   100,    92,   348,   235,    99,   218,   262,   386,
  600,   371,   223,   302,   376,   297,   366,   600,   211,   353,
  298,   393,   600,   188,   392,   349,   390,   387,   420,   201,
  290,   131,   600,   416,    62,   445,   242,   600,   236,    40,
  424,   200,   188,   423,   449,   421,   291,    84,   367,    73,
  441,   127,   600,   446,   201,    21,    22,   489,   370,   447,
  102,   123,    37,   126,   600,   494,   274,   441,    85,   216,
  600,   600,   473,    83,   564,   214,   477,   600,   349,   600,
  600,   357,   600,   491,   487,   474,   355,   567,   479,   462,
  600,   345,   563,   559,   452,   453,   600,    16,   286,    36,
  530,    50,   600,   504,   600,   600,   520,    16,    17,   579,
  460,    34,   600,   283,   459,   496,   464,    38,    17,   600,
  102,   580,   178,    35,   105,    17,   571,   245,   285,   201,
  517,   590,   563,   556,   491,   320,   129,   462,   247,   247,
  525,   103,   479,   478,   463,    37,    18,   511,    19,   286,
  379,   577,   497,   189,   186,    32,   245,    36,    37,    38,
  458,   600,   247,   600,    81,    39,    20,   600,   463,     7,
  139,   600,   462,   461,    45,    40,    33,    56,   600,   143,
  123,    68,    52,   163,   115,    82,   322,   184,   174,   319,
  114,   561,   463,   202,   338,    46,   168,   214,   379,   211,
   53,    60,    69,     7,   157,   600,   267,   262,   520,    78,
  224,    30,    31,   413,    51,   144,    61,   128,   125,   600,
  344,   343,    46,   600,   600,   215,   340,   279,    88,   600,
   79,   108,   600,   118,    68,    90,   167,   112,   153,    68,
  230,    40,   189,   229,   160,    94,    95,   284,   191,    89,
  221,   152,   201,    91,    38,   146,    91,    85,    36,    41,
  600,   600,    33,   159,   446,   243,   600,   237,    36,   220,
   96,   218,   217,   448,    92,   172,   119,    98,   174,   440,
  146,   210,   204,   600,   447,   100,   195,   197,    97,   600,
  194,    79,   147,   600,   600,    99,   600,   100,    22,   181,
  328,   104,   331,   600,   163,   149,   274,   105,   136,   600,
  162,   161,   329,   135,    67,   102,   101,   155,    92,   265,
  150,   326,   101,   111,   230,   156,    89,   168,   498,   112,
   81,   268,    61,   113,   353,   600,   266,   261,   306,   145,
   60,    84,   161,    94,   388,   156,   354,   305,   147,   493,
  358,   600,   600,   299,   294,   600,   158,   362,   196,    91,
  221,   230,   227,   600,   353,   347,   263,   355,   372,   244,
  200,   600,   375,   256,   600,   218,   385,   140,   301,   159,
  252,   374,   222,   600,   373,   600,   229,   285,   600,    17,
  600,   219,   259,   381,   361,   426,   103,   386,   600,   131,
   57,   321,   600,   106,   474,    67,   180,   428,   130,   125,
  600,   150,   427,   304,   128,   271,    60,   137,   161,   519,
  166,    58,   473,   471,   379,   355,   499,   468,   272,   353,
  413,   509,   151,   600,   324,   399,   503,   490,   600,    35,
   36,    64,   389,   511,    85,   600,   510,   497,   600,   600,
  220,   308,   306,   528,   377,   339,   358,   429,   600,   262,
  374,   529,    65,   378,   600,   318,   479,   285,   600,   247,
  506,   214,   530,   535,   529,   553,   458,   407,   180,   412,
  519,    31,    32,   150,   335,   319,    62,   600,   443,   423,
  532,   296,   540,   551,   386,   215,   316,   345,   548,   600,
  439,   356,   213,   542,   351,   600,   119,   541,   560,   477,
  491,   441,    24,    25,   324,   600,   600,   457,   472,   431,
  257,   559,   600,   117,   167,   248,   556,   120,   553,   316,
  577,   450,   551,   473,   322,   258,   582,   459,    30,   329,
  437,   233,    37,   460,   189,   320,   310,   600,   214,   600,
  464,   497,    43,   572,   323,   237,   191,   529,   236,   286,
  442,    38,    92,    18,   441,   322,   321,   600,   103,   360,
  439,   600,   175,    44,   216,   178,   104,   198,   184,   215,
  213,   340,    93,    71,   188,   600,   342,   240,   231,   184,
  202,   169,   341,   171,   200,   199,   600,   117,    33,   251,
  600,   188,   198,   250,   244,   241,   202,   254,    18,   232,
  112,   291,   238,   152,    67,   308,   295,   294,   163,   256,
  282,    83,   255,   293,   600,   355,   292,   310,    90,   600,
  309,   352,    90,   600,   600,   387,   306,   357,   224,   600,
  371,   298,   356,   324,   600,   148,   149,   389,   404,   414,
  388,   270,   410,   212,   375,   453,   306,   132,   226,   406,
  418,   449,   431,   405,   415,   103,   600,   457,   600,   232,
   25,   352,   456,   454,   153,   336,    45,   216,   115,   600,
  326,   600,   122,    65,   497,   600,   449,   524,   352,   454,
  114,   324,   600,   492,   325,    85,   527,   229,   457,   525,
  357,   600,   492,   168,   273,   213,   323,   328,   326,   549,
  241,   360,   185,   215,   525,   558,   334,   324,   151,   600,
  463,   367,   566,   478,   461,   356,   327,   559,   547,    76,
   77,   242,   519,   600,   586,    34,    28,   592,   503,   518,
  487,   541,   465,   366,   584,   519,   589,   547,   555,   520,
  318,   585,   491,   513,   573,   311,   585,   570,   502,   585,
  464,   287,   510,    34,   568,    16,   576,   493,    38,   368,
   63,    30,    38,    66,   108,   443,   153,   136,   287,    84,
   35,   286,   221,    69,    28,   299,   112,   116,   464,    67,
   70,    64,    31,   115,    64,   600,    85,   556,   476,   138,
  440,   153,   358,    86,    70,   600,   455,   410,   157,   106,
   76,    71,   179,   600,    94,   271,    93,   551,   273,   600,
  270,   136,   104,   600,    87,   600,   165,   600,   130,   346,
  359,    77,   194,    94,    56,    99,   182,    71,   140,   600,
  107,   600,   111,   600,   193,   600,   116,   479,   138,   247,
  139,   360,   110,   369,   154,   243,   100,   169,   108,   117,
  112,    87,   109,    88,   120,   116,   379,   286,   245,   122,
  146,   138,   104,   370,   236,   600,   147,   110,   135,    51,
   68,   141,   121,    58,   130,    44,   600,   123,   124,   600,
   65,   600,   106,   131,   600,   148,   342,   281,   127,   125,
   52,   135,   600,   600,   125,   133,    84,   166,   600,    70,
  132,    67,   165,   163,    88,   175,   149,   205,   398,   600,
  206,   181,   224,   195,   302,   223,   600,   180,   202,   209,
  399,   220,   179,   176,   208,   206,    44,   227,    45,   326,
  222,   600,   226,   224,   110,   201,   149,   239,   183,    39,
  168,   171,   600,   600,   600,   273,   154,    55,   221,   135,
  203,   223,   301,   248,   195,   129,   220,   334,   240,   335,
  221,   166,   219,   274,   168,   326,   213,   164,   192,    82,
  302,   336,   135,   213,   325,   329,   113,    55,   324,   493,
  214,   220,   352,   335,   166,   123,   124,    83,   333,   331,
   66,   351,    45,   237,   357,   192,   394,   490,   600,    82,
   66,   210,   228,   600,   600,   412,   600,   325,   395,   271,
  600,   102,   103,   382,   401,   137,   209,   276,   227,   447,
  187,   133,   178,   299,   225,   432,   223,   141,   275,   410,
  600,    20,   399,   600,   177,   324,   190,   187,   600,   255,
  100,   226,   600,   451,    49,   113,    77,   465,   442,    41,
  475,   143,    21,   470,   342,   246,   243,   212,   485,   367,
  152,   350,   476,   282,   600,   600,   341,   600,   366,   417,
   20,    21,   264,   487,   240,   110,   105,   600,   486,    76,
  491,   154,   440,   501,   214,   277,   536,   415,   514,   600,
  230,   344,   433,   265,   357,   216,   323,   106,   537,   391,
  473,   352,   480,   533,   502,   513,   510,   276,   313,   291,
  539,   344,   543,   214,   409,   130,   131,   341,   216,   600,
  557,   600,   546,   600,   600,   113,   441,   534,   350,   541,
  318,   403,   434,   420,   487,   600,   210,   518,   555,   547,
  552,   289,    23,    24,   568,    35,   114,   346,   570,   464,
  466,   600,   435,   203,   576,   600,   550,   211,   319,   569,
  473,   236,   600,   600,   312,    16,   374,   569,   201,   502,
  309,   600,   594,   530,   520,   493,   542,    23,    48,   237,
  600,   181,    93,   101,   217,    75,   194,   247,   217,   471,
  347,    53,   572,   479,   346,    49,   185,   182,    24,    24,
  347,   123,    97,    54,   105,   600,    76,   173,   167,   600,
  129,   600,    21,   600,   196,   151,   128,   156,   138,   600,
  600,   138,   124,    98,   600,   161,   259,   114,   127,   600,
  154,   245,   154,   152,   126,   160,    63,   600,   157,   600,
  137,   233,   173,   258,   255,   118,    69,   254,   247,   246,
  262,   189,    19,   159,   268,   279,   600,   238,   154,   219,
  281,   145,   234,   288,   113,   158,   600,   280,   600,   147,
  116,   124,   263,   296,   263,   224,    98,   150,   113,   299,
  277,    81,   297,   600,   289,   220,   307,   281,   115,   292,
  162,   107,   304,   292,   297,   219,    67,   227,   305,   134,
  298,   600,   295,    66,   303,   311,   313,   234,   165,   114,
  283,   321,   166,   262,   152,   125,   324,   600,   339,   202,
  312,   126,   325,   312,   309,   201,   307,   291,   323,   305,
  115,   314,   157,   600,   166,   285,   163,   161,   353,    31,
  139,   361,   158,   600,   377,   229,   202,   221,   390,   310,
  392,   226,   304,   373,   225,   378,   227,   255,   201,   352,
  247,   374,   297,   391,   407,   378,   379,   391,   388,   307,
  271,   291,   419,   600,   408,    39,    40,   271,   358,   600,
  600,   405,   150,   133,   473,   253,   177,   600,   128,   415,
   61,   421,   155,   420,   132,   265,   417,   423,   425,   600,
  164,   358,   600,   133,   434,   352,   422,   227,   587,   559,
  130,   487,   233,   428,   422,   292,   413,   133,   254,   426,
  439,   435,   319,   134,   436,   420,   237,   130,   574,   332,
  600,   303,   440,   166,   224,   486,   368,   454,   101,   600,
  176,   122,   322,   448,   490,   426,   459,   325,    38,   455,
  471,   492,   600,   448,   600,   325,    76,   331,   123,   323,
  287,   502,    56,   460,    83,    84,   515,   378,   105,   357,
  600,   274,   192,   525,   128,   455,   600,   323,   504,   503,
  463,   278,   279,    57,   511,   552,   314,   304,   526,   600,
  456,   180,   356,   329,   325,   551,   451,   379,   177,   600,
   38,    39,   466,   550,   330,   600,   289,    95,   332,   327,
  572,   460,   464,   571,   438,    35,   273,    67,   460,   256,
  108,   287,   113,   126,   212,   162,   115,   112,    96,   134,
  121,   479,   168,   114,   462,   142,   140,   136,    68,   113,
  160,   109,   139,   127,   600,   600,   600,   170,    68,   137,
  115,   122,    50,   143,   157,   163,    78,   176,   109,   600,
  159,   129,   172,   178,   171,   118,   158,   164,    96,   177,
  184,   116,   189,   600,   600,    57,   161,   600,   122,   183,
  173,   242,   294,    52,   600,   126,   206,   188,   185,   191,
  190,    19,   193,    19,   224,   249,   600,   134,   207,   243,
  219,   186,   175,   153,   600,   278,   225,   123,   286,   600,
  191,   600,   248,   238,   299,   161,    97,   274,   137,   275,
  600,   129,   283,   282,   600,   298,   279,   287,   219,   245,
  134,   331,   302,   600,   193,   220,   219,   275,   192,   322,
  225,   352,   128,   330,   243,   329,    84,   330,   164,   164,
  357,   600,   123,   192,   332,   376,   333,   600,   165,   325,
  321,   135,   136,   380,   187,   181,   325,   600,   323,   600,
  166,    67,   373,   371,   381,   327,   279,   600,   250,   117,
  375,   267,   384,   399,    78,   207,   169,   225,   393,   411,
  258,   227,   400,   270,   208,   376,   226,   416,   117,   413,
  118,   600,   158,   380,   325,   132,   389,   441,   225,   304,
  380,   449,   600,   327,   417,   295,   424,   382,    97,   133,
  321,   457,   203,   461,   246,   440,   600,   180,   148,   448,
  477,    55,    56,   478,   293,   246,   600,   261,   200,   455,
  481,   335,   163,    41,    42,   495,   347,   367,   476,   600,
  458,   336,   118,   442,   242,   482,   337,   480,   347,   520,
  379,   311,   510,   600,   545,   496,   360,   530,   323,   379,
  532,   600,   555,   119,   405,   563,   332,   476,   440,   464,
  286,   542,   309,   294,   437,   340,   422,   460,   247,   125,
  600,   376,   550,    82,   573,   450,   449,   600,   574,   443,
  471,   471,   597,   130,   559,   600,   600,   126,   133,   135,
  108,   569,   600,   138,   144,   311,   600,   600,   147,   332,
  146,   128,   580,   456,   131,   154,   134,   129,   600,   112,
  136,   114,   145,   166,   108,   120,   139,   174,   140,   148,
  600,    93,   180,   113,   181,   600,   112,   600,   186,   195,
  204,   164,   246,   600,    67,   182,   209,   220,   175,   269,
  177,   227,   178,   148,   247,    93,   187,   193,   196,   175,
   56,   205,   190,   186,   207,   219,   251,   163,   136,   225,
  197,   271,    67,   266,   191,   189,   293,   117,   303,   134,
  305,   309,   134,   310,   126,   319,   164,   164,   323,   137,
  325,   128,   111,   327,   267,   600,   600,   160,   335,   219,
  338,   159,   294,   344,   305,   345,    62,   350,   164,   126,
  129,   127,   343,   143,   144,   356,   330,   360,    54,   163,
  341,   336,   358,   600,   211,    50,    51,   101,    94,   367,
  280,   379,   370,   205,   187,   165,   162,   179,   142,   389,
  158,   388,   225,   131,   409,   600,   429,   225,   440,   368,
  179,   287,   191,   236,   427,   437,   458,   442,   132,   190,
  305,   406,   294,   418,   448,   197,   455,   340,   177,   135,
  456,   450,   438,   451,   451,   267,   340,   336,   242,   460,
  468,   287,    54,   476,   275,   105,   330,   129,   487,   600,
  333,   143,   449,   496,   533,   368,   503,   600,   504,   341,
  247,   449,   513,   451,    55,   518,   600,   541,   471,   165,
  521,   600,   337,   542,   360,   200,   282,   145,   283,   281,
  547,   127,   312,   295,   550,   466,   278,   435,   416,   559,
  177,   456,   585,   438,   342,   580,   126,   443,   128,   129,
  346,    50,   116,   132,   134,    82,   137,   139,   141,   443,
  333,   140,   569,   283,   143,   145,   456,   115,   158,   125,
  127,   159,   162,   164,   118,   114,   165,   138,   135,   142,
  167,   169,   104,   168,   171,   144,   146,   173,   178,   125,
  177,   179,   106,   119,   126,   183,   182,   162,   185,   188,
  187,   146,   170,   190,   138,   172,   191,   193,   174,   104,
  194,   135,   142,   196,   201,   203,   184,   181,   207,   186,
  189,   181,   208,   212,   186,   217,   219,   189,   105,   226,
  225,   179,   228,   238,   195,   191,   188,   248,   250,   129,
  251,   258,   267,   143,   172,   270,    94,   127,   275,   277,
  162,   126,   280,   141,   167,   282,   281,   283,   173,   249,
  287,   183,   238,   144,   295,   312,   170,   330,   333,   105,
  278,   337,   341,   195,   342,   346,   145,   174,   281,   347,
  368,   191,   371,   373,   375,   167,   295,   391,   129,   143,
  395,   405,   333,   188,   406,   184,    50,   410,   415,   417,
  165,   179,   418,   145,   281,    51,   422,   433,   295,   435,
  438,   208,   249,   443,   451,   183,   466,   471,    95,   416,
  173,   480,   537,   342,   569,   600,   600,   238,   141,   600,
  416,   342,   600,   600,   333,    55,   600,   278,   165,   600,
  600,   600,   283,   208,   600,   283};

/* Check vector for state transitions.  */
static const unsigned short cfv123_mem_check[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     1,   600,     1,    13,    13,    13,    13,    13,    13,
   13,    13,    13,    13,    13,    13,    13,    13,    13,    13,
   13,    13,    13,    13,   600,    13,    12,    12,   600,    12,
   12,    12,    12,    12,   600,    12,    12,    12,    12,    12,
  600,    12,    12,    12,    12,    72,    72,    12,    72,    72,
   72,    72,    72,    61,    72,    72,    72,    72,    72,    61,
   72,    72,    72,    72,     6,     6,    72,     6,   600,     6,
    6,     6,   600,     6,    61,     6,     6,     6,   600,     6,
  600,     6,     6,   600,     6,     6,   591,   591,   591,   591,
  591,   591,   600,    39,   591,   591,   600,   591,    39,   591,
  600,   591,   591,   600,    39,   591,   591,   591,     3,     3,
    3,     3,     3,     3,    39,   600,     3,     3,   600,     3,
  244,     3,   244,     3,     3,     7,     7,     3,     7,     3,
    7,     7,     7,   600,     7,   600,     7,     7,     7,   244,
    7,   244,     7,     7,   600,   600,     7,     4,     4,     4,
  444,     4,   444,   600,     4,   444,   444,     4,   444,   600,
    4,     4,   444,     4,     4,     4,     4,     4,     4,    79,
   79,   444,    79,   600,    79,    79,    79,   213,    79,   600,
   79,    79,    79,   213,    79,   600,    79,    79,   600,   213,
   79,   484,   484,   484,   484,   484,   600,   213,   213,   600,
  484,   484,   252,   600,   484,   600,   484,   484,   252,   484,
  484,   484,   484,   500,   500,   500,   500,   500,   500,   252,
  252,   500,   500,   252,   500,   593,   500,   593,   500,   500,
  593,   600,   500,   593,   500,   588,   588,   588,   588,   588,
  588,   588,   600,   588,   588,   593,   593,   588,   600,   600,
  588,   588,     5,   600,     5,   588,   588,     5,     5,   600,
    5,   600,   512,     5,     5,   512,     5,   512,    38,     5,
    5,     5,     5,     5,    10,   600,    10,   512,    10,   600,
   10,   600,   512,   512,    10,    38,    10,   600,    10,    38,
   10,    10,    10,    10,    10,    10,     9,     9,     9,     9,
    9,   600,    31,   600,    31,     9,     9,    31,    55,     9,
   31,     9,     9,    31,     9,     9,   600,     9,    29,    29,
   29,    31,    29,    31,   155,    29,    55,   155,    29,    55,
  600,    29,    29,   155,    29,    29,    29,    29,   600,    29,
   74,    74,    74,    74,    74,   155,   403,    35,   403,    74,
   74,   403,    35,    74,   403,    74,    74,   403,    74,    74,
  600,    74,   364,   364,   364,   403,   364,   403,    35,   364,
  383,   383,   364,   600,   383,   364,   364,    77,   364,   364,
  364,   364,   600,   364,   483,   483,   483,   483,   483,   483,
  483,   383,   483,   483,    77,    77,   483,    77,    77,   483,
  483,   600,   600,    36,    36,   483,   575,   575,   575,   575,
  575,   575,   575,   160,   575,   575,    36,   160,   575,   402,
  402,   575,   575,   402,    36,   600,   402,   575,   598,   598,
  598,   598,   598,   600,   160,   600,   402,   598,   598,   600,
  402,   598,   272,   272,   598,   272,   598,   598,   598,   598,
   11,   272,   516,    11,   516,    11,    11,   516,   516,    11,
  516,    11,    11,   272,   516,    11,   516,    11,    11,   516,
   11,    11,    22,   516,    22,   562,    22,   562,    22,   600,
  562,   562,    22,   562,    22,   600,    22,   562,    22,    22,
   22,    22,    26,    22,    26,   562,   562,    26,    26,   600,
   26,   600,   600,    26,    26,   600,    26,   600,   600,    26,
   26,    26,    33,    26,    33,   600,   600,    33,    33,   544,
   33,   600,   544,    33,    33,   600,    33,   600,   544,    33,
   33,    33,    47,    33,    47,   600,    47,   544,    47,   544,
  544,   366,    47,   366,    47,   600,    47,    85,    47,    47,
   47,    47,   600,    47,   522,   522,   522,   522,   522,   366,
  366,   366,   366,   522,   522,    85,    62,   522,    85,    62,
  522,   600,   522,   522,   600,   522,   581,   581,   581,   581,
  581,    62,   600,   600,    62,   581,   581,    62,   600,   581,
   21,    21,   581,    21,   581,   581,   595,   581,   595,    21,
  595,   260,   595,    21,   260,    21,   595,    42,    21,    42,
  595,    21,   595,   595,   595,   595,   595,   595,    44,   260,
  600,    44,   260,    44,    44,    42,    42,    44,    42,    44,
   44,   600,   600,    44,   600,    44,    44,    46,    46,    44,
   46,    46,   600,   600,   534,   534,    46,    46,   534,   600,
   46,    59,    46,    46,    59,    46,    59,    59,    46,   505,
   59,   505,    59,    59,   505,   534,    59,   505,    59,    59,
   73,    73,    59,    73,    73,    73,    73,    49,    71,    73,
  505,    71,    73,    71,    71,    73,    73,    71,   600,    71,
   71,    73,   234,    71,   234,    71,    71,    87,    49,    71,
   87,   600,    87,    87,   600,   600,    87,   600,    87,    87,
  234,   234,    87,   234,    87,    87,    89,    89,    87,    89,
   89,   600,   197,   600,   600,    89,    89,   197,   565,    89,
  565,    89,    89,   197,    89,   290,   290,    89,   290,   290,
  290,   290,   565,   197,   290,   565,   600,   290,   565,   565,
  290,   290,   600,   103,   363,   363,   290,   363,   363,   363,
  600,   600,   507,   363,   507,   363,   507,   363,   507,   363,
  363,   103,   507,   103,   103,   363,   507,   104,   507,   507,
  507,   507,   523,   507,   523,   430,   523,   430,   523,   430,
  511,   430,   523,   511,   523,   104,   523,   430,   104,   523,
  523,   430,   523,   523,   531,   531,   430,   531,   531,   531,
  511,   511,   578,   531,   578,   531,   578,   531,   578,   531,
  531,    83,   578,   600,    83,   531,   578,   600,   578,   578,
  578,   578,   600,   578,   583,   583,    83,   583,   600,   583,
  583,   583,    83,    50,   300,   300,   583,   300,   300,   583,
  600,   583,   600,   300,   583,   583,     2,     2,   600,     2,
  300,     2,     2,     2,    50,   300,   600,   600,     2,    14,
   14,     2,    14,     2,    14,    14,    14,     2,    25,    25,
  600,    14,    25,   600,    14,    25,    14,   452,    25,   452,
   14,    25,   600,   600,    25,    25,    25,   232,   232,    25,
  600,   232,   600,   600,   232,   452,   452,   232,   452,   152,
  232,   600,   152,   232,   232,   232,   600,   316,   232,   316,
  467,   316,   467,   316,   152,   467,   467,   316,   467,   316,
  152,   316,   467,   600,   316,   316,   396,   396,   316,   396,
  396,   467,   600,    41,    41,   396,   396,   600,    54,   396,
   28,    28,   396,    28,   396,    28,   397,   396,   397,    28,
  397,    28,   397,    28,    41,    28,   397,   600,   397,    54,
  397,    28,   600,   397,   397,   600,   600,   397,   488,   488,
  488,   488,   488,   315,   315,   508,   315,   488,   508,   600,
  508,   508,   315,   488,   488,   600,   315,   508,   488,   488,
  508,   315,   508,   508,   315,   508,   508,   517,   517,   600,
  517,   600,   517,   506,   506,   506,   517,   506,   517,   472,
  517,   472,   517,   472,   600,   472,   600,   517,   517,   538,
  538,   472,   538,   538,   506,   472,   199,   199,   538,   538,
  472,   600,   538,   554,   554,   538,   554,   538,   554,   554,
  538,   469,   554,   469,   596,   554,   596,   199,   554,   596,
  596,   600,   596,   554,   554,   235,   596,   235,   596,   469,
  469,   596,   469,    94,   596,   596,     8,     8,    18,     8,
  600,     8,     8,    18,    18,     8,   235,   600,     8,    18,
   18,     8,   600,   106,    94,    18,    18,     8,    18,    18,
   58,   261,   600,    27,    58,   261,    58,   261,    27,    27,
   58,   106,    58,   261,   106,    27,    58,    58,    58,    65,
   27,    58,   261,    65,    27,    65,   600,    15,    15,    65,
   15,    65,    15,   600,   192,    65,    65,    65,    80,    80,
   65,    80,    15,    80,    80,   600,   253,    80,    15,   253,
   80,   253,   253,    80,   192,   192,   600,   600,   253,    80,
  600,   253,   600,   253,   253,   276,   276,   253,   276,   600,
  276,   600,    24,   600,   276,    24,   276,    24,   276,   289,
  276,    24,   289,    24,   289,   289,   276,    24,   599,   599,
  599,   289,   599,    24,   289,   599,   289,   289,   317,   110,
  289,   317,   599,   317,   317,   599,   600,   317,   599,   599,
  317,   600,   349,   317,   349,   600,   349,   110,   317,   317,
  110,   600,   349,   600,   600,   365,   365,   365,   349,   365,
  349,   349,   349,   349,   348,   348,   348,   348,   348,   386,
  600,   365,   386,   348,   386,   386,   365,   600,   211,   348,
  348,   386,   600,   211,   386,   348,   386,   386,   420,   211,
  386,   420,   600,   420,   420,   445,   445,   600,   445,   211,
  420,   200,   200,   420,   445,   420,   420,    84,   445,   420,
  445,    84,   600,   445,   200,   445,   445,   489,   489,   489,
  489,   489,   200,    84,   600,   494,   489,   494,    84,   494,
  600,   600,   489,   489,   564,   494,   564,   600,   489,   600,
  600,   494,   600,   494,   494,   494,   494,   567,   567,   567,
  600,   567,   564,   564,   564,   564,   600,    16,    16,    16,
  567,    16,   600,   567,   600,   600,   567,   567,   567,   579,
   16,   579,   600,    16,   579,   579,    16,   579,    16,   600,
  102,   579,   102,   579,   102,    17,   579,    17,   285,   285,
  579,   590,   590,   590,   590,   590,   102,   462,   462,    17,
  590,   102,    17,    17,    17,    17,    17,   590,    19,   285,
  462,   590,   590,    19,    19,    32,    32,   462,   462,    19,
   19,   600,    32,   600,    81,    19,    19,   600,    32,    19,
   81,   600,    32,    32,    45,    32,    32,    45,   600,    45,
   45,    68,    52,    45,    68,    81,    45,    52,    52,    45,
   68,   561,   561,    52,    52,    45,    68,   214,   561,    52,
   52,    60,    68,    52,    60,   600,    60,    60,   561,    78,
   60,   561,   561,    60,    78,    78,    60,   214,   214,   600,
   78,    78,    60,   600,   600,   215,    78,    78,    88,   600,
   78,    88,   600,    88,    88,    90,    90,    88,    90,    90,
   88,    40,    40,    88,    90,   215,   215,   284,    40,    88,
   90,    90,   284,    91,    40,    91,    90,    91,    40,    40,
  600,   600,    40,    91,   446,   446,   600,   446,   284,    91,
   96,    91,    91,   446,    91,    96,    96,    98,    98,   446,
   98,    96,    96,   600,   446,   446,    98,    96,    96,   600,
   98,    96,    98,   600,   600,    98,   600,   100,    98,   100,
  328,   100,   328,   600,   328,   149,   328,   100,   149,   600,
  149,   149,   328,   100,   149,   100,   100,   149,   100,   265,
  149,   328,   101,   265,   230,   265,   149,   230,   498,   265,
  498,   265,   498,   230,   498,   600,   265,   265,   306,   306,
  265,   306,   306,   101,   498,   230,   354,   306,   354,   498,
  354,   600,   600,   306,   306,   600,   354,   362,   362,   306,
  362,   362,   354,   600,   354,   354,   362,   354,   372,   372,
  372,   600,   372,   362,   600,   218,   385,   218,   362,   218,
  385,   372,   385,   600,   372,   600,   385,   372,   600,   372,
  600,   218,   385,   385,   385,   426,   218,   385,   600,   426,
   57,   426,   600,    57,   474,   426,   474,   426,   474,    57,
  600,   150,   426,   426,   474,    57,   426,   150,    57,   519,
  474,    57,   474,   474,   519,   474,   499,   499,   499,   499,
  499,   509,   150,   600,   509,   499,   509,   509,   600,   519,
  519,    64,   499,   509,    64,   600,   509,   499,   600,   600,
   64,   509,   509,   528,   528,   528,    64,   528,   600,    64,
  528,   529,    64,   529,   600,   318,   529,   528,   600,   529,
  528,   318,   529,   535,   528,   553,   553,   535,   553,   535,
  529,   529,   529,   535,   553,   318,   318,   600,   553,   535,
  535,   535,   540,   553,   535,   540,   553,   540,   548,   600,
  548,   540,   548,   540,   548,   600,   119,   540,   560,   560,
  548,   560,   540,   540,   548,   600,   600,   560,   548,   548,
  257,   560,   600,   257,   119,   257,   560,   119,   560,   560,
  577,   577,   577,   577,   577,   257,   582,   582,   582,   577,
  582,   257,    37,   582,    37,   320,   577,   600,   320,   600,
  582,   577,    43,   582,   320,   237,    37,   582,    43,    37,
   37,    37,    92,    37,    43,   320,   320,   600,    92,    43,
   43,   600,    43,    43,    92,   237,   237,   198,   198,    92,
   92,   340,    92,    92,   198,   600,   340,   240,   231,   240,
  198,   231,   340,   231,   198,   198,   600,   231,   198,   231,
  600,   240,   340,   231,   240,   240,   240,   254,   240,   231,
  254,   291,   254,   254,   291,   308,   291,   291,   308,   254,
  308,   308,   254,   291,   600,   355,   291,   308,   254,   600,
  308,   355,   291,   600,   600,   387,   308,   355,   387,   600,
  387,   387,   355,   355,   600,   355,   355,   387,   404,   414,
  387,   404,   414,   404,   414,   453,   387,   404,   414,   404,
  414,   453,   431,   404,   414,   431,   600,   453,   600,   404,
  414,   431,   453,   453,   153,   453,   453,   431,   153,   600,
  431,   600,   431,   431,   497,   600,   497,   524,   497,   524,
  153,   524,   600,   524,   497,   153,   527,   229,   527,   524,
  527,   600,   497,   229,   497,   497,   527,   524,   524,   549,
  241,   549,   241,   549,   527,   558,   527,   527,   229,   600,
  558,   558,   566,   566,   566,   549,   566,   558,   549,   549,
  549,   241,   558,   600,   586,   558,   558,   592,   566,   592,
  586,   592,   566,   566,   584,   584,   589,   584,   589,   584,
  589,   586,   589,   592,   586,   586,   592,   592,   592,   584,
  464,   464,   589,    34,   584,   584,   589,   589,    34,    34,
   63,    30,    30,    66,    63,    34,    63,    66,    30,    66,
   34,   464,    63,    69,    34,    66,    63,    69,    30,    66,
   70,    63,    30,    69,    66,   600,    70,   556,   556,    69,
  556,    69,    70,    86,    69,   600,   556,    70,    70,    86,
   76,    70,    76,   600,    76,    86,    93,   556,   556,   600,
   86,    86,    93,   600,    86,   600,    76,   600,    93,    76,
  359,    76,   359,    93,    93,    99,    99,    93,    99,   600,
  107,   600,   111,   600,    99,   600,   107,   479,   111,   479,
   99,   359,   107,   369,   111,   369,    99,   107,   107,   111,
  111,   107,   109,   111,   120,   109,   479,   479,   479,   122,
  120,   109,   122,   369,   369,   600,   120,   109,   122,    51,
  109,   120,   120,   109,   122,   120,   600,   122,   124,   600,
  122,   600,   124,   131,   600,   148,    51,    51,   124,   131,
   51,   148,   600,   600,   124,   131,   124,   148,   600,   124,
  131,   131,   148,   148,   131,   175,   148,   205,   398,   600,
  398,   175,   398,   205,   398,   223,   600,   175,   202,   205,
  398,   223,   175,   175,   205,   205,   175,   223,   205,   398,
  222,   600,   223,   223,   222,   202,   223,   239,   239,   202,
  222,   239,   600,   600,   600,   273,   222,   273,   222,   273,
  239,   222,   301,   239,   301,   273,   301,   334,   239,   334,
  221,   334,   301,   273,   221,   326,   273,   334,   326,    82,
  301,   336,    82,   301,   326,   334,   221,   336,   334,   493,
  326,   221,   493,   336,    82,   326,   326,    82,   336,   336,
   82,   351,   336,   351,   493,   351,   394,   493,   600,   493,
  493,   394,   394,   600,   600,   412,   600,   351,   394,   412,
  600,   351,   351,   394,   401,   412,   401,   394,   401,   447,
  447,   412,   447,   412,   401,   432,   412,   432,   447,   432,
  600,    20,   401,   600,   447,   401,    20,    20,   600,   255,
  447,   432,   600,    20,   432,   255,   432,   465,   465,   465,
  475,   465,    20,   470,   470,   475,   475,   470,   485,   485,
  255,   485,   475,   465,   600,   600,   470,   600,   465,   470,
  475,   475,   264,   485,   470,   264,   105,   600,   485,   485,
  491,   264,   491,   501,   491,   501,   536,   501,   514,   600,
  264,   536,   536,   264,   514,   216,   491,   105,   536,   501,
  491,   491,   501,   536,   501,   514,   514,   536,   514,   514,
  539,   539,   543,   216,   539,   216,   216,   539,   543,   600,
  557,   600,   546,   600,   600,   113,   557,   539,   546,   543,
  543,   539,   543,   543,   546,   600,   210,   557,   557,   546,
  557,   557,   546,   546,   568,   568,   113,   568,   570,   568,
  570,   600,   570,   210,   576,   600,   576,   210,   576,   568,
  576,   236,   600,   600,   570,   568,   374,   570,   374,   570,
  576,   600,   594,   594,   594,   576,   594,    23,    48,   236,
  600,   236,   236,    23,    48,    75,    75,   374,    75,    23,
   48,    53,   594,   594,    23,    48,    53,    53,    23,    48,
   75,   123,    97,    53,   123,   600,    75,    97,    97,   600,
  123,   600,    53,   600,    97,   151,   123,   156,   151,   600,
  600,   156,   123,    97,   600,   161,   259,   156,   161,   600,
  151,   245,   259,   151,   161,   156,   151,   600,   156,   600,
  161,   233,   233,   259,   259,   233,   161,   259,   245,   245,
  262,   245,   245,   262,   268,   279,   600,   233,   268,   262,
  279,   279,   233,   288,   268,   262,   600,   279,   600,   288,
  116,   262,   268,   296,   263,   268,   279,   296,   263,   296,
  288,   288,   297,   600,   288,   297,   307,   307,   116,   296,
  307,   116,   304,   292,   296,   263,   304,   297,   304,   292,
  297,   600,   307,   297,   304,   311,   313,   307,   311,   114,
  311,   321,   313,   304,   292,   321,   324,   600,   339,   339,
  311,   321,   324,   313,   313,   339,   311,   313,   324,   321,
  114,   314,   321,   600,   314,   339,   324,   324,   353,   339,
  353,   361,   353,   600,   377,   361,   377,   361,   390,   314,
  392,   390,   314,   390,   353,   378,   392,   361,   377,   353,
  378,   377,   361,   390,   407,   377,   378,   392,   392,   390,
  407,   392,   419,   600,   408,   378,   378,   408,   419,   600,
  600,   407,   407,   408,   473,   407,   473,   600,   473,   419,
  419,   421,   408,   419,   421,   408,   421,   423,   425,   600,
  473,   425,   600,   423,   434,   473,   421,   425,   587,   587,
  434,   587,   421,   428,   423,   423,   425,   428,   423,   425,
  439,   434,   434,   428,   436,   434,   439,   436,   587,   587,
  600,   428,   439,   436,   428,   486,   486,   454,   486,   600,
  439,   439,   436,   454,   490,   436,   459,   490,   459,   454,
  486,   492,   600,   492,   600,   492,   486,   454,   454,   490,
  459,   502,    56,   459,   490,   490,   515,   459,    56,   515,
  600,   492,   492,   525,    56,   525,   600,   525,   502,   502,
  463,   502,   502,    56,   515,   552,   515,   515,   526,   600,
  526,   552,   526,   525,   525,   551,   551,   463,   551,   600,
  463,   463,   552,   552,   551,   600,   552,    95,   526,   526,
  572,   572,   572,   571,   572,   571,   551,    67,   571,   256,
  108,   571,   256,    67,    95,    95,   108,   112,    95,    67,
  121,   572,   108,   112,   571,   142,   121,   136,    67,   112,
  256,   108,   121,   136,   600,   600,   600,   170,   112,   136,
  115,   121,   142,   142,   157,   163,   142,   176,   136,   600,
  157,   163,   172,   176,   170,   170,   157,   163,   170,   176,
  184,   115,   189,   600,   600,   157,   163,   600,   176,   172,
  172,   242,   294,   172,   600,   294,   206,   184,   184,   189,
  189,   184,   206,   189,   224,   249,   600,   294,   206,   242,
  224,   242,   242,   294,   600,   278,   224,   206,   286,   600,
  286,   600,   249,   249,   299,   224,   249,   274,   299,   274,
  600,   274,   278,   278,   600,   298,   278,   286,   298,   286,
  299,   331,   302,   600,   302,   299,   302,   331,   274,   322,
  298,   352,   322,   331,   243,   329,   298,   329,   322,   329,
  357,   600,   331,   302,   332,   376,   332,   600,   332,   352,
  322,   352,   352,   380,   243,   243,   329,   600,   357,   600,
  357,   357,   376,   376,   381,   332,   376,   600,   381,   117,
  380,   380,   384,   399,   380,   399,   384,   399,   393,   411,
  381,   393,   400,   411,   400,   381,   400,   416,   384,   413,
  117,   600,   413,   384,   399,   411,   393,   441,   413,   393,
  411,   449,   600,   400,   416,   416,   424,   382,   416,   424,
  413,   457,   382,   461,   461,   441,   600,   441,   441,   449,
  477,   449,   449,   478,   424,   478,   600,   424,   382,   457,
  481,   457,   457,   461,   461,   495,   481,   495,   477,   600,
  477,   477,   118,   478,   478,   482,   482,   481,   482,   520,
  520,   481,   510,   600,   545,   495,   495,   530,   510,   530,
  532,   600,   555,   118,   532,   563,   482,   563,   555,   520,
  520,   545,   510,   510,   545,   545,   532,   530,   530,   125,
  600,   532,   555,   555,   573,   563,   563,   600,   574,   574,
  573,   574,   597,   130,   597,   600,   600,   125,   133,   135,
  125,   573,   600,   138,   144,   573,   600,   600,   147,   574,
  146,   130,   597,   597,   130,   154,   133,   135,   600,   133,
  135,   138,   144,   166,   138,   144,   147,   174,   146,   147,
  600,   146,   180,   154,   181,   600,   154,   600,   186,   195,
  204,   166,   246,   600,   166,   174,   209,   220,   174,   269,
  180,   227,   181,   180,   247,   181,   186,   195,   204,   186,
  195,   204,   246,   246,   209,   220,   269,   209,   220,   227,
  269,   271,   227,   266,   247,   247,   293,   266,   303,   293,
  305,   309,   303,   310,   305,   319,   310,   309,   323,   271,
  325,   319,   271,   327,   266,   600,   600,   293,   335,   303,
  338,   305,   309,   344,   310,   345,   319,   350,   323,   323,
  325,   325,   343,   327,   327,   356,   335,   360,   338,   335,
  344,   338,   358,   600,   344,   345,   345,   350,   350,   367,
  343,   379,   370,   343,   370,   356,   356,   360,   360,   389,
  358,   388,   389,   358,   409,   600,   429,   388,   440,   367,
  367,   379,   379,   370,   427,   437,   458,   442,   427,   442,
  389,   409,   388,   429,   448,   409,   455,   429,   440,   440,
  456,   450,   437,   450,   458,   427,   437,   458,   442,   460,
  468,   460,   468,   476,   448,   448,   455,   455,   487,   600,
  456,   456,   450,   496,   533,   496,   503,   600,   504,   533,
  460,   468,   513,   476,   476,   518,   600,   541,   487,   487,
  521,   600,   521,   542,   496,   533,   503,   503,   504,   504,
  547,   127,   513,   513,   550,   518,   518,   541,   541,   559,
  550,   521,   585,   542,   542,   580,   126,   580,   128,   129,
  547,   547,   127,   132,   134,   550,   137,   139,   141,   559,
  559,   140,   585,   585,   143,   145,   580,   126,   158,   128,
  129,   159,   162,   164,   132,   134,   165,   137,   139,   141,
  167,   169,   140,   168,   171,   143,   145,   173,   178,   158,
  177,   179,   159,   162,   164,   183,   182,   165,   185,   188,
  187,   167,   169,   190,   168,   171,   191,   193,   173,   178,
  194,   177,   179,   196,   201,   203,   183,   182,   207,   185,
  188,   187,   208,   212,   190,   217,   219,   191,   193,   226,
  225,   194,   228,   238,   196,   201,   203,   248,   250,   207,
  251,   258,   267,   208,   212,   270,   217,   219,   275,   277,
  226,   225,   280,   228,   238,   282,   281,   283,   248,   250,
  287,   251,   258,   267,   295,   312,   270,   330,   333,   275,
  277,   337,   341,   280,   342,   346,   282,   281,   283,   347,
  368,   287,   371,   373,   375,   295,   312,   391,   330,   333,
  395,   405,   337,   341,   406,   342,   346,   410,   415,   417,
  347,   368,   418,   371,   373,   375,   422,   433,   391,   435,
  438,   395,   405,   443,   451,   406,   466,   471,   410,   415,
  417,   480,   537,   418,   569,   600,   600,   422,   433,   600,
  435,   438,   600,   600,   443,   451,   600,   466,   471,   600,
  600,   600,   480,   537,   600,   569};

/* Base vector for state transitions.  */
static const unsigned short cfv123_mem_base[] = {
    0,    22,   896,   148,   187,   292,   104,   165,  1116,   336,
  314,   490,    66,    44,   909,  1167,  1367,  1395,  1118,  1418,
 2311,   630,   512,  2457,  1212,   918,   532,  1143,   990,   358,
 2041,   342,  1425,   552,  2033,   387,   443,  1812,   308,   133,
 1511,   983,   647,  1822,   658,  1444,   677,   572,  2458,   717,
  883,  2149,  1452,  2471,   988,   348,  2742,  1670,  1140,   691,
 1471,    93,   606,  2040,  1711,  1159,  2043,  2797,  1451,  2053,
 2060,   718,    85,   710,   380,  2465,  2080,   417,  1479,   209,
 1178,  1434,  2249,   861,  1317,   587,  2073,   737,  1498,   756,
 1505,  1523,  1832,  2086,  1113,  2787,  1540,  2482,  1547,  2105,
 1567,  1592,  1390,   793,   817,  2356,  1133,  2110,  2800,  2132,
 1239,  2112,  2807,  2405,  2589,  2830,  2550,  2959,  3032,  1776,
 2134,  2810,  2139,  2481,  2158,  3069,  3326,  3311,  3328,  3329,
 3083,  2163,  3333,  3088,  3334,  3089,  2817,  3336,  3093,  3337,
 3341,  3338,  2815,  3344,  3094,  3345,  3100,  3098,  2165,  1575,
 1681,  2495,   949,  1944,  3105,   364,  2497,  2834,  3348,  3351,
  453,  2505,  3352,  2835,  3353,  3356,  3113,  3360,  3363,  3361,
 2827,  3364,  2842,  3367,  3117,  2185,  2837,  3370,  3368,  3371,
 3122,  3124,  3376,  3375,  2850,  3378,  3128,  3380,  3379,  2852,
 3383,  3386,  1174,  3387,  3390,  3129,  3393,   762,  1847,  1076,
 1311,  3394,  2198,  3395,  3130,  2187,  2866,  3398,  3402,  3136,
 2416,  1288,  3403,   217,  1467,  1495,  2375,  3405,  1645,  3406,
 3137,  2240,  2210,  2195,  2874,  3410,  3409,  3141,  3412,  1967,
 1594,  1858,   937,  2521,   732,  1105,  2441,  1825,  3413,  2217,
 1857,  1980,  2861,  2924,   160,  2511,  3132,  3144,  3417,  2875,
 3418,  3420,   242,  1186,  1877,  2319,  2799,  1790,  3421,  2506,
  641,  1141,  2530,  2554,  2352,  1589,  3163,  3422,  2534,  3139,
 3425,  3161,   482,  2225,  2897,  3428,  1205,  3429,  2885,  2535,
 3432,  3436,  3435,  3437,  1517,  1398,  2888,  3440,  2543,  1219,
  775,  1881,  2573,  3166,  2862,  3444,  2553,  2562,  2905,  2894,
  884,  2232,  2912,  3168,  2572,  3170,  1608,  2566,  1885,  3171,
 3173,  2585,  3445,  2586,  2611,  1023,   957,  1238,  1735,  3175,
 1815,  2591,  2919,  3178,  2596,  3180,  2245,  3183,  1570,  2925,
 3447,  2911,  2934,  3448,  2237,  3188,  2251,  3451,  3190,  2598,
 1851,  3452,  3454,  3202,  3193,  3195,  3455,  3459,  1274,  1252,
 3197,  2271,  2921,  2618,  1616,  1895,  3205,  2930,  3212,  2100,
 3207,  2621,  1627,   794,   402,  1265,   581,  3219,  3460,  2123,
 3222,  3462,  1638,  3463,  2446,  3464,  2935,  2624,  2635,  3221,
 2943,  2954,  2997,   410,  2962,  1646,  1279,  1905,  3231,  3229,
 2628,  3467,  2630,  2968,  2276,  3470,   976,   996,  2188,  2963,
 2972,  2294,   459,   386,  1918,  3471,  3474,  2644,  2654,  3234,
 3477,  2969,  2285,  2979,  1919,  3478,  2977,  3479,  3482,  2652,
 1298,  2671,  3486,  2677,  2996,  2678,  1665,  3244,  2693,  3236,
  825,  1932,  2305,  3487,  2684,  3489,  2704,  3245,  3490,  2700,
 3238,  2987,  3247,  3493,   190,  1305,  1534,  2299,  3254,  2991,
 3261,  3494,   927,  1925,  2717,  3256,  3260,  3001,  3246,  2726,
 3269,  3003,  1407,  2760,  2030,  2327,  3496,   960,  3270,  1091,
 2333,  3497,  1059,  2664,  1674,  2330,  3273,  3010,  3013,  2117,
 3501,  3020,  3035,   424,   231,  2338,  2715,  3278,  1018,  1327,
 2724,  2360,  2731,  2259,  1335,  3025,  3283,  1954,  1598,  1696,
  253,  2363,  2741,  3286,  3288,   699,  1053,   802,  1025,  1701,
 3042,   830,   302,  3292,  2368,  2746,   492,  1047,  3295,  1689,
 3039,  3300,   594,   822,  1957,  2753,  2768,  1966,  1723,  1731,
 3047,   844,  3050,  3284,   684,  1743,  2366,  3502,  1069,  2390,
 1762,  3297,  3303,  2392,   559,  3044,  2402,  3310,  1768,  1979,
 3314,  2775,  2765,  1745,  1083,  3052,  2067,  2400,  1985,  3319,
 1778,  1461,   515,  3055,  1344,   768,  1992,  1357,  2424,  3504,
 2428,  2793,  2790,  3074,  3078,   446,  2434,  1800,   852,  1379,
 3325,   616,  1806,   874,  2014,  3322,  2004,  2688,   275,  2016,
 1401,   126,  2007,   265,  2452,   636,  1094,  3082,   468,  1228,
};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv123_mem_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,    16,     0,    16,    16,     0,    17,    33,     1,    32,
   16,    33,    32,     0,     0,     0,    33,     0,    16,    32,
   16,     1,    16,    16,     0,     2,     1,    16,    18,     1,
   16,     2,     0,     0,     0,     1,     1,    32,     1,     1,
   32,     1,     1,    32,     0,     0,     0,    16,    16,     0,
   16,    16,     0,    16,    16,     1,     0,     0,    16,    16,
    0,    16,    16,     0,    16,    16,     1,    32,     0,    16,
   16,     4,    80,    19,     1,    32,    18,    17,    32,     0,
    0,     2,    19,    64,     2,    16,    16,     1,     0,    16,
    2,     1,     1,     2,    49,     1,     2,     1,     0,     0,
    0,     1,    32,    16,     1,    32,    16,     1,    32,    16,
    2,     0,     0,    16,     0,     0,    16,     0,     0,    16,
    0,     1,    32,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,    16,     0,    16,    16,     0,    17,    33,
    1,    32,    16,    33,    32,     0,    16,    16,    52,    84,
   83,    49,    32,    18,    33,    32,     0,     3,     2,    35,
   67,    66,    32,    19,     1,    16,    16,     2,     2,    49,
   18,    50,    49,    18,     2,    48,     0,     0,     1,    33,
   32,     1,    33,    32,     1,    33,    32,     2,     0,     1,
   33,    32,     1,    33,    32,     1,    33,    32,     2,    48,
    1,    33,    32,     4,    81,    35,     1,    33,    34,    18,
   48,     0,    16,    18,    19,    64,    18,    16,    16,    17,
    1,    32,     2,     1,     1,     2,    49,     1,     2,     1,
    0,     0,    16,     2,    49,    33,     2,    49,    33,     2,
   49,    32,    35,    64,     1,    32,    16,    33,    32,    16,
   33,    32,    17,    18,    48,     0,    18,     1,    16,    18,
    1,    16,    18,     0,     1,    32,     1,     1,    32,     1,
    1,    32,     1,     1,    32,     0,    16,     1,    33,    32,
    2,    49,    33,     1,    33,    32,    34,    48,     0,    16,
   16,    33,    32,    16,    32,    16,    17,    17,    32,     0,
    2,     1,    16,    18,     1,    16,     2,     0,     0,    16,
    0,    20,    81,    48,    20,    81,    50,    52,    80,    33,
   32,     1,     3,    64,    33,     3,    64,    33,    35,    65,
   16,    16,     0,    18,    49,    16,    18,    49,    16,    18,
   48,     1,     0,     1,     1,    32,     1,     1,    32,     1,
    1,    32,     0,    16,     1,    33,    32,     2,    49,    33,
    1,    33,    32,    34,    48,     1,    36,    80,    52,    84,
   83,    49,    36,    82,    34,    48,     0,    19,    66,    35,
   67,    66,    32,    19,    65,    17,    32,     2,     2,    49,
   18,    50,    49,    18,     2,    48,     0,    16,     2,    52,
   81,    50,    52,    81,    50,    52,    80,    35,    64,     1,
   35,    64,    33,    35,    64,    33,    35,    65,    18,    48,
    0,    18,    49,    16,    18,    49,    16,    18,    48,     1,
   32,     0,    19,    67,    36,    83,    67,    36,    83,    66,
   17,    32,     3,     2,    50,    19,    66,    50,    19,    66,
   49,     0,    16,     2,    49,    33,     2,    49,    33,     2,
   49,    32,     3,     0,     1,    32,    16,     1,    32,    16,
    1,    32,    16,     2,    48,     1,    32,    16,     4,    80,
   19,     1,    32,    18,    18,    48,     0,    16,     2,    19,
   64,     2,    16,    16,     1,     1,    32,     2,     1,     1,
    2,    49,     1,     2,     1,     0,     0,    16,     2,    49,
   33,     2,    49,    33,     2,    49,    32,    35,    64,     4,
   84,    83,    52,    84,    83,    52,    84,    82,    37,    96,
    3,    67,    66,    35,    67,    66,    35,    67,    65,    20,
   80,     2,    50,    49,    18,    50,    49,    18,    50,    48,
    3,    64,     1,    33,    32,     1,    33,    32,     1,    33,
   32,     2,    48,     1,    33,    32,     4,    81,    35,     1,
   33,    34,    18,    48,     6,   115,    69,    38,   115,    69,
   38,   115,    68,    23,   128,     5,    98,    52,    21,    98,
   52,    21,    98,    51,     6,   112,     4,    81,    35,     4,
   81,    35,     4,    81,    34,    21,    96,     3,    64,    18,
   19,    64,    18,    19,    64,    17,     4,    80,     2,    49,
    1,     2,    49,     1,     2,    49,     0,     3,    64,     1,
   32,    16,     1,    32,    16,     1,    32,    16,     2,    48,
    1,    32,    16,     4,    80,    19,     1,    32,    18,    18,
   48,     6,   113,    37,     6,   115,    69,    38,   113,    36,
   23,   128,     5,    96,    20,    21,    98,    52,    21,    96,
   19,     6,   112,     4,    81,     3,     4,    81,    35,     4,
   81,     2,    21,    96,     3,    64,    18,    19,    64,    18,
   19,    64,    17,     4,    80,     2,    49,     1,     2,    49,
    1,     2,    49,     0,     3,    64,     4,    81,     3,     4,
   81,    35,     4,    81,     2,    21,    96,     5,    97,    36,
    5,    97,    36,     5,    97,    35,    38,   112,     4,    80,
   19,    36,    80,    19,    36,    80,    18,    21,    96,     3,
   66,     2,    19,    66,     2,    19,    66,     1,     4,    80,
    2,    49,    33,     2,    49,    33,     2,    49,    32,     3,
   64,     1,    32,    16,     1,    32,    16,     1,    32,    16,
    2,    48,     0,    16,     0,     0,    16,     0,     0,    16,
    0,     1,    32,     0,    16,     0,     4,    80,    19,     1,
   32,     2,    17,    32,     0,     0,     2,    19,    64,     2,
   16,    16,     1,     0,    16,     0,    16,    19,    52,    84,
   83,    52,    80,    18,    33,    32,     3,     3,     2,    35,
   67,    66,    35,    67,     1,    16,    16,     2,    50,    49,
   18,    50,    49,    18,    50,    48,     3,     0,     1,    33,
   32,     1,    33,    32,     1,    33,    32,     2,    48,     0,
   16,    16,     0,    16,    16,     0,    16,    16,     1,    32,
    0,    16,    16,     4,    80,    19,     1,    32,    18,    17,
   32,     6,   113,    37,     6,   115,    69,    38,   113,    36,
   23,   128,     5,    96,    20,    21,    98,    52,    21,    96,
   19,     6,   112,     5,    96,    20,    53,   100,    84,    53,
   96,    19,    38,   112,     4,    83,     3,    36,    83,    67,
   36,    83,     2,    21,    96,     3,    66,    50,    19,    66,
   50,    19,    66,    49,     4,    80,     2,    49,    33,     2,
   49,    33,     2,    49,    32,     3,    64,     1,    32,    16,
    1,    32,    16,     1,    32,    16,     2,    48,     1,    32,
   16,     4,    80,    19,     1,    32,    18,    18,    48,     0,
   16,     2,    19,    64,     2,    16,    16,     1,     1,    32,
    0,    16,     3,    36,    80,    19,    36,    80,     2,    17,
   32,     3,     2,     2,    19,    66,     2,    19,    66,     1,
    0,    16,     2,    49,    33,     2,    49,    33,     2,    49,
   32,     3,     0,     2,    49,    33,     2,    49,    33,     2,
   49,    32,     3,    64,     3,    67,    66,    35,    67,    66,
   35,    67,    65,    20,    80,     2,    50,    49,    18,    50,
   49,    18,    50,    48,     3,    64,     1,    33,    32,     1,
   33,    32,     1,    33,    32,     2,    48,     1,    33,    32,
    4,    81,    35,     1,    33,    34,    18,    48,     0,    16,
   18,    19,    64,    18,    16,    16,    17,     1,    32,     0,
   16,    19,    36,    80,    19,    36,    80,    18,    17,    32,
    3,     2,     2,    19,    66,     2,    19,    66,     1,     0,
   16,     4,    84,    83,    52,    84,    83,    52,    84,    82,
   37,    96,     4,     3,     3,    36,    83,    67,    36,    83,
    2,    21,    16,     3,    66,    50,    19,    66,    50,    19,
   66,    49,     4,     0,     3,    66,    50,    19,    66,    50,
   19,    66,    49,     4,    80,     4,    83,    67,    36,    83,
   67,    36,    83,    66,    21,    96,     3,    66,    50,    19,
   66,    50,    19,    66,    49,     4,    80,     2,    49,    33,
    2,    49,    33,     2,    49,    32,     3,    64,     4,    81,
   35,     4,    81,    35,     4,    81,    34,    21,    96,     3,
   64,    18,    19,    64,    18,    19,    64,    17,     4,    80,
    3,    66,    50,    22,   114,    53,    19,    66,    49,     4,
   80,     2,    49,    33,     5,    97,    36,     2,    49,    32,
    3,    64,     5,    97,    36,     5,    97,    36,     5,    97,
   35,    38,   112,     6,   117,   101,    70,   117,   101,    70,
  117,   100,    55,   128,     5,   100,    84,    53,   100,    84,
   53,   100,    83,    38,   112,     4,    83,    67,    36,    83,
   67,    36,    83,    66,    21,    96,     3,    66,    50,    19,
   66,    50,    19,    66,    49,     4,    80,     5,   100,    84,
   53,   100,    84,    53,   100,    83,    38,   112,     4,    83,
   67,    36,    83,    67,    36,    83,    66,    21,    96,     3,
   66,    50,    19,    66,    50,    19,    66,    49,     4,    80,
    2,    49,    33,     2,    49,    33,     2,    49,    32,     3,
   64,     4,    81,    35,     4,    81,    35,     4,    81,    34,
   21,    96,     3,    64,    18,    19,    64,    18,    19,    64,
   17,     4,    80,     4,    80,    19,    36,    80,    19,    36,
   80,    18,    21,    96,     3,    66,     2,    19,    66,     2,
   19,    66,     1,     4,    80,     5,    98,    52,    21,    98,
   52,    21,    98,    51,     6,   112,     5,   100,    84,    53,
  100,    84,    53,   100,    83,    38,   112,     4,    83,    67,
   36,    83,    67,    36,    83,    66,    21,    96,     6,   115,
   69,    38,   115,    69,    38,   115,    68,    23,   128,     5,
  100,    84,    53,   100,    84,    53,   100,    83,    38,   112,
    3,    66,    50,    22,   114,    53,    19,    66,    49,     4,
   80,     2,    49,    33,     5,    97,    36,     2,    49,    32,
    3,    64,     5,   100,    84,    53,   100,    84,    53,   100,
   83,    38,   112,     6,   114,    53,    22,   114,    53,    22,
  114,    52,     7,   128,     6,   117,   101,    70,   117,   101,
   70,   117,   100,    55,   128,     5,    98,    52,    21,    98,
   52,    21,    98,    51,     6,   112,     4,    81,    35,     4,
   81,    35,     4,    81,    34,    21,    96,     6,   115,    69,
   38,   115,    69,    38,   115,    68,    23,   128,     5,    98,
   52,    21,    98,    52,    21,    98,    51,     6,   112,     6,
  115,    69,    38,   115,    69,    38,   115,    68,    23,   128,
    4,    83,    67,    36,    83,    67,    36,    83,    66,    21,
   96,     3,    67,    66,    35,    67,    66,    35,    67,    65,
   20,    80,     2,    50,    49,    18,    50,    49,    18,    50,
   48,     3,    64,     4,    83,    67,    36,    83,    67,    36,
   83,    66,    21,    96,     3,    66,    50,    19,    66,    50,
   19,    66,    49,     4,    80,     4,    83,    67,    36,    83,
   67,    36,    83,    66,    21,    96,     3,    66,    50,    19,
   66,    50,    19,    66,    49,     4,    80,     3,    66,    50,
   22,   114,    53,    19,    66,    49,     4,    80,     2,    49,
   33,     5,    97,    36,     2,    49,    32,     3,    64,     1,
   32,    16,     4,    80,    19,     1,    32,    18,    18,    48,
    6,   113,    37,     6,   115,    69,    38,   113,    36,    23,
  128,     5,    96,    20,    21,    98,    52,    21,    96,    19,
    6,   112,     5,    96,    20,    53,   100,    84,    53,    96,
   19,    38,   112,     4,    83,     3,    36,    83,    67,    36,
   83,     2,    21,    96,     6,   114,    53,    22,   114,    53,
   22,   114,    52,     7,   128,     6,   112,    21,    38,   112,
   21,    38,   115,    68,    23,   128,     5,    98,     4,    21,
   98,     4,    21,    98,    51,     6,   112,     4,    81,    35,
    4,    81,    35,     4,    81,    34,    21,    96,     6,   115,
   69,    38,   115,    69,    38,   115,    68,    23,   128,     4,
   83,    67,    36,    83,    67,    36,    83,    66,    21,    96,
    5,   100,     4,    53,   100,    84,    53,   100,    83,    38,
  112,     4,    80,    19,    36,    80,    19,    36,    80,    18,
   21,    96,     4,    83,    67,    36,    83,    67,    36,    83,
   66,    21,    96,     5,    97,    36,     5,    97,    36,     5,
   97,    35,    38,   112,     6,   117,   101,    70,   117,   101,
   70,   117,   100,    55,   128,     5,   100,    84,    53,   100,
   84,    53,   100,    83,    38,   112,     6,   114,    53,    22,
  114,    53,    22,   114,    52,     7,   128,     4,    83,    67,
   36,    83,    67,    36,    83,    66,    21,    96,     6,   115,
   69,    38,   115,    69,    38,   115,    68,    23,   128,     3,
   67,    66,    35,    67,    66,    35,    67,    65,    20,    80,
    2,    50,    49,    18,    50,    49,    18,    50,    48,     3,
   64,     3,    67,    66,    35,    67,    66,    35,    67,    65,
   20,    80,     2,    50,    49,    18,    50,    49,    18,    50,
   48,     3,    64,     4,    83,    67,    36,    83,    67,    36,
   83,    66,    21,    96,     3,    66,    50,    19,    66,    50,
   19,    66,    49,     4,    80,     2,    49,    33,     2,    49,
   33,     2,    49,    32,     3,    64,     4,    81,    35,     4,
   81,    35,     4,    81,    34,    21,    96,     6,   115,    69,
   38,   115,    69,    38,   115,    68,    23,   128,     4,    83,
   67,    36,    83,    67,    36,    83,    66,    21,    96,     3,
   67,    66,    35,    67,    66,    35,    67,    65,    20,    80,
    3,    66,    50,    22,   114,    53,    19,    66,    49,     4,
   80,     3,    66,    50,    19,    66,    50,    19,    66,    49,
    4,    80,     4,    83,    67,    36,    83,    67,    36,    83,
   66,    21,    96,     3,    67,    66,    35,    67,    66,    35,
   67,    65,    20,    80,     2,    50,    49,    18,    50,    49,
   18,    50,    48,     3,    64,     4,    83,    67,    36,    83,
   67,    36,    83,    66,    21,    96,     3,    66,    50,    19,
   66,    50,    19,    66,    49,     4,    80,     4,    83,    67,
   36,    83,    67,    36,    83,    66,    21,    96,     3,    67,
   66,    35,    67,    66,    35,    67,    65,    20,    80,     2,
   50,    49,    18,    50,    49,    18,    50,    48,     3,    64,
    4,    83,    67,    36,    83,    67,    36,    83,    66,    21,
   96,     3,    67,    66,    35,    67,    66,    35,    67,    65,
   20,    80,     4,    83,    67,    36,    83,    67,    36,    83,
   66,    21,     0,     5,   100,    84,    53,   100,    84,    53,
  100,    83,    38,   112,     4,    84,    83,    52,    84,    83,
   52,    84,    82,    37,    96,     5,    98,    52,    21,    98,
   52,    21,    98,    51,     6,   112,     6,   115,    69,    38,
  115,    69,    38,   115,    68,    23,   128,     1,    35,    64,
   33,    35,    64,    33,    35,    65,    18,    48,     0,    18,
   49,    16,    18,    49,    16,    18,    48,     1,    32,     0,
   19,    67,    36,    83,    67,    36,    83,    66,    17,    32,
    0,    19,    66,    35,    67,    66,    32,    19,    65,    17,
   32,     4,    84,    83,    52,    84,    83,    52,    84,    82,
   37,    96,     2,    52,    81,    50,    52,    81,    50,    52,
   80,    35,    64,     4,    84,    83,    52,    84,    83,    52,
   84,    82,    37,    96,     3,    66,    50,    22,   114,    53,
   19,    66,    49,     4,    80,     2,    49,    33,     5,    97,
   36,     2,    49,    32,     3,    64,     5,    97,    36,     5,
   97,    36,     5,    97,    35,    38,   112,     6,   117,   101,
   70,   117,   101,    70,   117,   100,    55,   128,     5,   100,
   84,    53,   100,    84,    53,   100,    83,    38,   112,     6,
  114,    53,    22,   114,    53,    22,   114,    52,     7,   128,
    2,    52,    81,    50,    52,    81,    50,    52,    80,    35,
   64,     1,    35,    64,    33,    35,    64,    33,    35,    65,
   18,    48,     3,    67,    66,    35,    67,    66,    35,    67,
   65,    20,    80,     4,    81,    35,     4,    81,    35,     4,
   81,    34,    21,     0,     6,   115,    69,    38,   115,    69,
   38,   115,    68,    23,     0,     3,    67,    66,    35,    67,
   66,    35,    67,    65,    20,     0,     3,    66,    50,    22,
  114,    53,    19,    66,    49,     4,     0,     4,    84,    83,
   52,    84,    83,    52,    84,    82,    37,    96,     4,     3,
    3,    36,    83,    67,    36,    83,     2,    21,    16,     5,
  100,    84,    53,   100,    84,    53,   100,    83,    38,   112,
    5,    98,    52,    21,    98,    52,    21,    98,    51,     6,
  112,     6,   115,     5,    38,   115,    69,    38,   115,     4,
   23,   128,     3,    66,     2,    22,   114,     5,    19,    66,
    1,     4,    80,     2,    49,    33,     5,    97,    36,     2,
   49,    32,     3,    64,     5,    97,    36,     5,    97,    36,
    5,    97,    35,    38,   112,     6,   117,   101,    70,   117,
  101,    70,   117,   100,    55,   128,     5,   100,    84,    53,
  100,    84,    53,   100,    83,    38,   112,     6,   114,    53,
   22,   114,    53,    22,   114,    52,     7,   128,     4,    84,
   83,    52,    84,    83,    52,    84,    82,    37,    96,     6,
  113,    37,     6,   115,    69,    38,   113,    36,    23,   128,
    6,   112,    21,    38,   112,    21,    38,   115,    68,    23,
  128,     1,    32,    16,    33,    32,    16,    33,    32,    17,
   18,    48,     0,    18,     1,    16,    18,     1,    16,    18,
    0,     1,    32,     0,    19,     3,    36,    83,    67,    36,
   83,     2,    17,    32,     3,     2,    50,    19,    66,    50,
   19,    66,    49,     0,    16,     4,     3,    67,    36,    83,
   67,    36,    83,    66,    21,    16,     3,    66,    50,    19,
   66,    50,    19,    66,    49,     4,     0,     4,    83,    67,
   36,    83,    67,    36,    83,    66,    21,     0,     5,   100,
   84,    53,   100,    84,    53,   100,    83,    38,   112,     0,
   19,     2,    35,    67,    66,    32,    19,     1,    17,    32,
    2,     2,    49,    18,    50,    49,    18,     2,    48,     0,
   16,     4,     3,    67,    36,    83,    67,    36,    83,    66,
   21,    16,     3,    66,    50,    19,    66,    50,    19,    66,
   49,     4,     0,     4,    83,    67,    36,    83,    67,    36,
   83,    66,    21,     0,     3,     3,    66,    35,    67,    66,
   35,    67,    65,    16,    16,     2,    50,    49,    18,    50,
   49,    18,    50,    48,     3,     0,     4,    83,    67,    36,
   83,    67,    36,    83,    66,    21,     0,     3,    67,    66,
   35,    67,    66,    35,    67,    65,    20,     0,     5,   100,
   84,    53,   100,    84,    53,   100,    83,    38,   112,     2,
   50,    49,    21,    98,    52,    18,    50,    48,     3,    64,
    3,    67,    66,    38,   115,    69,    35,    67,    65,    20,
   80,     4,    84,    83,    52,    84,    83,    52,    84,    82,
   37,    96,     2,    49,    33,     6,   114,    53,    19,    65,
   32,     3,    64,     1,    32,    16,     5,    97,    36,     2,
   48,    16,     2,    48,     1,    32,    16,     5,    97,    36,
    5,    96,    19,    34,    48,     6,   113,    37,     6,   117,
  101,    70,   113,    36,    55,   128,     6,   112,    21,    70,
  117,   101,    70,   117,   100,    55,   128,     1,    32,    16,
   53,   100,    84,    53,    96,    19,    34,    48,     6,   117,
  101,    70,   117,   101,    70,   117,   100,    55,   128,     2,
   49,    33,     6,   114,    53,    22,   113,    32,     3,    64,
    6,   112,    21,    22,   114,    53,    22,   114,    52,     7,
  128,     5,    97,     4,     5,    97,    36,     5,    97,    35,
   38,   112,     4,    80,    19,    36,    80,    19,    36,    80,
   18,    21,    96,     6,   117,     5,    70,   117,   101,    70,
  117,   100,    55,   128,     3,    64,    18,    22,   112,    21,
   19,    66,    49,     4,    80,     2,    49,     1,     5,    97,
    4,     2,    49,    32,     3,    64,     5,   100,     4,    53,
  100,    84,    53,   100,    83,    38,   112,     4,    83,    67,
   36,    83,    67,    36,    83,    66,    21,    96,     6,   114,
    5,    22,   114,     5,    22,   114,    52,     7,   128,     2,
   52,    81,    50,    52,    81,    50,    52,    80,    35,    64,
    3,    67,    66,    35,    67,    66,    35,    67,    65,    20,
   80,     3,    66,    50,    22,   114,    53,    19,    66,    49,
    4,    80,     0,    16,    21,    38,   112,    21,    38,   115,
   68,    23,    32,     5,     2,     4,    21,    98,     4,    21,
   98,    51,     6,    16,     5,     4,     4,    53,   100,    84,
   53,   100,    83,    38,    16,     5,   100,    84,    53,   100,
   84,    53,   100,    83,    38,   112,     0,    16,    16,    33,
   32,    16,    32,    16,    17,    17,    32,     3,    67,    66,
   38,   115,    69,    35,    67,    65,    20,    80,     2,    50,
   49,    21,    98,    52,    18,    50,    48,     3,    64,     1,
   33,    32,     4,    81,    35,     1,    33,    34,    18,    48,
    6,   115,    69,    38,   115,    69,    38,   115,    68,    23,
  128,     4,    83,    67,    36,    83,    67,    36,    83,    66,
   21,    96,     5,   100,    84,    53,   100,    84,    53,   100,
   83,    38,   112,     5,   100,    84,    53,   100,    84,    53,
  100,    83,    38,   112,     1,    36,    80,    52,    84,    83,
   49,    36,    82,    34,    48,     0,    20,    83,    52,    84,
   83,    52,    84,    82,    33,    32,     3,     3,    66,    35,
   67,    66,    35,    67,    65,    16,    16,     4,    84,    83,
   52,    84,    83,    52,    84,    82,    37,    96,     2,    49,
   33,     6,   114,    53,    19,    65,    32,     3,    64,     1,
   32,    16,     5,    97,    36,     2,    48,    16,     2,    48,
    0,    16,     0,     4,    80,    19,     1,    32,     2,    17,
   32,     1,    32,    16,     5,    97,    36,     5,    96,    19,
   34,    48,     6,   113,    37,     6,   117,   101,    70,   113,
   36,    55,   128,     6,   112,    21,    70,   117,   101,    70,
  117,   100,    55,   128,     5,    96,    20,    53,   100,    84,
   53,    96,    19,    38,   112,     5,   100,    84,    53,   100,
   84,    53,   100,    83,    38,   112,     6,   113,     5,     6,
  115,    69,    38,   113,     4,    23,   128,     5,    96,    20,
   21,    98,    52,    21,    96,    19,     6,   112,     5,    96,
   20,    53,   100,    84,    53,    96,    19,    38,   112,     6,
  115,     5,    38,   115,    69,    38,   115,     4,    23,   128,
    0,    16,     5,    38,   112,    21,    38,   115,     4,    23,
   32,     5,     2,     4,    21,    98,     4,    21,    98,    51,
    6,    16,     5,     4,     4,    53,   100,    84,    53,   100,
   83,    38,    16,     6,   117,     5,    70,   117,   101,    70,
  117,   100,    55,   128,     5,    97,     4,     5,    97,    36,
    5,    97,    35,    38,   112,     5,   100,     4,    53,   100,
   84,    53,   100,    83,    38,   112,     0,    16,     3,    36,
   80,    19,    36,    80,     2,    17,    32,     0,    19,     3,
   36,    83,    67,    36,    83,     2,    17,    32,     1,    32,
   16,     5,    97,    36,     5,    96,    19,    34,    48,     6,
  113,    37,     6,   117,   101,    70,   113,    36,    55,   128,
    6,   112,    21,    70,   117,   101,    70,   117,   100,    55,
  128,     1,    32,    16,    53,   100,    84,    53,    96,    19,
   34,    48,     6,   117,   101,    70,   117,   101,    70,   117,
  100,    55,   128,     2,    49,    33,     6,   114,    53,    22,
  113,    32,     3,    64,     6,   112,    21,    22,   114,    53,
   22,   114,    52,     7,   128,     0,    16,    18,    22,   112,
   21,    16,    18,    49,     4,    32,     2,     1,     1,     5,
   97,     4,     2,     1,    32,     3,    16,     1,    32,    16,
    4,    80,    19,     1,    32,    18,    18,     0,     6,   113,
   37,     6,   115,    69,    38,   113,    36,    23,     0,     6,
  113,    37,     6,   115,    69,    38,   113,    36,    23,   128,
    6,   112,    21,    38,   112,    21,    38,   115,    68,    23,
    0,     5,    98,     4,    21,    98,     4,    21,    98,    51,
    6,   112,     6,   112,    21,    38,   112,    21,    38,   115,
   68,    23,   128,     6,   117,   101,    70,   117,   101,    70,
  117,   100,    55,     0,     5,    97,    36,     5,    97,    36,
    5,    97,    35,    38,     0,     5,   100,    84,    53,   100,
   84,    53,   100,    83,    38,     0,     4,    80,    19,    36,
   80,    19,    36,    80,    18,    21,     0,     4,    83,    67,
   36,    83,    67,    36,    83,    66,    21,     0,     5,     1,
    4,     5,    97,    36,     5,    97,    35,    38,    16,     6,
    5,     5,    70,   117,   101,    70,   117,   100,    55,    16,
    6,   117,   101,    70,   117,   101,    70,   117,   100,    55,
  128,     5,    97,    36,     5,    97,    36,     5,    97,    35,
   38,   112,     5,     4,     4,    53,   100,    84,    53,   100,
   83,    38,    16,     5,   100,    84,    53,   100,    84,    53,
  100,    83,    38,   112,     6,     2,     5,    22,   114,     5,
   22,   114,    52,     7,    16,     6,   114,    53,    22,   114,
   53,    22,   114,    52,     7,   128,     2,    49,    33,     5,
   97,    36,     2,    49,    32,     3,    64,     6,   117,   101,
   70,   117,   101,    70,   117,   100,    55,   128,     3,    66,
   50,    22,   114,    53,    19,    66,    49,     4,    80,     0,
   20,    81,    48,    20,    81,    50,    52,    80,    33,    32,
    1,    35,    64,    33,    35,    64,    33,    35,    65,    18,
   48,     4,    84,    83,    52,    84,    83,    52,    84,    82,
   37,    96,     3,    67,    66,    35,    67,    66,    35,    67,
   65,    20,    80,     3,    66,    50,    22,   114,    53,    19,
   66,    49,     4,    80,     2,    52,    81,    50,    52,    81,
   50,    52,    80,    35,    64,     3,    67,    66,    35,    67,
   66,    35,    67,    65,    20,     0,     4,    84,    83,    52,
   84,    83,    52,    84,    82,    37,    96,     6,   117,   101,
   70,   117,   101,    70,   117,   100,    55,   128,     0,     0,
    3,    36,    80,    19,    36,    80,     2,    17,    16,     3,
    2,     2,    19,    66,     2,    19,    66,     1,     0,     0,
    4,    84,    83,    52,    84,    83,    52,    84,    82,    37,
    0,     4,     3,     3,    36,    83,    67,    36,    83,     2,
   21,     0,     5,    98,    52,    21,    98,    52,    21,    98,
   51,     6,     0,     6,     3,     5,    38,   115,    69,    38,
  115,     4,    23,    16,     3,     2,     2,    22,   114,     5,
   19,    66,     1,     0,    16,     2,    49,    33,     5,    97,
   36,     2,    49,    32,     3,     0,     5,   100,    84,    53,
  100,    84,    53,   100,    83,    38,     0,     6,   114,    53,
   22,   114,    53,    22,   114,    52,     7,     0,     3,    66,
   50,    22,   114,    53,    19,    66,    49,     4,    80,     4,
    4,    83,    52,    84,    83,    52,    84,    82,    37,    16,
    3,    67,    66,    35,    67,    66,    35,    67,    65,    20,
    0,     6,   113,     5,     6,   115,    69,    38,   113,     4,
   23,   128,     0,    16,     5,    38,   112,    21,    38,   115,
    4,    23,    32,     0,    16,     0,    33,    32,    16,    32,
   16,     1,    17,    32,     0,     2,     1,    16,    18,     1,
   16,     2,     0,     0,    16,     0,     3,     3,    36,    83,
   67,    36,    83,     2,    17,    16,     3,     2,    50,    19,
   66,    50,    19,    66,    49,     0,     0,     4,    84,    83,
   52,    84,    83,    52,    84,    82,    37,     0,     4,    84,
   83,    52,    84,    83,    52,    84,    82,    37,    96,     4,
    3,    67,    36,    83,    67,    36,    83,    66,    21,     0,
    4,     3,    67,    36,    83,    67,    36,    83,    66,    21,
   16,     5,   100,    84,    53,   100,    84,    53,   100,    83,
   38,   112,     0,     3,     2,    35,    67,    66,    32,    19,
    1,    16,    16,     5,   100,    84,    53,   100,    84,    53,
  100,    83,    38,   112,     4,     4,    83,    52,    84,    83,
   52,    84,    82,    37,    16,     3,    67,    66,    35,    67,
   66,    35,    67,    65,    20,    80,     2,    50,    49,    21,
   98,    52,    18,    50,    48,     3,    64,     2,     4,    81,
   50,    52,    81,    50,     4,    80,    35,    16,     1,    35,
   64,    33,    35,    64,    33,    35,    65,    18,     0,     4,
   84,    83,    52,    84,    83,    52,    84,    82,    37,     0,
    2,    50,    49,    18,    50,    49,    18,    50,    48,     3,
   64,     3,    67,     2,    38,   115,    69,    35,    67,     1,
   20,    80,     1,    36,    80,    52,    84,    83,    49,    36,
   82,    34,    48,     0,    20,     3,    52,    84,    83,    52,
   84,    82,    33,    32,     3,    67,     2,    35,    67,    66,
   35,    67,     1,    20,    80,     2,    49,     1,     6,   114,
    5,    19,    65,     0,     3,    64,     1,    32,    16,     5,
   97,    36,     2,    48,    16,     2,    48,     1,    32,    16,
    5,    97,    36,     5,    96,    19,    34,    48,     6,   113,
   37,     6,   117,   101,    70,   113,    36,    55,   128,     6,
  112,    21,    70,   117,   101,    70,   117,   100,    55,   128,
    1,    32,    16,    53,   100,    84,    53,    96,    19,    34,
   48,     6,   117,   101,    70,   117,   101,    70,   117,   100,
   55,   128,     2,    49,    33,     6,   114,    53,    22,   113,
   32,     3,    64,     6,   112,    21,    22,   114,    53,    22,
  114,    52,     7,   128,     1,    33,    32,     2,    49,    33,
    1,    33,    32,    34,    48,     6,   117,   101,    70,   117,
  101,    70,   117,   100,    55,   128,     0,    16,     2,    22,
  112,     5,    16,    18,     1,     4,    32,     2,     1,     1,
    5,    97,     4,     2,     1,    32,     3,    16,     5,     1,
    4,     5,    97,    36,     5,    97,    35,    38,    16,     6,
    5,     5,    70,   117,   101,    70,   117,   100,    55,    16,
    5,     4,     4,    53,   100,    84,    53,   100,    83,    38,
   16,     6,     2,     5,    22,   114,     5,    22,   114,    52,
    7,    16,     0,    20,     1,    48,    20,    81,    50,    52,
   80,    33,    32,     1,     3,    64,    33,     3,    64,    33,
   35,    65,    16,    16,     1,    32,    16,    33,    32,    16,
   33,    32,    17,    18,    48,     3,    67,    66,    38,   115,
   69,    35,    67,    65,    20,    80,     4,    84,    83,    52,
   84,    83,    52,    84,    82,    37,    96,     2,    49,    33,
    6,   114,    53,    19,    65,    32,     3,    64,     3,    64,
   18,    22,   112,    21,    19,    66,    49,     4,    80,     2,
   52,    81,    50,    52,    81,    50,    52,    80,    35,    64,
    3,    67,    66,    35,    67,    66,    35,    67,    65,    20,
   80,     3,    67,     2,    35,    67,    66,    35,    67,     1,
   20,    80,     3,    66,     2,    22,   114,     5,    19,    66,
    1,     4,    80,     6,   112,    21,    38,   112,    21,    38,
  115,    68,    23,   128,     1,    32,    16,    33,    32,    16,
   33,    32,    17,    18,    48,     3,    67,    66,    38,   115,
   69,    35,    67,    65,    20,    80,     2,    50,    49,    21,
   98,    52,    18,    50,    48,     3,    64,     5,   100,    84,
   53,   100,    84,    53,   100,    83,    38,   112,     4,    84,
   83,    52,    84,    83,    52,    84,    82,    37,    96,     2,
   49,    33,     6,   114,    53,    19,    65,    32,     3,    64,
    1,    32,    16,     5,    97,    36,     2,    48,    16,     2,
   48,     1,    32,    16,    53,   100,    84,    53,    96,    19,
   34,    48,     6,   117,   101,    70,   117,   101,    70,   117,
  100,    55,   128,     2,    49,    33,     6,   114,    53,    22,
  113,    32,     3,    64,     6,   112,    21,    22,   114,    53,
   22,   114,    52,     7,   128,     3,    64,    18,    22,   112,
   21,    19,    66,    49,     4,    80,     2,    49,     1,     5,
   97,     4,     2,    49,    32,     3,    64,     5,   100,     4,
   53,   100,    84,    53,   100,    83,    38,   112,     6,   114,
    5,    22,   114,     5,    22,   114,    52,     7,   128,     2,
   52,    81,    50,    52,    81,    50,    52,    80,    35,    64,
    4,     1,     3,     4,    81,    35,     4,    81,     2,    21,
   16,     3,    64,    18,    19,    64,    18,    19,    64,    17,
    4,     0,     3,     3,     2,    35,    67,    66,    35,    67,
    1,    16,    16,     4,    84,    83,    52,    84,    83,    52,
   84,    82,    37,    96,     2,    49,    33,     6,   114,    53,
   19,    65,    32,     3,    64,     3,    67,    66,    38,   115,
   69,    35,    67,    65,    20,    80,     3,    64,    18,    22,
  112,    21,    19,    66,    49,     4,    80,     2,    52,    81,
   50,    52,    81,    50,    52,    80,    35,    64,     4,    84,
   83,    52,    84,    83,    52,    84,    82,    37,    96,     4,
   81,    35,     4,    81,    35,     4,    81,    34,    21,     0,
    6,   115,    69,    38,   115,    69,    38,   115,    68,    23,
    0,     3,    66,    50,    22,   114,    53,    19,    66,    49,
    4,     0,     4,     3,    67,    36,    83,    67,    36,    83,
   66,    21,    16,     6,   117,   101,    70,   117,   101,    70,
  117,   100,    55,   128,     1,     1,    32,     4,     1,    35,
    1,    33,    34,    18,    16,     0,    16,    18,    19,    64,
   18,    16,    16,    17,     1,     0,     0,    16,    19,    36,
   80,    19,    36,    80,    18,    17,     0,     0,    16,    19,
   36,    80,    19,    36,    80,    18,    17,    32,     5,   100,
   84,    53,   100,    84,    53,   100,    83,    38,     0,     5,
   98,    52,    21,    98,    52,    21,    98,    51,     6,     0,
    6,     3,    69,    38,   115,    69,    38,   115,    68,    23,
   16,     6,   115,    69,    38,   115,    69,    38,   115,    68,
   23,   128,     3,     2,    50,    22,   114,    53,    19,    66,
   49,     0,    16,     2,    49,    33,     5,    97,    36,     2,
   49,    32,     3,     0,     5,    97,    36,     5,    97,    36,
    5,    97,    35,    38,     0,     6,   117,   101,    70,   117,
  101,    70,   117,   100,    55,     0,     5,   100,    84,    53,
  100,    84,    53,   100,    83,    38,     0,     6,   114,    53,
   22,   114,    53,    22,   114,    52,     7,     0,     3,    66,
   50,    22,   114,    53,    19,    66,    49,     4,    80,     2,
    4,    81,    50,    52,    81,    50,     4,    80,    35,    16,
    4,     4,    83,    52,    84,    83,    52,    84,    82,    37,
   16,     0,    19,    67,    36,    83,    67,    36,    83,    66,
   17,     0,     0,    19,    66,    35,    67,    66,    32,    19,
   65,    17,     0,     2,    52,    81,    50,    52,    81,    50,
   52,    80,    35,     0,     0,    20,    83,    52,    84,    83,
   52,    84,    82,    33,    32,     0,     3,     3,    36,    83,
   67,    36,    83,     2,    17,    16,     3,    67,    66,    38,
  115,    69,    35,    67,    65,    20,    80,     1,     1,    32,
    4,     1,    35,     1,    33,    34,    18,    16,     6,     3,
   69,    38,   115,    69,    38,   115,    68,    23,    16,     3,
    2,    50,    22,   114,    53,    19,    66,    49,     0,    16,
    0,    19,     2,    35,    67,    66,    32,    19,     1,    17,
   32,     6,   117,   101,    70,   117,   101,    70,   117,   100,
   55,   128,     4,     1,     3,     4,    81,    35,     4,    81,
    2,    21,    16,     6,     3,     5,    38,   115,    69,    38,
  115,     4,    23,    16,     3,     2,     2,    22,   114,     5,
   19,    66,     1,     0,    16,     1,    33,    32,     4,    81,
   35,     1,    33,    34,    18,     0,     6,   115,    69,    38,
  115,    69,    38,   115,    68,    23,     0,     3,    66,    50,
   22,   114,    53,    19,    66,    49,     4,     0,     4,     3,
   67,    36,    83,    67,    36,    83,    66,    21,     0,     3,
    3,    66,    35,    67,    66,    35,    67,    65,    16,     0,
    6,   117,   101,    70,   117,   101,    70,   117,   100,    55,
  128,     2,    49,    33,     6,   117,   101,    70,   113,    32,
   51,    64,     0,    16,    21,    70,   117,   101,    70,   117,
  100,    55,    32,     0,     0,     0,     4,     0,    19,     1,
   32,     2,    17,    16,     0,     0,     2,    19,    64,     2,
   16,    16,     1,     0,     0,     0,    16,    19,    52,    84,
   83,    52,    80,    18,    33,     0,     0,    16,    19,    52,
   84,    83,    52,    80,    18,    33,    32,     6,   117,   101,
   70,   117,   101,    70,   117,   100,    55,     0,     0,     0,
    3,    36,    80,    19,    36,    80,     2,    17,     0,     0,
    0,     3,    36,    80,    19,    36,    80,     2,    17,    16,
    5,    96,    20,    53,   100,    84,    53,    96,    19,    38,
    0,     6,     3,     5,    38,   115,    69,    38,   115,     4,
   23,     0,     5,     4,     4,    53,   100,    84,    53,   100,
   83,    38,     0,     5,    96,    20,    21,    98,    52,    21,
   96,    19,     6,     0,     3,     2,     2,    22,   114,     5,
   19,    66,     1,     0,     0,     4,     4,    83,    52,    84,
   83,    52,    84,    82,    37,     0,     4,     4,    83,    52,
   84,    83,    52,    84,    82,    37,    16,     5,     2,     4,
   21,    98,     4,    21,    98,    51,     6,     0,     6,     1,
    5,     6,   115,    69,    38,   113,     4,    23,    16,     0,
    0,     5,    38,   112,    21,    38,   115,     4,    23,    16,
    0,     0,     0,    33,     0,    16,    32,    16,     1,    16,
   16,     3,     3,     2,    38,   115,    69,    35,    67,     1,
   16,    16,     2,    50,    49,    21,    98,    52,    18,    50,
   48,     3,     0,     5,   100,    84,    53,   100,    84,    53,
  100,    83,    38,     0,     5,   100,    84,    53,   100,    84,
   53,   100,    83,    38,     0,     1,     4,    80,    52,     4,
   83,    49,    36,    82,    34,    16,     0,     4,     3,    52,
   84,    83,    52,    84,    82,    33,    16,     2,     1,     1,
    6,   114,     5,    19,     1,     0,     0,    16,     1,    32,
   16,     5,    97,    36,     2,    48,    16,     2,     0,     1,
   32,    16,     5,    97,    36,     5,    96,    19,    34,     0,
    6,   113,    37,     6,   117,   101,    70,   113,    36,    55,
    0,     6,   112,    21,    70,   117,   101,    70,   117,   100,
   55,     0,     1,    32,    16,    53,   100,    84,    53,    96,
   19,    34,     0,     6,   117,   101,    70,   117,   101,    70,
  117,   100,    55,     0,     2,    49,    33,     6,   114,    53,
   22,   113,    32,     3,     0,     6,   112,    21,    22,   114,
   53,    22,   114,    52,     7,     0,     1,     1,    32,     2,
    1,    33,     1,     1,    32,    34,    16,     0,    16,    16,
   33,    32,    16,    32,    16,    17,    17,     0,     3,    67,
   66,    38,   115,    69,    35,    67,    65,    20,     0,     1,
   36,    80,    52,    84,    83,    49,    36,    82,    34,     0,
    0,    20,    83,    52,    84,    83,    52,    84,    82,    33,
    0,     6,     5,   101,    70,   117,   101,    70,   117,   100,
   55,    16,     0,     0,     2,    22,   112,     5,    16,    18,
    1,     0,    16,     2,     1,     1,     5,    97,     4,     2,
    1,    32,     3,     0,     5,     1,     4,     5,    97,    36,
    5,    97,    35,    38,     0,     6,     5,     5,    70,   117,
  101,    70,   117,   100,    55,     0,     5,     4,     4,    53,
  100,    84,    53,   100,    83,    38,     0,     6,     2,     5,
   22,   114,     5,    22,   114,    52,     7,     0,     0,     4,
    1,    48,    20,    81,    50,     4,    80,    33,    16,     1,
    3,    64,    33,     3,    64,    33,    35,    65,    16,     0,
    4,     4,    83,    52,    84,    83,    52,    84,    82,    37,
    0,     0,    16,     0,    33,    32,    16,    32,    16,     1,
   17,    32,     3,    67,     2,    38,   115,    69,    35,    67,
    1,    20,    80,     1,    36,    80,    52,    84,    83,    49,
   36,    82,    34,    48,     0,    20,     3,    52,    84,    83,
   52,    84,    82,    33,    32,     2,    49,     1,     6,   114,
    5,    19,    65,     0,     3,    64,     1,    33,    32,     2,
   49,    33,     1,    33,    32,    34,    48,     6,   117,   101,
   70,   117,   101,    70,   117,   100,    55,   128,     0,    16,
    2,    22,   112,     5,    16,    18,     1,     4,    32,     0,
   20,     1,    48,    20,    81,    50,    52,    80,    33,    32,
    1,    32,    16,    33,    32,    16,    33,    32,    17,    18,
    0,     3,    67,    66,    38,   115,    69,    35,    67,    65,
   20,     0,     4,    84,    83,    52,    84,    83,    52,    84,
   82,    37,     0,     2,    49,    33,     6,   114,    53,    19,
   65,    32,     3,     0,     3,    64,    18,    22,   112,    21,
   19,    66,    49,     4,     0,     2,    52,    81,    50,    52,
   81,    50,    52,    80,    35,     0,     2,    49,    33,     2,
   49,    33,     2,    49,    32,    35,     0,     4,    84,    83,
   52,    84,    83,    52,    84,    82,    37,     0,     4,     1,
    3,     4,    81,    35,     4,    81,     2,    21,     0,     3,
    3,     2,    35,    67,    66,    35,    67,     1,    16,     0,
    6,   113,    37,     6,   115,    69,    38,   113,    36,    23,
  128,     0,    16,    21,    38,   112,    21,    38,   115,    68,
   23,    32,     2,    49,    33,     6,   114,    53,    19,    65,
   32,     3,    64,     0,    16,    18,    22,   112,    21,    16,
   18,    49,     4,    32,     0,    16,    16,     4,    80,    19,
    1,    32,    18,    17,     0,     6,   113,    37,     6,   115,
   69,    38,   113,    36,    23,     0,     0,    16,    21,    38,
  112,    21,    38,   115,    68,    23,     0,     2,    49,    33,
    6,   114,    53,    19,    65,    32,     3,     0,     1,    33,
   32,     2,    49,    33,     1,    33,    32,    34,     0,     6,
  117,   101,    70,   117,   101,    70,   117,   100,    55,     0,
    0,    16,    18,    22,   112,    21,    16,    18,    49,     4,
    0,     0,    20,    81,    48,    20,    81,    50,    52,    80,
   33,     0,     1,     1,    32,     4,     1,    35,     1,    33,
   34,    18,     0,     6,     3,    69,    38,   115,    69,    38,
  115,    68,    23,     0,     3,     2,    50,    22,   114,    53,
   19,    66,    49,     0,     0,     2,     4,    81,    50,    52,
   81,    50,     4,    80,    35,     0,     0,     3,     3,    36,
   83,    67,    36,    83,     2,    17,     0,     0,     3,     2,
   35,    67,    66,    32,    19,     1,    16,     0,     0,    16,
   16,    52,    84,    83,    49,    32,    18,    33,    32,     6,
  117,   101,    70,   117,   101,    70,   117,   100,    55,   128,
    3,     3,     2,    38,   115,    69,    35,    67,     1,    16,
   16,     1,     4,    80,    52,     4,    83,    49,    36,    82,
   34,    16,     0,     4,     3,    52,    84,    83,    52,    84,
   82,    33,    16,     2,    49,    33,     6,   117,   101,    70,
  113,    32,    51,    64,     0,    16,    21,    70,   117,   101,
   70,   117,   100,    55,    32,     0,     0,     0,     4,     0,
   19,     1,    32,     2,    17,    16,     6,     1,     5,     6,
  115,    69,    38,   113,     4,    23,    16,     0,     0,     5,
   38,   112,    21,    38,   115,     4,    23,    16,     2,     1,
    1,     6,   114,     5,    19,     1,     0,     0,    16,     1,
    1,    32,     2,     1,    33,     1,     1,    32,    34,    16,
    6,     5,   101,    70,   117,   101,    70,   117,   100,    55,
   16,     0,     0,     2,    22,   112,     5,    16,    18,     1,
    0,    16,     0,     4,     1,    48,    20,    81,    50,     4,
   80,    33,    16,     0,    16,    16,     0,    17,    33,     1,
   32,    16,    33,     0,     0,    16,    16,    52,    84,    83,
   49,    32,    18,    33,     0,     6,   117,   101,    70,   117,
  101,    70,   117,   100,    55,     0,     2,    49,    33,     6,
  117,   101,    70,   113,    32,    51,     0,     0,    16,    21,
   70,   117,   101,    70,   117,   100,    55,     0,     0,     0,
    0,     4,     0,    19,     1,    32,     2,    17,     0,     6,
    1,     5,     6,   115,    69,    38,   113,     4,    23,     0,
    0,     0,     5,    38,   112,    21,    38,   115,     4,    23,
    0,     0,     0,     0,    33,     0,    16,    32,    16,     1,
   16,     0,     3,     3,     2,    38,   115,    69,    35,    67,
    1,    16,     0,     1,     4,    80,    52,     4,    83,    49,
   36,    82,    34,     0,     0,     4,     3,    52,    84,    83,
   52,    84,    82,    33,     0,     2,     1,     1,     6,   114,
    5,    19,     1,     0,     0,     0,     1,     1,    32,     2,
    1,    33,     1,     1,    32,    34,     0,     6,     5,   101,
   70,   117,   101,    70,   117,   100,    55,     0,     0,     0,
    2,    22,   112,     5,    16,    18,     1,     0,     0,     0,
    4,     1,    48,    20,    81,    50,     4,    80,    33,     0,
};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv123_mem_reserved_units[] = {
    0,     3,     3,     3,     0,     0,     0,     3,     3,     3,
    0,     0,     1,     2,     2,     2,     3,     0,     0,     3,
    3,     3,     3,     3,     3,     1,     2,     2,     3,     3,
    3,     3,     0,     3,     3,     3,     3,     3,     3,     3,
    3,     3,     3,     0,     3,     3,     1,     2,     2,     2,
    3,     1,     2,     2,     2,     3,     3,     1,     3,     2,
    2,     2,     1,     3,     2,     1,     1,     1,     3,     3,
    2,     1,     3,     3,     2,     2,     3,     0,     1,     2,
    2,     2,     3,     3,     1,     2,     1,     3,     3,     3,
    3,     2,     0,     3,     3,     1,     3,     3,     2,     2,
    3,     3,     3,     0,     3,     3,     1,     3,     3,     3,
    3,     3,     3,     3,     3,     3,     3,     3,     3,     3,
    2,     2,     3,     3,     1,     1,     1,     1,     3,     3,
    3,     1,     1,     1,     1,     3,     1,     1,     3,     2,
    2,     2,     3,     3,     1,     1,     2,     2,     3,     1,
    1,     3,     3,     3,     3,     1,     3,     2,     2,     2,
    3,     1,     1,     3,     3,     3,     3,     3,     3,     3,
    3,     3,     3,     3,     2,     3,     3,     3,     3,     3,
    3,     3,     2,     3,     2,     2,     3,     3,     2,     3,
    3,     3,     0,     2,     2,     2,     3,     3,     2,     2,
    2,     2,     2,     3,     3,     2,     2,     2,     2,     2,
    3,     2,     1,     0,     0,     0,     0,     2,     2,     2,
    2,     3,     3,     2,     2,     2,     2,     2,     3,     3,
    3,     3,     3,     3,     2,     2,     0,     0,     3,     3,
    2,     2,     0,     0,     2,     0,     0,     0,     3,     3,
    3,     3,     3,     3,     3,     3,     3,     3,     3,     3,
    3,     3,     2,     3,     3,     3,     3,     2,     3,     3,
    1,     1,     2,     3,     3,     3,     2,     2,     3,     1,
    1,     1,     3,     3,     2,     2,     3,     3,     2,     3,
    1,     1,     1,     1,     1,     1,     1,     2,     2,     1,
    1,     2,     2,     1,     1,     1,     1,     1,     3,     3,
    3,     3,     3,     3,     3,     2,     3,     0,     0,     3,
    0,     1,     3,     0,     0,     0,     0,     0,     3,     3,
    3,     3,     3,     3,     3,     3,     3,     2,     2,     2,
    1,     1,     1,     1,     1,     0,     3,     2,     2,     0,
    0,     0,     0,     2,     2,     0,     0,     0,     2,     2,
    0,     3,     3,     3,     2,     2,     0,     0,     3,     0,
    3,     2,     2,     2,     2,     2,     2,     2,     0,     0,
    2,     3,     3,     3,     3,     3,     2,     2,     2,     2,
    2,     2,     2,     2,     3,     3,     3,     2,     2,     2,
    2,     2,     3,     2,     1,     1,     1,     1,     1,     1,
    2,     1,     1,     2,     2,     2,     1,     1,     2,     2,
    1,     1,     1,     1,     1,     2,     1,     1,     1,     2,
    2,     0,     2,     1,     3,     3,     3,     3,     3,     0,
    0,     0,     3,     3,     3,     0,     0,     3,     0,     0,
    3,     3,     3,     0,     0,     0,     0,     0,     3,     3,
    3,     0,     0,     0,     3,     3,     3,     2,     2,     2,
    1,     3,     3,     3,     3,     0,     0,     0,     0,     0,
    2,     2,     2,     2,     0,     0,     3,     0,     0,     3,
    0,     0,     0,     0,     0,     0,     3,     0,     2,     2,
    2,     2,     0,     0,     0,     2,     2,     2,     0,     0,
    0,     0,     0,     0,     0,     0,     2,     0,     0,     0,
    0,     2,     2,     0,     0,     0,     0,     0,     2,     0,
    0,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    3,     3,     3,     3,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     3,     3,
    3,     3,     3,     3,     3,     3,     3,     3,     3,     3,
    3,     3,     3,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cf_mac_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     1,     1,     1,     1,     1,     1,     2,
    2,     2,     3,     3,     3,     2,     2,     2,     3,     3,
    3,     3,     3,     4,     4,     5,     5,     5,     6,     6,
    6,     2,     2,     2,     6,     6,     6,     2,     2,     2,
    2,     2,     3,     3,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     7};

/* Vector for state transitions.  */
static const unsigned char cf_mac_transitions[] ATTRIBUTE_UNUSED = {
    0,    59,    50,    57,    63,    52,     1,     0,     1,     2,
   38,    42,    62,    29,    64,    59,     2,    64,     3,    18,
   61,    30,    64,    44,     3,    64,    64,     4,    28,     8,
   64,    30,     4,    64,    64,    64,     5,     7,    64,     8,
    5,    64,    64,    64,    64,     6,    64,     7,     6,    64,
   64,    64,    64,    64,    64,     7,     7,    64,    64,    64,
    6,    64,    64,     8,     8,    64,    64,     7,     9,    64,
   64,    30,     9,    64,    64,     6,    64,    64,    64,    10,
   10,    64,     7,    64,    11,    64,    64,    20,    11,    64,
    6,    64,    64,    64,    64,    12,    12,    64,    64,    64,
   13,    64,     7,    16,    13,    64,    64,    64,    64,    64,
    6,    14,    14,     7,    64,    64,    15,    64,    64,     3,
   15,     6,    64,    64,    64,    64,    64,     4,    16,     8,
   64,    14,    17,    64,    64,     2,    17,     9,    64,    15,
   64,    64,    64,    18,    18,    64,     4,    64,    19,    10,
   64,    20,    19,    64,     5,    64,    64,    11,    64,    12,
   20,    64,    64,    12,    21,    64,     8,    29,    21,    64,
   64,    13,    64,    64,     9,    22,    22,    10,    14,    64,
   23,    64,    64,    26,    23,    11,    15,    64,    64,    64,
   64,    24,    24,    64,    64,    64,    25,    12,     4,    16,
   25,    64,    64,    64,    64,    13,     5,    14,    26,    64,
   64,    24,    27,    20,     3,    29,    27,    64,    64,    25,
   64,    21,    28,    22,    28,    64,    64,     5,    64,     9,
   64,    10,    29,    30,    16,    22,    54,    64,    64,    59,
   30,    64,     8,    10,    31,    64,    64,    44,    31,    64,
    9,    11,    64,    64,    64,    32,    32,    64,    12,    64,
   33,    64,    10,    40,    33,    64,    13,    64,    64,    64,
   11,    34,    34,    12,    64,    64,    35,    64,    14,    38,
   35,    13,    64,    64,    64,    64,    15,    36,    36,     4,
   64,    64,    37,    14,    64,     3,    37,     5,    64,    64,
   64,    15,    64,     4,    38,     3,    64,    36,    39,    16,
   64,     2,    39,    28,    64,    37,    64,    17,    64,    18,
   40,    20,    64,    34,    41,    64,    16,     1,    41,    21,
   64,    35,    64,    64,    17,    42,    42,    18,    36,    64,
   43,    22,    64,    26,    43,    19,    37,    64,    64,    23,
   64,    24,    44,    64,    20,    32,    45,    64,    30,    52,
   45,    64,    21,    33,    64,    64,    31,    46,    46,    32,
   34,    64,    47,    64,    22,    50,    47,    33,    35,    64,
   64,    64,    23,    48,    48,    24,    64,    64,    49,    34,
   36,    38,    49,    25,    64,    64,    64,    35,    37,    36,
   50,    26,    64,    48,    51,    40,    38,     1,    51,    27,
   64,    49,    64,    41,    39,    42,    52,    44,    40,    46,
   53,    64,    29,     0,    53,    45,    41,    47,    64,    64,
   54,    57,    54,    31,    17,    23,    64,    64,    64,    55,
   55,    64,    24,    64,    56,    32,    18,    40,    56,    64,
   25,    64,    64,    33,    19,    34,    57,    55,    48,    64,
   58,    46,    42,    50,    58,    56,    49,    64,    64,    47,
   43,    48,    59,    64,    26,    55,    60,    44,     2,    52,
   60,    64,    27,    56,    64,    45,    61,    46,    61,    64,
   28,    19,    64,    31,    64,    32,    62,    61,    39,    43,
   64,    54,    64,    55,    63,    60,    51,    58,    64,    53,
   62,    57};

/* Vector of min issue delay of insns.  */
static const unsigned char cf_mac_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,    16,     2,     0,
    0,    16,     3,    16,     0,    32,     4,    33,     0,    48,
    5,    50,    16,    64,     5,    50,    22,    64,     4,    33,
    5,    48,     3,    16,     4,    32,     3,    16,    20,    32,
    2,     1,     3,    16,     2,     2,    19,    16,     1,    33,
    2,     0,     1,    50,    18,     0,     0,    33,     1,    48,
    0,    50,    17,    64,     0,    16,     1,    32,     0,    16,
   17,    32,     2,     1,     0,    16,     2,     2,    16,    16,
    1,    16,     2,     0,     1,    16,    18,     0,     0,     1,
    1,    16,     0,     2,    17,    16,     1,    33,     0,     0,
    1,    50,    16,     0,     1,    16,     0,     0,     1,    16,
   16,     0,     3,    16,    16,    32,     0,     0,     1,    16,
    2,     0,     3,    16,     2,     0,    19,    16,     1,     1,
    2,     0,     1,     2,    18,     0,     0,    33,     1,     0,
    0,    50,    17,     0,     0,    33,     0,    48,     0,    50,
   16,    64,     0,    16,     0,    32,     0,    16,    16,    32,
    0,    16,     1,     0,     0,    16,    17,     0,     0,     1,
    0,    16,     0,     2,    16,    16,     1,     0,     2,     0,
    1,     0,    18,     0,     0,     1,     1,     0,     0,     2,
   17,     0,     0,    33,     0,     0,     0,    50,    16,     0,
    0,    16,     0,     0,     0,    16,    16,     0,     0,     0,
    1,     0,     0,     0,    17,     0,     0,     0,    17,    16,
    1,     1,     0,     0,     1,     2,    16,     0,     0,     1,
    0,     0,     0,     2,    16,     0,     1,     0,     0,     0,
    1,     0,    16,     0,     2,     0,    16,    16,     0,     0,
   16,    16,     0,     0,    16,     0};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cf_mac_reserved_units[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv123_guess_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     1,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     2};

/* Vector for state transitions.  */
static const unsigned char cfv123_guess_transitions[] ATTRIBUTE_UNUSED = {
    0,     1,     0,     1,     2,     0};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv123_guess_min_issue_delay[] ATTRIBUTE_UNUSED = {
    8};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv123_guess_reserved_units[] = {
    0,     4};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv4_oep_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     1,     2,     3,     4,     5,     6,     1,
    6,     7,     8,     8,     9,    10,    11,     8,     8,     9,
   10,    12,     6,    13,    13,    14,    15,    15,     6,     6,
    8,     6,     6,     6,     6,    16,     6,     6,     6,     6,
    6,     6,     6,     6,     6,    17,     6,     0,    18};

/* Comb vector for state transitions.  */
static const unsigned char cfv4_oep_transitions[] ATTRIBUTE_UNUSED = {
    0,     4,     6,     6,     7,     6,     4,     7,     8,     9,
   10,     4,    11,    14,    13,    27,     2,     1,     0,     5,
    4,     6,     6,     7,     6,     4,     7,     8,     9,    10,
    4,    11,    14,    13,    27,     2,    44,    41,    41,     4,
    6,     6,     7,     6,     4,     7,     8,     9,    10,     4,
   11,    14,    13,    27,     2,    44,    42,    42,     4,     6,
    6,     7,     6,     4,     7,     8,     9,    10,     4,    11,
   14,    13,    27,     2,    44,    43,    43,     4,     6,     6,
    7,     6,     4,     7,     8,     9,    10,     4,    11,    14,
   13,    27,     2,    44,     0,     3,     4,     6,     6,     7,
    6,     4,     7,     8,    44,    10,    44,    11,    14,    13,
   27,     2,    12,    41,     7,     4,     4,    44,     4,     4,
    8,     1,    10,     6,     4,     2,    13,     4,     4,     9,
    5,     4,     5,    10,     4,     8,     8,    11,     8,     0,
   13,     5,    14,     3,    15,     5,    16,     5,    17,    18,
   19,     4,    20,    21,     4,    12,    22,    23,    14,    24,
   15,    25,    16,    26,    17,    27,    18,    19,    20,    28,
   21,    22,    29,    30,    23,    24,    31,    25,    32,    26,
   33,    11,    34,    28,    35,    36,    37,    29,    38,    39,
   30,    31,    40,    44,    32,    44,    33,    44,    34,    44,
   35,    44,    36,    37,    38,    44,    39,    40,    44,    44,
   13};

/* Check vector for state transitions.  */
static const unsigned char cfv4_oep_check[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     5,
    5,     5,     5,     5,     5,     5,     5,     5,     5,     5,
    5,     5,     5,     5,     5,     5,    44,     5,    41,    41,
   41,    41,    41,    41,    41,    41,    41,    41,    41,    41,
   41,    41,    41,    41,    41,    44,    41,    42,    42,    42,
   42,    42,    42,    42,    42,    42,    42,    42,    42,    42,
   42,    42,    42,    42,    44,    42,    43,    43,    43,    43,
   43,    43,    43,    43,    43,    43,    43,    43,    43,    43,
   43,    43,    43,    44,    43,     3,     3,     3,     3,     3,
    3,     3,     3,     3,    44,     3,    44,     3,     3,     3,
    3,     3,    12,     3,     7,     7,     7,    44,     7,     7,
   12,     1,    12,     6,     6,     2,    12,     4,     6,     9,
   12,     9,     7,    10,     9,    10,     8,    11,    10,     1,
   13,     6,    14,     2,    15,     4,    16,     9,    17,    18,
   19,    10,    20,    21,     8,    11,    22,    23,    13,    24,
   14,    25,    15,    26,    16,    27,    17,    18,    19,    28,
   20,    21,    29,    30,    22,    23,    31,    24,    32,    25,
   33,    26,    34,    27,    35,    36,    37,    28,    38,    39,
   29,    30,    40,    44,    31,    44,    32,    44,    33,    44,
   34,    44,    35,    36,    37,    44,    38,    39,    44,    44,
   40};

/* Base vector for state transitions.  */
static const unsigned char cfv4_oep_base[] = {
    0,   121,   125,    95,   127,    19,   123,   114,   136,   129,
  133,   137,   112,   140,   142,   144,   146,   148,   149,   150,
  152,   153,   156,   157,   159,   161,   163,   165,   169,   172,
  173,   176,   178,   180,   182,   184,   185,   186,   188,   189,
  192,    38,    57,    76};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv4_oep_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     1,     1,     1,     1,     1,     1,     0,     0,     1,
    1,     1,     1,     1,     1,     1,     1,     2,     1,     2,
    1,     1,     1,     1,     1,     5,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     1,     0,     1,     0,
    0,     0,     0,     0,     4,     0,     0,     1,     1,     1,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     1,     1,     5,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     4,     0,     0,     0,     1,     1,     1,     0,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    1,     5,     0,     0,     0,     0,     1,     0,     0,     1,
    1,     1,     1,     1,     1,     1,     1,     1,     1,     1,
    5,     0,     0,     2,     2,     2,     2,     2,     2,     2,
    2,     2,     2,     2,     2,     2,     2,     2,     2,     6,
    0,     0,     1,     0,     1,     1,     0,     1,     1,     1,
    1,     1,     1,     1,     1,     1,     1,     1,     5,     0,
    0,     2,     0,     2,     2,     0,     2,     2,     2,     2,
    2,     2,     2,     2,     2,     2,     2,     6,     0,     0,
    2,     1,     2,     2,     1,     2,     2,     1,     2,     1,
    2,     2,     2,     1,     2,     2,     6,     0,     0,     1,
    0,     1,     1,     0,     1,     1,     0,     1,     0,     1,
    1,     1,     0,     1,     1,     5,     0,     0,    16,    15,
   16,    16,    15,    16,    16,    15,    16,    15,    16,    16,
   16,    15,    16,    16,    20,     0,     0,    15,    14,    15,
   15,    14,    15,    15,    14,    15,    14,    15,    15,    15,
   14,    15,    15,    19,     0,     0,    14,    13,    14,    14,
   13,    14,    14,    13,    14,    13,    14,    14,    14,    13,
   14,    14,    18,     0,     0,    13,    12,    13,    13,    12,
   13,    13,    12,    13,    12,    13,    13,    13,    12,    13,
   13,    17,     0,     0,    12,    11,    12,    12,    11,    12,
   12,    11,    12,    11,    12,    12,    12,    11,    12,    12,
   16,     0,     0,    11,    10,    11,    11,    10,    11,    11,
   10,    11,    10,    11,    11,    11,    10,    11,    11,    15,
    0,     0,    10,     9,    10,    10,     9,    10,    10,     9,
   10,     9,    10,    10,    10,     9,    10,    10,    14,     0,
    0,     9,     8,     9,     9,     8,     9,     9,     8,     9,
    8,     9,     9,     9,     8,     9,     9,    13,     0,     0,
    8,     7,     8,     8,     7,     8,     8,     7,     8,     7,
    8,     8,     8,     7,     8,     8,    12,     0,     0,     7,
    6,     7,     7,     6,     7,     7,     6,     7,     6,     7,
    7,     7,     6,     7,     7,    11,     0,     0,     6,     5,
    6,     6,     5,     6,     6,     5,     6,     5,     6,     6,
    6,     5,     6,     6,    10,     0,     0,     5,     4,     5,
    5,     4,     5,     5,     4,     5,     4,     5,     5,     5,
    4,     5,     5,     9,     0,     0,     4,     3,     4,     4,
    3,     4,     4,     3,     4,     3,     4,     4,     4,     3,
    4,     4,     8,     0,     0,     3,     2,     3,     3,     2,
    3,     3,     2,     3,     2,     3,     3,     3,     2,     3,
    3,     7,     0,     0,    30,    29,    30,    30,    29,    30,
   30,    29,    30,    29,    30,    30,    30,    29,    30,    30,
   34,     0,     0,    29,    28,    29,    29,    28,    29,    29,
   28,    29,    28,    29,    29,    29,    28,    29,    29,    33,
    0,     0,    28,    27,    28,    28,    27,    28,    28,    27,
   28,    27,    28,    28,    28,    27,    28,    28,    32,     0,
    0,    27,    26,    27,    27,    26,    27,    27,    26,    27,
   26,    27,    27,    27,    26,    27,    27,    31,     0,     0,
   26,    25,    26,    26,    25,    26,    26,    25,    26,    25,
   26,    26,    26,    25,    26,    26,    30,     0,     0,    25,
   24,    25,    25,    24,    25,    25,    24,    25,    24,    25,
   25,    25,    24,    25,    25,    29,     0,     0,    24,    23,
   24,    24,    23,    24,    24,    23,    24,    23,    24,    24,
   24,    23,    24,    24,    28,     0,     0,    23,    22,    23,
   23,    22,    23,    23,    22,    23,    22,    23,    23,    23,
   22,    23,    23,    27,     0,     0,    22,    21,    22,    22,
   21,    22,    22,    21,    22,    21,    22,    22,    22,    21,
   22,    22,    26,     0,     0,    21,    20,    21,    21,    20,
   21,    21,    20,    21,    20,    21,    21,    21,    20,    21,
   21,    25,     0,     0,    20,    19,    20,    20,    19,    20,
   20,    19,    20,    19,    20,    20,    20,    19,    20,    20,
   24,     0,     0,    19,    18,    19,    19,    18,    19,    19,
   18,    19,    18,    19,    19,    19,    18,    19,    19,    23,
    0,     0,    18,    17,    18,    18,    17,    18,    18,    17,
   18,    17,    18,    18,    18,    17,    18,    18,    22,     0,
    0,    17,    16,    17,    17,    16,    17,    17,    16,    17,
   16,    17,    17,    17,    16,    17,    17,    21,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     3,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     2,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     1,     0};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv4_oep_reserved_units[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv4_mem_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    1,     1,     2,     2,     3,     4,     5,     6,     6,     3,
    4,     4,     1,     0,     1,     2,     0,     1,     0,     1,
    2,     0,     1,     0,     1,     4,     0,     1,     0,     1,
    0,     0,     0,     0,     1,     7,     1,     0,     8};

/* Vector for state transitions.  */
static const unsigned short cfv4_mem_transitions[] ATTRIBUTE_UNUSED = {
    0,     7,     6,   253,   255,     3,   250,     1,     0,     1,
   27,    41,   241,   252,    11,     2,   256,     0,     2,    28,
  256,   178,   256,    12,   256,   256,     3,     3,   256,   191,
  256,   249,   256,   192,    11,     4,     4,    43,    24,   232,
  251,    13,   235,    21,     5,     5,    25,    15,   220,   212,
   23,   193,   256,     6,     6,    16,   256,   210,   250,   191,
  256,    41,     7,     7,   256,    16,     3,   248,   256,   239,
   27,     8,     8,    17,    26,   206,   247,    29,   234,     9,
    1,     9,    18,    54,   228,   240,    20,    10,   256,     1,
   10,    19,   256,   157,   256,   158,   256,   256,    11,    11,
  256,    42,   256,   231,   256,    12,   256,     4,    12,   256,
  256,   256,   256,   256,   256,   256,    13,    13,   256,   105,
  256,   184,   256,   106,    31,    14,    14,    48,    34,   155,
  141,    33,   108,   256,    15,    15,    35,   256,   137,   193,
  103,   256,   256,    16,    16,   256,   256,   191,   239,   256,
  256,    50,    17,    17,   256,    36,    29,   238,   256,   185,
   18,     9,    18,   256,    37,    20,   237,   256,    19,   256,
    9,    19,   256,   256,   158,   256,   256,   256,   256,    20,
   20,   256,    38,   256,   204,   256,   158,   256,    21,    21,
   39,    46,   187,   236,    31,    22,   256,     5,    22,   180,
  256,   109,   256,    32,   256,   256,    23,    23,   256,   103,
  256,   160,   256,   107,   256,    24,    24,   104,   256,   161,
  235,   105,   256,    46,    25,    25,   256,    35,    23,   159,
  256,   129,   256,    26,    26,    36,   256,   132,   234,   128,
  256,    54,    27,    27,   256,    50,    11,   205,   256,    28,
  256,     8,    28,   256,   256,    12,   256,   256,   256,   256,
   29,    29,   256,   128,   256,   186,   256,    30,    20,    21,
   30,   256,   256,   256,   256,   256,   256,   158,    31,    31,
  256,    47,   256,   183,   256,    32,   256,    14,    32,   256,
  256,   256,   256,   256,   256,   256,    33,    33,   256,    67,
  256,   116,   256,    66,   256,    34,    34,    68,   256,    97,
  108,    67,   256,   256,    35,    35,   256,   256,   103,   129,
  256,   256,   256,    36,    36,   256,   256,   128,   185,   256,
  256,    37,    18,    37,   256,   256,    38,    19,   256,   256,
  256,    18,    38,   256,   256,   256,   158,   256,   256,   256,
   39,    39,   256,    52,    31,   182,   256,   180,   256,    40,
   40,    53,    49,   172,   179,    45,    59,   256,    41,    41,
   50,   256,   119,     2,    42,   256,   256,     7,    42,   256,
  256,   256,    12,   256,   256,   256,    43,    43,   256,   104,
   13,   181,   256,    44,    39,    40,    44,   256,   256,   106,
  256,   256,   256,   180,    45,    45,   256,    51,   256,    80,
  256,    60,   256,    46,    46,    52,   256,    81,    22,    47,
  256,   256,    25,    47,   256,   256,   256,    32,   256,   256,
  256,    48,    48,   256,    68,    33,   117,   256,    65,   256,
   49,    49,    69,   256,    73,    59,    51,   256,   256,    50,
   50,   256,   256,    42,    28,   256,   256,   256,    17,    51,
  256,   256,   256,    60,   256,   256,   256,    52,    52,   256,
  256,    47,   180,   256,   256,   256,    53,    53,   256,    69,
   45,    79,   256,    70,   256,    54,    54,    37,   256,    55,
   10,    38,   256,   256,    27,    55,    38,   256,   256,   157,
  256,   256,   256,    56,    56,   256,    74,   134,   175,   256,
  112,   256,    57,    57,    75,    83,   124,   118,   111,    58,
   40,    41,    58,    76,   256,    86,   256,    77,   256,    59,
   42,    59,    70,   256,    61,   256,    60,   256,   256,    42,
   60,   256,   256,   256,   256,   256,   256,   256,    47,    61,
   60,   256,   256,   256,   256,   256,   256,    62,    62,   256,
  256,   256,   113,   256,   256,   256,    63,    63,   256,    96,
  114,    72,   256,    64,    48,    49,    64,   256,   256,    71,
  256,   256,   256,    65,    51,    65,   256,   256,    66,   256,
  256,   256,   256,    51,    66,   256,   256,   256,   256,   256,
  256,   256,    67,    67,   256,   256,   256,    66,   256,   256,
  256,    68,    68,   256,   256,    67,    65,   256,   256,   256,
   69,    69,   256,   256,    51,    70,   256,   256,   256,    37,
   70,   256,   256,    60,   256,   256,   256,   256,    38,    71,
  256,   256,   256,   256,   256,   256,    66,    67,    72,   256,
   64,   115,   256,   256,   256,   117,    73,    73,    51,   256,
  256,    61,   256,   256,   256,    74,    74,   256,   256,    62,
  112,   256,   256,   256,    75,    75,   256,    87,   111,    78,
  256,    76,    53,    54,    76,   256,   256,    77,   256,   256,
  256,    70,    38,    77,   256,   256,   256,   256,   256,   256,
   60,    47,    78,   256,    76,   110,   256,   256,   256,    79,
   55,    79,   256,    70,    80,   256,   256,   256,   256,    55,
   80,   256,    60,   256,   256,   256,   256,   256,    81,    81,
   47,   256,   256,   109,   256,   256,   256,    82,    82,   256,
   94,   100,    91,   256,    88,   256,    83,    83,    87,   256,
   85,    58,    84,   256,    49,    50,    84,   256,   256,   256,
   77,   256,   256,    51,    52,    85,    84,   256,   256,    86,
  256,   256,    73,    74,    86,    77,   256,   256,   256,   256,
  256,    61,    62,    87,   256,   256,    84,    76,   256,   256,
   69,    37,    88,   256,   256,    89,   256,   256,   256,   256,
   84,    89,   256,   256,   256,   256,   256,   256,   256,    90,
   90,   256,   256,   256,    71,   256,   256,    67,    68,    91,
  256,    88,    92,   256,   256,   256,   256,    85,    92,   256,
   89,   256,   256,   256,   256,   256,    93,    93,    90,   256,
  256,    99,   256,   256,    97,    94,    94,   256,   256,    95,
   88,   256,   256,   256,    87,    95,   256,   256,   256,    89,
  256,   256,   256,    96,    96,   256,   256,    90,    64,   256,
  256,    68,    69,    97,    67,   256,   256,    98,   256,   256,
  256,    94,    98,    66,   256,   256,   256,   256,   256,   256,
   95,    99,    71,   256,   256,   256,   256,   256,    98,    95,
  100,   256,    95,   256,    92,   256,    89,   256,   101,   101,
   96,   256,    93,   102,    90,   256,    34,    35,   102,    64,
  256,    99,   256,    71,   256,   108,   103,   103,   256,   256,
  256,   107,   256,   256,   256,   104,   104,   256,   256,   105,
   44,   256,   256,    52,    53,   105,   256,   256,   256,   106,
  256,   256,    47,    48,   106,   256,   256,   256,   256,   256,
  256,    32,    33,   107,   256,   256,   256,   256,   256,   256,
  256,   105,   108,    65,   256,    98,   256,    66,   256,   256,
  103,   109,    32,   256,   256,   256,   256,   256,   256,   100,
  110,   256,    77,   256,   256,   256,   256,    80,    81,   111,
  256,    84,   256,   110,   256,    77,    45,    46,   112,   256,
  256,   113,   256,   256,   256,   256,   111,   113,   256,   256,
  256,   256,   256,   256,   256,   114,   114,   256,    90,   256,
  115,   256,    71,    33,    34,   115,   256,    71,   256,   256,
  256,   256,   116,    97,   116,   256,    66,   256,   256,   256,
  256,   256,    97,   117,   256,    65,   116,   256,   256,   256,
  256,    73,   118,    78,    58,   174,   256,   110,   256,   179,
  119,   119,    42,   256,   256,   178,   256,   256,   256,   120,
  120,   256,   138,   177,   123,   256,   121,    56,    57,   121,
  256,   256,   122,   256,   256,   256,   112,   111,   122,   256,
  256,   256,   256,   256,   256,   113,   114,   123,   256,   121,
  176,   256,   256,   256,   175,   124,   124,   111,    85,   256,
  174,   256,    86,   172,   125,   125,    74,   256,   169,   165,
   62,   256,   256,   126,   126,   256,   152,   164,   131,   256,
  127,    25,    26,   127,   256,   256,   130,   256,   256,   256,
  129,   128,   128,   256,   256,   256,    30,   256,   256,    38,
   39,   129,   256,   256,   107,   256,   256,   256,   256,   128,
  130,   256,   256,   256,   256,   256,   256,   107,   105,   131,
  256,   127,   163,   256,   256,   256,   159,   132,   132,   128,
  256,   256,   133,   256,   256,    55,    56,   133,    30,   256,
  256,   256,   256,   256,   157,   134,   134,   256,    62,   256,
  156,   256,   113,   256,   135,   135,    63,   101,   150,   136,
  114,   102,    14,    15,   136,    72,   102,   149,   256,   115,
  256,   141,   137,   137,   103,   256,   256,   140,   256,   256,
  256,   138,   138,   256,   256,   139,   121,   256,   256,    74,
   75,   139,   256,   256,   256,   122,   256,   256,    62,    63,
  140,   107,   256,   256,   256,   256,   256,   256,   139,   141,
  117,   108,   142,   256,   116,   256,   256,   137,   142,   116,
   98,   256,   256,   256,   256,   256,   143,   143,    95,   256,
  256,   148,   256,   256,   256,   144,   144,   256,   256,   147,
  145,   256,   256,    94,    87,   145,   256,   256,   146,   256,
  256,   256,    88,    84,   146,   256,   256,   256,   256,   256,
  256,    89,    90,   147,   256,   256,   256,   146,   256,   256,
   95,    96,   148,    89,   256,   256,   256,   256,   256,   256,
  147,   149,   115,    99,   256,   256,   256,   256,   142,   143,
  150,   114,    93,   256,   149,   256,    99,   155,   151,   151,
   94,   256,   143,   154,    95,   256,   256,   152,   152,   256,
  256,   153,   127,   256,   256,    35,    36,   153,   256,   256,
  256,   130,   256,   256,   103,   104,   154,    88,   256,   148,
  256,    89,   256,   256,   153,   155,    33,    97,   256,   142,
  256,    98,   256,   151,   156,   256,   113,   256,   256,   256,
  256,   256,   150,   157,   158,   256,   256,   256,   256,   256,
  256,   134,   158,   256,   256,   256,   256,   256,   256,   256,
   31,   159,   256,   129,   160,   256,   256,   256,   256,   132,
  160,   256,   107,   256,   256,   256,   256,   256,   161,   161,
  105,   256,   256,   162,   256,   256,    81,    82,   162,   106,
  256,   256,   256,   256,   256,   109,   100,   163,   256,   130,
  256,   256,   256,   256,   160,   161,   164,   256,   153,   256,
  163,   256,   130,    23,    24,   165,   112,   256,   166,   256,
  113,   256,   256,   164,   166,   113,   256,   256,   256,   256,
  256,   256,   167,   167,   256,   147,   256,   168,   256,   146,
  100,   101,   168,   256,   146,   256,   256,   256,   256,    92,
   93,   169,    62,   256,   256,   166,   256,   256,   256,   170,
  170,   256,   144,   167,   171,   256,   145,    82,    83,   171,
  256,   145,   168,   256,   256,   256,    91,    85,   172,    45,
   73,   256,   173,   256,    61,   256,   125,   173,    80,    61,
  256,   256,   256,   256,   256,   169,   174,   110,    86,   256,
  256,   256,   256,   173,   169,   175,   256,   112,   156,   256,
  256,   256,   256,   124,   176,   256,   122,   256,   256,   256,
  256,   156,   150,   177,   256,   139,   256,   176,   256,   122,
  134,   135,   178,    12,   256,   256,   256,   256,   256,   256,
  177,   179,    79,    59,   173,   256,    80,   256,   256,   119,
  180,   256,   256,    32,   256,   256,   256,   256,    45,   181,
  256,    44,   184,   256,   256,   256,   182,   172,   182,   256,
  180,   183,   256,   256,   256,   256,   172,   183,   256,    32,
  256,   256,   256,   256,   256,   155,   184,   256,   106,   256,
  256,   256,   256,   183,   155,   185,   256,   256,    30,   256,
  256,   256,    19,    20,   186,   256,    30,   256,   256,   256,
  256,   204,   187,   187,    31,    81,   256,   203,   256,   109,
  256,   188,   188,    82,   151,   200,   196,   100,   154,   256,
  189,   189,   152,   256,   195,   190,   153,   256,    15,    16,
  190,   127,   256,   194,   256,   130,   256,   193,   191,   191,
  256,   256,   256,   192,   256,   256,    42,    43,   192,   256,
  256,   256,   256,   256,   256,    12,    13,   193,   129,   256,
  140,   256,   107,   256,   256,   191,   194,   130,   256,   256,
  256,   256,   256,   140,   139,   195,   153,   256,   256,   194,
  256,   256,   137,   138,   196,    91,   154,   197,   256,    92,
  256,   256,   195,   197,    92,   148,   256,   256,   256,   256,
  256,   198,   198,   147,   256,   256,   199,   256,   256,   143,
  144,   199,   146,   256,   256,   256,   256,   256,   148,   147,
  200,   100,   143,   256,   197,   256,   148,   256,   201,   201,
  144,   256,   198,   202,   147,   256,   151,   152,   202,   145,
  256,   199,   256,   146,   256,   154,   153,   203,   183,   109,
  256,   256,   256,   256,   256,   200,   204,   256,   158,   256,
  256,   256,   256,   256,   187,   205,   256,    28,   231,   256,
  256,   256,   256,   206,   206,    29,   132,   256,   230,   256,
  133,   228,   207,   207,    56,   125,   225,   221,   134,   165,
  256,   208,   208,   126,   189,   217,   209,   164,   190,     5,
    6,   209,   131,   190,   216,   256,   163,   256,   212,   210,
  210,   191,   256,   256,   211,   256,   256,   119,   120,   211,
  192,   256,   256,   256,   256,   256,   178,   177,   212,   159,
  193,   213,   256,   160,   256,   256,   210,   213,   160,   140,
  256,   256,   256,   256,   256,   214,   214,   139,   256,   256,
  215,   256,   256,   169,   170,   215,   122,   256,   256,   256,
  256,   256,   166,   167,   216,   163,   194,   256,   256,   256,
  256,   213,   214,   217,   164,   195,   256,   216,   256,   194,
  220,   218,   218,   138,   256,   214,   219,   139,   256,   125,
  126,   219,   121,   256,   215,   256,   122,   256,   165,   164,
  220,    23,   137,   256,   213,   256,   140,   256,   218,   221,
  175,   165,   222,   256,   156,   256,   256,   217,   222,   156,
  166,   256,   256,   256,   256,   256,   223,   223,   167,   198,
  256,   224,   256,   199,   200,   201,   224,   168,   199,   256,
  256,   256,   256,   197,   198,   225,   134,   169,   256,   222,
  256,   166,   256,   226,   226,   170,   201,   223,   227,   167,
  202,   188,   189,   227,   171,   202,   224,   256,   168,   256,
  196,   195,   228,    20,    55,   256,   229,   256,   157,   256,
  207,   229,   204,   157,   256,   256,   256,   256,   256,   225,
  230,   186,   133,   256,   256,   256,   256,   229,   225,   231,
  256,    12,   256,   256,   256,   256,   256,   232,   232,    13,
  161,   256,   233,   256,   162,   187,   188,   233,   184,   162,
  256,   256,   256,   256,   203,   200,   234,   185,   256,   133,
  256,    30,   256,    10,    11,   235,    44,   256,   162,   256,
  106,   256,    22,    23,   236,   182,    22,   203,   256,   183,
  256,   256,   220,   237,   256,    19,   204,   256,   256,   256,
  256,   228,   238,   256,   185,   186,   256,   256,   256,   237,
  228,   239,   256,   256,   192,   256,   256,   256,    28,    29,
  240,   237,    10,   229,   256,   204,   256,   256,   241,   241,
   11,   119,   256,   246,   256,   178,   256,   242,   242,   120,
  218,   245,   243,   177,   219,   207,   208,   243,   123,   219,
  244,   256,   176,   256,   221,   217,   244,   176,   215,   256,
  256,   256,   256,   222,   223,   245,   177,   214,   256,   244,
  256,   215,   225,   226,   246,   231,   178,   256,   256,   256,
  256,   256,   245,   247,   238,   234,   230,   256,   186,   256,
  240,   241,   248,   256,   239,   249,   256,   256,   256,   205,
  206,   249,   256,   192,   256,   256,   256,   256,   231,   232,
  250,   239,   256,   211,   256,   192,   256,     2,     3,   251,
  181,   235,   233,   256,   184,   256,   236,   220,   252,   205,
    2,   246,   256,   231,   256,   256,   253,   253,     3,   210,
  256,   254,   256,   211,   241,   242,   254,   249,   211,   256,
  256,   256,   256,   246,   245,   255,   248,   250,   254,   256,
  249,   256,   252,   253};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv4_mem_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,    16,     0,
   16,    16,    17,     0,    16,    16,    16,     0,     0,     0,
    0,     0,     0,     0,     0,     0,    16,     0,    16,     0,
   16,     0,    16,     0,    16,     0,     0,     0,     0,     0,
    0,     0,     0,     0,    32,     0,    16,    16,    18,     0,
   16,    16,    16,    16,     2,    18,    18,    17,     0,    16,
   16,    16,     0,     0,     0,     0,     2,     0,     2,     0,
    2,    16,     2,    16,     2,    16,     0,    16,     0,    16,
    0,     1,     0,     1,     3,     0,    33,     1,    33,    64,
    1,     1,     1,     3,     0,     0,     0,     0,    32,     0,
   16,    16,    18,     0,    16,    16,    16,    16,     0,    16,
    0,    16,     0,    16,     0,    16,    16,     0,    16,     0,
   16,     0,    16,     0,    16,    16,     2,    16,    18,    17,
    0,    16,    16,    16,     0,     2,    18,    18,    16,     0,
   16,    16,    16,    48,     2,    18,    18,    20,     0,    16,
   16,    16,    48,     0,    48,     0,    50,     0,    50,     0,
   50,    16,     2,    16,     2,    16,     0,    33,     0,    33,
   64,     2,    17,     2,    20,     0,    16,     0,    16,    48,
    0,     0,     0,     2,     0,     1,     0,     1,    16,     2,
   17,     2,    17,     0,    16,     0,    16,     0,     2,    16,
   18,    16,     0,    16,    16,    16,    48,     0,    16,     0,
   18,     0,    33,    16,    33,    64,     1,     0,     1,     3,
    0,     2,     0,     2,    32,     2,    16,     2,    17,     0,
   50,    16,    50,    80,     2,    16,     2,    20,     0,    16,
    0,    16,    48,     0,    16,     0,    18,     0,     1,    16,
   33,    32,     1,     0,     1,     1,     0,     0,     0,     0,
    0,     0,    32,    16,    32,     0,     2,     1,     2,    32,
    3,    34,    19,    37,     0,     2,    33,    50,    32,     2,
   17,     2,    17,     0,    16,     0,    16,     0,     4,    48,
   20,    48,     0,    67,     1,    67,    96,     6,    82,    22,
   88,     0,    84,    16,    84,   112,     4,    48,     4,    54,
    0,    50,     0,    50,    80,     3,    32,    19,    37,     0,
  101,    33,   101,     0,     1,     0,    20,    48,     0,     2,
   16,    50,    32,     2,    16,     2,    17,     0,    16,     0,
   16,     0,     3,    32,    19,    32,     0,    50,    33,    50,
    0,     1,     0,    19,    32,     0,    16,     1,    50,    48,
    1,     2,    19,    35,     0,     1,    16,    33,    32,     1,
    0,     1,     1,     0,     2,     0,     2,     0,     3,    33,
    3,    32,     0,     2,    16,    50,     0,     0,    34,    19,
   32,     0,    50,     0,    50,     0,     4,    48,    20,    49,
    0,   101,    33,   101,    16,     5,    65,     5,    64,     0,
   16,     1,    67,    16,     1,     2,    22,    81,     0,     4,
   16,    84,     0,     4,    48,     4,    49,     0,    84,    16,
   84,    16,     4,    48,     4,    48,     0,     4,    16,    84,
   32,     0,    82,    22,    82,     0,     5,    33,   101,     0,
    1,     1,     1,     1,     0,     3,     0,     3,     0,     0,
   48,    16,    48,     0,    50,    16,    50,    16,     2,    16,
    2,    16,     0,    33,    16,    33,     0,     2,    18,    18,
   16,     0,    50,    33,    50,    16,     0,    48,    16,    50,
    0,     1,    33,    33,    32,     1,     2,    19,    32,     0,
   16,    16,    16,     0,     2,    16,    18,    17,     0,    33,
   33,    33,    16,     1,     1,     1,     0,     0,    16,    33,
  101,     0,     1,     2,    22,    83,     0,    16,     1,    67,
   48,     0,     0,    16,    32,     0,     1,    16,    33,    16,
    1,     0,     1,     0,     0,    33,     1,    33,     0,     2,
   18,    18,    16,     0,    16,     1,    33,     0,     0,     1,
    1,     0,     0,     1,     0,     1,    16,     1,     0,     1,
    0,     0,    50,     1,    50,     0,     2,    17,     2,    16,
    0,    50,     1,    50,    16,     3,    34,    19,    32,     0,
   16,     1,    50,     0,     0,    17,     2,    16,     0,     1,
   33,    33,     0,     1,     1,     1,     1,     0,     0,     0,
    0,     0,     0,     0,    16,    48,     0,     2,    16,    50,
   16,     2,    16,     2,    16,     0,    33,    16,    33,     0,
    0,    34,    19,    33,     0,     0,     1,     3,    32,     0,
    2,    22,    82,     0,     4,    16,    84,    16,     4,    48,
    4,    48,     0,    67,     1,    67,     0,     6,    82,    22,
   80,     0,    84,    16,    84,     0,     0,    82,    22,    81,
    0,     0,    33,   101,     0,     0,     1,     1,     0,     0,
    3,     0,     3,    16,     3,    32,     3,    32,     0,    50,
   16,    50,     0,     0,    48,    16,    49,     0,     0,    16,
   16,    32,     1,     2,    18,    17,     0,     1,    33,    33,
   32,     2,    18,    18,    20,     0,    16,     1,    50,    16,
    1,     2,    19,    33,     0,     1,    16,    33,     0,     0,
   18,    18,    16,     0,    16,    33,    50,     0,     1,     1,
    1,     0,     0,     1,     1,     1,    16,     0,    18,    18,
   17,     0,    16,    16,    16,     0,     1,     2,    22,    80,
    0,     1,    16,    33,    16,     1,     0,     1,     0,     0,
   16,     1,    67,     0,     0,     1,     1,     2,     0,     0,
   33,    50,    32,     0,     2,    19,    32,     0,    16,     1,
   33,    16,     1,     2,    18,    16,     0,    16,    16,    16,
    0,     0,    18,    18,    17,     0,     0,     1,     2,    32,
    2,    16,    18,    20,     0,    16,     1,    33,     0,     1,
    0,    18,    19,     0,    16,    33,    33,    48,     1,     2,
   18,    16,     0,    33,     1,    33,     0,     1,     2,    18,
   16,     0,     0,    16,    16,    32,     0,     0,     0,     1,
    0,     2,     0,     2,     0,     0,    32,    16,    32,     0,
   33,    16,    33,     0,     2,    18,    18,    16,     0,     2,
    1,     2,    16,     0,    34,    19,    32,     0,     2,    16,
   50,     0,     0,     0,    16,    49,     0,     0,    33,   101,
   16,     0,    65,     5,    64,     0,     5,    33,   101,     0,
    0,     1,     1,     1,     0,     3,     0,     3,     0,     0,
   48,    16,    48,     0,     0,    33,    33,    32,     1,     2,
   18,    19,     0,    16,     1,    33,    16,     0,     1,     1,
    0,     0,     0,     0,     0,    16,     0,     0,     0,     0,
    0,     0,     1,     2,     0,     0,    17,     2,    16,     0,
    1,    33,    33,     0,     0,     0,    16,    33,     0,     0,
   33,    50,    16,     0,    17,     2,    16,     0,     1,    33,
   33,     0,     0,     2,    19,    32,     0,     0,    16,    16,
    0,     0,    16,     0,    16,     0,     1,     1,     1,     0,
    0,     1,     1,     1,     0,     0,     1,     1,    16,     0,
    2,    18,    17,     0,     0,    16,    16,     0,     0,     2,
   22,    80,     0,     0,    16,    16,    16,     0,     0,     0,
    0,     0,     0,     1,     3,     0,     0,     1,     1,     2,
    0,     0,    33,    33,    32,     0,     2,    18,    16,     0,
   16,    33,    33,    16,     0,     1,     1,     0,     0,     0,
   33,    33,     0,     0,    16,    16,    16,     0,     1,     1,
    1,     0,     0,     0,    16,    18,     0,    16,     1,    33,
   48,     1,     0,    18,    16,     0,    33,     1,    33,     0,
    0,     0,    16,    18,     0,     0,    16,    16,    16,     0,
    0,     0,     0,     0,     0,     1,     1,     0,     0,     2,
   18,    16,     0,     0,    16,    16,     0,     0,     2,    18,
   17,     0,     0,     1,     1,     0,     1,     0,    18,    16,
    0,    16,    33,    33,     0,     0,    16,    16,    16,     0,
    0,     1,     1,     0,     0,     0,    16,    17,     0,     0,
   16,    16,     0,     0,     2,    18,    16,     0,     0,     1,
    1,     0};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv4_mem_reserved_units[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv4_emac_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     1,     1,
    2,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     1,     0,     3};

/* Vector for state transitions.  */
static const unsigned char cfv4_emac_transitions[] ATTRIBUTE_UNUSED = {
    0,     2,     1,     0,     1,     3,     4,     2,     2,     4,
    3,     0,     3,     4,     4,     2};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv4_emac_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     4,    16,    36};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv4_emac_reserved_units[] = {
    0,     0,     0,     0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv4_fp_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     1,     1,     1,     1,     1,     2,     2,     3,     3,
    0,     1,     0,     0,     0,     0,     1,     0,     4};

/* Vector for state transitions.  */
static const unsigned char cfv4_fp_transitions[] ATTRIBUTE_UNUSED = {
    0,    50,    34,     1,     0,     1,    51,    51,    51,     2,
    2,    51,    51,    51,     3,     3,    51,    51,    51,     4,
    4,    51,    51,    51,     5,     5,    51,    51,    51,     6,
    6,    51,    51,    51,     7,     7,    51,    51,    51,     8,
    8,    51,    51,    51,     9,     9,    51,    51,    51,    10,
   10,    51,    51,    51,    11,    11,    51,    51,    51,    12,
   12,    51,    51,    51,    13,    13,    51,    51,    51,    14,
   14,    51,    51,    51,    15,    15,    51,    51,    51,    16,
   16,    51,    51,    51,    17,    17,    51,    51,    51,    18,
   18,    51,    51,    51,    19,    19,    51,    51,    51,    20,
   20,    51,    51,    51,    21,    21,    51,    51,    51,    22,
   22,    51,    51,    51,    23,    23,    51,    51,    51,    24,
   24,    51,    51,    51,    25,    25,    51,    51,    51,    26,
   26,    51,    51,    51,    27,    27,    51,    51,    51,    28,
   28,    51,    51,    51,    29,    29,    51,    51,    51,    30,
   30,    51,    51,    51,    31,    31,    51,    51,    51,    32,
   32,    51,    51,    51,    33,    33,    51,    51,    51,    34,
   34,    51,    51,    51,    35,    35,    51,    51,    51,    36,
   36,    51,    51,    51,    37,    37,    51,    51,    51,    38,
   38,    51,    51,    51,    39,    39,    51,    51,    51,    40,
   40,    51,    51,    51,    41,    41,    51,    51,    51,    42,
   42,    51,    51,    51,    43,    43,    51,    51,    51,    44,
   44,    51,    51,    51,    45,    45,    51,    51,    51,    46,
   46,    51,    51,    51,    47,    47,    51,    51,    51,    48,
   48,    51,    51,    51,    49,    49,    51,    51,    51,    50,
   50,    51,    51,    51,     0};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv4_fp_min_issue_delay[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,    50,    50,    50,     0,
    0,    49,    49,    49,     0,     0,    48,    48,    48,     0,
    0,    47,    47,    47,     0,     0,    46,    46,    46,     0,
    0,    45,    45,    45,     0,     0,    44,    44,    44,     0,
    0,    43,    43,    43,     0,     0,    42,    42,    42,     0,
    0,    41,    41,    41,     0,     0,    40,    40,    40,     0,
    0,    39,    39,    39,     0,     0,    38,    38,    38,     0,
    0,    37,    37,    37,     0,     0,    36,    36,    36,     0,
    0,    35,    35,    35,     0,     0,    34,    34,    34,     0,
    0,    33,    33,    33,     0,     0,    32,    32,    32,     0,
    0,    31,    31,    31,     0,     0,    30,    30,    30,     0,
    0,    29,    29,    29,     0,     0,    28,    28,    28,     0,
    0,    27,    27,    27,     0,     0,    26,    26,    26,     0,
    0,    25,    25,    25,     0,     0,    24,    24,    24,     0,
    0,    23,    23,    23,     0,     0,    22,    22,    22,     0,
    0,    21,    21,    21,     0,     0,    20,    20,    20,     0,
    0,    19,    19,    19,     0,     0,    18,    18,    18,     0,
    0,    17,    17,    17,     0,     0,    16,    16,    16,     0,
    0,    15,    15,    15,     0,     0,    14,    14,    14,     0,
    0,    13,    13,    13,     0,     0,    12,    12,    12,     0,
    0,    11,    11,    11,     0,     0,    10,    10,    10,     0,
    0,     9,     9,     9,     0,     0,     8,     8,     8,     0,
    0,     7,     7,     7,     0,     0,     6,     6,     6,     0,
    0,     5,     5,     5,     0,     0,     4,     4,     4,     0,
    0,     3,     3,     3,     0,     0,     2,     2,     2,     0,
    0,     1,     1,     1,     0};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv4_fp_reserved_units[] = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0};
#endif /* #if CPU_UNITS_QUERY */

/* Vector translating external insn codes to internal ones.*/
static const unsigned char cfv4_guess_translate[] ATTRIBUTE_UNUSED = {
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
    0,     0,     0,     0,     0,     0,     1,     0,     2};

/* Vector for state transitions.  */
static const unsigned char cfv4_guess_transitions[] ATTRIBUTE_UNUSED = {
    0,     1,     0,     1,     2,     0};

/* Vector of min issue delay of insns.  */
static const unsigned char cfv4_guess_min_issue_delay[] ATTRIBUTE_UNUSED = {
    8};


#if CPU_UNITS_QUERY
/* Vector for reserved units of states.  */
static const unsigned char cfv4_guess_reserved_units[] = {
    0,     8};
#endif /* #if CPU_UNITS_QUERY */


#define DFA__ADVANCE_CYCLE 238

struct DFA_chip
{
  unsigned char cfv123_ib_automaton_state;
  unsigned char cfv123_oep_automaton_state;
  unsigned char cfv123_chr_automaton_state;
  unsigned short cfv123_mem_automaton_state;
  unsigned char cf_mac_automaton_state;
  unsigned char cfv123_guess_automaton_state;
  unsigned char cfv4_oep_automaton_state;
  unsigned short cfv4_mem_automaton_state;
  unsigned char cfv4_emac_automaton_state;
  unsigned char cfv4_fp_automaton_state;
  unsigned char cfv4_guess_automaton_state;
};


const int max_insn_queue_index = 63;

static int
internal_min_issue_delay (int insn_code, struct DFA_chip *chip ATTRIBUTE_UNUSED)
{
  int temp ATTRIBUTE_UNUSED;
  int res = -1;

  switch (insn_code)
    {
    case 0: /* cf_ib1 */

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      res = temp;
      break;

    case 1: /* cfv123_alu_00_1 */
    case 2: /* cfv123_alu_00_2 */
    case 3: /* cfv123_alu_00_3 */
    case 86: /* cfv123_lea_10_1 */
    case 87: /* cfv123_lea_10_2 */
    case 88: /* cfv123_lea_10_3 */
    case 89: /* cfv123_lea_i0_2 */
    case 90: /* cfv123_lea_i0_3 */
    case 101: /* cfv123_mul_l_00_1 */
    case 102: /* cfv123_mul_l_00_2 */
    case 103: /* cfv123_mul_l_00_3 */
    case 104: /* cfv123_mul_w_00_1 */
    case 105: /* cfv123_mul_w_00_2 */
    case 106: /* cfv123_mul_w_00_3 */
    case 172: /* cfv12_bcc_1 */
    case 173: /* cfv12_bcc_2 */
    case 174: /* cfv12_bcc_3 */
    case 175: /* cfv3_bcc_1 */
    case 176: /* cfv3_bcc_2 */
    case 177: /* cfv3_bcc_3 */
    case 184: /* cfv12_jmp_1 */
    case 185: /* cfv12_jmp_2 */
    case 186: /* cfv12_jmp_3 */
    case 187: /* cfv3_jmp_1 */
    case 188: /* cfv3_jmp_2 */
    case 189: /* cfv3_jmp_3 */

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;

    case 4: /* cfv1_alu_10_1 */
    case 5: /* cfv1_alu_10_2 */
    case 6: /* cfv1_alu_10_3 */
    case 7: /* cfv1_omove_10_1 */
    case 8: /* cfv1_omove_10_2 */
    case 9: /* cfv1_omove_10_3 */
    case 10: /* cfv2_alu_10_1 */
    case 11: /* cfv2_alu_10_2 */
    case 12: /* cfv2_alu_10_3 */
    case 13: /* cfv2_omove_10_1 */
    case 14: /* cfv2_omove_10_2 */
    case 15: /* cfv2_omove_10_3 */
    case 16: /* cfv3_alu_10_1 */
    case 17: /* cfv3_alu_10_2 */
    case 18: /* cfv3_alu_10_3 */
    case 19: /* cfv3_omove_10_1 */
    case 20: /* cfv3_omove_10_2 */
    case 21: /* cfv3_omove_10_3 */
    case 22: /* cfv1_alu_i0_2 */
    case 23: /* cfv1_alu_i0_3 */
    case 24: /* cfv1_omove_i0_2 */
    case 25: /* cfv1_omove_i0_3 */
    case 26: /* cfv2_alu_i0_2 */
    case 27: /* cfv2_alu_i0_3 */
    case 28: /* cfv2_omove_i0_2 */
    case 29: /* cfv2_omove_i0_3 */
    case 30: /* cfv3_alu_i0_2 */
    case 31: /* cfv3_alu_i0_3 */
    case 32: /* cfv3_omove_i0_2 */
    case 33: /* cfv3_omove_i0_3 */
    case 107: /* cfv12_mul_l_10_1 */
    case 108: /* cfv12_mul_l_10_2 */
    case 109: /* cfv12_mul_l_10_3 */
    case 110: /* cfv3_mul_l_10_1 */
    case 111: /* cfv3_mul_l_10_2 */
    case 112: /* cfv3_mul_l_10_3 */
    case 113: /* cfv12_mul_w_10_1 */
    case 114: /* cfv12_mul_w_10_2 */
    case 115: /* cfv12_mul_w_10_3 */
    case 116: /* cfv3_mul_w_10_1 */
    case 117: /* cfv3_mul_w_10_2 */
    case 118: /* cfv3_mul_w_10_3 */
    case 119: /* cfv12_mul_w_i0_2 */
    case 120: /* cfv12_mul_w_i0_3 */
    case 121: /* cfv3_mul_w_i0_2 */
    case 122: /* cfv3_mul_w_i0_3 */
    case 164: /* cfv12_rts */
    case 165: /* cfv3_rts */
    case 190: /* cfv12_unlk */
    case 191: /* cfv3_unlk */

      temp = cfv123_mem_min_issue_delay [(cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) / 2];
      temp = (temp >> (8 - ((cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) % 2 + 1) * 4)) & 15;
      res = temp;

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      if (temp > res)
        res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;

    case 34: /* cfv12_alu_01_1 */
    case 35: /* cfv12_alu_01_2 */
    case 36: /* cfv12_alu_01_3 */
    case 37: /* cfv3_alu_01_1 */
    case 38: /* cfv3_alu_01_2 */
    case 39: /* cfv3_alu_01_3 */
    case 40: /* cfv12_alu_0i_2 */
    case 41: /* cfv12_alu_0i_3 */
    case 42: /* cfv3_alu_0i_2 */
    case 43: /* cfv3_alu_0i_3 */
    case 44: /* cfv1_alu_11_1 */
    case 45: /* cfv1_alu_11_2 */
    case 46: /* cfv1_alu_11_3 */
    case 47: /* cfv1_omove_11_1 */
    case 48: /* cfv1_omove_11_2 */
    case 49: /* cfv1_omove_11_3 */
    case 50: /* cfv2_alu_11_1 */
    case 51: /* cfv2_alu_11_2 */
    case 52: /* cfv2_alu_11_3 */
    case 53: /* cfv2_omove_11_1 */
    case 54: /* cfv2_omove_11_2 */
    case 55: /* cfv2_omove_11_3 */
    case 56: /* cfv3_alu_11_1 */
    case 57: /* cfv3_alu_11_2 */
    case 58: /* cfv3_alu_11_3 */
    case 59: /* cfv3_omove_11_1 */
    case 60: /* cfv3_omove_11_2 */
    case 61: /* cfv3_omove_11_3 */
    case 62: /* cfv1_alu_i1_2 */
    case 63: /* cfv1_alu_i1_3 */
    case 64: /* cfv1_omove_i1_2 */
    case 65: /* cfv1_omove_i1_3 */
    case 66: /* cfv2_alu_i1_2 */
    case 67: /* cfv2_alu_i1_3 */
    case 68: /* cfv2_omove_i1_2 */
    case 69: /* cfv2_omove_i1_3 */
    case 70: /* cfv3_alu_i1_2 */
    case 71: /* cfv3_alu_i1_3 */
    case 72: /* cfv3_omove_i1_2 */
    case 73: /* cfv3_omove_i1_3 */
    case 74: /* cfv1_alu_1i_2 */
    case 75: /* cfv1_alu_1i_3 */
    case 76: /* cfv1_omove_1i_2 */
    case 77: /* cfv1_omove_1i_3 */
    case 78: /* cfv2_alu_1i_2 */
    case 79: /* cfv2_alu_1i_3 */
    case 80: /* cfv2_omove_1i_2 */
    case 81: /* cfv2_omove_1i_3 */
    case 82: /* cfv3_alu_1i_2 */
    case 83: /* cfv3_alu_1i_3 */
    case 84: /* cfv3_omove_1i_2 */
    case 85: /* cfv3_omove_1i_3 */
    case 91: /* cfv12_pea_11_1 */
    case 92: /* cfv12_pea_11_2 */
    case 93: /* cfv12_pea_11_3 */
    case 94: /* cfv3_pea_11_1 */
    case 95: /* cfv3_pea_11_2 */
    case 96: /* cfv3_pea_11_3 */
    case 97: /* cfv12_pea_i1_2 */
    case 98: /* cfv12_pea_i1_3 */
    case 99: /* cfv3_pea_i1_2 */
    case 100: /* cfv3_pea_i1_3 */
    case 166: /* cfv12_call_1 */
    case 167: /* cfv12_call_2 */
    case 168: /* cfv12_call_3 */
    case 169: /* cfv3_call_1 */
    case 170: /* cfv3_call_2 */
    case 171: /* cfv3_call_3 */
    case 178: /* cfv12_bra_1 */
    case 179: /* cfv12_bra_2 */
    case 180: /* cfv12_bra_3 */
    case 181: /* cfv3_bra_1 */
    case 182: /* cfv3_bra_2 */
    case 183: /* cfv3_bra_3 */

      temp = cfv123_mem_min_issue_delay [(cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) / 2];
      temp = (temp >> (8 - ((cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) % 2 + 1) * 4)) & 15;
      res = temp;

      temp = cfv123_chr_min_issue_delay [(cfv123_chr_translate [insn_code] + chip->cfv123_chr_automaton_state * 8) / 2];
      temp = (temp >> (8 - ((cfv123_chr_translate [insn_code] + chip->cfv123_chr_automaton_state * 8) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      if (temp > res)
        res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;

    case 123: /* cfv123_mac_l_00_1 */
    case 124: /* cfv123_mac_l_00_2 */
    case 125: /* cfv123_mac_l_00_3 */
    case 126: /* cfv123_mac_w_00_1 */
    case 127: /* cfv123_mac_w_00_2 */
    case 128: /* cfv123_mac_w_00_3 */
    case 145: /* cfv123_emac_00_1 */
    case 146: /* cfv123_emac_00_2 */
    case 147: /* cfv123_emac_00_3 */

      temp = cf_mac_min_issue_delay [(cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8) / 2];
      temp = (temp >> (8 - ((cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8) % 2 + 1) * 4)) & 15;
      res = temp;

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      if (temp > res)
        res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;

    case 129: /* cfv12_mac_l_10_1 */
    case 130: /* cfv12_mac_l_10_2 */
    case 131: /* cfv12_mac_l_10_3 */
    case 132: /* cfv3_mac_l_10_1 */
    case 133: /* cfv3_mac_l_10_2 */
    case 134: /* cfv3_mac_l_10_3 */
    case 135: /* cfv12_mac_w_10_1 */
    case 136: /* cfv12_mac_w_10_2 */
    case 137: /* cfv12_mac_w_10_3 */
    case 138: /* cfv3_mac_w_10_1 */
    case 139: /* cfv3_mac_w_10_2 */
    case 140: /* cfv3_mac_w_10_3 */
    case 141: /* cfv12_mac_w_i0_2 */
    case 142: /* cfv12_mac_w_i0_3 */
    case 143: /* cfv3_mac_w_i0_2 */
    case 144: /* cfv3_mac_w_i0_3 */
    case 148: /* cfv12_emac_l_10_1 */
    case 149: /* cfv12_emac_l_10_2 */
    case 150: /* cfv12_emac_l_10_3 */
    case 151: /* cfv3_emac_l_10_1 */
    case 152: /* cfv3_emac_l_10_2 */
    case 153: /* cfv3_emac_l_10_3 */
    case 154: /* cfv12_emac_w_10_1 */
    case 155: /* cfv12_emac_w_10_2 */
    case 156: /* cfv12_emac_w_10_3 */
    case 157: /* cfv3_emac_w_10_1 */
    case 158: /* cfv3_emac_w_10_2 */
    case 159: /* cfv3_emac_w_10_3 */
    case 160: /* cfv12_emac_w_i0_2 */
    case 161: /* cfv12_emac_w_i0_3 */
    case 162: /* cfv3_emac_w_i0_2 */
    case 163: /* cfv3_emac_w_i0_3 */

      temp = cf_mac_min_issue_delay [(cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8) / 2];
      temp = (temp >> (8 - ((cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8) % 2 + 1) * 4)) & 15;
      res = temp;

      temp = cfv123_mem_min_issue_delay [(cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) / 2];
      temp = (temp >> (8 - ((cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      if (temp > res)
        res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;

    case 192: /* cfv123_guess */

      temp = cfv123_guess_min_issue_delay [(cfv123_guess_translate [insn_code] + chip->cfv123_guess_automaton_state * 3) / 8];
      temp = (temp >> (8 - ((cfv123_guess_translate [insn_code] + chip->cfv123_guess_automaton_state * 3) % 8 + 1) * 1)) & 1;
      res = temp;

      temp = cfv123_mem_min_issue_delay [(cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) / 2];
      temp = (temp >> (8 - ((cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      if (temp > res)
        res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;

    case 193: /* cfv4_00_oag */
    case 194: /* cfv4_00_oag_pOEP3_sOEP12 */
    case 195: /* cfv4_00_oag_lea */
    case 196: /* cfv4_00_oag_pOEP1 */
    case 197: /* cfv4_00_oag_moveql */
    case 198: /* cfv4_00_ex */
    case 199: /* cfv4_00_ex_sOEP13 */
    case 213: /* cfv4_divw_00 */
    case 216: /* cfv4_divl_00 */
    case 230: /* cfv4_bcc */
    case 232: /* cfv4_bra_bsr */
    case 233: /* cfv4_jmp_jsr */

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      res = temp;
      break;

    case 200: /* cfv4_10 */
    case 201: /* cfv4_10_pOEP1 */
    case 202: /* cfv4_i0 */
    case 203: /* cfv4_i0_pOEP1 */
    case 204: /* cfv4_01 */
    case 205: /* cfv4_0i */
    case 206: /* cfv4_11 */
    case 207: /* cfv4_i1 */
    case 208: /* cfv4_1i */
    case 209: /* cfv4_11_pea */
    case 210: /* cfv4_i1_pea */
    case 211: /* cfv4_link */
    case 212: /* cfv4_unlink */
    case 214: /* cfv4_divw_10 */
    case 215: /* cfv4_divw_i0 */
    case 217: /* cfv4_divl_10 */
    case 234: /* cfv4_rts */
    case 235: /* cfv4_nop */

      temp = cfv4_mem_min_issue_delay [(cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) / 2];
      temp = (temp >> (8 - ((cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) % 2 + 1) * 4)) & 15;
      res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;
      break;

    case 218: /* cfv4_emac_mul_00 */

      temp = cfv4_emac_min_issue_delay [(cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) / 4];
      temp = (temp >> (8 - ((cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) % 4 + 1) * 2)) & 3;
      res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;
      break;

    case 219: /* cfv4_emac_mul_10 */
    case 220: /* cfv4_emac_mul_i0 */

      temp = cfv4_emac_min_issue_delay [(cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) / 4];
      temp = (temp >> (8 - ((cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) % 4 + 1) * 2)) & 3;
      res = temp;

      temp = cfv4_mem_min_issue_delay [(cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) / 2];
      temp = (temp >> (8 - ((cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;
      break;

    case 221: /* cfv4_falu_00 */
    case 223: /* cfv4_fneg_00 */
    case 226: /* cfv4_fdiv_00 */
    case 228: /* cfv4_fsqrt_00 */
    case 231: /* cfv4_fbcc */

      temp = cfv4_fp_min_issue_delay [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
      res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;
      break;

    case 222: /* cfv4_falu_10 */
    case 224: /* cfv4_fmove_fneg_10 */
    case 225: /* cfv4_fmove_01 */
    case 227: /* cfv4_fdiv_10 */
    case 229: /* cfv4_fsqrt_10 */

      temp = cfv4_fp_min_issue_delay [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
      res = temp;

      temp = cfv4_mem_min_issue_delay [(cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) / 2];
      temp = (temp >> (8 - ((cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;
      break;

    case 236: /* cfv4_guess */

      temp = cfv4_guess_min_issue_delay [(cfv4_guess_translate [insn_code] + chip->cfv4_guess_automaton_state * 3) / 8];
      temp = (temp >> (8 - ((cfv4_guess_translate [insn_code] + chip->cfv4_guess_automaton_state * 3) % 8 + 1) * 1)) & 1;
      res = temp;

      temp = cfv4_fp_min_issue_delay [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
      if (temp > res)
        res = temp;

      temp = cfv4_emac_min_issue_delay [(cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) / 4];
      temp = (temp >> (8 - ((cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) % 4 + 1) * 2)) & 3;
      if (temp > res)
        res = temp;

      temp = cfv4_mem_min_issue_delay [(cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) / 2];
      temp = (temp >> (8 - ((cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;
      break;

    case 237: /* ignore */
      break;

    case 238: /* $advance_cycle */

      temp = cfv4_guess_min_issue_delay [(cfv4_guess_translate [insn_code] + chip->cfv4_guess_automaton_state * 3) / 8];
      temp = (temp >> (8 - ((cfv4_guess_translate [insn_code] + chip->cfv4_guess_automaton_state * 3) % 8 + 1) * 1)) & 1;
      res = temp;

      temp = cfv4_fp_min_issue_delay [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
      if (temp > res)
        res = temp;

      temp = cfv4_emac_min_issue_delay [(cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) / 4];
      temp = (temp >> (8 - ((cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4) % 4 + 1) * 2)) & 3;
      if (temp > res)
        res = temp;

      temp = cfv4_mem_min_issue_delay [(cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) / 2];
      temp = (temp >> (8 - ((cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv4_oep_min_issue_delay [cfv4_oep_translate [insn_code] + chip->cfv4_oep_automaton_state * 19];
      if (temp > res)
        res = temp;

      temp = cfv123_guess_min_issue_delay [(cfv123_guess_translate [insn_code] + chip->cfv123_guess_automaton_state * 3) / 8];
      temp = (temp >> (8 - ((cfv123_guess_translate [insn_code] + chip->cfv123_guess_automaton_state * 3) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;

      temp = cf_mac_min_issue_delay [(cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8) / 2];
      temp = (temp >> (8 - ((cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv123_mem_min_issue_delay [(cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) / 2];
      temp = (temp >> (8 - ((cfv123_mem_translate [insn_code] + chip->cfv123_mem_automaton_state * 22) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv123_chr_min_issue_delay [(cfv123_chr_translate [insn_code] + chip->cfv123_chr_automaton_state * 8) / 2];
      temp = (temp >> (8 - ((cfv123_chr_translate [insn_code] + chip->cfv123_chr_automaton_state * 8) % 2 + 1) * 4)) & 15;
      if (temp > res)
        res = temp;

      temp = cfv123_oep_min_issue_delay [cfv123_oep_translate [insn_code] + chip->cfv123_oep_automaton_state * 30];
      if (temp > res)
        res = temp;

      temp = cfv123_ib_min_issue_delay [(cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) / 8];
      temp = (temp >> (8 - ((cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6) % 8 + 1) * 1)) & 1;
      if (temp > res)
        res = temp;
      break;


    default:
      res = -1;
      break;
    }
  return res;
}

static int
internal_state_transition (int insn_code, struct DFA_chip *chip ATTRIBUTE_UNUSED)
{
  int temp ATTRIBUTE_UNUSED;

  switch (insn_code)
    {
    case 0: /* cf_ib1 */
      {

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        return -1;
      }
    case 1: /* cfv123_alu_00_1 */
    case 2: /* cfv123_alu_00_2 */
    case 3: /* cfv123_alu_00_3 */
    case 86: /* cfv123_lea_10_1 */
    case 87: /* cfv123_lea_10_2 */
    case 88: /* cfv123_lea_10_3 */
    case 89: /* cfv123_lea_i0_2 */
    case 90: /* cfv123_lea_i0_3 */
    case 101: /* cfv123_mul_l_00_1 */
    case 102: /* cfv123_mul_l_00_2 */
    case 103: /* cfv123_mul_l_00_3 */
    case 104: /* cfv123_mul_w_00_1 */
    case 105: /* cfv123_mul_w_00_2 */
    case 106: /* cfv123_mul_w_00_3 */
    case 172: /* cfv12_bcc_1 */
    case 173: /* cfv12_bcc_2 */
    case 174: /* cfv12_bcc_3 */
    case 175: /* cfv3_bcc_1 */
    case 176: /* cfv3_bcc_2 */
    case 177: /* cfv3_bcc_3 */
    case 184: /* cfv12_jmp_1 */
    case 185: /* cfv12_jmp_2 */
    case 186: /* cfv12_jmp_3 */
    case 187: /* cfv3_jmp_1 */
    case 188: /* cfv3_jmp_2 */
    case 189: /* cfv3_jmp_3 */
      {
        unsigned char _cfv123_oep_automaton_state;

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }
    case 4: /* cfv1_alu_10_1 */
    case 5: /* cfv1_alu_10_2 */
    case 6: /* cfv1_alu_10_3 */
    case 7: /* cfv1_omove_10_1 */
    case 8: /* cfv1_omove_10_2 */
    case 9: /* cfv1_omove_10_3 */
    case 10: /* cfv2_alu_10_1 */
    case 11: /* cfv2_alu_10_2 */
    case 12: /* cfv2_alu_10_3 */
    case 13: /* cfv2_omove_10_1 */
    case 14: /* cfv2_omove_10_2 */
    case 15: /* cfv2_omove_10_3 */
    case 16: /* cfv3_alu_10_1 */
    case 17: /* cfv3_alu_10_2 */
    case 18: /* cfv3_alu_10_3 */
    case 19: /* cfv3_omove_10_1 */
    case 20: /* cfv3_omove_10_2 */
    case 21: /* cfv3_omove_10_3 */
    case 22: /* cfv1_alu_i0_2 */
    case 23: /* cfv1_alu_i0_3 */
    case 24: /* cfv1_omove_i0_2 */
    case 25: /* cfv1_omove_i0_3 */
    case 26: /* cfv2_alu_i0_2 */
    case 27: /* cfv2_alu_i0_3 */
    case 28: /* cfv2_omove_i0_2 */
    case 29: /* cfv2_omove_i0_3 */
    case 30: /* cfv3_alu_i0_2 */
    case 31: /* cfv3_alu_i0_3 */
    case 32: /* cfv3_omove_i0_2 */
    case 33: /* cfv3_omove_i0_3 */
    case 107: /* cfv12_mul_l_10_1 */
    case 108: /* cfv12_mul_l_10_2 */
    case 109: /* cfv12_mul_l_10_3 */
    case 110: /* cfv3_mul_l_10_1 */
    case 111: /* cfv3_mul_l_10_2 */
    case 112: /* cfv3_mul_l_10_3 */
    case 113: /* cfv12_mul_w_10_1 */
    case 114: /* cfv12_mul_w_10_2 */
    case 115: /* cfv12_mul_w_10_3 */
    case 116: /* cfv3_mul_w_10_1 */
    case 117: /* cfv3_mul_w_10_2 */
    case 118: /* cfv3_mul_w_10_3 */
    case 119: /* cfv12_mul_w_i0_2 */
    case 120: /* cfv12_mul_w_i0_3 */
    case 121: /* cfv3_mul_w_i0_2 */
    case 122: /* cfv3_mul_w_i0_3 */
    case 164: /* cfv12_rts */
    case 165: /* cfv3_rts */
    case 190: /* cfv12_unlk */
    case 191: /* cfv3_unlk */
      {
        unsigned short _cfv123_mem_automaton_state;
        unsigned char _cfv123_oep_automaton_state;

        temp = cfv123_mem_base [chip->cfv123_mem_automaton_state] + cfv123_mem_translate [insn_code];
        if (cfv123_mem_check [temp] != chip->cfv123_mem_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_mem_automaton_state = cfv123_mem_transitions [temp];

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cfv123_mem_automaton_state = _cfv123_mem_automaton_state;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }
    case 34: /* cfv12_alu_01_1 */
    case 35: /* cfv12_alu_01_2 */
    case 36: /* cfv12_alu_01_3 */
    case 37: /* cfv3_alu_01_1 */
    case 38: /* cfv3_alu_01_2 */
    case 39: /* cfv3_alu_01_3 */
    case 40: /* cfv12_alu_0i_2 */
    case 41: /* cfv12_alu_0i_3 */
    case 42: /* cfv3_alu_0i_2 */
    case 43: /* cfv3_alu_0i_3 */
    case 44: /* cfv1_alu_11_1 */
    case 45: /* cfv1_alu_11_2 */
    case 46: /* cfv1_alu_11_3 */
    case 47: /* cfv1_omove_11_1 */
    case 48: /* cfv1_omove_11_2 */
    case 49: /* cfv1_omove_11_3 */
    case 50: /* cfv2_alu_11_1 */
    case 51: /* cfv2_alu_11_2 */
    case 52: /* cfv2_alu_11_3 */
    case 53: /* cfv2_omove_11_1 */
    case 54: /* cfv2_omove_11_2 */
    case 55: /* cfv2_omove_11_3 */
    case 56: /* cfv3_alu_11_1 */
    case 57: /* cfv3_alu_11_2 */
    case 58: /* cfv3_alu_11_3 */
    case 59: /* cfv3_omove_11_1 */
    case 60: /* cfv3_omove_11_2 */
    case 61: /* cfv3_omove_11_3 */
    case 62: /* cfv1_alu_i1_2 */
    case 63: /* cfv1_alu_i1_3 */
    case 64: /* cfv1_omove_i1_2 */
    case 65: /* cfv1_omove_i1_3 */
    case 66: /* cfv2_alu_i1_2 */
    case 67: /* cfv2_alu_i1_3 */
    case 68: /* cfv2_omove_i1_2 */
    case 69: /* cfv2_omove_i1_3 */
    case 70: /* cfv3_alu_i1_2 */
    case 71: /* cfv3_alu_i1_3 */
    case 72: /* cfv3_omove_i1_2 */
    case 73: /* cfv3_omove_i1_3 */
    case 74: /* cfv1_alu_1i_2 */
    case 75: /* cfv1_alu_1i_3 */
    case 76: /* cfv1_omove_1i_2 */
    case 77: /* cfv1_omove_1i_3 */
    case 78: /* cfv2_alu_1i_2 */
    case 79: /* cfv2_alu_1i_3 */
    case 80: /* cfv2_omove_1i_2 */
    case 81: /* cfv2_omove_1i_3 */
    case 82: /* cfv3_alu_1i_2 */
    case 83: /* cfv3_alu_1i_3 */
    case 84: /* cfv3_omove_1i_2 */
    case 85: /* cfv3_omove_1i_3 */
    case 91: /* cfv12_pea_11_1 */
    case 92: /* cfv12_pea_11_2 */
    case 93: /* cfv12_pea_11_3 */
    case 94: /* cfv3_pea_11_1 */
    case 95: /* cfv3_pea_11_2 */
    case 96: /* cfv3_pea_11_3 */
    case 97: /* cfv12_pea_i1_2 */
    case 98: /* cfv12_pea_i1_3 */
    case 99: /* cfv3_pea_i1_2 */
    case 100: /* cfv3_pea_i1_3 */
    case 166: /* cfv12_call_1 */
    case 167: /* cfv12_call_2 */
    case 168: /* cfv12_call_3 */
    case 169: /* cfv3_call_1 */
    case 170: /* cfv3_call_2 */
    case 171: /* cfv3_call_3 */
    case 178: /* cfv12_bra_1 */
    case 179: /* cfv12_bra_2 */
    case 180: /* cfv12_bra_3 */
    case 181: /* cfv3_bra_1 */
    case 182: /* cfv3_bra_2 */
    case 183: /* cfv3_bra_3 */
      {
        unsigned short _cfv123_mem_automaton_state;
        unsigned char _cfv123_chr_automaton_state;
        unsigned char _cfv123_oep_automaton_state;

        temp = cfv123_mem_base [chip->cfv123_mem_automaton_state] + cfv123_mem_translate [insn_code];
        if (cfv123_mem_check [temp] != chip->cfv123_mem_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_mem_automaton_state = cfv123_mem_transitions [temp];

        temp = cfv123_chr_transitions [cfv123_chr_translate [insn_code] + chip->cfv123_chr_automaton_state * 8];
        if (temp >= 15)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_chr_automaton_state = temp;

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cfv123_mem_automaton_state = _cfv123_mem_automaton_state;
        chip->cfv123_chr_automaton_state = _cfv123_chr_automaton_state;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }
    case 123: /* cfv123_mac_l_00_1 */
    case 124: /* cfv123_mac_l_00_2 */
    case 125: /* cfv123_mac_l_00_3 */
    case 126: /* cfv123_mac_w_00_1 */
    case 127: /* cfv123_mac_w_00_2 */
    case 128: /* cfv123_mac_w_00_3 */
    case 145: /* cfv123_emac_00_1 */
    case 146: /* cfv123_emac_00_2 */
    case 147: /* cfv123_emac_00_3 */
      {
        unsigned char _cf_mac_automaton_state;
        unsigned char _cfv123_oep_automaton_state;

        temp = cf_mac_transitions [cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8];
        if (temp >= 64)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cf_mac_automaton_state = temp;

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cf_mac_automaton_state = _cf_mac_automaton_state;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }
    case 129: /* cfv12_mac_l_10_1 */
    case 130: /* cfv12_mac_l_10_2 */
    case 131: /* cfv12_mac_l_10_3 */
    case 132: /* cfv3_mac_l_10_1 */
    case 133: /* cfv3_mac_l_10_2 */
    case 134: /* cfv3_mac_l_10_3 */
    case 135: /* cfv12_mac_w_10_1 */
    case 136: /* cfv12_mac_w_10_2 */
    case 137: /* cfv12_mac_w_10_3 */
    case 138: /* cfv3_mac_w_10_1 */
    case 139: /* cfv3_mac_w_10_2 */
    case 140: /* cfv3_mac_w_10_3 */
    case 141: /* cfv12_mac_w_i0_2 */
    case 142: /* cfv12_mac_w_i0_3 */
    case 143: /* cfv3_mac_w_i0_2 */
    case 144: /* cfv3_mac_w_i0_3 */
    case 148: /* cfv12_emac_l_10_1 */
    case 149: /* cfv12_emac_l_10_2 */
    case 150: /* cfv12_emac_l_10_3 */
    case 151: /* cfv3_emac_l_10_1 */
    case 152: /* cfv3_emac_l_10_2 */
    case 153: /* cfv3_emac_l_10_3 */
    case 154: /* cfv12_emac_w_10_1 */
    case 155: /* cfv12_emac_w_10_2 */
    case 156: /* cfv12_emac_w_10_3 */
    case 157: /* cfv3_emac_w_10_1 */
    case 158: /* cfv3_emac_w_10_2 */
    case 159: /* cfv3_emac_w_10_3 */
    case 160: /* cfv12_emac_w_i0_2 */
    case 161: /* cfv12_emac_w_i0_3 */
    case 162: /* cfv3_emac_w_i0_2 */
    case 163: /* cfv3_emac_w_i0_3 */
      {
        unsigned char _cf_mac_automaton_state;
        unsigned short _cfv123_mem_automaton_state;
        unsigned char _cfv123_oep_automaton_state;

        temp = cf_mac_transitions [cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8];
        if (temp >= 64)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cf_mac_automaton_state = temp;

        temp = cfv123_mem_base [chip->cfv123_mem_automaton_state] + cfv123_mem_translate [insn_code];
        if (cfv123_mem_check [temp] != chip->cfv123_mem_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_mem_automaton_state = cfv123_mem_transitions [temp];

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cf_mac_automaton_state = _cf_mac_automaton_state;
        chip->cfv123_mem_automaton_state = _cfv123_mem_automaton_state;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }
    case 192: /* cfv123_guess */
      {
        unsigned char _cfv123_guess_automaton_state;
        unsigned short _cfv123_mem_automaton_state;
        unsigned char _cfv123_oep_automaton_state;

        temp = cfv123_guess_transitions [cfv123_guess_translate [insn_code] + chip->cfv123_guess_automaton_state * 3];
        if (temp >= 2)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_guess_automaton_state = temp;

        temp = cfv123_mem_base [chip->cfv123_mem_automaton_state] + cfv123_mem_translate [insn_code];
        if (cfv123_mem_check [temp] != chip->cfv123_mem_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_mem_automaton_state = cfv123_mem_transitions [temp];

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cfv123_guess_automaton_state = _cfv123_guess_automaton_state;
        chip->cfv123_mem_automaton_state = _cfv123_mem_automaton_state;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }
    case 193: /* cfv4_00_oag */
    case 194: /* cfv4_00_oag_pOEP3_sOEP12 */
    case 195: /* cfv4_00_oag_lea */
    case 196: /* cfv4_00_oag_pOEP1 */
    case 197: /* cfv4_00_oag_moveql */
    case 198: /* cfv4_00_ex */
    case 199: /* cfv4_00_ex_sOEP13 */
    case 213: /* cfv4_divw_00 */
    case 216: /* cfv4_divl_00 */
    case 230: /* cfv4_bcc */
    case 232: /* cfv4_bra_bsr */
    case 233: /* cfv4_jmp_jsr */
      {

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        return -1;
      }
    case 200: /* cfv4_10 */
    case 201: /* cfv4_10_pOEP1 */
    case 202: /* cfv4_i0 */
    case 203: /* cfv4_i0_pOEP1 */
    case 204: /* cfv4_01 */
    case 205: /* cfv4_0i */
    case 206: /* cfv4_11 */
    case 207: /* cfv4_i1 */
    case 208: /* cfv4_1i */
    case 209: /* cfv4_11_pea */
    case 210: /* cfv4_i1_pea */
    case 211: /* cfv4_link */
    case 212: /* cfv4_unlink */
    case 214: /* cfv4_divw_10 */
    case 215: /* cfv4_divw_i0 */
    case 217: /* cfv4_divl_10 */
    case 234: /* cfv4_rts */
    case 235: /* cfv4_nop */
      {
        unsigned short _cfv4_mem_automaton_state;

        temp = cfv4_mem_transitions [cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9];
        if (temp >= 256)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_mem_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        chip->cfv4_mem_automaton_state = _cfv4_mem_automaton_state;
        return -1;
      }
    case 218: /* cfv4_emac_mul_00 */
      {
        unsigned char _cfv4_emac_automaton_state;

        temp = cfv4_emac_transitions [cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4];
        if (temp >= 4)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_emac_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        chip->cfv4_emac_automaton_state = _cfv4_emac_automaton_state;
        return -1;
      }
    case 219: /* cfv4_emac_mul_10 */
    case 220: /* cfv4_emac_mul_i0 */
      {
        unsigned char _cfv4_emac_automaton_state;
        unsigned short _cfv4_mem_automaton_state;

        temp = cfv4_emac_transitions [cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4];
        if (temp >= 4)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_emac_automaton_state = temp;

        temp = cfv4_mem_transitions [cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9];
        if (temp >= 256)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_mem_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        chip->cfv4_emac_automaton_state = _cfv4_emac_automaton_state;
        chip->cfv4_mem_automaton_state = _cfv4_mem_automaton_state;
        return -1;
      }
    case 221: /* cfv4_falu_00 */
    case 223: /* cfv4_fneg_00 */
    case 226: /* cfv4_fdiv_00 */
    case 228: /* cfv4_fsqrt_00 */
    case 231: /* cfv4_fbcc */
      {
        unsigned char _cfv4_fp_automaton_state;

        temp = cfv4_fp_transitions [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
        if (temp >= 51)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_fp_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        chip->cfv4_fp_automaton_state = _cfv4_fp_automaton_state;
        return -1;
      }
    case 222: /* cfv4_falu_10 */
    case 224: /* cfv4_fmove_fneg_10 */
    case 225: /* cfv4_fmove_01 */
    case 227: /* cfv4_fdiv_10 */
    case 229: /* cfv4_fsqrt_10 */
      {
        unsigned char _cfv4_fp_automaton_state;
        unsigned short _cfv4_mem_automaton_state;

        temp = cfv4_fp_transitions [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
        if (temp >= 51)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_fp_automaton_state = temp;

        temp = cfv4_mem_transitions [cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9];
        if (temp >= 256)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_mem_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        chip->cfv4_fp_automaton_state = _cfv4_fp_automaton_state;
        chip->cfv4_mem_automaton_state = _cfv4_mem_automaton_state;
        return -1;
      }
    case 236: /* cfv4_guess */
      {
        unsigned char _cfv4_guess_automaton_state;
        unsigned char _cfv4_fp_automaton_state;
        unsigned char _cfv4_emac_automaton_state;
        unsigned short _cfv4_mem_automaton_state;

        temp = cfv4_guess_transitions [cfv4_guess_translate [insn_code] + chip->cfv4_guess_automaton_state * 3];
        if (temp >= 2)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_guess_automaton_state = temp;

        temp = cfv4_fp_transitions [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
        if (temp >= 51)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_fp_automaton_state = temp;

        temp = cfv4_emac_transitions [cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4];
        if (temp >= 4)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_emac_automaton_state = temp;

        temp = cfv4_mem_transitions [cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9];
        if (temp >= 256)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_mem_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv4_oep_automaton_state = cfv4_oep_transitions [temp];
        chip->cfv4_guess_automaton_state = _cfv4_guess_automaton_state;
        chip->cfv4_fp_automaton_state = _cfv4_fp_automaton_state;
        chip->cfv4_emac_automaton_state = _cfv4_emac_automaton_state;
        chip->cfv4_mem_automaton_state = _cfv4_mem_automaton_state;
        return -1;
      }
    case 237: /* ignore */
      {
        return -1;
      }
    case 238: /* $advance_cycle */
      {
        unsigned char _cfv4_guess_automaton_state;
        unsigned char _cfv4_fp_automaton_state;
        unsigned char _cfv4_emac_automaton_state;
        unsigned short _cfv4_mem_automaton_state;
        unsigned char _cfv4_oep_automaton_state;
        unsigned char _cfv123_guess_automaton_state;
        unsigned char _cf_mac_automaton_state;
        unsigned short _cfv123_mem_automaton_state;
        unsigned char _cfv123_chr_automaton_state;
        unsigned char _cfv123_oep_automaton_state;

        temp = cfv4_guess_transitions [cfv4_guess_translate [insn_code] + chip->cfv4_guess_automaton_state * 3];
        if (temp >= 2)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_guess_automaton_state = temp;

        temp = cfv4_fp_transitions [cfv4_fp_translate [insn_code] + chip->cfv4_fp_automaton_state * 5];
        if (temp >= 51)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_fp_automaton_state = temp;

        temp = cfv4_emac_transitions [cfv4_emac_translate [insn_code] + chip->cfv4_emac_automaton_state * 4];
        if (temp >= 4)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_emac_automaton_state = temp;

        temp = cfv4_mem_transitions [cfv4_mem_translate [insn_code] + chip->cfv4_mem_automaton_state * 9];
        if (temp >= 256)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_mem_automaton_state = temp;

        temp = cfv4_oep_base [chip->cfv4_oep_automaton_state] + cfv4_oep_translate [insn_code];
        if (cfv4_oep_check [temp] != chip->cfv4_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv4_oep_automaton_state = cfv4_oep_transitions [temp];

        temp = cfv123_guess_transitions [cfv123_guess_translate [insn_code] + chip->cfv123_guess_automaton_state * 3];
        if (temp >= 2)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_guess_automaton_state = temp;

        temp = cf_mac_transitions [cf_mac_translate [insn_code] + chip->cf_mac_automaton_state * 8];
        if (temp >= 64)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cf_mac_automaton_state = temp;

        temp = cfv123_mem_base [chip->cfv123_mem_automaton_state] + cfv123_mem_translate [insn_code];
        if (cfv123_mem_check [temp] != chip->cfv123_mem_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_mem_automaton_state = cfv123_mem_transitions [temp];

        temp = cfv123_chr_transitions [cfv123_chr_translate [insn_code] + chip->cfv123_chr_automaton_state * 8];
        if (temp >= 15)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_chr_automaton_state = temp;

        temp = cfv123_oep_base [chip->cfv123_oep_automaton_state] + cfv123_oep_translate [insn_code];
        if (cfv123_oep_check [temp] != chip->cfv123_oep_automaton_state)
          return internal_min_issue_delay (insn_code, chip);
        else
          _cfv123_oep_automaton_state = cfv123_oep_transitions [temp];

        temp = cfv123_ib_transitions [cfv123_ib_translate [insn_code] + chip->cfv123_ib_automaton_state * 6];
        if (temp >= 6)
          return internal_min_issue_delay (insn_code, chip);
        else
          chip->cfv123_ib_automaton_state = temp;
        chip->cfv4_guess_automaton_state = _cfv4_guess_automaton_state;
        chip->cfv4_fp_automaton_state = _cfv4_fp_automaton_state;
        chip->cfv4_emac_automaton_state = _cfv4_emac_automaton_state;
        chip->cfv4_mem_automaton_state = _cfv4_mem_automaton_state;
        chip->cfv4_oep_automaton_state = _cfv4_oep_automaton_state;
        chip->cfv123_guess_automaton_state = _cfv123_guess_automaton_state;
        chip->cf_mac_automaton_state = _cf_mac_automaton_state;
        chip->cfv123_mem_automaton_state = _cfv123_mem_automaton_state;
        chip->cfv123_chr_automaton_state = _cfv123_chr_automaton_state;
        chip->cfv123_oep_automaton_state = _cfv123_oep_automaton_state;
        return -1;
      }

    default:
      return -1;
    }
}


static int *dfa_insn_codes;

static int dfa_insn_codes_length;

static void
dfa_insn_code_enlarge (int uid)
{
  int i = dfa_insn_codes_length;
  dfa_insn_codes_length = 2 * uid;
  dfa_insn_codes = XRESIZEVEC (int, dfa_insn_codes,
                 dfa_insn_codes_length);
  for (; i < dfa_insn_codes_length; i++)
    dfa_insn_codes[i] = -1;
}

static inline int
dfa_insn_code (rtx_insn *insn)
{
  int uid = INSN_UID (insn);
  int insn_code;

  if (uid >= dfa_insn_codes_length)
    dfa_insn_code_enlarge (uid);

  insn_code = dfa_insn_codes[uid];
  if (insn_code < 0)
    {
      insn_code = internal_dfa_insn_code (insn);
      dfa_insn_codes[uid] = insn_code;
    }
  return insn_code;
}

int
state_transition (state_t state, rtx insn)
{
  int insn_code;

  if (insn == 0)
    insn_code = DFA__ADVANCE_CYCLE;
  else
    {
      insn_code = dfa_insn_code (as_a <rtx_insn *> (insn));
      if (insn_code > DFA__ADVANCE_CYCLE)
        return -1;
    }
  return internal_state_transition (insn_code, (struct DFA_chip *) state);
}

int
min_issue_delay (state_t state, rtx_insn *insn)
{
  int insn_code;

  if (insn != 0)
    {
      insn_code = dfa_insn_code (insn);
      if (insn_code > DFA__ADVANCE_CYCLE)
        return 0;
    }
  else
    insn_code = DFA__ADVANCE_CYCLE;

  return internal_min_issue_delay (insn_code, (struct DFA_chip *) state);
}

static int
internal_state_dead_lock_p (struct DFA_chip *ARG_UNUSED (chip))
{
  return 0/* FALSE */;
}

int
state_dead_lock_p (state_t state)
{
  return internal_state_dead_lock_p ((struct DFA_chip *) state);
}

int
state_size (void)
{
  return sizeof (struct DFA_chip);
}

static inline void
internal_reset (struct DFA_chip *chip)
{
  memset (chip, 0, sizeof (struct DFA_chip));
}

void
state_reset (state_t state)
{
  internal_reset ((struct DFA_chip *) state);
}

int
min_insn_conflict_delay (state_t state, rtx_insn *insn, rtx_insn *insn2)
{
  struct DFA_chip DFA_chip;
  int insn_code, insn2_code, transition;
  gcc_checking_assert (insn != 0);
  insn_code = dfa_insn_code (insn);
  if (insn_code >= DFA__ADVANCE_CYCLE)
    return 0;
  gcc_checking_assert (insn2 != 0);
  insn2_code = dfa_insn_code (insn2);
  if (insn2_code >= DFA__ADVANCE_CYCLE)
    return 0;
  memcpy (&DFA_chip, state, sizeof (DFA_chip));
  internal_reset (&DFA_chip);
  transition = internal_state_transition (insn_code, &DFA_chip);
  gcc_assert (transition <= 0);
  return internal_min_issue_delay (insn2_code, &DFA_chip);
}

  static const unsigned char default_latencies[] =
    {
        0,   1,   1,   1,   3,   3,   3,   2,
        2,   2,   3,   3,   3,   2,   2,   2,
        4,   4,   4,   3,   3,   3,   4,   4,
        3,   3,   4,   4,   3,   3,   5,   5,
        4,   4,   1,   1,   1,   1,   1,   1,
        2,   2,   2,   2,   1,   1,   1,   1,
        1,   1,   1,   1,   1,   1,   1,   1,
        1,   1,   1,   1,   1,   1,   2,   2,
        2,   2,   2,   2,   2,   2,   2,   2,
        2,   2,   2,   2,   2,   2,   2,   2,
        2,   2,   2,   2,   2,   2,   1,   1,
        1,   2,   2,   1,   1,   1,   1,   1,
        1,   2,   2,   2,   2,  18,  18,  18,
        9,   9,   9,  20,  20,  20,  21,  21,
       21,  11,  11,  11,  12,  12,  12,  12,
       12,  13,  13,   5,   5,   5,   3,   3,
        3,   7,   7,   7,   8,   8,   8,   5,
        5,   5,   6,   6,   6,   6,   6,   7,
        7,   4,   4,   4,   6,   6,   6,   7,
        7,   7,   6,   6,   6,   7,   7,   7,
        7,   7,   8,   8,   5,   8,   3,   3,
        3,   1,   1,   1,   2,   2,   2,   1,
        1,   1,   2,   2,   2,   1,   1,   1,
        3,   3,   3,   5,   5,   5,   2,   3,
        3,   1,   1,   1,   1,   1,   4,   4,
        4,   3,   5,   4,   1,   2,   1,   2,
        2,   1,   1,   2,   2,  20,  20,  21,
       35,  35,   7,   7,   8,   7,   7,   4,
        4,   1,  23,  23,  56,  56,   0,   2,
        1,   5,   2,   1,  10,   0,
    };
static int
internal_insn_latency (int insn_code ATTRIBUTE_UNUSED, int insn2_code ATTRIBUTE_UNUSED,
	rtx_insn *insn ATTRIBUTE_UNUSED, rtx_insn *insn2 ATTRIBUTE_UNUSED)
{
  switch (insn_code)
    {
    case 193:
      switch (insn2_code)
        {
        case 202:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        case 203:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        }
      break;
    case 194:
      switch (insn2_code)
        {
        case 202:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        case 203:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        }
      break;
    case 195:
      switch (insn2_code)
        {
        case 202:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        case 203:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        }
      break;
    case 196:
      switch (insn2_code)
        {
        case 193:
          return 0;
        case 194:
          return 0;
        case 196:
          return 0;
        case 197:
          return 0;
        case 199:
          return 0;
        case 202:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        case 203:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        }
      break;
    case 197:
      switch (insn2_code)
        {
        case 202:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        case 203:
          if (m68k_sched_indexed_address_bypass_p (insn, insn2))
            return 4;
          break;
        }
      break;
    case 198:
      switch (insn2_code)
        {
        case 198:
          return 1;
        case 199:
          return 1;
        case 200:
          if (!m68k_sched_address_bypass_p (insn, insn2))
            return 1;
          break;
        case 201:
          if (!m68k_sched_address_bypass_p (insn, insn2))
            return 1;
          break;
        case 202:
          if (!m68k_sched_address_bypass_p (insn, insn2))
            return 1;
          break;
        case 203:
          if (!m68k_sched_address_bypass_p (insn, insn2))
            return 1;
          break;
        }
      break;
    case 201:
      switch (insn2_code)
        {
        case 193:
          return 0;
        case 194:
          return 0;
        case 196:
          return 0;
        case 197:
          return 0;
        case 199:
          return 0;
        }
      break;
    case 203:
      switch (insn2_code)
        {
        case 193:
          return 0;
        case 194:
          return 0;
        case 196:
          return 0;
        case 197:
          return 0;
        case 199:
          return 0;
        }
      break;
    }
  return default_latencies[insn_code];
}

int
insn_latency (rtx_insn *insn, rtx_insn *insn2)
{
  int insn_code, insn2_code;
  gcc_checking_assert (insn != 0);
  insn_code = dfa_insn_code (insn);
  if (insn_code >= DFA__ADVANCE_CYCLE)
    return 0;
  gcc_checking_assert (insn2 != 0);
  insn2_code = dfa_insn_code (insn2);
  if (insn2_code >= DFA__ADVANCE_CYCLE)
    return 0;
  return internal_insn_latency (insn_code, insn2_code, insn, insn2);
}

static int
internal_maximal_insn_latency (int insn_code ATTRIBUTE_UNUSED)
{
  switch (insn_code)
    {
    case 193: { return 4; }
      break;
    case 194: { return 4; }
      break;
    case 195: { return 4; }
      break;
    case 196: { return 4; }
      break;
    case 197: { return 4; }
      break;
    case 198: { return 4; }
      break;
    case 201: { return 3; }
      break;
    case 203: { return 4; }
      break;
    }
  return default_latencies[insn_code];
}

int
maximal_insn_latency (rtx_insn *insn)
{
  int insn_code;
  gcc_checking_assert (insn != 0);
  insn_code = dfa_insn_code (insn);
  if (insn_code >= DFA__ADVANCE_CYCLE)
    return 0;
  return internal_maximal_insn_latency (insn_code);
}

void
print_reservation (FILE *f, rtx_insn *insn ATTRIBUTE_UNUSED)
{
  static const char *const reservation_names[] =
    {
      "cf_ib_w3|cf_ib_w2|cf_ib_w1",
      "(cf_ib1+cfv123_alu_00)",
      "(cf_ib2+cfv123_alu_00)",
      "(cf_ib3+cfv123_alu_00)",
      "(cf_ib1+cfv12_alu_10)",
      "(cf_ib2+cfv12_alu_10)",
      "(cf_ib3+cfv12_alu_10)",
      "(cf_ib1+cfv12_omove_10)",
      "(cf_ib2+cfv12_omove_10)",
      "(cf_ib3+cfv12_omove_10)",
      "(cf_ib1+cfv12_alu_10)",
      "(cf_ib2+cfv12_alu_10)",
      "(cf_ib3+cfv12_alu_10)",
      "(cf_ib1+cfv12_omove_10)",
      "(cf_ib2+cfv12_omove_10)",
      "(cf_ib3+cfv12_omove_10)",
      "(cf_ib1+cfv3_alu_10)",
      "(cf_ib2+cfv3_alu_10)",
      "(cf_ib3+cfv3_alu_10)",
      "(cf_ib1+cfv3_omove_10)",
      "(cf_ib2+cfv3_omove_10)",
      "(cf_ib3+cfv3_omove_10)",
      "(cf_ib2+cfv12_alu_i0)",
      "(cf_ib3+cfv12_alu_i0)",
      "(cf_ib2+cfv12_omove_i0)",
      "(cf_ib3+cfv12_omove_i0)",
      "(cf_ib2+cfv12_alu_i0)",
      "(cf_ib3+cfv12_alu_i0)",
      "(cf_ib2+cfv12_omove_i0)",
      "(cf_ib3+cfv12_omove_i0)",
      "(cf_ib2+cfv3_alu_i0)",
      "(cf_ib3+cfv3_alu_i0)",
      "(cf_ib2+cfv3_omove_i0)",
      "(cf_ib3+cfv3_omove_i0)",
      "(cf_ib1+cfv12_alu_01)",
      "(cf_ib2+cfv12_alu_01)",
      "(cf_ib3+cfv12_alu_01)",
      "(cf_ib1+cfv3_alu_01)",
      "(cf_ib2+cfv3_alu_01)",
      "(cf_ib3+cfv3_alu_01)",
      "(cf_ib2+cfv12_alu_0i)",
      "(cf_ib3+cfv12_alu_0i)",
      "(cf_ib2+cfv3_alu_0i)",
      "(cf_ib3+cfv3_alu_0i)",
      "(cf_ib1+cfv12_alu_11)",
      "(cf_ib2+cfv12_alu_11)",
      "(cf_ib3+cfv12_alu_11)",
      "(cf_ib1+cfv12_omove_11)",
      "(cf_ib2+cfv12_omove_11)",
      "(cf_ib3+cfv12_omove_11)",
      "(cf_ib1+cfv12_alu_11)",
      "(cf_ib2+cfv12_alu_11)",
      "(cf_ib3+cfv12_alu_11)",
      "(cf_ib1+cfv12_omove_11)",
      "(cf_ib2+cfv12_omove_11)",
      "(cf_ib3+cfv12_omove_11)",
      "(cf_ib1+cfv3_alu_11)",
      "(cf_ib2+cfv3_alu_11)",
      "(cf_ib3+cfv3_alu_11)",
      "(cf_ib1+cfv3_omove_11)",
      "(cf_ib2+cfv3_omove_11)",
      "(cf_ib3+cfv3_omove_11)",
      "(cf_ib2+cfv12_alu_i1)",
      "(cf_ib3+cfv12_alu_i1)",
      "(cf_ib2+cfv12_omove_i1)",
      "(cf_ib3+cfv12_omove_i1)",
      "(cf_ib2+cfv12_alu_i1)",
      "(cf_ib3+cfv12_alu_i1)",
      "(cf_ib2+cfv12_omove_i1)",
      "(cf_ib3+cfv12_omove_i1)",
      "(cf_ib2+cfv3_alu_i1)",
      "(cf_ib3+cfv3_alu_i1)",
      "(cf_ib2+cfv3_omove_i1)",
      "(cf_ib3+cfv3_omove_i1)",
      "(cf_ib2+cfv12_alu_1i)",
      "(cf_ib3+cfv12_alu_1i)",
      "(cf_ib2+cfv12_omove_1i)",
      "(cf_ib3+cfv12_omove_1i)",
      "(cf_ib2+cfv12_alu_1i)",
      "(cf_ib3+cfv12_alu_1i)",
      "(cf_ib2+cfv12_omove_1i)",
      "(cf_ib3+cfv12_omove_1i)",
      "(cf_ib2+cfv3_alu_1i)",
      "(cf_ib3+cfv3_alu_1i)",
      "(cf_ib2+cfv3_omove_1i)",
      "(cf_ib3+cfv3_omove_1i)",
      "(cf_ib1+cfv123_lea_10)",
      "(cf_ib2+cfv123_lea_10)",
      "(cf_ib3+cfv123_lea_10)",
      "(cf_ib2+cfv123_lea_i0)",
      "(cf_ib3+cfv123_lea_i0)",
      "(cf_ib1+cfv12_pea_11)",
      "(cf_ib2+cfv12_pea_11)",
      "(cf_ib3+cfv12_pea_11)",
      "(cf_ib1+cfv3_pea_11)",
      "(cf_ib2+cfv3_pea_11)",
      "(cf_ib3+cfv3_pea_11)",
      "(cf_ib2+cfv12_pea_i1)",
      "(cf_ib3+cfv12_pea_i1)",
      "(cf_ib2+cfv3_pea_i1)",
      "(cf_ib3+cfv3_pea_i1)",
      "(cf_ib1+cfv123_mul_l_00)",
      "(cf_ib2+cfv123_mul_l_00)",
      "(cf_ib3+cfv123_mul_l_00)",
      "(cf_ib1+cfv123_mul_w_00)",
      "(cf_ib2+cfv123_mul_w_00)",
      "(cf_ib3+cfv123_mul_w_00)",
      "(cf_ib1+cfv12_mul_l_10)",
      "(cf_ib2+cfv12_mul_l_10)",
      "(cf_ib3+cfv12_mul_l_10)",
      "(cf_ib1+cfv3_mul_l_10)",
      "(cf_ib2+cfv3_mul_l_10)",
      "(cf_ib3+cfv3_mul_l_10)",
      "(cf_ib1+cfv12_mul_w_10)",
      "(cf_ib2+cfv12_mul_w_10)",
      "(cf_ib3+cfv12_mul_w_10)",
      "(cf_ib1+cfv3_mul_w_10)",
      "(cf_ib2+cfv3_mul_w_10)",
      "(cf_ib3+cfv3_mul_w_10)",
      "(cf_ib2+cfv12_mul_w_i0)",
      "(cf_ib3+cfv12_mul_w_i0)",
      "(cf_ib2+cfv3_mul_w_i0)",
      "(cf_ib3+cfv3_mul_w_i0)",
      "(cf_ib1+cfv123_mac_l_00)",
      "(cf_ib2+cfv123_mac_l_00)",
      "(cf_ib3+cfv123_mac_l_00)",
      "(cf_ib1+cfv123_mac_w_00)",
      "(cf_ib2+cfv123_mac_w_00)",
      "(cf_ib3+cfv123_mac_w_00)",
      "(cf_ib1+cfv12_mac_l_10)",
      "(cf_ib2+cfv12_mac_l_10)",
      "(cf_ib3+cfv12_mac_l_10)",
      "(cf_ib1+cfv3_mac_l_10)",
      "(cf_ib2+cfv3_mac_l_10)",
      "(cf_ib3+cfv3_mac_l_10)",
      "(cf_ib1+cfv12_mac_w_10)",
      "(cf_ib2+cfv12_mac_w_10)",
      "(cf_ib3+cfv12_mac_w_10)",
      "(cf_ib1+cfv3_mac_w_10)",
      "(cf_ib2+cfv3_mac_w_10)",
      "(cf_ib3+cfv3_mac_w_10)",
      "(cf_ib2+cfv12_mac_w_i0)",
      "(cf_ib3+cfv12_mac_w_i0)",
      "(cf_ib2+cfv3_mac_w_i0)",
      "(cf_ib3+cfv3_mac_w_i0)",
      "(cf_ib1+cfv123_emac_00)",
      "(cf_ib2+cfv123_emac_00)",
      "(cf_ib3+cfv123_emac_00)",
      "(cf_ib1+cfv12_emac_10)",
      "(cf_ib2+cfv12_emac_10)",
      "(cf_ib3+cfv12_emac_10)",
      "(cf_ib1+cfv3_emac_10)",
      "(cf_ib2+cfv3_emac_10)",
      "(cf_ib3+cfv3_emac_10)",
      "(cf_ib1+cfv12_emac_10)",
      "(cf_ib2+cfv12_emac_10)",
      "(cf_ib3+cfv12_emac_10)",
      "(cf_ib1+cfv3_emac_10)",
      "(cf_ib2+cfv3_emac_10)",
      "(cf_ib3+cfv3_emac_10)",
      "(cf_ib2+cfv12_emac_w_i0)",
      "(cf_ib3+cfv12_emac_w_i0)",
      "(cf_ib2+cfv3_emac_w_i0)",
      "(cf_ib3+cfv3_emac_w_i0)",
      "(cf_ib1+cfv12_rts)",
      "(cf_ib1+cfv3_rts)",
      "(cf_ib1+cfv12_call)",
      "(cf_ib2+cfv12_call)",
      "(cf_ib3+cfv12_call)",
      "(cf_ib1+cfv3_call)",
      "(cf_ib2+cfv3_call)",
      "(cf_ib3+cfv3_call)",
      "(cf_ib1+cfv12_bcc)",
      "(cf_ib2+cfv12_bcc)",
      "(cf_ib3+cfv12_bcc)",
      "(cf_ib1+cfv3_bcc)",
      "(cf_ib2+cfv3_bcc)",
      "(cf_ib3+cfv3_bcc)",
      "(cf_ib1+cfv12_bra)",
      "(cf_ib2+cfv12_bra)",
      "(cf_ib3+cfv12_bra)",
      "(cf_ib1+cfv3_bra)",
      "(cf_ib2+cfv3_bra)",
      "(cf_ib3+cfv3_bra)",
      "(cf_ib1+cfv12_jmp)",
      "(cf_ib2+cfv12_jmp)",
      "(cf_ib3+cfv12_jmp)",
      "(cf_ib1+cfv3_jmp)",
      "(cf_ib2+cfv3_jmp)",
      "(cf_ib3+cfv3_jmp)",
      "(cf_ib1+cfv12_alu_10)",
      "(cf_ib1+cfv3_alu_10)",
      "(cf_ib3+cfv123_guess+cf_dsoc+cf_agex+cf_mem)",
      "cfv4_sOEP1|cfv4_sOEP3|(cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex)",
      "cfv4_sOEP1|cfv4_sOEP2|(cfv4_pOEP3,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex)",
      "cfv4_pOEP3,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex",
      "cfv4_sOEP1|(cfv4_pOEP1,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex)",
      "cfv4_sOEP1|cfv4_sOEP2|cfv4_sOEP3|(cfv4_pOEP3,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex)",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex",
      "cfv4_sOEP1|cfv4_sOEP3|(cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex)",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex",
      "cfv4_pOEP1,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex",
      "cfv4_ds,cfv4_oag,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex",
      "cfv4_ds,cfv4_oag,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex",
      "cfv4_pOEP2,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_pOEP2,cfv4_oag,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_ds,cfv4_oag,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_ds,cfv4_oag,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_pOEP2,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_pOEP2,cfv4_oag,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_ex,cfv4_da,cfv4_mem",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex*15",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex*15",
      "cfv4_ds,cfv4_oag,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex*15",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex*30",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex*30",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_emac",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_emac",
      "cfv4_ds,cfv4_oag,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_emac",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_fp",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_fp",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_fp",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_fp",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_fp,cfv4_da,cfv4_mem",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_fp*17",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_fp*17",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_fp*50",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,cfv4_fp*50",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex,cfv4_fp",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex",
      "cfv4_ds,cfv4_oag,cfv4_oc1,cfv4_oc2,cfv4_ex",
      "cfv4_ds,cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex",
      "(cfv4_ds+cfv4_oag+cfv4_oc1+cfv4_mem+cfv4_oc2+cfv4_ex)",
      "(cfv4_guess+cfv4_ds),cfv4_oag,(cfv4_oc1+cfv4_mem),cfv4_oc2,cfv4_ex,(cfv4_emac+cfv4_fp)",
      "nothing",
      "nothing"
    };
  int insn_code;

  if (insn == 0)
    insn_code = DFA__ADVANCE_CYCLE;
  else
    {
      insn_code = dfa_insn_code (insn);
      if (insn_code > DFA__ADVANCE_CYCLE)
        insn_code = DFA__ADVANCE_CYCLE;
    }
  fputs (reservation_names[insn_code], f);
}


#if CPU_UNITS_QUERY

int
get_cpu_unit_code (const char *cpu_unit_name)
{
  struct name_code {const char *name; int code;};
  int cmp, l, m, h;
  static struct name_code name_code_table [] =
    {
      {"cf_mem1", 0},
      {"cf_mem2", 1},
      {"cfv123_guess", 2},
      {"cfv4_guess", 3},
    };

  /* The following is binary search: */
  l = 0;
  h = sizeof (name_code_table) / sizeof (struct name_code) - 1;
  while (l <= h)
    {
      m = (l + h) / 2;
      cmp = strcmp (cpu_unit_name, name_code_table [m].name);
      if (cmp < 0)
        h = m - 1;
      else if (cmp > 0)
        l = m + 1;
      else
        return name_code_table [m].code;
    }
  return -1;
}

int
cpu_unit_reservation_p (state_t state, int cpu_unit_code)
{
  gcc_assert (cpu_unit_code >= 0 && cpu_unit_code < 4);
  if ((cfv123_ib_reserved_units [((struct DFA_chip *) state)->cfv123_ib_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv123_oep_reserved_units [((struct DFA_chip *) state)->cfv123_oep_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv123_chr_reserved_units [((struct DFA_chip *) state)->cfv123_chr_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv123_mem_reserved_units [((struct DFA_chip *) state)->cfv123_mem_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cf_mac_reserved_units [((struct DFA_chip *) state)->cf_mac_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv123_guess_reserved_units [((struct DFA_chip *) state)->cfv123_guess_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv4_oep_reserved_units [((struct DFA_chip *) state)->cfv4_oep_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv4_mem_reserved_units [((struct DFA_chip *) state)->cfv4_mem_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv4_emac_reserved_units [((struct DFA_chip *) state)->cfv4_emac_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv4_fp_reserved_units [((struct DFA_chip *) state)->cfv4_fp_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  if ((cfv4_guess_reserved_units [((struct DFA_chip *) state)->cfv4_guess_automaton_state * 1 + cpu_unit_code / 8] >> (cpu_unit_code % 8)) & 1)
    return 1;
  return 0;
}

bool
insn_has_dfa_reservation_p (rtx_insn *insn ATTRIBUTE_UNUSED)
{
  int insn_code;

  if (insn == 0)
    insn_code = DFA__ADVANCE_CYCLE;
  else
    {
      insn_code = dfa_insn_code (insn);
      if (insn_code > DFA__ADVANCE_CYCLE)
        insn_code = DFA__ADVANCE_CYCLE;
    }

  return insn_code != DFA__ADVANCE_CYCLE;
}


#endif /* #if CPU_UNITS_QUERY */

void
dfa_clean_insn_cache (void)
{
  int i;

  for (i = 0; i < dfa_insn_codes_length; i++)
    dfa_insn_codes [i] = -1;
}

void
dfa_clear_single_insn_cache (rtx_insn *insn)
{
  int i;

  i = INSN_UID (insn);
  if (i < dfa_insn_codes_length)
    dfa_insn_codes [i] = -1;
}

void
dfa_start (void)
{
  dfa_insn_codes_length = get_max_uid ();
  dfa_insn_codes = XNEWVEC (int, dfa_insn_codes_length);
  dfa_clean_insn_cache ();
}

void
dfa_finish (void)
{
  free (dfa_insn_codes);
}

