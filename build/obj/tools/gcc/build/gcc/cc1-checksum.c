#include "config.h"
#include "system.h"
EXPORTED_CONST unsigned char executable_checksum[16] = { 0x59, 0x72, 0x81, 0x08, 0x3d, 0xe9, 0x5e, 0x54, 0xea, 0x62, 0x5b, 0x9e, 0x15, 0x23, 0x0a, 0xe5 };
