#include "config.h"
#include "system.h"
EXPORTED_CONST unsigned char executable_checksum[16] = { 0xc1, 0x5d, 0x9c, 0x79, 0xc3, 0xc9, 0xee, 0x1a, 0x65, 0xb3, 0x86, 0x8c, 0x08, 0x32, 0x49, 0x08 };
