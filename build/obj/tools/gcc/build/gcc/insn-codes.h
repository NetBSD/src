/* Generated automatically by the program `gencodes'
   from the machine description file `md'.  */

#ifndef GCC_INSN_CODES_H
#define GCC_INSN_CODES_H

enum insn_code {
  CODE_FOR_nothing = 0,
  CODE_FOR_pushdi = 2,
  CODE_FOR_beq0_di = 3,
  CODE_FOR_bne0_di = 4,
  CODE_FOR_cbranchdi4_insn = 5,
  CODE_FOR_cbranchqi4_insn = 6,
  CODE_FOR_cbranchhi4_insn = 7,
  CODE_FOR_cbranchsi4_insn = 8,
  CODE_FOR_cbranchqi4_insn_rev = 9,
  CODE_FOR_cbranchhi4_insn_rev = 10,
  CODE_FOR_cbranchsi4_insn_rev = 11,
  CODE_FOR_cbranchqi4_insn_cf = 12,
  CODE_FOR_cbranchhi4_insn_cf = 13,
  CODE_FOR_cbranchsi4_insn_cf = 14,
  CODE_FOR_cbranchqi4_insn_cf_rev = 15,
  CODE_FOR_cbranchhi4_insn_cf_rev = 16,
  CODE_FOR_cbranchsi4_insn_cf_rev = 17,
  CODE_FOR_cstoreqi4_insn = 18,
  CODE_FOR_cstorehi4_insn = 19,
  CODE_FOR_cstoresi4_insn = 20,
  CODE_FOR_cstoreqi4_insn_cf = 21,
  CODE_FOR_cstorehi4_insn_cf = 22,
  CODE_FOR_cstoresi4_insn_cf = 23,
  CODE_FOR_cbranchsi4_btst_mem_insn = 24,
  CODE_FOR_cbranchsi4_btst_reg_insn = 25,
  CODE_FOR_cbranchsi4_btst_mem_insn_1 = 26,
  CODE_FOR_cbranchsi4_btst_reg_insn_1 = 27,
  CODE_FOR_cbranch_bftstqi_insn = 28,
  CODE_FOR_cbranch_bftstsi_insn = 29,
  CODE_FOR_cstore_bftstqi_insn = 30,
  CODE_FOR_cstore_bftstsi_insn = 31,
  CODE_FOR_cbranchsf4_insn_68881 = 32,
  CODE_FOR_cbranchdf4_insn_68881 = 33,
  CODE_FOR_cbranchxf4_insn_68881 = 34,
  CODE_FOR_cbranchsf4_insn_cf = 35,
  CODE_FOR_cbranchdf4_insn_cf = 36,
  CODE_FOR_cbranchxf4_insn_cf = 37,
  CODE_FOR_cbranchsf4_insn_rev_68881 = 38,
  CODE_FOR_cbranchdf4_insn_rev_68881 = 39,
  CODE_FOR_cbranchxf4_insn_rev_68881 = 40,
  CODE_FOR_cbranchsf4_insn_rev_cf = 41,
  CODE_FOR_cbranchdf4_insn_rev_cf = 42,
  CODE_FOR_cbranchxf4_insn_rev_cf = 43,
  CODE_FOR_cstoresf4_insn_68881 = 44,
  CODE_FOR_cstoredf4_insn_68881 = 45,
  CODE_FOR_cstorexf4_insn_68881 = 46,
  CODE_FOR_cstoresf4_insn_cf = 47,
  CODE_FOR_cstoredf4_insn_cf = 48,
   CODE_FOR_cstorexf4_insn_cf = CODE_FOR_nothing,
  CODE_FOR_pushexthisi_const = 49,
  CODE_FOR_movsf_cf_soft = 66,
  CODE_FOR_movsf_cf_hard = 67,
  CODE_FOR_movdf_cf_soft = 69,
  CODE_FOR_movdf_cf_hard = 70,
  CODE_FOR_pushasi = 76,
  CODE_FOR_truncsiqi2 = 77,
  CODE_FOR_trunchiqi2 = 78,
  CODE_FOR_truncsihi2 = 79,
  CODE_FOR_zero_extendqidi2 = 82,
  CODE_FOR_zero_extendhidi2 = 83,
  CODE_FOR_zero_extendhisi2 = 86,
  CODE_FOR_zero_extendqisi2 = 89,
  CODE_FOR_extendqidi2 = 90,
  CODE_FOR_extendhidi2 = 91,
  CODE_FOR_extendsidi2 = 92,
  CODE_FOR_extendplussidi = 93,
  CODE_FOR_extendqihi2 = 96,
  CODE_FOR_extendsfdf2_cf = 100,
  CODE_FOR_truncdfsf2_cf = 102,
  CODE_FOR_floatsisf2_68881 = 104,
  CODE_FOR_floatsidf2_68881 = 105,
  CODE_FOR_floatsixf2_68881 = 106,
  CODE_FOR_floatsisf2_cf = 107,
  CODE_FOR_floatsidf2_cf = 108,
   CODE_FOR_floatsixf2_cf = CODE_FOR_nothing,
  CODE_FOR_floathisf2_68881 = 109,
  CODE_FOR_floathidf2_68881 = 110,
  CODE_FOR_floathixf2_68881 = 111,
  CODE_FOR_floathisf2_cf = 112,
  CODE_FOR_floathidf2_cf = 113,
   CODE_FOR_floathixf2_cf = CODE_FOR_nothing,
  CODE_FOR_floatqisf2_68881 = 114,
  CODE_FOR_floatqidf2_68881 = 115,
  CODE_FOR_floatqixf2_68881 = 116,
  CODE_FOR_floatqisf2_cf = 117,
  CODE_FOR_floatqidf2_cf = 118,
   CODE_FOR_floatqixf2_cf = CODE_FOR_nothing,
  CODE_FOR_fix_truncdfsi2 = 119,
  CODE_FOR_fix_truncdfhi2 = 120,
  CODE_FOR_fix_truncdfqi2 = 121,
  CODE_FOR_ftruncsf2_68881 = 122,
  CODE_FOR_ftruncdf2_68881 = 123,
  CODE_FOR_ftruncxf2_68881 = 124,
  CODE_FOR_ftruncsf2_cf = 125,
  CODE_FOR_ftruncdf2_cf = 126,
   CODE_FOR_ftruncxf2_cf = CODE_FOR_nothing,
  CODE_FOR_fixsfqi2_68881 = 127,
  CODE_FOR_fixdfqi2_68881 = 128,
  CODE_FOR_fixxfqi2_68881 = 129,
  CODE_FOR_fixsfqi2_cf = 130,
  CODE_FOR_fixdfqi2_cf = 131,
   CODE_FOR_fixxfqi2_cf = CODE_FOR_nothing,
  CODE_FOR_fixsfhi2_68881 = 132,
  CODE_FOR_fixdfhi2_68881 = 133,
  CODE_FOR_fixxfhi2_68881 = 134,
  CODE_FOR_fixsfhi2_cf = 135,
  CODE_FOR_fixdfhi2_cf = 136,
   CODE_FOR_fixxfhi2_cf = CODE_FOR_nothing,
  CODE_FOR_fixsfsi2_68881 = 137,
  CODE_FOR_fixdfsi2_68881 = 138,
  CODE_FOR_fixxfsi2_68881 = 139,
  CODE_FOR_fixsfsi2_cf = 140,
  CODE_FOR_fixdfsi2_cf = 141,
   CODE_FOR_fixxfsi2_cf = CODE_FOR_nothing,
  CODE_FOR_adddi_lshrdi_63 = 142,
  CODE_FOR_adddi_sexthishl32 = 143,
  CODE_FOR_adddi_dishl32 = 146,
  CODE_FOR_adddi3 = 147,
  CODE_FOR_addsi_lshrsi_31 = 148,
  CODE_FOR_addhi3 = 152,
  CODE_FOR_addqi3 = 155,
  CODE_FOR_addsf3_floatsi_68881 = 158,
  CODE_FOR_adddf3_floatsi_68881 = 159,
  CODE_FOR_addxf3_floatsi_68881 = 160,
  CODE_FOR_addsf3_floathi_68881 = 161,
  CODE_FOR_adddf3_floathi_68881 = 162,
  CODE_FOR_addxf3_floathi_68881 = 163,
  CODE_FOR_addsf3_floatqi_68881 = 164,
  CODE_FOR_adddf3_floatqi_68881 = 165,
  CODE_FOR_addxf3_floatqi_68881 = 166,
  CODE_FOR_addsf3_68881 = 167,
  CODE_FOR_adddf3_68881 = 168,
  CODE_FOR_addxf3_68881 = 169,
  CODE_FOR_addsf3_cf = 170,
  CODE_FOR_adddf3_cf = 171,
   CODE_FOR_addxf3_cf = CODE_FOR_nothing,
  CODE_FOR_subdi_sexthishl32 = 172,
  CODE_FOR_subdi_dishl32 = 173,
  CODE_FOR_subdi3 = 174,
  CODE_FOR_subsi3 = 175,
  CODE_FOR_subhi3 = 177,
  CODE_FOR_subqi3 = 179,
  CODE_FOR_subsf3_floatsi_68881 = 181,
  CODE_FOR_subdf3_floatsi_68881 = 182,
  CODE_FOR_subxf3_floatsi_68881 = 183,
  CODE_FOR_subsf3_floathi_68881 = 184,
  CODE_FOR_subdf3_floathi_68881 = 185,
  CODE_FOR_subxf3_floathi_68881 = 186,
  CODE_FOR_subsf3_floatqi_68881 = 187,
  CODE_FOR_subdf3_floatqi_68881 = 188,
  CODE_FOR_subxf3_floatqi_68881 = 189,
  CODE_FOR_subsf3_68881 = 190,
  CODE_FOR_subdf3_68881 = 191,
  CODE_FOR_subxf3_68881 = 192,
  CODE_FOR_subsf3_cf = 193,
  CODE_FOR_subdf3_cf = 194,
   CODE_FOR_subxf3_cf = CODE_FOR_nothing,
  CODE_FOR_mulhi3 = 195,
  CODE_FOR_mulhisi3 = 196,
  CODE_FOR_umulhisi3 = 200,
  CODE_FOR_const_umulsi3_highpart = 207,
  CODE_FOR_const_smulsi3_highpart = 209,
  CODE_FOR_mulsf3_floatsi_68881 = 210,
  CODE_FOR_muldf3_floatsi_68881 = 211,
  CODE_FOR_mulxf3_floatsi_68881 = 212,
  CODE_FOR_mulsf3_floathi_68881 = 213,
  CODE_FOR_muldf3_floathi_68881 = 214,
  CODE_FOR_mulxf3_floathi_68881 = 215,
  CODE_FOR_mulsf3_floatqi_68881 = 216,
  CODE_FOR_muldf3_floatqi_68881 = 217,
  CODE_FOR_mulxf3_floatqi_68881 = 218,
  CODE_FOR_muldf_68881 = 219,
  CODE_FOR_mulsf_68881 = 220,
  CODE_FOR_mulxf3_68881 = 221,
  CODE_FOR_fmulsf3_cf = 222,
  CODE_FOR_fmuldf3_cf = 223,
   CODE_FOR_fmulxf3_cf = CODE_FOR_nothing,
  CODE_FOR_divsf3_floatsi_68881 = 224,
  CODE_FOR_divdf3_floatsi_68881 = 225,
  CODE_FOR_divxf3_floatsi_68881 = 226,
  CODE_FOR_divsf3_floathi_68881 = 227,
  CODE_FOR_divdf3_floathi_68881 = 228,
  CODE_FOR_divxf3_floathi_68881 = 229,
  CODE_FOR_divsf3_floatqi_68881 = 230,
  CODE_FOR_divdf3_floatqi_68881 = 231,
  CODE_FOR_divxf3_floatqi_68881 = 232,
  CODE_FOR_divsf3_68881 = 233,
  CODE_FOR_divdf3_68881 = 234,
  CODE_FOR_divxf3_68881 = 235,
  CODE_FOR_divsf3_cf = 236,
  CODE_FOR_divdf3_cf = 237,
   CODE_FOR_divxf3_cf = CODE_FOR_nothing,
  CODE_FOR_divmodhi4 = 242,
  CODE_FOR_udivmodhi4 = 243,
  CODE_FOR_andsi3_internal = 245,
  CODE_FOR_andsi3_5200 = 246,
  CODE_FOR_andhi3 = 247,
  CODE_FOR_andqi3 = 250,
  CODE_FOR_iordi_zext = 253,
  CODE_FOR_iorsi3_internal = 254,
  CODE_FOR_iorsi3_5200 = 255,
  CODE_FOR_iorhi3 = 256,
  CODE_FOR_iorqi3 = 259,
  CODE_FOR_iorsi_zexthi_ashl16 = 262,
  CODE_FOR_iorsi_zext = 263,
  CODE_FOR_xorsi3_internal = 264,
  CODE_FOR_xorsi3_5200 = 265,
  CODE_FOR_xorhi3 = 266,
  CODE_FOR_xorqi3 = 269,
  CODE_FOR_negdi2_internal = 272,
  CODE_FOR_negdi2_5200 = 273,
  CODE_FOR_negsi2_internal = 274,
  CODE_FOR_negsi2_5200 = 275,
  CODE_FOR_neghi2 = 276,
  CODE_FOR_negqi2 = 278,
  CODE_FOR_negsf2_68881 = 280,
  CODE_FOR_negdf2_68881 = 281,
  CODE_FOR_negxf2_68881 = 282,
  CODE_FOR_negsf2_cf = 283,
  CODE_FOR_negdf2_cf = 284,
   CODE_FOR_negxf2_cf = CODE_FOR_nothing,
  CODE_FOR_sqrtsf2_68881 = 285,
  CODE_FOR_sqrtdf2_68881 = 286,
  CODE_FOR_sqrtxf2_68881 = 287,
  CODE_FOR_sqrtsf2_cf = 288,
  CODE_FOR_sqrtdf2_cf = 289,
   CODE_FOR_sqrtxf2_cf = CODE_FOR_nothing,
  CODE_FOR_abssf2_68881 = 290,
  CODE_FOR_absdf2_68881 = 291,
  CODE_FOR_absxf2_68881 = 292,
  CODE_FOR_abssf2_cf = 293,
  CODE_FOR_absdf2_cf = 294,
   CODE_FOR_absxf2_cf = CODE_FOR_nothing,
  CODE_FOR_one_cmplsi2_internal = 297,
  CODE_FOR_one_cmplsi2_5200 = 298,
  CODE_FOR_one_cmplhi2 = 299,
  CODE_FOR_one_cmplqi2 = 301,
  CODE_FOR_ashldi_extsi = 303,
  CODE_FOR_ashldi_sexthi = 304,
  CODE_FOR_ashlsi_16 = 308,
  CODE_FOR_ashlsi_17_24 = 309,
  CODE_FOR_ashlsi3 = 310,
  CODE_FOR_ashlhi3 = 311,
  CODE_FOR_ashlqi3 = 313,
  CODE_FOR_ashrsi_16 = 315,
  CODE_FOR_subreghi1ashrdi_const32 = 317,
  CODE_FOR_subregsi1ashrdi_const32 = 318,
  CODE_FOR_ashrdi_const = 322,
  CODE_FOR_ashrsi_31 = 323,
  CODE_FOR_ashrsi3 = 324,
  CODE_FOR_ashrhi3 = 325,
  CODE_FOR_ashrqi3 = 327,
  CODE_FOR_subreg1lshrdi_const32 = 329,
  CODE_FOR_lshrsi_31 = 334,
  CODE_FOR_lshrsi_16 = 335,
  CODE_FOR_lshrsi_17_24 = 336,
  CODE_FOR_lshrsi3 = 337,
  CODE_FOR_lshrhi3 = 338,
  CODE_FOR_lshrqi3 = 340,
  CODE_FOR_rotlsi_16 = 342,
  CODE_FOR_rotlsi3 = 343,
  CODE_FOR_rotlhi3 = 344,
  CODE_FOR_rotlqi3 = 346,
  CODE_FOR_rotrsi3 = 348,
  CODE_FOR_rotrhi3 = 349,
  CODE_FOR_rotrhi_lowpart = 350,
  CODE_FOR_rotrqi3 = 351,
  CODE_FOR_bsetmemqi = 353,
  CODE_FOR_bclrmemqi = 358,
  CODE_FOR_scc0_di = 377,
  CODE_FOR_scc0_di_5200 = 378,
  CODE_FOR_scc_di = 379,
  CODE_FOR_scc_di_5200 = 380,
  CODE_FOR_jump = 381,
  CODE_FOR_blockage = 395,
  CODE_FOR_nop = 396,
  CODE_FOR_load_got = 404,
  CODE_FOR_indirect_jump = 405,
  CODE_FOR_extendsfxf2 = 407,
  CODE_FOR_extenddfxf2 = 408,
  CODE_FOR_truncxfdf2 = 409,
  CODE_FOR_truncxfsf2 = 410,
  CODE_FOR_sinsf2 = 411,
  CODE_FOR_sindf2 = 412,
  CODE_FOR_sinxf2 = 413,
  CODE_FOR_cossf2 = 414,
  CODE_FOR_cosdf2 = 415,
  CODE_FOR_cosxf2 = 416,
  CODE_FOR_trap = 417,
  CODE_FOR_ctrapqi4 = 418,
  CODE_FOR_ctraphi4 = 419,
  CODE_FOR_ctrapsi4 = 420,
  CODE_FOR_ctrapqi4_cf = 421,
  CODE_FOR_ctraphi4_cf = 422,
  CODE_FOR_ctrapsi4_cf = 423,
  CODE_FOR_stack_tie = 424,
  CODE_FOR_ib = 425,
  CODE_FOR_atomic_compare_and_swapqi_1 = 426,
  CODE_FOR_atomic_compare_and_swaphi_1 = 427,
  CODE_FOR_atomic_compare_and_swapsi_1 = 428,
  CODE_FOR_atomic_test_and_set_1 = 429,
  CODE_FOR_cbranchdi4 = 430,
  CODE_FOR_cstoredi4 = 431,
  CODE_FOR_cbranchqi4 = 432,
  CODE_FOR_cbranchhi4 = 433,
  CODE_FOR_cbranchsi4 = 434,
  CODE_FOR_cstoreqi4 = 435,
  CODE_FOR_cstorehi4 = 436,
  CODE_FOR_cstoresi4 = 437,
  CODE_FOR_cbranchsf4 = 438,
  CODE_FOR_cbranchdf4 = 439,
  CODE_FOR_cbranchxf4 = 440,
  CODE_FOR_cstoresf4 = 441,
  CODE_FOR_cstoredf4 = 442,
  CODE_FOR_cstorexf4 = 443,
  CODE_FOR_movsi = 444,
  CODE_FOR_movhi = 445,
  CODE_FOR_movstricthi = 446,
  CODE_FOR_movqi = 447,
  CODE_FOR_movstrictqi = 448,
  CODE_FOR_pushqi1 = 449,
  CODE_FOR_reload_insf = 450,
  CODE_FOR_reload_outsf = 451,
  CODE_FOR_movsf = 452,
  CODE_FOR_reload_indf = 453,
  CODE_FOR_reload_outdf = 454,
  CODE_FOR_movdf = 455,
  CODE_FOR_movxf = 456,
  CODE_FOR_movdi = 457,
  CODE_FOR_zero_extendsidi2 = 458,
  CODE_FOR_zero_extendqihi2 = 459,
  CODE_FOR_extendhisi2 = 460,
  CODE_FOR_extendqisi2 = 461,
  CODE_FOR_extendsfdf2 = 462,
  CODE_FOR_truncdfsf2 = 463,
  CODE_FOR_floatsisf2 = 464,
  CODE_FOR_floatsidf2 = 465,
  CODE_FOR_floatsixf2 = 466,
  CODE_FOR_floathisf2 = 467,
  CODE_FOR_floathidf2 = 468,
  CODE_FOR_floathixf2 = 469,
  CODE_FOR_floatqisf2 = 470,
  CODE_FOR_floatqidf2 = 471,
  CODE_FOR_floatqixf2 = 472,
  CODE_FOR_ftruncsf2 = 473,
  CODE_FOR_ftruncdf2 = 474,
  CODE_FOR_ftruncxf2 = 475,
  CODE_FOR_fixsfqi2 = 476,
  CODE_FOR_fixdfqi2 = 477,
  CODE_FOR_fixxfqi2 = 478,
  CODE_FOR_fixsfhi2 = 479,
  CODE_FOR_fixdfhi2 = 480,
  CODE_FOR_fixxfhi2 = 481,
  CODE_FOR_fixsfsi2 = 482,
  CODE_FOR_fixdfsi2 = 483,
  CODE_FOR_fixxfsi2 = 484,
  CODE_FOR_addsi3 = 485,
  CODE_FOR_addsf3 = 486,
  CODE_FOR_adddf3 = 487,
  CODE_FOR_addxf3 = 488,
  CODE_FOR_subsf3 = 489,
  CODE_FOR_subdf3 = 490,
  CODE_FOR_subxf3 = 491,
  CODE_FOR_mulsi3 = 492,
  CODE_FOR_umulsidi3 = 493,
  CODE_FOR_mulsidi3 = 494,
  CODE_FOR_umulsi3_highpart = 495,
  CODE_FOR_smulsi3_highpart = 496,
  CODE_FOR_mulsf3 = 497,
  CODE_FOR_muldf3 = 498,
  CODE_FOR_mulxf3 = 499,
  CODE_FOR_divsf3 = 500,
  CODE_FOR_divdf3 = 501,
  CODE_FOR_divxf3 = 502,
  CODE_FOR_divmodsi4 = 503,
  CODE_FOR_udivmodsi4 = 504,
  CODE_FOR_andsi3 = 505,
  CODE_FOR_iorsi3 = 506,
  CODE_FOR_xorsi3 = 507,
  CODE_FOR_negdi2 = 508,
  CODE_FOR_negsi2 = 509,
  CODE_FOR_negsf2 = 510,
  CODE_FOR_negdf2 = 511,
  CODE_FOR_negxf2 = 512,
  CODE_FOR_sqrtsf2 = 513,
  CODE_FOR_sqrtdf2 = 514,
  CODE_FOR_sqrtxf2 = 515,
  CODE_FOR_abssf2 = 516,
  CODE_FOR_absdf2 = 517,
  CODE_FOR_absxf2 = 518,
  CODE_FOR_clzsi2 = 519,
  CODE_FOR_one_cmplsi2 = 520,
  CODE_FOR_ashldi3 = 521,
  CODE_FOR_ashrdi3 = 522,
  CODE_FOR_lshrdi3 = 523,
  CODE_FOR_bswapsi2 = 524,
  CODE_FOR_extv = 525,
  CODE_FOR_extzv = 526,
  CODE_FOR_insv = 527,
  CODE_FOR_tablejump = 528,
  CODE_FOR_decrement_and_branch_until_zero = 529,
  CODE_FOR_sibcall = 530,
  CODE_FOR_sibcall_value = 531,
  CODE_FOR_call = 532,
  CODE_FOR_call_value = 533,
  CODE_FOR_untyped_call = 534,
  CODE_FOR_prologue = 535,
  CODE_FOR_epilogue = 536,
  CODE_FOR_sibcall_epilogue = 537,
  CODE_FOR_return = 538,
  CODE_FOR_link = 539,
  CODE_FOR_unlink = 540,
  CODE_FOR_atomic_compare_and_swapqi = 553,
  CODE_FOR_atomic_compare_and_swaphi = 554,
  CODE_FOR_atomic_compare_and_swapsi = 555,
  CODE_FOR_atomic_test_and_set = 556
};

const unsigned int NUM_INSN_CODES = 557;
#endif /* GCC_INSN_CODES_H */
