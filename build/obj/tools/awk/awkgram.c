#if HAVE_NBTOOL_CONFIG_H
#include "nbtool_config.h"
#endif
/* original parser id follows */
/* yysccsid[] = "@(#)yaccpar	1.9 (Berkeley) 02/21/93" */
/* (use YYMAJOR/YYMINOR for ifdefs dependent on parser version) */

#define YYBYACC 1
#define YYMAJOR 2
#define YYMINOR 0

#define YYEMPTY        (-1)
#define yyclearin      (yychar = YYEMPTY)
#define yyerrok        (yyerrflag = 0)
#define YYRECOVERING() (yyerrflag != 0)
#define YYENOMEM       (-2)
#define YYEOF          0
#undef YYBTYACC
#define YYBTYACC 0
#define YYDEBUGSTR YYPREFIX "debug"
#define YYPREFIX "yy"

#define YYPURE 0

#line 26 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
#if HAVE_NBTOOL_CONFIG_H
#include "nbtool_config.h"
#endif

#include <stdio.h>
#include <string.h>
#include "awk.h"

void checkdup(Node *list, Cell *item);
int yywrap(void) { return(1); }

Node	*beginloc = 0;
Node	*endloc = 0;
bool	infunc	= false;	/* = true if in arglist or body of func */
int	inloop	= 0;	/* >= 1 if in while, for, do; can't be bool, since loops can next */
char	*curfname = 0;	/* current function name */
Node	*arglist = 0;	/* list of args for current function */
#ifdef YYSTYPE
#undef  YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#endif
#ifndef YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#line 45 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
typedef union {
	Node	*p;
	Cell	*cp;
	int	i;
	char	*s;
} YYSTYPE;
#endif /* !YYSTYPE_IS_DECLARED */
#line 55 "awkgram.c"

/* compatibility with bison */
#ifdef YYPARSE_PARAM
/* compatibility with FreeBSD */
# ifdef YYPARSE_PARAM_TYPE
#  define YYPARSE_DECL() yyparse(YYPARSE_PARAM_TYPE YYPARSE_PARAM)
# else
#  define YYPARSE_DECL() yyparse(void *YYPARSE_PARAM)
# endif
#else
# define YYPARSE_DECL() yyparse(void)
#endif

/* Parameters sent to lex. */
#ifdef YYLEX_PARAM
# define YYLEX_DECL() yylex(void *YYLEX_PARAM)
# define YYLEX yylex(YYLEX_PARAM)
#else
# define YYLEX_DECL() yylex(void)
# define YYLEX yylex()
#endif

#if !(defined(yylex) || defined(YYSTATE))
int YYLEX_DECL();
#endif

/* Parameters sent to yyerror. */
#ifndef YYERROR_DECL
#define YYERROR_DECL() yyerror(const char *s)
#endif
#ifndef YYERROR_CALL
#define YYERROR_CALL(msg) yyerror(msg)
#endif

extern int YYPARSE_DECL();

#define FIRSTTOKEN 257
#define PROGRAM 258
#define PASTAT 259
#define PASTAT2 260
#define XBEGIN 261
#define XEND 262
#define NL 263
#define ARRAY 264
#define MATCH 265
#define NOTMATCH 266
#define MATCHOP 267
#define FINAL 268
#define DOT 269
#define ALL 270
#define CCL 271
#define NCCL 272
#define CHAR 273
#define OR 274
#define STAR 275
#define QUEST 276
#define PLUS 277
#define EMPTYRE 278
#define ZERO 279
#define AND 280
#define BOR 281
#define APPEND 282
#define EQ 283
#define GE 284
#define GT 285
#define LE 286
#define LT 287
#define NE 288
#define IN 289
#define ARG 290
#define BLTIN 291
#define BREAK 292
#define CLOSE 293
#define CONTINUE 294
#define DELETE 295
#define DO 296
#define EXIT 297
#define FOR 298
#define FUNC 299
#define GENSUB 300
#define SUB 301
#define GSUB 302
#define IF 303
#define INDEX 304
#define LSUBSTR 305
#define MATCHFCN 306
#define NEXT 307
#define NEXTFILE 308
#define ADD 309
#define MINUS 310
#define MULT 311
#define DIVIDE 312
#define MOD 313
#define ASSIGN 314
#define ASGNOP 315
#define ADDEQ 316
#define SUBEQ 317
#define MULTEQ 318
#define DIVEQ 319
#define MODEQ 320
#define POWEQ 321
#define PRINT 322
#define PRINTF 323
#define SPRINTF 324
#define ELSE 325
#define INTEST 326
#define CONDEXPR 327
#define POSTINCR 328
#define PREINCR 329
#define POSTDECR 330
#define PREDECR 331
#define VAR 332
#define IVAR 333
#define VARNF 334
#define CALL 335
#define NUMBER 336
#define STRING 337
#define REGEXPR 338
#define GETLINE 339
#define RETURN 340
#define SPLIT 341
#define SUBSTR 342
#define WHILE 343
#define CAT 344
#define NOT 345
#define UMINUS 346
#define UPLUS 347
#define POWER 348
#define DECR 349
#define INCR 350
#define INDIRECT 351
#define LASTTOKEN 352
#define YYERRCODE 256
typedef int YYINT;
static const YYINT yylhs[] = {                           -1,
    0,    0,   36,   36,   37,   37,   33,   33,   26,   26,
   24,   24,   41,   22,   42,   22,   43,   22,   20,   20,
   23,   30,   30,   34,   34,   35,   35,   29,   29,   15,
   15,    1,    1,   10,   11,   11,   11,   11,   11,   11,
   11,   44,   11,   12,   12,    6,    6,    3,    3,    3,
    3,    3,    3,    3,    3,    3,    3,    3,    2,    2,
    2,    2,    2,    2,    2,    2,    2,    2,    2,    2,
    2,    2,    2,    2,    2,    2,    2,    4,    4,    5,
    5,    7,    7,    7,   39,   39,   28,   28,   28,   28,
   31,   31,    9,    9,   45,   13,   32,   32,   14,   14,
   14,   14,   14,   14,   14,   14,   27,   27,   16,   16,
   46,   47,   16,   16,   16,   16,   16,   16,   16,   16,
   16,   16,   16,   16,   48,   16,   16,   17,   17,   38,
   38,   40,   40,    8,    8,    8,    8,    8,    8,    8,
    8,    8,    8,    8,    8,    8,    8,    8,    8,    8,
    8,    8,    8,    8,    8,    8,    8,    8,    8,    8,
    8,    8,    8,    8,    8,    8,    8,    8,    8,    8,
    8,    8,    8,    8,    8,    8,    8,    8,    8,   18,
   18,   18,   18,   21,   21,   21,   19,   19,   19,   25,
};
static const YYINT yylen[] = {                            2,
    1,    1,    1,    2,    1,    2,    1,    2,    1,    2,
    1,    2,    0,   12,    0,   10,    0,    8,    1,    1,
    4,    1,    2,    1,    2,    0,    1,    0,    1,    0,
    1,    1,    3,    1,    1,    4,    4,    7,    3,    4,
    4,    0,    9,    1,    3,    1,    3,    3,    5,    3,
    3,    3,    3,    3,    5,    2,    1,    1,    3,    5,
    3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
    3,    5,    4,    3,    2,    1,    1,    3,    3,    1,
    3,    0,    1,    3,    1,    1,    1,    1,    2,    2,
    1,    2,    1,    2,    0,    4,    1,    2,    4,    4,
    4,    2,    5,    2,    1,    1,    1,    2,    2,    2,
    0,    0,    9,    3,    2,    1,    4,    2,    3,    2,
    2,    3,    2,    2,    0,    3,    2,    1,    2,    1,
    1,    1,    2,    4,    3,    3,    3,    3,    3,    3,
    2,    2,    2,    3,    4,    1,    3,    4,    2,    2,
    2,    2,    2,    8,    8,   10,   10,    4,    3,    2,
    1,    6,    6,    3,    6,    6,    1,    8,    8,    6,
    4,    1,    6,    6,    8,    8,    8,    6,    1,    1,
    4,    1,    2,    0,    1,    3,    1,    1,    1,    4,
};
static const YYINT yydefred[] = {                         0,
    2,   87,   88,    0,    1,    0,    0,   89,   90,    0,
    0,   22,    0,   95,  188,    0,    0,    0,    0,  130,
  131,    0,    0,    0,  187,  182,  189,    0,  167,  132,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   76,    0,   44,    0,   93,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   19,   20,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   94,  150,  151,  183,
    0,    0,    3,    5,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  152,  153,    0,  106,   23,
    0,    0,    0,    0,    9,    0,    0,    0,    0,    0,
   85,   86,    0,    0,    0,    0,  128,    0,  116,    0,
  125,    0,    0,    0,    0,  133,    0,    0,    7,  164,
    0,    0,    0,    0,  144,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  147,    0,    0,    0,    0,    0,
    0,    0,   69,    0,    0,    0,    0,    0,    0,   71,
    0,    4,    0,    6,    0,    0,    0,    0,    0,    0,
    0,    0,   24,    0,    0,    0,   45,    0,    0,  127,
    0,  109,    0,  110,    0,    0,  115,    0,    0,  120,
  121,    0,  123,    0,  124,   39,  129,    0,    0,   10,
    0,    0,    0,    0,    0,    0,    0,   57,    0,    0,
    0,   40,   41,    8,    0,    0,    0,   96,  145,    0,
  185,    0,    0,    0,    0,    0,  171,  148,    0,    0,
    0,   73,    0,    0,   25,    0,   36,  181,  108,    0,
  114,   31,    0,    0,    0,  122,    0,   11,    0,  126,
  112,   91,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   72,    0,   97,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   12,  117,    0,
   92,    0,    0,    0,   52,   54,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   98,    0,  186,    0,
    0,  162,  163,  166,  165,  170,    0,  178,    0,    0,
  103,    0,    0,    0,    0,    0,    0,    0,  174,    0,
  173,    0,    0,    0,    0,    0,    0,    0,   38,    0,
    0,    0,    0,   55,    0,    0,    0,    0,    0,  155,
    0,  154,    0,  168,  169,  177,    0,    0,    0,    0,
  176,  175,   43,    0,    0,    0,    0,   18,    0,  157,
  156,    0,    0,  113,   16,    0,    0,   14,
};
#if defined(YYDESTRUCT_CALL) || defined(YYSTYPE_TOSTRING)
static const YYINT yystos[] = {                           0,
  256,  263,   59,  354,  355,  382,  383,  263,   59,  261,
  262,  123,   40,   47,  290,  291,  293,  299,  300,  301,
  302,  304,  306,  324,  332,  333,  334,  335,  336,  337,
  339,  341,  342,   43,   45,  345,  349,  350,  351,  356,
  362,  363,  364,  365,  366,  367,  372,  373,  384,  392,
  394,  384,  384,  356,  358,  399,   40,   40,  345,  362,
  372,  332,  335,  374,   40,   40,   40,   40,   40,  287,
  372,   40,   40,  362,  362,  362,  363,  372,  372,  362,
  124,  267,  280,  281,  283,  284,  285,  286,  287,  288,
  289,   63,  362,  390,  391,   47,   43,   45,   42,   37,
  348,   44,  384,  383,  315,  349,  350,   91,  256,  263,
   59,  292,  294,  295,  296,  297,  298,  303,  307,  308,
  322,  323,  340,  343,  356,  368,  370,  371,  376,  377,
  379,  380,  384,  393,   40,  337,  371,  371,   44,   41,
  387,   41,  387,  338,   41,  356,  360,  356,   40,  356,
  367,  356,  356,  360,   41,  360,  362,  287,  356,  356,
  339,  356,  367,  356,  356,  356,  356,  356,  356,  373,
  356,  263,  356,  263,  356,  315,  362,  362,  362,  362,
  362,  362,  263,  388,  389,  371,  365,  356,  360,  389,
   59,  381,  388,  381,  373,  356,  381,   40,   40,  381,
  381,  356,  381,   40,  381,  125,  370,  370,  402,  263,
  400,  371,   40,  357,  359,  361,  362,  363,  372,  356,
  367,  125,  125,  263,  356,  289,  356,   47,   41,  387,
  332,  375,  387,  387,  387,  387,   41,   41,  362,  387,
  387,  372,   58,  362,  263,  364,  125,   93,  389,   91,
  381,  368,  369,  373,  356,  381,  356,  325,  378,  370,
  370,  125,  385,  358,  267,  289,   63,  362,  390,  391,
  387,  124,  282,  285,  315,  387,  387,  373,  356,   41,
  386,  387,  356,  356,  356,  367,  356,  367,  373,  356,
  356,  384,  360,   59,  289,  386,  386,  263,  370,  401,
  263,   41,   40,  357,  367,  373,  357,  357,  357,  357,
  362,  362,  362,  357,  356,  356,  263,  398,  332,  387,
  387,   41,   41,   41,   41,   41,  387,   41,  387,  371,
   93,   59,  389,  373,  343,  289,  358,   58,   41,  387,
   41,  387,  384,  356,  356,  356,  367,  356,  125,  389,
  356,  386,   40,  373,   41,  357,  372,  372,  371,   41,
  387,   41,  387,   41,   41,   41,  369,   59,  397,  356,
   41,   41,  125,  356,  356,  386,  389,  370,   41,   41,
   41,  396,  369,  381,  370,  386,  395,  370,
};
#endif /* YYDESTRUCT_CALL || YYSTYPE_TOSTRING */
static const YYINT yydgoto[] = {                          4,
    5,  125,  214,   55,  215,  147,  216,   41,   42,   43,
   44,   45,   46,  126,  253,  127,  128,   47,   48,   64,
  232,  129,  130,  259,  131,  132,  192,    6,    7,  133,
  263,  281,  230,  193,  185,   94,   95,   50,  134,   51,
  387,  382,  369,  318,   56,  211,  300,  209,
};
static const YYINT yysindex[] = {                       -54,
    0,    0,    0,    0,    0,  -57, 8851,    0,    0,  -77,
  -77,    0, 1477,    0,    0,   16, 9611, -266,   47,    0,
    0,   58,   59,   64,    0,    0,    0,   66,    0,    0,
   30,   76,   82, 9611, 9611, 9346, -214, -214, 9611, 8240,
  -13,    0,   15,    0,  -34,    0, -226,  -21, 5032,   99,
 -277, 5032, 5032, 6542,   50, -192,  384, 1477, 9611,  -13,
 -272,    0,    0,  113, 1477, 1477, 1477, 1477,  977, 9611,
 -117, 1477, 1477, -176, -176, -176,    0,    0,    0,    0,
 -162, 1477,    0,    0, 1477, 1477, 1477, 1477, 1477, 1477,
 -222, 1477,  -13, 9028, 9081, 9399, 9611, 9611, 9611, 9611,
 9611,  -82, 5032, 8851, 1477,    0,    0, 1477,    0,    0,
  -82,  -24,  -24, -222,    0, 8975,  142,  160,  -24,  -24,
    0,    0, 8975,  167, 8240,  -24,    0, 5094,    0, 5767,
    0,  -73, 5032, 9452, 1477,    0, 5164, 5366,    0,    0,
 9134,  -78, 9134,  165,    0, 8240,   52, 7187, -115, 7273,
  201, 7273, 7273,   86,    0,  121,  -13, 9611, 7273, 7273,
 -214, 9664,    0, 9664, 9664, 9664, 9664, 9664, 9664,    0,
 7359,    0, 8657,    0, 8584, 9611, -176,  -36,  -36, -176,
 -176, -176,    0,  -14, 1477, 5435,    0, 8240,   10,    0,
  -82,    0,  -14,    0,  168, 6652,    0, 8922, 1477,    0,
    0, 6652,    0, 1477,    0,    0,    0,  -65, 5767,    0,
 5767, 5498, 1477, 2889,  201,  -81,  -13,    0, -189, 7273,
  201,    0,    0,    0, 8240, -222, 8240,    0,    0, 9134,
    0,  148, 9134, 9134, 9134, 9134,    0,    0,  -13, -106,
 9134,    0, 1477,  -13,    0,  -77,    0,    0,    0, 1477,
    0,    0,  205,  -55, 7454,    0, 7454,    0, 5560,    0,
    0,    0,   12,  150, 9505, -222, 9505,  -13, 9187, 9240,
 9293, 9611, 9611, 9611, 9505, 9134, 9134,    0, 8240,    0,
   14, -225, 7273, 7273, 7527,  242, 7626,  243,  179, 6741,
 8240, 5032,   21,  -12, -222,   14,   14,    0,    0,  -48,
    0,   -1, 1477, 9664,    0,    0, 8759, 5639,  886, 2889,
  -13,  -13,  -13, 2889, 6827, 6920,    0,  -77,    0, 9134,
 9134,    0,    0,    0,    0,    0, 9134,    0, 9134, 5704,
    0,  -82, 1477,  248,  256, -222,  181, 9505,    0, -158,
    0, -158, 5032, 7008, 7094, 7721,  260, 7794,    0, 8922,
 7893,   14, 1477,    0,   -1, 2889,  267,  268, 5829,    0,
 9134,    0, 9134,    0,    0,    0,  248,  -82, 5767, 7988,
    0,    0,    0, 8061, 8160,   14, 8922,    0,  -24,    0,
    0, 5767,  248,    0,    0,   14, 5767,    0,
};
static const YYINT yyrindex[] = {                      3327,
    0,    0,    0,    0,    0, 3853,  313,    0,    0,    0,
    0,    0,    0,    0,    0,  704,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
 4026,    0,    0,    0,    0,    0,    0,    0,    0,   41,
 3581,    0, 1972,    0, 3327,    0, 2612,  613,    0,    0,
  799,    0,    0,    0,    0,    0,    0,    0,    0, 3051,
 2300,    0,    0,    0,    0,    0,    0,    0,    0,    0,
 1115,    0,    0, 1206, 1300, 1616,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0, 3673,    0,    0,    0,    0,    0,    0,    0,
    0, 9558,    0,  318,    0,    0,    0,    0,    0,    0,
 4720,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  -32,    0,    0,    0,    0,    0,
    0, 6036,    0,   56,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   20,    0,    0,  292,    0,
 8313,    0,    0,    0,    0,    0, 3143,    0,    0,    0,
 4120,  183,    0, 3118, 4168, 4210, 4223, 4236, 4395,    0,
    0,    0,  451,    0, 1629,    0, 1701, 2703, 2797, 1800,
 2116, 2201,    0, 4619,    0,    0,    0,  812,    0,    0,
 4720,    0, 4824,    0,  -31,    0,    0,  263,    0,    0,
    0,    0,    0,    0,    0,    0,    0, 5891,    0,    0,
    0,    0,    0, 1069,  206,  -28, 8414,    0, 4557,    0,
 8313,    0,    0,    0,  307,    0,  335,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0, 3235,    0,
    0,    0,    0, 3489,    0, 3758,    0,    0,    0,    0,
    0,    0,    0, 4468,    0,    0,    0,    0,    0,    0,
    0,    0, 4941,    0,    0,    0,    0, 8507,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  266,    0,
  203,    0,    0,    0,    0, 8313,    0, 8313,    0,    0,
 1215,    0,    0, 9558,    0, 6098, 6160,    0,    0,    0,
    0,  600,    0,  155,    0,    0,    0,  325, 1329, 1083,
   -2,    8,   31,  714,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0, 2483,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0, 8313,    0,    0,  283,
    0, 6222,    0,    0,    0,  744,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0, 2483,    0,    0,
    0,    0,    0,    0,    0, 6367,  283,    0,    0,    0,
    0,    0,    0,    0,    0, 6429,    0,    0,
};
#if YYBTYACC
static const YYINT yycindex[] = {                         0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,
};
#endif
static const YYINT yygindex[] = {                         0,
    0,  557,  103, -163,    0,   -6,    0,  246,   85,  147,
  233,    0,  -49, -172, -306,  340,   22,  -17,  342,    0,
    0,    0,    0,    0,    0,    0,  -68,    0,  304,   -3,
    0, -146, 2466,  -99,  -96, -141,  176,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,
};
#define YYTABLESIZE 10015
static const YYINT yytable[] = {                         61,
  100,    9,  184,   49,    3,   99,   52,   53,  105,  104,
   96,  184,  102,   71,  190,  151,   61,   61,   61,   78,
   79,   61,   61,  100,    3,  252,  105,  104,   99,   97,
  102,   98,  163,   96,  191,  108,   61,  224,   99,  103,
   34,   61,  272,  367,  194,   12,  332,  197,  100,  264,
  200,  201,   61,  139,  203,   57,   99,  205,  102,  136,
   46,  154,  156,   46,  139,   62,  100,   15,   63,  108,
  383,  101,  269,  137,  138,   15,  106,  107,   61,   61,
   61,   61,   61,   61,   34,  221,   65,   34,  105,  101,
  142,  184,  229,  139,  249,  139,   82,   66,   67,   34,
   49,  189,  248,   68,  224,   69,  319,   61,  296,   25,
  297,   27,   46,  331,   82,   72,  219,   25,   26,   27,
   77,   73,  106,  107,  186,  275,  237,  251,   61,  139,
   61,   15,   61,  256,   61,   61,   39,   12,  135,  337,
   61,   61,   61,  242,   61,  144,   61,   61,   61,   61,
   61,   61,  149,   61,  212,   61,  224,   61,   61,  106,
  107,  238,  269,   34,  139,  269,  269,  269,  269,  158,
   61,  101,  269,   25,   26,   27,  161,  252,   61,   82,
  183,  198,   70,   15,   61,  286,  288,  352,  280,  210,
  302,  139,   39,  139,  184,   53,   61,  333,   53,  199,
  273,    1,   61,  274,  252,    8,  204,   61,    2,   61,
  226,  228,   53,   53,  269,  305,  231,   53,  218,  326,
  376,  355,  139,   70,  139,   25,   70,   27,    2,   70,
  105,  104,  184,  295,  102,  350,  386,   61,  183,   61,
   70,   70,  292,  293,  139,   70,   83,  219,  245,  219,
  183,  219,  219,  219,   61,   61,   61,  219,  250,  258,
   99,   61,   60,  294,   83,   61,   61,   61,  184,   61,
  100,  377,   61,   61,  301,   70,  317,  347,   53,   74,
   75,   76,  323,  325,   80,   93,   61,  336,  280,   61,
   61,   61,   61,  101,  335,  353,   61,   61,   61,   93,
  365,   34,   34,   34,   76,   70,   47,  371,  372,   47,
  384,  101,   32,  330,  343,  157,   70,   33,   82,   15,
  219,   30,  357,   30,  358,   42,   61,   61,   61,   83,
   61,  246,  184,   61,  101,  184,  187,   82,   61,   34,
   82,  177,  178,  179,  180,  181,  182,   78,  104,  218,
   78,  218,   61,  218,  218,  218,   61,   61,   47,  218,
    0,   25,   26,   27,  359,   51,    0,  304,   51,  307,
   93,  308,  309,  310,    0,   79,    0,  314,   79,  217,
   39,    0,   51,   51,    0,    0,    0,   51,    0,  270,
    0,   93,    0,   93,    0,   93,    0,   93,   93,    0,
    0,    0,    0,  239,   93,   93,    0,   93,    0,   93,
   93,   93,   93,   93,   93,    0,   93,   53,   93,    0,
   93,  244,  218,   13,  145,    0,   34,    0,   35,    0,
   14,    0,  170,   93,   53,   53,   53,    0,    0,   53,
  356,   93,    0,   70,   70,   70,    0,   93,   51,    0,
   62,    0,    0,    0,    0,  195,    0,    0,    0,  268,
    0,    0,   70,   70,    0,   93,    0,  207,   83,  208,
   93,    0,   93,    0,    0,    0,  207,  207,    0,  270,
    0,   70,  270,  270,  270,  270,    0,   83,    0,  270,
   83,   62,    0,   53,   62,    0,    0,   62,    0,    0,
   93,    0,   93,    0,    0,    0,    0,    0,   62,   62,
  217,    0,  217,   62,  217,  217,  217,  311,  312,  313,
  217,   70,    0,    0,   93,  207,    0,    0,   93,   93,
   93,  270,   93,    0,    0,   93,   93,    0,    0,  254,
    0,    0,    0,   62,    0,    0,    0,    0,  260,  268,
  261,  207,  268,  268,  268,  268,    0,    0,    0,  268,
   93,   93,    0,   40,    0,    0,    0,  278,    0,   54,
    0,    0,    0,   62,    0,    0,    0,    0,    0,    0,
    0,  289,    0,  217,    0,    0,    0,   51,    0,   93,
   93,   93,    0,   93,    0,    0,   93,    0,  299,    0,
    0,  268,    0,    0,   51,   51,   51,  306,    0,   51,
    0,    0,  180,  146,  148,   93,    0,    0,    0,   93,
   93,  150,  152,  153,  146,  146,    0,    0,  159,  160,
    0,    0,    0,    0,    0,    0,  334,    0,  162,    0,
   84,  164,  165,  166,  167,  168,  169,    0,  171,  180,
  173,  175,  180,  180,  180,  180,  180,  180,   84,  180,
   40,  188,    0,    0,  146,    0,    0,    0,    0,  207,
  180,  180,  196,   15,   16,  180,   17,  354,    0,  202,
    0,    0,    0,   19,   20,   21,    0,   22,    0,   23,
    0,  220,    0,    0,    0,    0,    0,  225,  207,  227,
    0,    0,    0,  146,    0,  180,    0,   24,  378,    0,
    0,   62,   62,   62,    0,   25,   26,   27,   28,   29,
   30,  385,   31,   84,   32,   33,  388,    0,   36,    0,
   62,   62,   37,   38,   39,  180,  180,    0,    0,    0,
  146,   40,    0,    0,  146,  146,  146,  146,  146,   62,
  146,    0,    0,    0,   48,  255,    0,   48,    0,    0,
  257,  146,  146,    0,    0,    0,  146,    0,    0,   54,
    0,   48,   48,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   49,    0,  279,   49,    0,  283,
  284,  285,  287,    0,    0,    0,  146,  290,  172,  291,
    0,   49,   49,    0,    0,    0,  146,    0,    0,    0,
    0,   59,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  146,  146,    0,    0,
    0,    0,  315,  316,    0,  172,    0,   48,  172,  172,
  172,  172,  172,  172,    0,  172,    0,    0,    0,    0,
    0,    0,   59,    0,    0,   59,  172,  172,   59,   54,
    0,  172,   84,    0,    0,    0,    0,   49,    0,   59,
   59,    0,    0,  180,  180,  180,  344,  345,    0,  180,
    0,   84,    0,  346,   84,  348,    0,    0,    0,  351,
    0,  172,  180,  180,  180,  180,  180,  180,  180,  180,
  180,  180,  180,  180,   59,  180,    0,    0,    0,  370,
    0,  180,  180,  180,  180,    0,  180,  374,  180,  375,
    0,  172,  172,    0,    0,   58,    0,  180,   34,    0,
   35,    0,    0,    0,   59,    0,  180,    0,    0,    0,
    0,    0,    0,    0,  180,  180,  180,  180,  180,  180,
    0,  180,    0,  180,  180,    0,    0,  180,    0,    0,
  180,  180,  180,  180,  146,  146,  146,    0,    0,    0,
  146,    0,    0,    0,    0,    0,   48,    0,    0,    0,
    0,    0,    0,  146,  146,  146,  146,  146,  146,  146,
  146,  146,  146,  146,  146,   48,  146,    0,   48,    0,
    0,    0,  146,  146,  146,  146,   49,  146,    0,  146,
    0,    0,    0,    0,    0,    0,   13,  155,  146,   34,
    0,   35,    0,   14,    0,   49,    0,  146,   49,    0,
    0,    0,    0,    0,    0,  146,  146,  146,  146,  146,
  146,    0,  146,    0,  146,  146,    0,    0,  146,    0,
    0,  146,  146,  146,  146,    0,    0,    0,    0,  172,
  172,  172,    0,    0,    0,  172,    0,    0,    0,    0,
    0,    0,   59,   59,   59,    0,    0,    0,  172,  172,
  172,  172,  172,  172,  172,  172,  172,  172,  172,  172,
    0,  172,    0,    0,    0,    0,    0,  172,  172,  172,
  172,    0,  172,    0,  172,    0,    0,    0,    0,   80,
   59,    0,   80,  172,  160,    0,    0,    0,    0,    0,
    0,    0,  172,   81,    0,    0,   81,   80,    0,    0,
  172,  172,  172,  172,  172,    0,    0,  172,    0,  172,
  172,   81,    0,  172,    0,    0,  172,  172,  172,  172,
    0,  160,  265,    0,  160,  160,  160,  160,  160,  160,
    0,  160,    0,    0,    0,   83,    0,    0,    0,    0,
    0,    0,  160,  160,  266,   15,   16,  160,   17,    0,
    0,    0,    0,    0,    0,   19,   20,   21,    0,   22,
    0,   23,   80,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  142,   81,  160,    0,   24,
    0,    0,    0,    0,   60,    0,    0,   25,   26,   27,
   28,   29,   30,    0,   31,    0,   32,   33,    0,    0,
   59,    0,    0,    0,   37,   38,   39,  160,  160,    0,
    0,    0,  142,    0,    0,  142,  142,  142,  142,  142,
  142,    0,  142,    0,    0,   60,    0,    0,   60,    0,
    0,   60,    0,  142,  142,    0,   15,   16,  142,   17,
    0,    0,   60,   60,    0,    0,   19,   20,   21,    0,
   22,    0,   23,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  142,  141,
   24,    0,    0,    0,    0,    0,    0,   60,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,    0,
    0,   36,    0,    0,    0,   37,   38,   39,  142,  142,
    0,   80,    0,    0,    0,    0,  141,   60,    0,  141,
  141,  141,  141,  141,  141,   81,  141,    0,    0,    0,
   80,    0,    0,   80,    0,    0,    0,  141,  141,    0,
    0,    0,  141,    0,   81,    0,    0,   81,    0,   50,
    0,    0,   50,    0,    0,  160,  160,  160,    0,    0,
    0,  160,    0,    0,    0,    0,   50,   50,    0,    0,
    0,   50,  141,    0,  160,  160,  160,  160,  160,  160,
  160,    0,  160,  160,  160,  160,    0,  160,    0,    0,
    0,    0,    0,  160,  160,  160,  160,    0,  160,    0,
  160,    0,  141,  141,    0,    0,    0,    0,    0,  160,
    0,    0,    0,    0,    0,    0,    0,    0,  160,    0,
    0,    0,    0,    0,    0,    0,  160,  160,  160,  160,
  160,  160,   50,  160,    0,  160,  160,    0,    0,  160,
    0,    0,  160,  160,  160,  160,  142,  142,  142,    0,
    0,    0,  142,    0,    0,   60,   60,   60,    0,    0,
    0,    0,    0,    0,    0,  142,  142,  142,  142,  142,
  142,  142,  142,  142,  142,  142,  142,    0,  142,    0,
    0,    0,    0,    0,  142,  142,  142,  142,    0,  142,
    0,  142,    0,   60,    0,    0,   13,    0,    0,   34,
  142,   35,    0,   14,    0,    0,    0,    0,    0,  142,
    0,    0,    0,    0,    0,    0,    0,  142,  142,  142,
  142,  142,  142,    0,  142,    0,  142,  142,    0,    0,
  142,    0,    0,    0,  142,  142,  142,    0,    0,    0,
  141,  141,  141,    0,    0,    0,  141,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  141,
  141,  141,  141,  141,  141,  141,  141,  141,  141,  141,
  141,   50,  141,    0,    0,    0,    0,    0,  141,  141,
  141,  141,    0,  141,    0,  141,    0,    0,    0,   50,
   50,    0,    0,   50,  141,  143,    0,    0,    0,    0,
    0,    0,    0,  141,    0,    0,    0,    0,   61,    0,
    0,  141,  141,  141,  141,  141,  141,    0,  141,    0,
  141,  141,    0,    0,  141,    0,    0,    0,  141,  141,
  141,    0,  143,    0,    0,  143,  143,  143,  143,  143,
  143,    0,  143,    0,    0,    0,    0,    0,    0,   61,
    0,    0,   61,  143,  143,   61,    0,    0,  143,    0,
    0,    0,    0,    0,    0,    0,   61,   61,    0,    0,
    0,   61,    0,    0,    0,    0,    0,    0,    0,    0,
  138,    0,    0,    0,    0,    0,    0,    0,  143,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   61,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  138,  143,  143,
  138,  138,  138,  138,  138,  138,    0,  138,    0,    0,
    0,   61,    0,    0,    0,    0,    0,    0,  138,  138,
    0,    0,    0,  138,    0,    0,   15,   16,    0,   17,
    0,    0,    0,    0,    0,    0,   19,   20,   21,    0,
   22,    0,   23,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  138,    0,    0,    0,    0,    0,  137,
   24,    0,    0,    0,    0,    0,    0,    0,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,    0,
    0,   36,    0,  138,  138,   37,   38,   39,    0,    0,
    0,    0,    0,    0,    0,    0,  137,    0,    0,  137,
  137,  137,  137,  137,  137,    0,  137,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  137,  137,    0,
    0,    0,  137,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  143,  143,  143,    0,
    0,    0,  143,    0,    0,    0,    0,    0,    0,   61,
   61,   61,  137,    0,    0,  143,  143,  143,  143,  143,
  143,  143,  143,  143,  143,  143,  143,    0,  143,   61,
    0,    0,    0,    0,  143,  143,  143,  143,    0,  143,
    0,  143,  137,  137,    0,    0,    0,   61,    0,    0,
  143,    0,    0,    0,    0,    0,    0,    0,    0,  143,
    0,    0,    0,    0,    0,    0,    0,  143,  143,  143,
  143,  143,  143,    0,  143,    0,  143,  143,    0,    0,
  143,  138,  138,  138,  143,  143,  143,  138,    0,    0,
    0,   35,    0,    0,    0,    0,    0,    0,    0,    0,
  138,  138,  138,  138,  138,  138,  138,  138,  138,  138,
  138,  138,    0,  138,    0,    0,    0,    0,    0,  138,
  138,  138,  138,    0,  138,    0,  138,    0,    0,    0,
    0,   35,    0,    0,   35,  138,   35,    0,   35,    0,
    0,    0,    0,    0,  138,    0,    0,    0,    0,    0,
   35,    0,  138,  138,  138,  138,  138,  138,    0,  138,
    0,  138,  138,    0,    0,  138,    0,    0,    0,  138,
  138,  138,    0,    0,    0,    0,    0,    0,    0,    0,
  137,  137,  137,    0,    0,    0,  137,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  137,
  137,  137,  137,  137,  137,  137,  137,  137,  137,  137,
  137,    0,  137,    0,    0,    0,    0,    0,  137,  137,
  137,  137,    0,  137,    0,  137,    0,    0,    0,    0,
    0,    0,    0,    0,  137,  139,    0,    0,    0,    0,
    0,    0,    0,  137,    0,    0,    0,    0,    0,    0,
    0,  137,  137,  137,  137,  137,  137,    0,  137,    0,
  137,  137,    0,    0,  137,    0,    0,    0,  137,  137,
  137,    0,  139,    0,    0,  139,  139,  139,  139,  139,
  139,    0,  139,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  139,  139,    0,    0,    0,  139,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  140,    0,    0,    0,    0,    0,    0,    0,  139,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   35,   35,   35,    0,    0,  140,  139,  139,
  140,  140,  140,  140,  140,  140,    0,  140,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  140,  140,
    0,   35,   35,  140,   35,    0,    0,    0,    0,    0,
   35,   35,   35,   35,    0,   35,    0,   35,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  140,    0,   35,    0,    0,    0,  179,
    0,    0,    0,   35,   35,   35,   35,   35,   35,    0,
   35,    0,   35,   35,    0,    0,   35,    0,    0,    0,
   35,   35,   35,  140,  140,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  179,    0,    0,  179,
  179,  179,  179,  179,  179,    0,  179,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  179,  179,    0,
    0,    0,  179,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  139,  139,  139,    0,
    0,    0,  139,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  179,    0,    0,  139,  139,  139,  139,  139,
  139,  139,  139,  139,  139,  139,  139,    0,  139,    0,
    0,    0,    0,    0,  139,  139,  139,  139,    0,  139,
    0,  139,  179,  179,    0,    0,    0,    0,    0,    0,
  139,    0,    0,    0,    0,    0,    0,    0,    0,  139,
    0,    0,    0,    0,    0,    0,    0,  139,  139,  139,
  139,  139,  139,    0,  139,    0,  139,  139,    0,    0,
  139,  140,  140,  140,  139,  139,  139,  140,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  140,  140,  140,  140,  140,  140,  140,  140,  140,  140,
  140,  140,    0,  140,    0,    0,    0,    0,    0,  140,
  140,  140,  140,    0,  140,    0,  140,    0,    0,    0,
    0,    0,    0,    0,    0,  140,    0,    0,    0,  141,
  143,    0,   26,   26,  140,   26,    0,   26,    0,   26,
    0,    0,  140,  140,  140,  140,  140,  140,    0,  140,
    0,  140,  140,    0,    0,  140,    0,    0,    0,  140,
  140,  140,    0,    0,    0,    0,    0,    0,    0,    0,
  179,  179,  179,    0,    0,    0,  179,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  179,
  179,  179,  179,  179,  179,  179,  179,  179,  179,  179,
  179,    0,  179,    0,    0,    0,    0,    0,  179,  179,
  179,  179,    0,  179,    0,  179,    0,    0,    0,    0,
    0,  179,    0,    0,  179,  233,  234,  235,  236,    0,
    0,    0,    0,  179,  240,  241,    0,    0,    0,    0,
    0,  179,  179,  179,  179,  179,  179,    0,  179,    0,
  179,  179,    0,    0,  179,    0,    0,  179,  179,    0,
  179,  179,  179,  179,  179,  179,  179,    0,  179,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  179,
  179,    0,    0,    0,  179,    0,    0,    0,    0,    0,
  271,    0,    0,    0,    0,  276,  277,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  282,    0,    0,
    0,    0,  135,    0,  179,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  143,
    0,    0,    0,    0,  179,  179,    0,    0,   26,    0,
    0,    0,  135,  135,    0,  135,  135,  135,  320,  321,
    0,    0,    0,    0,  327,  329,    0,    0,    0,    0,
  135,  135,    0,    0,    0,  135,    0,    0,    0,    0,
    0,    0,   26,   26,    0,   26,    0,   26,    0,    0,
  340,  342,   26,   26,   26,    0,   26,    0,   26,    0,
    0,    0,    0,    0,    0,  135,  136,    0,    0,    0,
    0,    0,  143,    0,   26,   26,   26,    0,    0,  361,
  363,    0,    0,    0,   26,   26,   26,   26,   26,   26,
    0,   26,    0,   26,   26,  135,  135,   26,    0,    0,
    0,   26,   26,   26,    0,    0,  136,  136,    0,  136,
  136,  136,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  136,  136,    0,    0,    0,  136,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  179,  179,  179,    0,    0,    0,  179,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  136,
    0,  179,  179,    0,  179,  179,  179,  179,  179,  179,
  179,  179,  179,    0,  179,    0,    0,    0,    0,    0,
  179,  179,  179,  179,    0,  179,    0,  179,    0,  136,
  136,    0,    0,    0,    0,    0,    0,    0,   58,    0,
    0,   34,    0,   35,    0,  179,    0,    0,    0,    0,
    0,    0,    0,  179,  179,  179,  179,  179,  179,    0,
  179,  267,  179,  179,    0,    0,  179,    0,    0,  179,
    0,    0,  179,  135,  135,  135,    0,    0,    0,  135,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  135,  135,  135,  135,  135,  135,  135,  135,
  135,  135,  135,  135,    0,  135,    0,    0,    0,    0,
    0,  135,  135,  135,  135,    0,  135,    0,  135,    0,
    0,    0,    0,    0,    0,    0,    0,  135,    0,    0,
    0,    0,    0,    0,    0,    0,  135,    0,    0,    0,
    0,    0,    0,    0,  135,  135,  135,  135,  135,  135,
    0,  135,    0,  135,  135,    0,    0,  135,    0,    0,
  149,  135,  135,  135,    0,    0,    0,  136,  136,  136,
    0,    0,    0,  136,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  136,  136,  136,  136,
  136,  136,  136,  136,  136,  136,  136,  136,    0,  136,
  149,  149,    0,    0,  149,  136,  136,  136,  136,    0,
  136,    0,  136,    0,    0,    0,    0,    0,  149,  149,
    0,  136,    0,  149,    0,    0,    0,   63,    0,    0,
  136,    0,    0,    0,    0,    0,    0,    0,  136,  136,
  136,  136,  136,  136,    0,  136,    0,  136,  136,    0,
    0,  136,  159,  149,    0,  136,  136,  136,    0,    0,
    0,    0,    0,    0,    0,  265,    0,    0,   63,    0,
    0,   63,    0,    0,   63,    0,    0,    0,   83,   84,
    0,    0,    0,  149,  149,   63,   63,  266,   15,   16,
   63,   17,  159,  159,    0,    0,  159,    0,   19,   20,
   21,    0,   22,    0,   23,    0,    0,    0,    0,    0,
  159,  159,    0,    0,    0,  159,    0,    0,    0,    0,
   63,    0,   24,    0,    0,    0,    0,    0,    0,    0,
   25,   26,   27,   28,   29,   30,    0,   31,    0,   32,
   33,    0,    0,   59,  158,  159,    0,   37,   38,   39,
   63,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  159,  159,    0,    0,    0,
    0,    0,    0,    0,  158,  158,    0,    0,  158,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  158,  158,    0,    0,    0,  158,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  149,  149,  149,    0,    0,    0,  149,    0,    0,
    0,    0,    0,    0,    0,    0,   28,  158,    0,    0,
  149,  149,  149,  149,  149,  149,  149,  149,  149,  149,
  149,  149,    0,  149,    0,    0,    0,    0,    0,  149,
  149,  149,  149,    0,  149,    0,  149,  158,  158,    0,
    0,    0,    0,    0,    0,  149,   28,    0,    0,   28,
    0,   28,    0,   28,  149,    0,    0,    0,   63,   63,
   63,    0,  149,  149,  149,  149,  149,  149,    0,  149,
    0,  149,  149,    0,    0,  149,    0,   63,   63,  149,
  149,  149,    0,  159,  159,  159,    0,    0,    0,  159,
    0,    0,    0,    0,    0,    0,   63,    0,    0,    0,
    0,    0,  159,  159,  159,  159,  159,  159,  159,  159,
  159,  159,  159,  159,    0,  159,    0,    0,    0,    0,
    0,  159,  159,  159,  159,    0,  159,    0,  159,   28,
    0,    0,    0,    0,    0,    0,   63,  159,    0,    0,
    0,    0,    0,    0,    0,    0,  159,    0,    0,    0,
    0,    0,    0,    0,  159,  159,  159,  159,  159,  159,
    0,  159,    0,  159,  159,    0,    0,  159,  134,    0,
    0,  159,  159,  159,    0,  158,  158,  158,    0,    0,
    0,  158,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  158,  158,  158,  158,  158,  158,
  158,  158,  158,  158,  158,  158,    0,  158,  134,  134,
    0,    0,  134,  158,  158,  158,  158,    0,  158,    0,
  158,    0,    0,    0,    0,    0,  134,  134,    0,  158,
    0,  134,    0,    0,    0,    0,    0,    0,  158,    0,
    0,    0,    0,    0,    0,    0,  158,  158,  158,  158,
  158,  158,    0,  158,    0,  158,  158,    0,    0,  158,
   77,  134,    0,  158,  158,  158,    0,   28,   28,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  134,  134,    0,    0,    0,   28,   28,    0,   28,
   77,   77,    0,    0,   77,   28,   28,   28,   28,    0,
   28,    0,   28,    0,    0,    0,    0,    0,   77,   77,
    0,    0,    0,   77,    0,    0,    0,    0,    0,    0,
   28,    0,    0,    0,    0,    0,    0,    0,   28,   28,
   28,   28,   28,   28,    0,   28,    0,   28,   28,    0,
    0,   28,   75,   77,    0,   28,   28,   28,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   77,   77,    0,    0,    0,    0,    0,
    0,    0,   75,   75,    0,    0,   75,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   75,   75,    0,    0,    0,   75,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  134,
  134,  134,    0,    0,    0,  134,    0,   37,    0,    0,
    0,    0,    0,    0,    0,   75,    0,    0,  134,  134,
  134,  134,  134,  134,  134,  134,  134,  134,  134,  134,
    0,  134,    0,    0,    0,    0,    0,  134,  134,  134,
  134,    0,  134,    0,  134,   75,   75,   37,    0,    0,
   37,    0,   37,  134,   37,    0,    0,    0,    0,    0,
    0,    0,  134,    0,    0,    0,   37,    0,    0,    0,
  134,  134,  134,  134,  134,  134,    0,  134,    0,  134,
  134,    0,    0,  134,    0,    0,    0,  134,  134,  134,
    0,   77,   77,   77,    0,    0,    0,   77,    0,    0,
    0,    0,   29,    0,    0,    0,    0,    0,    0,    0,
   77,   77,    0,   77,   77,   77,   77,   77,   77,   77,
   77,   77,    0,   77,    0,    0,    0,    0,    0,   77,
   77,   77,   77,    0,   77,    0,   77,    0,    0,    0,
    0,    0,   29,    0,    0,   29,    0,   29,    0,   29,
    0,    0,    0,    0,   77,    0,    0,    0,    0,    0,
    0,    0,   77,   77,   77,   77,   77,   77,    0,   77,
    0,   77,   77,    0,    0,   77,    0,    0,    0,   77,
   77,   77,    0,   75,   75,   75,    0,    0,    0,   75,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   75,   75,    0,   75,   75,   75,   75,   75,
   75,   75,   75,   75,    0,   75,    0,    0,    0,    0,
    0,   75,   75,   75,   75,   29,   75,    0,   75,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   75,    0,    0,    0,
    0,    0,    0,    0,   75,   75,   75,   75,   75,   75,
    0,   75,    0,   75,   75,    0,    0,   75,   37,   37,
   37,   75,   75,   75,    0,  161,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   37,   37,    0,
   37,    0,    0,    0,    0,    0,   37,   37,   37,   37,
    0,   37,  161,   37,    0,  161,  161,  161,  161,  161,
  161,    0,  161,    0,    0,    0,    0,    0,    0,    0,
    0,   37,    0,  161,  161,    0,    0,    0,  161,   37,
   37,   37,   37,   37,   37,    0,   37,    0,   37,   37,
    0,    0,   37,    0,    0,    0,   37,   37,   37,    0,
    0,    0,    0,   29,   29,    0,    0,    0,  161,   74,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   29,   29,    0,   29,    0,    0,  161,  161,
    0,   29,   29,   29,   29,    0,   29,    0,   29,   74,
   74,    0,   74,   74,   74,    0,   74,   64,    0,    0,
    0,    0,    0,    0,    0,    0,   29,   74,   74,    0,
    0,    0,   74,    0,   29,   29,   29,   29,   29,   29,
    0,   29,    0,   29,   29,    0,    0,   29,    0,    0,
    0,   29,   29,   29,    0,    0,    0,    0,   64,   65,
    0,   64,   74,    0,   64,    0,    0,    0,    0,    0,
    0,    0,   66,    0,    0,   64,   64,    0,    0,    0,
   64,    0,    0,    0,    0,   67,    0,    0,    0,    0,
    0,    0,   74,   74,    0,    0,    0,    0,    0,    0,
   65,    0,    0,   65,    0,    0,   65,    0,    0,    0,
   64,    0,    0,   66,    0,    0,   66,   65,   65,   66,
    0,    0,   65,    0,    0,    0,   67,    0,    0,   67,
   66,   66,   67,    0,    0,   66,  161,  161,  161,    0,
   64,    0,  161,   67,   67,    0,    0,    0,   67,    0,
    0,    0,   65,    0,    0,  161,  161,  161,  161,  161,
  161,  161,    0,  161,  161,   66,  161,    0,  161,    0,
    0,    0,    0,    0,  161,  161,  161,  161,   67,  161,
    0,  161,   65,    0,    0,    0,    0,    0,    0,    0,
  161,    0,    0,    0,    0,   66,    0,    0,    0,  161,
    0,    0,    0,    0,    0,    0,    0,    0,   67,    0,
  161,  161,  161,    0,  161,    0,  161,  161,    0,    0,
  161,    0,    0,  161,  161,  161,    0,    0,    0,    0,
   74,   74,   74,    0,    0,    0,   74,    0,    0,    0,
    0,    0,    0,    0,   68,    0,    0,    0,    0,   74,
   74,    0,   74,   74,   74,   74,   74,   74,   74,    0,
   74,    0,   74,    0,    0,    0,    0,    0,   74,   74,
   74,   74,    0,   74,    0,   74,    0,    0,   64,   64,
   64,    0,    0,    0,    0,   68,    0,    0,   68,    0,
    0,   68,    0,   74,    0,    0,    0,   64,   64,    0,
    0,    0,   68,   68,   74,   74,   74,   68,   74,    0,
   74,   74,    0,    0,   74,    0,   64,    0,   74,   74,
   65,   65,   65,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   66,   66,   66,    0,   68,    0,   65,
   65,    0,    0,    0,    0,    0,   67,   67,   67,    0,
    0,    0,   66,   66,  180,    0,   64,  180,   65,  180,
  180,    0,  180,    0,  180,   67,   67,   68,    0,    0,
    0,   66,    0,    0,    0,    0,  180,    0,    0,    0,
  180,    0,    0,    0,   67,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   65,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   66,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   67,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  180,    0,  179,    0,    0,  179,  179,  179,  179,
  179,  179,    0,  179,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  179,  179,    0,    0,    0,  179,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   68,   68,   68,   27,   27,
    0,   27,    0,   27,    0,   27,    0,    0,    0,    0,
    0,    0,    0,    0,   68,   68,    0,   27,    0,    0,
  179,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   68,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   68,  180,    0,    0,    0,    0,    0,
    0,   27,    0,   27,    0,    0,    0,  180,  180,    0,
  180,  180,  180,  180,  180,  180,    0,  180,  180,   26,
  180,    0,   26,    0,   26,    0,   26,  180,  180,  180,
    0,  180,    0,  180,    0,    0,    0,    0,   26,    0,
    0,    0,  180,    0,    0,    0,    0,    0,    0,    0,
    0,  180,    0,    0,    0,    0,    0,    0,    0,  180,
  180,  180,  180,  180,  180,    0,  180,    0,  180,  180,
    0,    0,  180,    0,    0,  180,  180,  180,  180,  179,
    0,    0,    0,  179,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  179,  179,  179,    0,
    0,  179,   26,    0,   26,  179,  179,  179,    0,  179,
    0,    0,    0,    0,    0,    0,  179,  179,  179,    0,
  179,    0,  179,  107,    0,    0,  107,    0,  107,    0,
  107,    0,    0,    0,   27,    0,    0,    0,    0,    0,
  179,    0,  107,    0,    0,    0,    0,    0,  179,  179,
  179,  179,  179,  179,    0,  179,    0,  179,  179,    0,
    0,  179,    0,    0,  179,    0,    0,  179,   27,   27,
   27,   27,   27,   27,   27,   27,   27,    0,   27,   27,
   27,   27,   27,    0,   27,   27,   27,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   27,   27,   27,   27,    0,    0,  107,    0,  107,    0,
   27,   27,   27,   27,   27,   27,    0,   27,   27,   27,
   27,   27,    0,   27,    0,    0,    0,   27,   27,   27,
    0,    0,    0,    0,    0,   26,    0,    0,    0,    0,
  119,    0,    0,  119,    0,  119,    0,  119,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  119,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   26,
   26,   26,   26,   26,   26,   26,   26,   26,    0,   26,
   26,   26,   26,   26,    0,   26,   26,   26,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   26,   26,   26,   26,    0,    0,    0,    0,    0,
    0,   26,   26,   26,   26,   26,   26,    0,   26,   26,
   26,   26,   26,  119,   26,  119,    0,    0,   26,   26,
   26,   13,    0,    0,   34,    0,   35,    0,   14,  107,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  111,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  107,  107,  107,  107,  107,  107,  107,
  107,  107,    0,  107,  107,  107,  107,  107,    0,  107,
  107,  107,    0,   13,    0,    0,   34,    0,   35,    0,
   14,    0,    0,    0,    0,  107,  107,  107,  107,    0,
    0,    0,  111,    0,   12,  107,  107,  107,  107,  107,
  107,    0,  107,  107,  107,  107,  107,    0,  107,    0,
    0,    0,  107,  107,  107,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  119,    0,    0,    0,
    0,    0,    0,   13,    0,    0,   34,    0,   35,    0,
   14,    0,    0,    0,    0,    0,   12,    0,  206,    0,
    0,    0,  111,    0,    0,    0,    0,    0,    0,    0,
  119,  119,  119,  119,  119,  119,  119,  119,  119,    0,
  119,  119,  119,  119,  119,    0,  119,  119,  119,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  119,  119,  119,  119,    0,    0,    0,    0,
    0,    0,  119,  119,  119,  119,  119,  119,    0,  119,
  119,  119,  119,  119,    0,  119,   12,  109,  222,  119,
  119,  119,    0,    0,  110,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   15,   16,  112,   17,  113,  114,  115,  116,  117,
    0,   19,   20,   21,  118,   22,    0,   23,  119,  120,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  109,
    0,    0,    0,  121,  122,   24,    0,    0,    0,    0,
    0,    0,    0,   25,   26,   27,   28,   29,   30,    0,
   31,  123,   32,   33,  124,    0,   36,    0,    0,    0,
   37,   38,   39,   15,   16,  112,   17,  113,  114,  115,
  116,  117,    0,   19,   20,   21,  118,   22,    0,   23,
  119,  120,    0,    0,    0,   13,    0,    0,   34,    0,
   35,    0,   14,    0,    0,  121,  122,   24,    0,  109,
    0,    0,    0,    0,  111,   25,   26,   27,   28,   29,
   30,    0,   31,  123,   32,   33,  124,    0,   36,    0,
    0,    0,   37,   38,   39,    0,    0,    0,    0,    0,
    0,    0,    0,   15,   16,  112,   17,  113,  114,  115,
  116,  117,    0,   19,   20,   21,  118,   22,    0,   23,
  119,  120,    0,    0,   13,    0,    0,   34,    0,   35,
    0,   14,    0,    0,    0,  121,  122,   24,   12,    0,
  223,    0,    0,  111,    0,   25,   26,   27,   28,   29,
   30,    0,   31,  123,   32,   33,  124,    0,   36,    0,
    0,    0,   37,   38,   39,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   13,    0,    0,
   34,    0,   35,    0,   14,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  111,   12,    0,  247,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   13,
    0,    0,   34,    0,   35,    0,   14,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  111,    0,
   12,  109,  262,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   15,   16,  112,   17,  113,
  114,  115,  116,  117,    0,   19,   20,   21,  118,   22,
    0,   23,  119,  120,    0,    0,    0,    0,   58,    0,
    0,   34,   12,   35,    0,    0,    0,  121,  122,   24,
  109,    0,    0,    0,    0,    0,    0,   25,   26,   27,
   28,   29,   30,    0,   31,  123,   32,   33,  124,    0,
   36,    0,    0,    0,   37,   38,   39,    0,    0,    0,
    0,    0,    0,    0,   15,   16,  112,   17,  113,  114,
  115,  116,  117,    0,   19,   20,   21,  118,   22,    0,
   23,  119,  120,   13,    0,    0,   34,    0,   35,    0,
   14,    0,    0,  109,    0,    0,  121,  122,   24,    0,
    0,    0,  111,    0,    0,    0,   25,   26,   27,   28,
   29,   30,    0,   31,  123,   32,   33,  124,    0,   36,
    0,    0,    0,   37,   38,   39,    0,   15,   16,  112,
   17,  113,  114,  115,  116,  117,    0,   19,   20,   21,
  118,   22,    0,   23,  119,  120,   13,    0,    0,   34,
    0,   35,    0,   14,    0,  109,    0,    0,    0,  121,
  122,   24,  298,    0,    0,  111,   12,    0,  349,   25,
   26,   27,   28,   29,   30,    0,   31,  123,   32,   33,
  124,    0,   36,    0,    0,    0,   37,   38,   39,   15,
   16,  112,   17,  113,  114,  115,  116,  117,    0,   19,
   20,   21,  118,   22,    0,   23,  119,  120,   13,    0,
    0,   34,    0,   35,    0,   14,    0,    0,    0,    0,
    0,  121,  122,   24,    0,    0,    0,  111,    0,   12,
    0,   25,   26,   27,   28,   29,   30,    0,   31,  123,
   32,   33,  124,    0,   36,  265,    0,    0,   37,   38,
   39,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  266,   15,   16,
  118,   17,    0,  118,    0,  118,    0,  118,   19,   20,
   21,    0,   22,    0,   23,    0,    0,    0,    0,  118,
    0,   12,    0,  373,    0,    0,    0,    0,    0,  109,
    0,    0,   24,    0,    0,    0,    0,    0,    0,    0,
   25,   26,   27,   28,   29,   30,    0,   31,    0,   32,
   33,    0,    0,   59,    0,    0,    0,   37,   38,   39,
    0,    0,    0,   15,   16,  112,   17,  113,  114,  115,
  116,  117,    0,   19,   20,   21,  118,   22,    0,   23,
  119,  120,    0,  118,    0,  118,    0,    0,    0,    0,
    0,    0,  109,    0,    0,  121,  122,   24,    0,    0,
    0,    0,    0,    0,    0,   25,   26,   27,   28,   29,
   30,    0,   31,  123,   32,   33,  124,    0,   36,    0,
    0,    0,   37,   38,   39,    0,   15,   16,  112,   17,
  113,  114,  115,  116,  117,    0,   19,   20,   21,  118,
   22,    0,   23,  119,  120,  111,    0,    0,  111,    0,
  111,    0,  111,    0,  109,    0,    0,    0,  121,  122,
   24,    0,    0,    0,  111,    0,    0,    0,   25,   26,
   27,   28,   29,   30,    0,   31,  123,   32,   33,  124,
    0,   36,    0,    0,    0,   37,   38,   39,   15,   16,
  112,   17,  113,  114,  115,  116,  117,    0,   19,   20,
   21,  118,   22,    0,   23,  119,  120,   21,    0,    0,
   21,    0,   21,    0,   21,    0,  118,    0,    0,    0,
  121,  122,   24,    0,    0,    0,   21,    0,  111,    0,
   25,   26,   27,   28,   29,   30,    0,   31,  123,   32,
   33,  124,    0,   36,    0,    0,    0,   37,   38,   39,
  118,  118,  118,  118,  118,  118,  118,  118,  118,    0,
  118,  118,  118,  118,  118,    0,  118,  118,  118,  190,
    0,    0,  190,    0,  190,    0,  190,    0,    0,    0,
    0,    0,  118,  118,  118,    0,    0,    0,  190,    0,
   21,    0,  118,  118,  118,  118,  118,  118,    0,  118,
  118,  118,  118,  118,    0,  118,    0,    0,    0,  118,
  118,  118,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   17,    0,    0,   17,    0,   17,    0,   17,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   17,    0,  190,    0,    0,    0,    0,    0,    0,    0,
    0,  111,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,  111,  111,  111,  111,  111,
  111,  111,  111,  111,    0,  111,  111,  111,  111,  111,
    0,  111,  111,  111,   17,    0,    0,    0,    0,    0,
    0,    0,    0,   21,    0,    0,    0,  111,  111,  111,
    0,    0,    0,    0,    0,    0,    0,  111,  111,  111,
  111,  111,  111,    0,  111,  111,  111,  111,  111,    0,
  111,    0,    0,    0,  111,  111,  111,   21,   21,   21,
   21,   21,   21,   21,   21,   21,    0,   21,   21,   21,
   21,   21,    0,   21,   21,   21,   15,    0,    0,   15,
    0,   15,    0,   15,    0,  190,    0,    0,    0,   21,
   21,   21,    0,    0,    0,   15,    0,    0,    0,   21,
   21,   21,   21,   21,   21,    0,   21,   21,   21,   21,
   21,    0,   21,    0,    0,    0,   21,   21,   21,  190,
  190,  190,  190,  190,  190,  190,  190,  190,    0,  190,
  190,  190,  190,  190,    0,  190,  190,  190,   13,    0,
    0,   13,    0,   13,    0,   13,    0,   17,    0,    0,
    0,  190,  190,  190,    0,    0,    0,   13,    0,   15,
    0,  190,  190,  190,  190,  190,  190,    0,  190,  190,
  190,  190,  190,    0,  190,    0,    0,    0,  190,  190,
  190,   17,   17,   17,   17,   17,   17,   17,   17,   17,
    0,   17,   17,   17,   17,   17,    0,   17,   17,   17,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   17,   17,   17,    0,    0,    0,    0,
    0,   13,    0,   17,   17,   17,   17,   17,   17,    0,
   17,   17,   17,   17,   17,    0,   17,    0,    0,    0,
   17,   17,   17,    0,    0,    0,    0,    0,    0,    0,
    0,   58,  140,    0,   34,  139,   35,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   92,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   15,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   15,   15,   15,   15,
   15,   15,   15,   15,   15,   81,   15,   15,   15,   15,
   15,    0,   15,   15,   15,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   13,    0,    0,    0,   15,   15,
   15,   58,    0,    0,   34,    0,   35,    0,   15,   15,
   15,   15,   15,   15,    0,   15,   15,   15,   15,   15,
  191,   15,    0,    0,   92,   15,   15,   15,   13,   13,
   13,   13,   13,   13,   13,   13,   13,    0,   13,   13,
   13,   13,   13,    0,   13,   13,   13,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   13,   13,   13,    0,    0,    0,    0,    0,    0,    0,
   13,   13,   13,   13,   13,   13,    0,   13,   13,   13,
   13,   13,    0,   13,    0,   81,    0,   13,   13,   13,
   58,  328,    0,   34,  139,   35,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   92,    0,    0,    0,    0,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   83,   84,    0,   85,   86,   87,   88,   89,   90,
   91,   15,   16,    0,   17,    0,    0,    0,    0,    0,
    0,   19,   20,   21,    0,   22,    0,   23,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   81,   24,   58,  339,    0,   34,
  139,   35,    0,   25,   26,   27,   28,   29,   30,    0,
   31,    0,   32,   33,    0,    0,   59,    0,    0,   92,
   37,   38,   39,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  183,    0,    0,    0,   82,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   83,   84,    0,   85,   86,   87,   88,   89,   90,
   91,   15,   16,    0,   17,    0,    0,    0,    0,    0,
   81,   19,   20,   21,    0,   22,    0,   23,    0,   58,
  341,    0,   34,  139,   35,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   24,    0,    0,    0,    0,
    0,    0,   92,   25,   26,   27,   28,   29,   30,    0,
   31,    0,   32,   33,    0,    0,   59,    0,    0,    0,
   37,   38,   39,    0,    0,    0,    0,   82,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   83,   84,    0,   85,   86,   87,   88,   89,   90,   91,
   15,   16,    0,   17,    0,    0,    0,    0,    0,    0,
   19,   20,   21,   81,   22,    0,   23,   58,  360,    0,
   34,  139,   35,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   24,    0,    0,    0,    0,    0,
   92,    0,   25,   26,   27,   28,   29,   30,    0,   31,
    0,   32,   33,    0,    0,   59,    0,    0,    0,   37,
   38,   39,    0,   82,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,    0,   85,
   86,   87,   88,   89,   90,   91,   15,   16,    0,   17,
    0,    0,    0,    0,    0,    0,   19,   20,   21,    0,
   22,   81,   23,   58,  362,    0,   34,  139,   35,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   24,    0,    0,    0,    0,    0,   92,    0,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,    0,
    0,   59,    0,    0,    0,   37,   38,   39,    0,    0,
    0,    0,    0,    0,    0,    0,   82,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   83,
   84,    0,   85,   86,   87,   88,   89,   90,   91,   15,
   16,    0,   17,    0,    0,    0,    0,   81,    0,   19,
   20,   21,    0,   22,    0,   23,   58,  140,    0,   34,
    0,   35,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   24,    0,    0,    0,    0,    0,   92,
    0,   25,   26,   27,   28,   29,   30,    0,   31,    0,
   32,   33,    0,    0,   59,    0,    0,    0,   37,   38,
   39,    0,    0,    0,   82,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   83,   84,    0,
   85,   86,   87,   88,   89,   90,   91,   15,   16,    0,
   17,    0,    0,    0,    0,    0,    0,   19,   20,   21,
   81,   22,   58,   23,    0,   34,  139,   35,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   24,    0,    0,    0,   92,    0,    0,    0,   25,
   26,   27,   28,   29,   30,    0,   31,    0,   32,   33,
    0,    0,   59,    0,    0,    0,   37,   38,   39,    0,
   82,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   83,   84,    0,   85,   86,   87,   88,
   89,   90,   91,   15,   16,    0,   17,    0,    0,    0,
    0,    0,    0,   19,   20,   21,   81,   22,   58,   23,
    0,   34,    0,   35,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  243,   24,    0,    0,
    0,   92,    0,    0,    0,   25,   26,   27,   28,   29,
   30,    0,   31,    0,   32,   33,    0,    0,   59,    0,
    0,    0,   37,   38,   39,    0,    0,    0,    0,    0,
    0,    0,    0,   82,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   83,   84,    0,   85,
   86,   87,   88,   89,   90,   91,   15,   16,    0,   17,
    0,    0,   81,    0,    0,    0,   19,   20,   21,    0,
   22,    0,   23,   58,  280,    0,   34,    0,   35,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   24,    0,    0,    0,    0,    0,   92,    0,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,    0,
    0,   59,    0,    0,    0,   37,   38,   39,    0,   82,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   83,   84,    0,   85,   86,   87,   88,   89,
   90,   91,   15,   16,    0,   17,   58,  322,    0,   34,
    0,   35,   19,   20,   21,    0,   22,   81,   23,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   92,
    0,    0,    0,    0,    0,    0,   24,    0,    0,    0,
    0,    0,    0,    0,   25,   26,   27,   28,   29,   30,
    0,   31,    0,   32,   33,    0,    0,   59,    0,    0,
    0,   37,   38,   39,    0,   82,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   83,   84,
    0,   85,   86,   87,   88,   89,   90,   91,   15,   16,
   81,   17,    0,    0,    0,    0,    0,    0,   19,   20,
   21,    0,   22,    0,   23,   58,  324,    0,   34,    0,
   35,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   24,    0,    0,    0,    0,    0,   92,    0,
   25,   26,   27,   28,   29,   30,    0,   31,    0,   32,
   33,    0,    0,   59,    0,    0,    0,   37,   38,   39,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   82,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   83,   84,    0,   85,   86,   87,   88,
   89,   90,   91,   15,   16,    0,   17,    0,    0,   81,
    0,    0,    0,   19,   20,   21,    0,   22,    0,   23,
   58,  364,    0,   34,    0,   35,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   24,    0,    0,
    0,    0,    0,   92,    0,   25,   26,   27,   28,   29,
   30,    0,   31,   82,   32,   33,    0,    0,   59,    0,
    0,    0,   37,   38,   39,    0,   83,   84,    0,   85,
   86,   87,   88,   89,   90,   91,   15,   16,    0,   17,
    0,    0,    0,    0,    0,    0,   19,   20,   21,    0,
   22,    0,   23,   58,  366,    0,   34,    0,   35,    0,
    0,    0,    0,    0,   81,    0,    0,    0,    0,    0,
   24,    0,    0,    0,    0,    0,   92,    0,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,    0,
    0,   59,    0,    0,    0,   37,   38,   39,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   82,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   83,   84,    0,   85,   86,
   87,   88,   89,   90,   91,   15,   16,   81,   17,    0,
    0,    0,    0,    0,    0,   19,   20,   21,    0,   22,
    0,   23,   58,    0,    0,   34,    0,   35,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   24,
    0,  368,    0,    0,    0,   92,    0,   25,   26,   27,
   28,   29,   30,    0,   31,    0,   32,   33,    0,    0,
   59,    0,    0,    0,   37,   38,   39,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   82,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   83,   84,    0,   85,   86,   87,   88,   89,   90,   91,
   15,   16,    0,   17,    0,    0,   81,    0,    0,    0,
   19,   20,   21,    0,   22,    0,   23,   58,  379,    0,
   34,    0,   35,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   24,    0,    0,    0,    0,    0,
   92,    0,   25,   26,   27,   28,   29,   30,    0,   31,
   82,   32,   33,    0,    0,   59,    0,    0,    0,   37,
   38,   39,    0,   83,   84,    0,   85,   86,   87,   88,
   89,   90,   91,   15,   16,    0,   17,    0,    0,    0,
    0,    0,    0,   19,   20,   21,    0,   22,    0,   23,
   58,  380,    0,   34,    0,   35,    0,    0,    0,    0,
    0,   81,    0,    0,    0,    0,    0,   24,    0,    0,
    0,    0,    0,   92,    0,   25,   26,   27,   28,   29,
   30,    0,   31,    0,   32,   33,    0,    0,   59,    0,
    0,    0,   37,   38,   39,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   82,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,   83,   84,    0,   85,   86,   87,   88,   89,
   90,   91,   15,   16,   81,   17,    0,    0,    0,    0,
    0,    0,   19,   20,   21,    0,   22,    0,   23,   58,
  381,    0,   34,    0,   35,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   24,    0,    0,    0,
    0,    0,   92,    0,   25,   26,   27,   28,   29,   30,
    0,   31,    0,   32,   33,    0,    0,   59,    0,    0,
    0,   37,   38,   39,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   82,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   83,   84,    0,
   85,   86,   87,   88,   89,   90,   91,   15,   16,   58,
   17,    0,   34,   81,   35,    0,    0,   19,   20,   21,
    0,   22,    0,   23,    0,    0,    0,    0,    0,    0,
    0,    0,   92,    0,    0,    0,    0,    0,    0,    0,
    0,   24,    0,    0,    0,    0,    0,    0,    0,   25,
   26,   27,   28,   29,   30,    0,   31,   82,   32,   33,
    0,    0,   59,    0,    0,    0,   37,   38,   39,    0,
   83,   84,    0,   85,   86,   87,   88,   89,   90,   91,
   15,   16,   93,   17,    0,   93,    0,   93,    0,    0,
   19,   20,   21,   81,   22,    0,   23,    0,    0,    0,
    0,    0,    0,    0,    0,   93,    0,    0,    0,    0,
    0,    0,    0,    0,   24,    0,    0,    0,    0,    0,
    0,    0,   25,   26,   27,   28,   29,   30,    0,   31,
    0,   32,   33,    0,    0,   59,    0,    0,    0,   37,
   38,   39,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   82,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   93,    0,    0,   83,
   84,    0,   85,   86,   87,   88,   89,   90,   91,   15,
   16,    0,   17,   58,   58,    0,    0,   58,    0,   19,
   20,   21,    0,   22,    0,   23,    0,    0,    0,    0,
    0,   58,   58,    0,    0,    0,   58,    0,    0,    0,
    0,    0,    0,   24,    0,    0,    0,    0,    0,    0,
    0,   25,   26,   27,   28,   29,   30,    0,   31,    0,
   32,   33,    0,    0,   59,    0,   82,    0,   37,   38,
   39,    0,    0,    0,    0,    0,    0,    0,    0,   83,
   84,    0,   85,   86,   87,   88,   89,   90,   91,   15,
   16,    0,   17,    0,    0,    0,    0,   58,    0,   19,
   20,   21,    0,   22,    0,   23,   56,   56,    0,    0,
   56,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   24,   56,   56,    0,    0,    0,   56,
    0,   25,   26,   27,   28,   29,   30,    0,   31,   93,
   32,   33,    0,    0,   59,    0,    0,    0,   37,   38,
   39,    0,   93,   93,    0,   93,   93,   93,   93,   93,
   93,   93,   93,   93,    0,   93,    0,    0,    0,    0,
    0,    0,   93,   93,   93,    0,   93,    0,   93,    0,
    0,    0,    0,   58,    0,    0,   34,    0,   35,    0,
   56,    0,    0,    0,    0,    0,   93,    0,    0,    0,
    0,    0,    0,    0,   93,   93,   93,   93,   93,   93,
    0,   93,    0,   93,   93,    0,    0,   93,    0,    0,
    0,   93,   93,   93,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   58,    0,    0,    0,
   58,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   58,   58,   58,   58,    0,   58,   34,
    0,   35,   58,   58,   58,    0,   58,   81,    0,    0,
    0,    0,    0,   58,   58,   58,    0,   58,    0,   58,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   58,    0,    0,
    0,    0,    0,    0,    0,   58,   58,   58,   58,   58,
   58,    0,   58,    0,   58,   58,    0,    0,   58,    0,
    0,    0,   58,   58,   58,    0,    0,    0,    0,   56,
    0,    0,    0,   56,    0,    0,    0,    0,    0,    0,
   81,    0,    0,    0,    0,    0,   56,   56,   56,    0,
    0,   56,    0,    0,    0,   56,   56,   56,   58,   56,
    0,   34,    0,   35,    0,    0,   56,   56,   56,    0,
   56,    0,   56,    0,    0,    0,  338,    0,    0,    0,
    0,  267,    0,    0,    0,    0,    0,    0,    0,    0,
   56,    0,    0,    0,    0,    0,    0,    0,   56,   56,
   56,   56,   56,   56,    0,   56,    0,   56,   56,    0,
   82,   56,    0,    0,    0,   56,   56,   56,    0,    0,
    0,    0,    0,   83,    0,    0,   85,   86,   87,   88,
   89,   90,   91,   15,   16,    0,   17,    0,    0,    0,
    0,    0,    0,   19,   20,   21,    0,   22,    0,   23,
   13,    0,    0,   34,    0,   35,    0,   14,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   24,    0,    0,
    0,    0,    0,    0,    0,   25,   26,   27,   28,   29,
   30,    0,   31,   82,   32,   33,    0,    0,   59,    0,
    0,    0,   37,   38,   39,    0,    0,    0,    0,   85,
   86,   87,   88,   89,   90,   91,   15,   16,    0,   17,
    0,    0,    0,    0,    0,    0,   19,   20,   21,    0,
   22,   13,   23,    0,   34,    0,   35,    0,   14,    0,
    0,    0,    0,   12,    0,    0,    0,    0,    0,    0,
   24,    0,    0,    0,    0,    0,    0,    0,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,    0,
    0,   59,    0,    0,    0,   37,   38,   39,    0,    0,
    0,    0,    0,    0,   13,    0,    0,   34,    0,   35,
    0,   14,    0,    0,    0,  265,    0,    0,    0,    0,
    0,    0,    0,  191,    0,    0,    0,    0,   83,   84,
    0,    0,    0,    0,    0,    0,    0,  266,   15,   16,
    0,   17,    0,    0,    0,    0,    0,    0,   19,   20,
   21,    0,   22,    0,   23,    0,    0,   13,    0,    0,
   34,    0,   35,    0,   14,    0,    0,    0,    0,    0,
    0,    0,   24,    0,    0,    0,    0,    0,    0,    0,
   25,   26,   27,   28,   29,   30,    0,   31,    0,   32,
   33,    0,    0,   59,    0,    0,    0,   37,   38,   39,
    0,   10,   11,    0,    0,    0,    0,    0,    0,    0,
   13,    0,    0,   34,    0,   35,    0,   14,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   15,   16,    0,   17,    0,    0,    0,    0,    0,   18,
   19,   20,   21,    0,   22,    0,   23,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,   13,   24,    0,   34,  109,   35,    0,
   14,    0,   25,   26,   27,   28,   29,   30,    0,   31,
    0,   32,   33,    0,    0,   36,    0,    0,    0,   37,
   38,   39,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   15,   16,    0,   17,    0,  114,    0,    0,    0,
    0,   19,   20,   21,    0,   22,  303,   23,    0,   34,
    0,   35,    0,   14,    0,    0,    0,  183,    0,    0,
    0,    0,    0,  121,  122,   24,    0,    0,    0,    0,
    0,    0,    0,   25,   26,   27,   28,   29,   30,    0,
   31,    0,   32,   33,   15,   16,   36,   17,    0,    0,
   37,   38,   39,    0,   19,   20,   21,    0,   22,  303,
   23,    0,   34,    0,   35,    0,   14,    0,    0,    0,
  172,    0,    0,    0,    0,    0,    0,    0,   24,    0,
    0,    0,    0,    0,    0,    0,   25,   26,   27,   28,
   29,   30,    0,   31,    0,   32,   33,   15,   16,   36,
   17,    0,    0,   37,   38,   39,    0,   19,   20,   21,
    0,   22,  303,   23,    0,   34,    0,   35,    0,   14,
    0,    0,    0,  174,    0,    0,    0,    0,    0,    0,
    0,   24,    0,    0,    0,    0,    0,    0,    0,   25,
   26,   27,   28,   29,   30,    0,   31,    0,   32,   33,
   15,   16,   36,   17,    0,    0,   37,   38,   39,    0,
   19,   20,   21,    0,   22,   58,   23,    0,   34,    0,
   35,    0,   14,    0,    0,    0,  224,    0,    0,    0,
    0,    0,    0,    0,   24,    0,    0,    0,    0,    0,
    0,    0,   25,   26,   27,   28,   29,   30,    0,   31,
    0,   32,   33,   15,   16,   36,   17,    0,    0,   37,
   38,   39,    0,   19,   20,   21,    0,   22,   58,   23,
    0,   34,    0,   35,    0,    0,    0,    0,    0,  172,
    0,    0,    0,    0,    0,    0,    0,   24,    0,    0,
    0,    0,    0,    0,    0,   25,   26,   27,   28,   29,
   30,    0,   31,    0,   32,   33,   15,   16,   36,   17,
    0,    0,   37,   38,   39,    0,   19,   20,   21,    0,
   22,  213,   23,    0,   34,    0,   35,    0,   14,    0,
    0,    0,  174,    0,    0,    0,    0,    0,    0,    0,
   24,    0,    0,    0,    0,    0,    0,    0,   25,   26,
   27,   28,   29,   30,    0,   31,    0,   32,   33,   15,
   16,   36,   17,    0,    0,   37,   38,   39,    0,   19,
   20,   21,    0,   22,  303,   23,    0,   34,    0,   35,
    0,   14,    0,    0,    0,  224,    0,    0,    0,    0,
    0,    0,    0,   24,    0,    0,    0,    0,    0,    0,
    0,   25,   26,   27,   28,   29,   30,    0,   31,    0,
   32,   33,   15,   16,   36,   17,    0,    0,   37,   38,
   39,    0,   19,   20,   21,    0,   22,   26,   23,    0,
   26,    0,   26,    0,   26,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,   24,    0,    0,    0,
    0,    0,    0,    0,   25,   26,   27,   28,   29,   30,
    0,   31,    0,   32,   33,   15,   16,   36,   17,    0,
    0,   37,   38,   39,    0,   19,   20,   21,    0,   22,
   58,   23,    0,   34,    0,   35,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,   24,
    0,    0,    0,    0,    0,    0,    0,   25,   26,   27,
   28,   29,   30,    0,   31,    0,   32,   33,   15,   16,
   36,   17,    0,    0,   37,   38,   39,    0,   19,   20,
   21,    0,   22,   58,   23,    0,   34,    0,   35,    0,
    0,    0,    0,  176,    0,    0,    0,    0,    0,    0,
    0,    0,   24,    0,    0,    0,    0,    0,    0,    0,
   25,   26,   27,   28,   29,   30,    0,   31,    0,   32,
   33,   15,   16,   59,   17,    0,    0,   37,   38,   39,
    0,   19,   20,   21,    0,   22,    0,   23,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,   24,    0,    0,    0,    0,
    0,    0,    0,   25,   26,   27,   28,   29,   30,    0,
   31,    0,   32,   33,   15,   16,   36,   17,    0,    0,
   37,   38,   39,    0,   19,   20,   21,    0,   22,    0,
   23,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   24,    0,
    0,    0,    0,    0,    0,    0,   25,   26,   27,   28,
   29,   30,    0,   31,    0,   32,   33,   26,   26,   36,
   26,    0,    0,   37,   38,   39,    0,   26,   26,   26,
    0,   26,    0,   26,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,   26,    0,    0,    0,    0,    0,    0,    0,   26,
   26,   26,   26,   26,   26,    0,   26,    0,   26,   26,
   15,   16,   26,   17,    0,    0,   26,   26,   26,    0,
   19,   20,   21,    0,   22,    0,   23,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   24,    0,    0,    0,    0,    0,
    0,    0,   25,   26,   27,   28,   29,   30,    0,   31,
    0,   32,   33,   15,   16,   59,   17,    0,    0,   37,
   38,   39,    0,   19,   20,   21,    0,   22,    0,   23,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,   24,    0,    0,
    0,    0,    0,    0,    0,   25,   26,   27,   28,   29,
   30,    0,    0,    0,   32,   33,    0,    0,   59,    0,
    0,    0,   37,   38,   39,
};
static const YYINT yycheck[] = {                         17,
   37,   59,  102,    7,   59,   42,   10,   11,   41,   41,
   47,  111,   41,   31,  111,   65,   34,   35,   36,   37,
   38,   39,   40,   37,   59,  198,   59,   59,   42,   43,
   59,   45,   82,   47,   59,   91,   54,  263,   41,   43,
    0,   59,  124,  350,  113,  123,   59,  116,   41,  213,
  119,  120,   70,   44,  123,   40,   59,  126,   44,  337,
   41,   68,   69,   44,   44,  332,   59,  290,  335,   91,
  377,   41,  214,   52,   53,  290,  349,  350,   96,   97,
   98,   99,  100,  101,   44,  135,   40,   47,  315,   59,
   41,  191,   41,   44,  191,   44,   41,   40,   40,   59,
  104,  108,   93,   40,  263,   40,  332,  125,  255,  332,
  257,  334,   93,   93,   59,   40,  134,  332,  333,  334,
   36,   40,  349,  350,  103,  315,   41,  196,  146,   44,
  148,  290,  150,  202,  152,  153,  351,  123,   40,  303,
  158,  159,  160,  161,  162,  338,  164,  165,  166,  167,
  168,  169,   40,  171,  133,  173,  263,  175,  176,  349,
  350,   41,  304,  123,   44,  307,  308,  309,  310,  287,
  188,  348,  314,  332,  333,  334,  339,  350,  196,  124,
  263,   40,    0,  290,  202,  235,  236,  334,   41,  263,
   41,   44,  351,   44,  294,   41,  214,  294,   44,   40,
  282,  256,  220,  285,  377,  263,   40,  225,  263,  227,
  289,   47,   58,   59,  356,  265,  332,   63,  134,   41,
  367,   41,   44,   41,   44,  332,   44,  334,  263,   47,
  263,  263,  332,  289,  263,  332,  383,  255,  263,  257,
   58,   59,  246,  250,   44,   63,   41,  265,  263,  267,
  263,  269,  270,  271,  272,  273,  274,  275,   91,  325,
  263,  279,   17,   59,   59,  283,  284,  285,  368,  287,
  263,  368,  290,  291,  263,   93,  263,  327,  124,   34,
   35,   36,   41,   41,   39,   40,  304,  289,   41,  307,
  308,  309,  310,  263,  343,   40,  314,  315,  316,   54,
   41,  261,  262,  263,   59,  123,   41,   41,   41,   44,
  379,  348,    0,  292,  318,   70,  287,    0,  263,  290,
  338,   59,  340,   41,  342,  123,  344,  345,  346,  124,
  348,  185,   41,  351,  348,   44,  104,  282,  356,  299,
  285,   96,   97,   98,   99,  100,  101,   41,   45,  265,
   44,  267,  370,  269,  270,  271,  374,  375,   93,  275,
   -1,  332,  333,  334,  343,   41,   -1,  265,   44,  267,
  125,  269,  270,  271,   -1,   41,   -1,  275,   44,  134,
  351,   -1,   58,   59,   -1,   -1,   -1,   63,   -1,  214,
   -1,  146,   -1,  148,   -1,  150,   -1,  152,  153,   -1,
   -1,   -1,   -1,  158,  159,  160,   -1,  162,   -1,  164,
  165,  166,  167,  168,  169,   -1,  171,  263,  173,   -1,
  175,  176,  338,   40,   41,   -1,   43,   -1,   45,   -1,
   47,   -1,   91,  188,  280,  281,  282,   -1,   -1,  285,
  338,  196,   -1,  261,  262,  263,   -1,  202,  124,   -1,
    0,   -1,   -1,   -1,   -1,  114,   -1,   -1,   -1,  214,
   -1,   -1,  280,  281,   -1,  220,   -1,  128,  263,  130,
  225,   -1,  227,   -1,   -1,   -1,  137,  138,   -1,  304,
   -1,  299,  307,  308,  309,  310,   -1,  282,   -1,  314,
  285,   41,   -1,  339,   44,   -1,   -1,   47,   -1,   -1,
  255,   -1,  257,   -1,   -1,   -1,   -1,   -1,   58,   59,
  265,   -1,  267,   63,  269,  270,  271,  272,  273,  274,
  275,  339,   -1,   -1,  279,  186,   -1,   -1,  283,  284,
  285,  356,  287,   -1,   -1,  290,  291,   -1,   -1,  198,
   -1,   -1,   -1,   93,   -1,   -1,   -1,   -1,  209,  304,
  211,  212,  307,  308,  309,  310,   -1,   -1,   -1,  314,
  315,  316,   -1,    7,   -1,   -1,   -1,  226,   -1,   13,
   -1,   -1,   -1,  123,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  240,   -1,  338,   -1,   -1,   -1,  263,   -1,  344,
  345,  346,   -1,  348,   -1,   -1,  351,   -1,  259,   -1,
   -1,  356,   -1,   -1,  280,  281,  282,  266,   -1,  285,
   -1,   -1,    0,   57,   58,  370,   -1,   -1,   -1,  374,
  375,   65,   66,   67,   68,   69,   -1,   -1,   72,   73,
   -1,   -1,   -1,   -1,   -1,   -1,  295,   -1,   82,   -1,
   41,   85,   86,   87,   88,   89,   90,   -1,   92,   37,
   94,   95,   40,   41,   42,   43,   44,   45,   59,   47,
  104,  105,   -1,   -1,  108,   -1,   -1,   -1,   -1,  330,
   58,   59,  116,  290,  291,   63,  293,  336,   -1,  123,
   -1,   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,
   -1,  135,   -1,   -1,   -1,   -1,   -1,  141,  359,  143,
   -1,   -1,   -1,    0,   -1,   93,   -1,  324,  369,   -1,
   -1,  261,  262,  263,   -1,  332,  333,  334,  335,  336,
  337,  382,  339,  124,  341,  342,  387,   -1,  345,   -1,
  280,  281,  349,  350,  351,  123,  124,   -1,   -1,   -1,
   37,  185,   -1,   -1,   41,   42,   43,   44,   45,  299,
   47,   -1,   -1,   -1,   41,  199,   -1,   44,   -1,   -1,
  204,   58,   59,   -1,   -1,   -1,   63,   -1,   -1,  213,
   -1,   58,   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   41,   -1,  230,   44,   -1,  233,
  234,  235,  236,   -1,   -1,   -1,   93,  241,    0,  243,
   -1,   58,   59,   -1,   -1,   -1,  250,   -1,   -1,   -1,
   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  123,  124,   -1,   -1,
   -1,   -1,  276,  277,   -1,   37,   -1,  124,   40,   41,
   42,   43,   44,   45,   -1,   47,   -1,   -1,   -1,   -1,
   -1,   -1,   41,   -1,   -1,   44,   58,   59,   47,  303,
   -1,   63,  263,   -1,   -1,   -1,   -1,  124,   -1,   58,
   59,   -1,   -1,  261,  262,  263,  320,  321,   -1,  267,
   -1,  282,   -1,  327,  285,  329,   -1,   -1,   -1,  333,
   -1,   93,  280,  281,  282,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   93,  293,   -1,   -1,   -1,  353,
   -1,  299,  300,  301,  302,   -1,  304,  361,  306,  363,
   -1,  123,  124,   -1,   -1,   40,   -1,  315,   43,   -1,
   45,   -1,   -1,   -1,  123,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,
  348,  349,  350,  351,  261,  262,  263,   -1,   -1,   -1,
  267,   -1,   -1,   -1,   -1,   -1,  263,   -1,   -1,   -1,
   -1,   -1,   -1,  280,  281,  282,  283,  284,  285,  286,
  287,  288,  289,  290,  291,  282,  293,   -1,  285,   -1,
   -1,   -1,  299,  300,  301,  302,  263,  304,   -1,  306,
   -1,   -1,   -1,   -1,   -1,   -1,   40,   41,  315,   43,
   -1,   45,   -1,   47,   -1,  282,   -1,  324,  285,   -1,
   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,
   -1,  348,  349,  350,  351,   -1,   -1,   -1,   -1,  261,
  262,  263,   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,
   -1,   -1,  261,  262,  263,   -1,   -1,   -1,  280,  281,
  282,  283,  284,  285,  286,  287,  288,  289,  290,  291,
   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,  300,  301,
  302,   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,   41,
  299,   -1,   44,  315,    0,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  324,   41,   -1,   -1,   44,   59,   -1,   -1,
  332,  333,  334,  335,  336,   -1,   -1,  339,   -1,  341,
  342,   59,   -1,  345,   -1,   -1,  348,  349,  350,  351,
   -1,   37,  267,   -1,   40,   41,   42,   43,   44,   45,
   -1,   47,   -1,   -1,   -1,  280,   -1,   -1,   -1,   -1,
   -1,   -1,   58,   59,  289,  290,  291,   63,  293,   -1,
   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,  304,
   -1,  306,  124,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,    0,  124,   93,   -1,  324,
   -1,   -1,   -1,   -1,    0,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,
  345,   -1,   -1,   -1,  349,  350,  351,  123,  124,   -1,
   -1,   -1,   37,   -1,   -1,   40,   41,   42,   43,   44,
   45,   -1,   47,   -1,   -1,   41,   -1,   -1,   44,   -1,
   -1,   47,   -1,   58,   59,   -1,  290,  291,   63,  293,
   -1,   -1,   58,   59,   -1,   -1,  300,  301,  302,   -1,
  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,    0,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   93,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,   -1,   -1,  349,  350,  351,  123,  124,
   -1,  263,   -1,   -1,   -1,   -1,   37,  123,   -1,   40,
   41,   42,   43,   44,   45,  263,   47,   -1,   -1,   -1,
  282,   -1,   -1,  285,   -1,   -1,   -1,   58,   59,   -1,
   -1,   -1,   63,   -1,  282,   -1,   -1,  285,   -1,   41,
   -1,   -1,   44,   -1,   -1,  261,  262,  263,   -1,   -1,
   -1,  267,   -1,   -1,   -1,   -1,   58,   59,   -1,   -1,
   -1,   63,   93,   -1,  280,  281,  282,  283,  284,  285,
  286,   -1,  288,  289,  290,  291,   -1,  293,   -1,   -1,
   -1,   -1,   -1,  299,  300,  301,  302,   -1,  304,   -1,
  306,   -1,  123,  124,   -1,   -1,   -1,   -1,   -1,  315,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,
  336,  337,  124,  339,   -1,  341,  342,   -1,   -1,  345,
   -1,   -1,  348,  349,  350,  351,  261,  262,  263,   -1,
   -1,   -1,  267,   -1,   -1,  261,  262,  263,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  280,  281,  282,  283,  284,
  285,  286,  287,  288,  289,  290,  291,   -1,  293,   -1,
   -1,   -1,   -1,   -1,  299,  300,  301,  302,   -1,  304,
   -1,  306,   -1,  299,   -1,   -1,   40,   -1,   -1,   43,
  315,   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,  324,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,
  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,   -1,
  261,  262,  263,   -1,   -1,   -1,  267,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,
  281,  282,  283,  284,  285,  286,  287,  288,  289,  290,
  291,  263,  293,   -1,   -1,   -1,   -1,   -1,  299,  300,
  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,  281,
  282,   -1,   -1,  285,  315,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,    0,   -1,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,   -1,
  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,
  351,   -1,   37,   -1,   -1,   40,   41,   42,   43,   44,
   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,   -1,   41,
   -1,   -1,   44,   58,   59,   47,   -1,   -1,   63,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   58,   59,   -1,   -1,
   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   93,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   37,  123,  124,
   40,   41,   42,   43,   44,   45,   -1,   47,   -1,   -1,
   -1,  123,   -1,   -1,   -1,   -1,   -1,   -1,   58,   59,
   -1,   -1,   -1,   63,   -1,   -1,  290,  291,   -1,  293,
   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,
  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   93,   -1,   -1,   -1,   -1,   -1,    0,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,  123,  124,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   37,   -1,   -1,   40,
   41,   42,   43,   44,   45,   -1,   47,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   58,   59,   -1,
   -1,   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  261,  262,  263,   -1,
   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,  261,
  262,  263,   93,   -1,   -1,  280,  281,  282,  283,  284,
  285,  286,  287,  288,  289,  290,  291,   -1,  293,  281,
   -1,   -1,   -1,   -1,  299,  300,  301,  302,   -1,  304,
   -1,  306,  123,  124,   -1,   -1,   -1,  299,   -1,   -1,
  315,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,
  345,  261,  262,  263,  349,  350,  351,  267,   -1,   -1,
   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  280,  281,  282,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,
  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   43,  315,   45,   -1,   47,   -1,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   59,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  261,  262,  263,   -1,   -1,   -1,  267,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,
  281,  282,  283,  284,  285,  286,  287,  288,  289,  290,
  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,  300,
  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  315,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,   -1,
  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,
  351,   -1,   37,   -1,   -1,   40,   41,   42,   43,   44,
   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   58,   59,   -1,   -1,   -1,   63,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  261,  262,  263,   -1,   -1,   37,  123,  124,
   40,   41,   42,   43,   44,   45,   -1,   47,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   58,   59,
   -1,  290,  291,   63,  293,   -1,   -1,   -1,   -1,   -1,
  299,  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   93,   -1,  324,   -1,   -1,   -1,    0,
   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,
  349,  350,  351,  123,  124,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   37,   -1,   -1,   40,
   41,   42,   43,   44,   45,   -1,   47,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   58,   59,   -1,
   -1,   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  261,  262,  263,   -1,
   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   93,   -1,   -1,  280,  281,  282,  283,  284,
  285,  286,  287,  288,  289,  290,  291,   -1,  293,   -1,
   -1,   -1,   -1,   -1,  299,  300,  301,  302,   -1,  304,
   -1,  306,  123,  124,   -1,   -1,   -1,   -1,   -1,   -1,
  315,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,
  345,  261,  262,  263,  349,  350,  351,  267,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  280,  281,  282,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,
  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  315,   -1,   -1,   -1,   54,
   55,   -1,   40,   41,  324,   43,   -1,   45,   -1,   47,
   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  261,  262,  263,   -1,   -1,   -1,  267,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,
  281,  282,  283,  284,  285,  286,  287,  288,  289,  290,
  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,  300,
  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,
   -1,    0,   -1,   -1,  315,  150,  151,  152,  153,   -1,
   -1,   -1,   -1,  324,  159,  160,   -1,   -1,   -1,   -1,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,   -1,
  341,  342,   -1,   -1,  345,   -1,   -1,  348,   37,   -1,
  351,   40,   41,   42,   43,   44,   45,   -1,   47,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   58,
   59,   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,   -1,
  215,   -1,   -1,   -1,   -1,  220,  221,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  232,   -1,   -1,
   -1,   -1,    0,   -1,   93,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  264,
   -1,   -1,   -1,   -1,  123,  124,   -1,   -1,  256,   -1,
   -1,   -1,   40,   41,   -1,   43,   44,   45,  283,  284,
   -1,   -1,   -1,   -1,  289,  290,   -1,   -1,   -1,   -1,
   58,   59,   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,
   -1,   -1,  290,  291,   -1,  293,   -1,  295,   -1,   -1,
  315,  316,  300,  301,  302,   -1,  304,   -1,  306,   -1,
   -1,   -1,   -1,   -1,   -1,   93,    0,   -1,   -1,   -1,
   -1,   -1,  337,   -1,  322,  323,  324,   -1,   -1,  344,
  345,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,  123,  124,  345,   -1,   -1,
   -1,  349,  350,  351,   -1,   -1,   40,   41,   -1,   43,
   44,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   58,   59,   -1,   -1,   -1,   63,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  261,  262,  263,   -1,   -1,   -1,  267,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   93,
   -1,  280,  281,   -1,  283,  284,  285,  286,  287,  288,
  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,
  299,  300,  301,  302,   -1,  304,   -1,  306,   -1,  123,
  124,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   43,   -1,   45,   -1,  324,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,   63,  341,  342,   -1,   -1,  345,   -1,   -1,  348,
   -1,   -1,  351,  261,  262,  263,   -1,   -1,   -1,  267,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  280,  281,  282,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,
   -1,  299,  300,  301,  302,   -1,  304,   -1,  306,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  315,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,
    0,  349,  350,  351,   -1,   -1,   -1,  261,  262,  263,
   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,  282,  283,
  284,  285,  286,  287,  288,  289,  290,  291,   -1,  293,
   40,   41,   -1,   -1,   44,  299,  300,  301,  302,   -1,
  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,   58,   59,
   -1,  315,   -1,   63,   -1,   -1,   -1,    0,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,    0,   93,   -1,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  267,   -1,   -1,   41,   -1,
   -1,   44,   -1,   -1,   47,   -1,   -1,   -1,  280,  281,
   -1,   -1,   -1,  123,  124,   58,   59,  289,  290,  291,
   63,  293,   40,   41,   -1,   -1,   44,   -1,  300,  301,
  302,   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,
   58,   59,   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,
   93,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,   -1,  341,
  342,   -1,   -1,  345,    0,   93,   -1,  349,  350,  351,
  123,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  123,  124,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   40,   41,   -1,   -1,   44,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   58,   59,   -1,   -1,   -1,   63,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  261,  262,  263,   -1,   -1,   -1,  267,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,    0,   93,   -1,   -1,
  280,  281,  282,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,
  300,  301,  302,   -1,  304,   -1,  306,  123,  124,   -1,
   -1,   -1,   -1,   -1,   -1,  315,   40,   -1,   -1,   43,
   -1,   45,   -1,   47,  324,   -1,   -1,   -1,  261,  262,
  263,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,  280,  281,  349,
  350,  351,   -1,  261,  262,  263,   -1,   -1,   -1,  267,
   -1,   -1,   -1,   -1,   -1,   -1,  299,   -1,   -1,   -1,
   -1,   -1,  280,  281,  282,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,
   -1,  299,  300,  301,  302,   -1,  304,   -1,  306,  123,
   -1,   -1,   -1,   -1,   -1,   -1,  339,  315,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,    0,   -1,
   -1,  349,  350,  351,   -1,  261,  262,  263,   -1,   -1,
   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  280,  281,  282,  283,  284,  285,
  286,  287,  288,  289,  290,  291,   -1,  293,   40,   41,
   -1,   -1,   44,  299,  300,  301,  302,   -1,  304,   -1,
  306,   -1,   -1,   -1,   -1,   -1,   58,   59,   -1,  315,
   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,
  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,  345,
    0,   93,   -1,  349,  350,  351,   -1,  261,  262,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  123,  124,   -1,   -1,   -1,  290,  291,   -1,  293,
   40,   41,   -1,   -1,   44,  299,  300,  301,  302,   -1,
  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,   58,   59,
   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,    0,   93,   -1,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  123,  124,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   40,   41,   -1,   -1,   44,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   58,   59,   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  261,
  262,  263,   -1,   -1,   -1,  267,   -1,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   93,   -1,   -1,  280,  281,
  282,  283,  284,  285,  286,  287,  288,  289,  290,  291,
   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,  300,  301,
  302,   -1,  304,   -1,  306,  123,  124,   40,   -1,   -1,
   43,   -1,   45,  315,   47,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  324,   -1,   -1,   -1,   59,   -1,   -1,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,   -1,  341,
  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,
   -1,  261,  262,  263,   -1,   -1,   -1,  267,   -1,   -1,
   -1,   -1,    0,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  280,  281,   -1,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,
  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,
   -1,   -1,   40,   -1,   -1,   43,   -1,   45,   -1,   47,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,  261,  262,  263,   -1,   -1,   -1,  267,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  280,  281,   -1,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,
   -1,  299,  300,  301,  302,  123,  304,   -1,  306,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,  261,  262,
  263,  349,  350,  351,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  290,  291,   -1,
  293,   -1,   -1,   -1,   -1,   -1,  299,  300,  301,  302,
   -1,  304,   37,  306,   -1,   40,   41,   42,   43,   44,
   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  324,   -1,   58,   59,   -1,   -1,   -1,   63,  332,
  333,  334,  335,  336,  337,   -1,  339,   -1,  341,  342,
   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,
   -1,   -1,   -1,  261,  262,   -1,   -1,   -1,   93,    0,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  290,  291,   -1,  293,   -1,   -1,  123,  124,
   -1,  299,  300,  301,  302,   -1,  304,   -1,  306,   40,
   41,   -1,   43,   44,   45,   -1,   47,    0,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   58,   59,   -1,
   -1,   -1,   63,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,
   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   41,    0,
   -1,   44,   93,   -1,   47,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,    0,   -1,   -1,   58,   59,   -1,   -1,   -1,
   63,   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,
   -1,   -1,  123,  124,   -1,   -1,   -1,   -1,   -1,   -1,
   41,   -1,   -1,   44,   -1,   -1,   47,   -1,   -1,   -1,
   93,   -1,   -1,   41,   -1,   -1,   44,   58,   59,   47,
   -1,   -1,   63,   -1,   -1,   -1,   41,   -1,   -1,   44,
   58,   59,   47,   -1,   -1,   63,  261,  262,  263,   -1,
  123,   -1,  267,   58,   59,   -1,   -1,   -1,   63,   -1,
   -1,   -1,   93,   -1,   -1,  280,  281,  282,  283,  284,
  285,  286,   -1,  288,  289,   93,  291,   -1,  293,   -1,
   -1,   -1,   -1,   -1,  299,  300,  301,  302,   93,  304,
   -1,  306,  123,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  315,   -1,   -1,   -1,   -1,  123,   -1,   -1,   -1,  324,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  123,   -1,
  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,
  345,   -1,   -1,  348,  349,  350,   -1,   -1,   -1,   -1,
  261,  262,  263,   -1,   -1,   -1,  267,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,    0,   -1,   -1,   -1,   -1,  280,
  281,   -1,  283,  284,  285,  286,  287,  288,  289,   -1,
  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,  300,
  301,  302,   -1,  304,   -1,  306,   -1,   -1,  261,  262,
  263,   -1,   -1,   -1,   -1,   41,   -1,   -1,   44,   -1,
   -1,   47,   -1,  324,   -1,   -1,   -1,  280,  281,   -1,
   -1,   -1,   58,   59,  335,  336,  337,   63,  339,   -1,
  341,  342,   -1,   -1,  345,   -1,  299,   -1,  349,  350,
  261,  262,  263,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  261,  262,  263,   -1,   93,   -1,  280,
  281,   -1,   -1,   -1,   -1,   -1,  261,  262,  263,   -1,
   -1,   -1,  280,  281,   37,   -1,  339,   40,  299,   42,
   43,   -1,   45,   -1,   47,  280,  281,  123,   -1,   -1,
   -1,  299,   -1,   -1,   -1,   -1,   59,   -1,   -1,   -1,
   63,   -1,   -1,   -1,  299,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  339,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  339,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  339,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  124,   -1,   37,   -1,   -1,   40,   41,   42,   43,
   44,   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   58,   59,   -1,   -1,   -1,   63,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  261,  262,  263,   40,   41,
   -1,   43,   -1,   45,   -1,   47,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  280,  281,   -1,   59,   -1,   -1,
  124,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  299,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  339,  267,   -1,   -1,   -1,   -1,   -1,
   -1,  123,   -1,  125,   -1,   -1,   -1,  280,  281,   -1,
  283,  284,  285,  286,  287,  288,   -1,  290,  291,   40,
  293,   -1,   43,   -1,   45,   -1,   47,  300,  301,  302,
   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,   59,   -1,
   -1,   -1,  315,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,
  333,  334,  335,  336,  337,   -1,  339,   -1,  341,  342,
   -1,   -1,  345,   -1,   -1,  348,  349,  350,  351,  263,
   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,  282,   -1,
   -1,  285,  123,   -1,  125,  289,  290,  291,   -1,  293,
   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,
  304,   -1,  306,   40,   -1,   -1,   43,   -1,   45,   -1,
   47,   -1,   -1,   -1,  256,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   59,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,   -1,  348,   -1,   -1,  351,  290,  291,
  292,  293,  294,  295,  296,  297,  298,   -1,  300,  301,
  302,  303,  304,   -1,  306,  307,  308,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  322,  323,  324,  325,   -1,   -1,  123,   -1,  125,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,  340,  341,
  342,  343,   -1,  345,   -1,   -1,   -1,  349,  350,  351,
   -1,   -1,   -1,   -1,   -1,  256,   -1,   -1,   -1,   -1,
   40,   -1,   -1,   43,   -1,   45,   -1,   47,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  290,
  291,  292,  293,  294,  295,  296,  297,  298,   -1,  300,
  301,  302,  303,  304,   -1,  306,  307,  308,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  322,  323,  324,  325,   -1,   -1,   -1,   -1,   -1,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,  340,
  341,  342,  343,  123,  345,  125,   -1,   -1,  349,  350,
  351,   40,   -1,   -1,   43,   -1,   45,   -1,   47,  256,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  290,  291,  292,  293,  294,  295,  296,
  297,  298,   -1,  300,  301,  302,  303,  304,   -1,  306,
  307,  308,   -1,   40,   -1,   -1,   43,   -1,   45,   -1,
   47,   -1,   -1,   -1,   -1,  322,  323,  324,  325,   -1,
   -1,   -1,   59,   -1,  123,  332,  333,  334,  335,  336,
  337,   -1,  339,  340,  341,  342,  343,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  256,   -1,   -1,   -1,
   -1,   -1,   -1,   40,   -1,   -1,   43,   -1,   45,   -1,
   47,   -1,   -1,   -1,   -1,   -1,  123,   -1,  125,   -1,
   -1,   -1,   59,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  290,  291,  292,  293,  294,  295,  296,  297,  298,   -1,
  300,  301,  302,  303,  304,   -1,  306,  307,  308,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  322,  323,  324,  325,   -1,   -1,   -1,   -1,
   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
  340,  341,  342,  343,   -1,  345,  123,  256,  125,  349,
  350,  351,   -1,   -1,  263,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  290,  291,  292,  293,  294,  295,  296,  297,  298,
   -1,  300,  301,  302,  303,  304,   -1,  306,  307,  308,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  256,
   -1,   -1,   -1,  322,  323,  324,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,  340,  341,  342,  343,   -1,  345,   -1,   -1,   -1,
  349,  350,  351,  290,  291,  292,  293,  294,  295,  296,
  297,  298,   -1,  300,  301,  302,  303,  304,   -1,  306,
  307,  308,   -1,   -1,   -1,   40,   -1,   -1,   43,   -1,
   45,   -1,   47,   -1,   -1,  322,  323,  324,   -1,  256,
   -1,   -1,   -1,   -1,   59,  332,  333,  334,  335,  336,
  337,   -1,  339,  340,  341,  342,  343,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  290,  291,  292,  293,  294,  295,  296,
  297,  298,   -1,  300,  301,  302,  303,  304,   -1,  306,
  307,  308,   -1,   -1,   40,   -1,   -1,   43,   -1,   45,
   -1,   47,   -1,   -1,   -1,  322,  323,  324,  123,   -1,
  125,   -1,   -1,   59,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,  340,  341,  342,  343,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   40,   -1,   -1,
   43,   -1,   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   59,  123,   -1,  125,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   40,
   -1,   -1,   43,   -1,   45,   -1,   47,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   59,   -1,
  123,  256,  125,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  290,  291,  292,  293,  294,
  295,  296,  297,  298,   -1,  300,  301,  302,  303,  304,
   -1,  306,  307,  308,   -1,   -1,   -1,   -1,   40,   -1,
   -1,   43,  123,   45,   -1,   -1,   -1,  322,  323,  324,
  256,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,  340,  341,  342,  343,   -1,
  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  290,  291,  292,  293,  294,  295,
  296,  297,  298,   -1,  300,  301,  302,  303,  304,   -1,
  306,  307,  308,   40,   -1,   -1,   43,   -1,   45,   -1,
   47,   -1,   -1,  256,   -1,   -1,  322,  323,  324,   -1,
   -1,   -1,   59,   -1,   -1,   -1,  332,  333,  334,  335,
  336,  337,   -1,  339,  340,  341,  342,  343,   -1,  345,
   -1,   -1,   -1,  349,  350,  351,   -1,  290,  291,  292,
  293,  294,  295,  296,  297,  298,   -1,  300,  301,  302,
  303,  304,   -1,  306,  307,  308,   40,   -1,   -1,   43,
   -1,   45,   -1,   47,   -1,  256,   -1,   -1,   -1,  322,
  323,  324,  263,   -1,   -1,   59,  123,   -1,  125,  332,
  333,  334,  335,  336,  337,   -1,  339,  340,  341,  342,
  343,   -1,  345,   -1,   -1,   -1,  349,  350,  351,  290,
  291,  292,  293,  294,  295,  296,  297,  298,   -1,  300,
  301,  302,  303,  304,   -1,  306,  307,  308,   40,   -1,
   -1,   43,   -1,   45,   -1,   47,   -1,   -1,   -1,   -1,
   -1,  322,  323,  324,   -1,   -1,   -1,   59,   -1,  123,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,  340,
  341,  342,  343,   -1,  345,  267,   -1,   -1,  349,  350,
  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  289,  290,  291,
   40,  293,   -1,   43,   -1,   45,   -1,   47,  300,  301,
  302,   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,   59,
   -1,  123,   -1,  125,   -1,   -1,   -1,   -1,   -1,  256,
   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,   -1,  341,
  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,
   -1,   -1,   -1,  290,  291,  292,  293,  294,  295,  296,
  297,  298,   -1,  300,  301,  302,  303,  304,   -1,  306,
  307,  308,   -1,  123,   -1,  125,   -1,   -1,   -1,   -1,
   -1,   -1,  256,   -1,   -1,  322,  323,  324,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,  340,  341,  342,  343,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,  290,  291,  292,  293,
  294,  295,  296,  297,  298,   -1,  300,  301,  302,  303,
  304,   -1,  306,  307,  308,   40,   -1,   -1,   43,   -1,
   45,   -1,   47,   -1,  256,   -1,   -1,   -1,  322,  323,
  324,   -1,   -1,   -1,   59,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,  340,  341,  342,  343,
   -1,  345,   -1,   -1,   -1,  349,  350,  351,  290,  291,
  292,  293,  294,  295,  296,  297,  298,   -1,  300,  301,
  302,  303,  304,   -1,  306,  307,  308,   40,   -1,   -1,
   43,   -1,   45,   -1,   47,   -1,  256,   -1,   -1,   -1,
  322,  323,  324,   -1,   -1,   -1,   59,   -1,  123,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,  340,  341,
  342,  343,   -1,  345,   -1,   -1,   -1,  349,  350,  351,
  290,  291,  292,  293,  294,  295,  296,  297,  298,   -1,
  300,  301,  302,  303,  304,   -1,  306,  307,  308,   40,
   -1,   -1,   43,   -1,   45,   -1,   47,   -1,   -1,   -1,
   -1,   -1,  322,  323,  324,   -1,   -1,   -1,   59,   -1,
  123,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
  340,  341,  342,  343,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   -1,   -1,   43,   -1,   45,   -1,   47,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   59,   -1,  123,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  256,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  290,  291,  292,  293,  294,
  295,  296,  297,  298,   -1,  300,  301,  302,  303,  304,
   -1,  306,  307,  308,  123,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  256,   -1,   -1,   -1,  322,  323,  324,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,  340,  341,  342,  343,   -1,
  345,   -1,   -1,   -1,  349,  350,  351,  290,  291,  292,
  293,  294,  295,  296,  297,  298,   -1,  300,  301,  302,
  303,  304,   -1,  306,  307,  308,   40,   -1,   -1,   43,
   -1,   45,   -1,   47,   -1,  256,   -1,   -1,   -1,  322,
  323,  324,   -1,   -1,   -1,   59,   -1,   -1,   -1,  332,
  333,  334,  335,  336,  337,   -1,  339,  340,  341,  342,
  343,   -1,  345,   -1,   -1,   -1,  349,  350,  351,  290,
  291,  292,  293,  294,  295,  296,  297,  298,   -1,  300,
  301,  302,  303,  304,   -1,  306,  307,  308,   40,   -1,
   -1,   43,   -1,   45,   -1,   47,   -1,  256,   -1,   -1,
   -1,  322,  323,  324,   -1,   -1,   -1,   59,   -1,  123,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,  340,
  341,  342,  343,   -1,  345,   -1,   -1,   -1,  349,  350,
  351,  290,  291,  292,  293,  294,  295,  296,  297,  298,
   -1,  300,  301,  302,  303,  304,   -1,  306,  307,  308,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  322,  323,  324,   -1,   -1,   -1,   -1,
   -1,  123,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,  340,  341,  342,  343,   -1,  345,   -1,   -1,   -1,
  349,  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   40,   41,   -1,   43,   44,   45,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  256,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  290,  291,  292,  293,
  294,  295,  296,  297,  298,  124,  300,  301,  302,  303,
  304,   -1,  306,  307,  308,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  256,   -1,   -1,   -1,  322,  323,
  324,   40,   -1,   -1,   43,   -1,   45,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,  340,  341,  342,  343,
   59,  345,   -1,   -1,   63,  349,  350,  351,  290,  291,
  292,  293,  294,  295,  296,  297,  298,   -1,  300,  301,
  302,  303,  304,   -1,  306,  307,  308,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  322,  323,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,  340,  341,
  342,  343,   -1,  345,   -1,  124,   -1,  349,  350,  351,
   40,   41,   -1,   43,   44,   45,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,  267,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  280,  281,   -1,  283,  284,  285,  286,  287,  288,
  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,
   -1,  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  124,  324,   40,   41,   -1,   43,
   44,   45,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   63,
  349,  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  263,   -1,   -1,   -1,  267,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  280,  281,   -1,  283,  284,  285,  286,  287,  288,
  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,
  124,  300,  301,  302,   -1,  304,   -1,  306,   -1,   40,
   41,   -1,   43,   44,   45,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,
   -1,   -1,   63,  332,  333,  334,  335,  336,  337,   -1,
  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,
  349,  350,  351,   -1,   -1,   -1,   -1,  267,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  280,  281,   -1,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,   -1,
  300,  301,  302,  124,  304,   -1,  306,   40,   41,   -1,
   43,   44,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   63,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,   -1,  283,
  284,  285,  286,  287,  288,  289,  290,  291,   -1,  293,
   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,
  304,  124,  306,   40,   41,   -1,   43,   44,   45,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   63,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  267,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,
  281,   -1,  283,  284,  285,  286,  287,  288,  289,  290,
  291,   -1,  293,   -1,   -1,   -1,   -1,  124,   -1,  300,
  301,  302,   -1,  304,   -1,  306,   40,   41,   -1,   43,
   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   63,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,   -1,
  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,
  351,   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,   -1,
  283,  284,  285,  286,  287,  288,  289,  290,  291,   -1,
  293,   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,  302,
  124,  304,   40,  306,   -1,   43,   44,   45,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  324,   -1,   -1,   -1,   63,   -1,   -1,   -1,  332,
  333,  334,  335,  336,  337,   -1,  339,   -1,  341,  342,
   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,
  267,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  280,  281,   -1,  283,  284,  285,  286,
  287,  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,
   -1,   -1,   -1,  300,  301,  302,  124,  304,   40,  306,
   -1,   43,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   58,  324,   -1,   -1,
   -1,   63,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,   -1,  283,
  284,  285,  286,  287,  288,  289,  290,  291,   -1,  293,
   -1,   -1,  124,   -1,   -1,   -1,  300,  301,  302,   -1,
  304,   -1,  306,   40,   41,   -1,   43,   -1,   45,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   63,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,  267,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  280,  281,   -1,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   -1,  293,   40,   41,   -1,   43,
   -1,   45,  300,  301,  302,   -1,  304,  124,  306,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   63,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,
   -1,  349,  350,  351,   -1,  267,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,
   -1,  283,  284,  285,  286,  287,  288,  289,  290,  291,
  124,  293,   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,
  302,   -1,  304,   -1,  306,   40,   41,   -1,   43,   -1,
   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   63,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,   -1,  341,
  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  267,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  280,  281,   -1,  283,  284,  285,  286,
  287,  288,  289,  290,  291,   -1,  293,   -1,   -1,  124,
   -1,   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,
   40,   41,   -1,   43,   -1,   45,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,
   -1,   -1,   -1,   63,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,  267,  341,  342,   -1,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,  280,  281,   -1,  283,
  284,  285,  286,  287,  288,  289,  290,  291,   -1,  293,
   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,
  304,   -1,  306,   40,   41,   -1,   43,   -1,   45,   -1,
   -1,   -1,   -1,   -1,  124,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   63,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  280,  281,   -1,  283,  284,
  285,  286,  287,  288,  289,  290,  291,  124,  293,   -1,
   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,  304,
   -1,  306,   40,   -1,   -1,   43,   -1,   45,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,
   -1,   59,   -1,   -1,   -1,   63,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,   -1,
  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  267,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  280,  281,   -1,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,  293,   -1,   -1,  124,   -1,   -1,   -1,
  300,  301,  302,   -1,  304,   -1,  306,   40,   41,   -1,
   43,   -1,   45,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   63,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
  267,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,  280,  281,   -1,  283,  284,  285,  286,
  287,  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,
   -1,   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,
   40,   41,   -1,   43,   -1,   45,   -1,   -1,   -1,   -1,
   -1,  124,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,
   -1,   -1,   -1,   63,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  267,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  280,  281,   -1,  283,  284,  285,  286,  287,
  288,  289,  290,  291,  124,  293,   -1,   -1,   -1,   -1,
   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,   40,
   41,   -1,   43,   -1,   45,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   63,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,
   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,  281,   -1,
  283,  284,  285,  286,  287,  288,  289,  290,  291,   40,
  293,   -1,   43,  124,   45,   -1,   -1,  300,  301,  302,
   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,
  333,  334,  335,  336,  337,   -1,  339,  267,  341,  342,
   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,
  280,  281,   -1,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   40,  293,   -1,   43,   -1,   45,   -1,   -1,
  300,  301,  302,  124,  304,   -1,  306,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   63,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  267,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  124,   -1,   -1,  280,
  281,   -1,  283,  284,  285,  286,  287,  288,  289,  290,
  291,   -1,  293,   40,   41,   -1,   -1,   44,   -1,  300,
  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,
   -1,   58,   59,   -1,   -1,   -1,   63,   -1,   -1,   -1,
   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,   -1,
  341,  342,   -1,   -1,  345,   -1,  267,   -1,  349,  350,
  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  280,
  281,   -1,  283,  284,  285,  286,  287,  288,  289,  290,
  291,   -1,  293,   -1,   -1,   -1,   -1,  124,   -1,  300,
  301,  302,   -1,  304,   -1,  306,   40,   41,   -1,   -1,
   44,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  324,   58,   59,   -1,   -1,   -1,   63,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,  267,
  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,
  351,   -1,  280,  281,   -1,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,   -1,
   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,   -1,
   -1,   -1,   -1,   40,   -1,   -1,   43,   -1,   45,   -1,
  124,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,   -1,
   -1,  349,  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  263,   -1,   -1,   -1,
  267,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  280,  281,  282,   40,   -1,  285,   43,
   -1,   45,  289,  290,  291,   -1,  293,  124,   -1,   -1,
   -1,   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,   -1,  341,  342,   -1,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,  263,
   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,   -1,   -1,
  124,   -1,   -1,   -1,   -1,   -1,  280,  281,  282,   -1,
   -1,  285,   -1,   -1,   -1,  289,  290,  291,   40,  293,
   -1,   43,   -1,   45,   -1,   -1,  300,  301,  302,   -1,
  304,   -1,  306,   -1,   -1,   -1,   58,   -1,   -1,   -1,
   -1,   63,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
  267,  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,  280,   -1,   -1,  283,  284,  285,  286,
  287,  288,  289,  290,  291,   -1,  293,   -1,   -1,   -1,
   -1,   -1,   -1,  300,  301,  302,   -1,  304,   -1,  306,
   40,   -1,   -1,   43,   -1,   45,   -1,   47,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,  267,  341,  342,   -1,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,   -1,   -1,   -1,   -1,  283,
  284,  285,  286,  287,  288,  289,  290,  291,   -1,  293,
   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,  302,   -1,
  304,   40,  306,   -1,   43,   -1,   45,   -1,   47,   -1,
   -1,   -1,   -1,  123,   -1,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,   -1,
   -1,  345,   -1,   -1,   -1,  349,  350,  351,   -1,   -1,
   -1,   -1,   -1,   -1,   40,   -1,   -1,   43,   -1,   45,
   -1,   47,   -1,   -1,   -1,  267,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   59,   -1,   -1,   -1,   -1,  280,  281,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  289,  290,  291,
   -1,  293,   -1,   -1,   -1,   -1,   -1,   -1,  300,  301,
  302,   -1,  304,   -1,  306,   -1,   -1,   40,   -1,   -1,
   43,   -1,   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,   -1,  341,
  342,   -1,   -1,  345,   -1,   -1,   -1,  349,  350,  351,
   -1,  261,  262,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   40,   -1,   -1,   43,   -1,   45,   -1,   47,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  290,  291,   -1,  293,   -1,   -1,   -1,   -1,   -1,  299,
  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   40,  324,   -1,   43,  256,   45,   -1,
   47,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,   -1,   -1,  345,   -1,   -1,   -1,  349,
  350,  351,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  290,  291,   -1,  293,   -1,  295,   -1,   -1,   -1,
   -1,  300,  301,  302,   -1,  304,   40,  306,   -1,   43,
   -1,   45,   -1,   47,   -1,   -1,   -1,  263,   -1,   -1,
   -1,   -1,   -1,  322,  323,  324,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,   -1,  341,  342,  290,  291,  345,  293,   -1,   -1,
  349,  350,  351,   -1,  300,  301,  302,   -1,  304,   40,
  306,   -1,   43,   -1,   45,   -1,   47,   -1,   -1,   -1,
  263,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,
  336,  337,   -1,  339,   -1,  341,  342,  290,  291,  345,
  293,   -1,   -1,  349,  350,  351,   -1,  300,  301,  302,
   -1,  304,   40,  306,   -1,   43,   -1,   45,   -1,   47,
   -1,   -1,   -1,  263,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,
  333,  334,  335,  336,  337,   -1,  339,   -1,  341,  342,
  290,  291,  345,  293,   -1,   -1,  349,  350,  351,   -1,
  300,  301,  302,   -1,  304,   40,  306,   -1,   43,   -1,
   45,   -1,   47,   -1,   -1,   -1,  263,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,  290,  291,  345,  293,   -1,   -1,  349,
  350,  351,   -1,  300,  301,  302,   -1,  304,   40,  306,
   -1,   43,   -1,   45,   -1,   -1,   -1,   -1,   -1,  263,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,  339,   -1,  341,  342,  290,  291,  345,  293,
   -1,   -1,  349,  350,  351,   -1,  300,  301,  302,   -1,
  304,   40,  306,   -1,   43,   -1,   45,   -1,   47,   -1,
   -1,   -1,  263,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,
  334,  335,  336,  337,   -1,  339,   -1,  341,  342,  290,
  291,  345,  293,   -1,   -1,  349,  350,  351,   -1,  300,
  301,  302,   -1,  304,   40,  306,   -1,   43,   -1,   45,
   -1,   47,   -1,   -1,   -1,  263,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  332,  333,  334,  335,  336,  337,   -1,  339,   -1,
  341,  342,  290,  291,  345,  293,   -1,   -1,  349,  350,
  351,   -1,  300,  301,  302,   -1,  304,   40,  306,   -1,
   43,   -1,   45,   -1,   47,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,
   -1,  339,   -1,  341,  342,  290,  291,  345,  293,   -1,
   -1,  349,  350,  351,   -1,  300,  301,  302,   -1,  304,
   40,  306,   -1,   43,   -1,   45,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,
  335,  336,  337,   -1,  339,   -1,  341,  342,  290,  291,
  345,  293,   -1,   -1,  349,  350,  351,   -1,  300,  301,
  302,   -1,  304,   40,  306,   -1,   43,   -1,   45,   -1,
   -1,   -1,   -1,  315,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  332,  333,  334,  335,  336,  337,   -1,  339,   -1,  341,
  342,  290,  291,  345,  293,   -1,   -1,  349,  350,  351,
   -1,  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,
  339,   -1,  341,  342,  290,  291,  345,  293,   -1,   -1,
  349,  350,  351,   -1,  300,  301,  302,   -1,  304,   -1,
  306,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,
  336,  337,   -1,  339,   -1,  341,  342,  290,  291,  345,
  293,   -1,   -1,  349,  350,  351,   -1,  300,  301,  302,
   -1,  304,   -1,  306,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  324,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  332,
  333,  334,  335,  336,  337,   -1,  339,   -1,  341,  342,
  290,  291,  345,  293,   -1,   -1,  349,  350,  351,   -1,
  300,  301,  302,   -1,  304,   -1,  306,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  324,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  332,  333,  334,  335,  336,  337,   -1,  339,
   -1,  341,  342,  290,  291,  345,  293,   -1,   -1,  349,
  350,  351,   -1,  300,  301,  302,   -1,  304,   -1,  306,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,  324,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  332,  333,  334,  335,  336,
  337,   -1,   -1,   -1,  341,  342,   -1,   -1,  345,   -1,
   -1,   -1,  349,  350,  351,
};
#if YYBTYACC
static const YYINT yyctable[] = {                        -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,
};
#endif
#define YYFINAL 4
#ifndef YYDEBUG
#define YYDEBUG 0
#endif
#define YYMAXTOKEN 352
#define YYUNDFTOKEN 403
#define YYTRANSLATE(a) ((a) > YYMAXTOKEN ? YYUNDFTOKEN : (a))
#if YYDEBUG
static const char *const yyname[] = {

"$end",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
"'%'",0,0,"'('","')'","'*'","'+'","','","'-'",0,"'/'",0,0,0,0,0,0,0,0,0,0,"':'",
"';'",0,0,0,"'?'",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,"'['",0,
"']'",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,"'{'","'|'",
"'}'",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,"error","FIRSTTOKEN","PROGRAM","PASTAT","PASTAT2",
"XBEGIN","XEND","NL","ARRAY","MATCH","NOTMATCH","MATCHOP","FINAL","DOT","ALL",
"CCL","NCCL","CHAR","OR","STAR","QUEST","PLUS","EMPTYRE","ZERO","AND","BOR",
"APPEND","EQ","GE","GT","LE","LT","NE","IN","ARG","BLTIN","BREAK","CLOSE",
"CONTINUE","DELETE","DO","EXIT","FOR","FUNC","GENSUB","SUB","GSUB","IF","INDEX",
"LSUBSTR","MATCHFCN","NEXT","NEXTFILE","ADD","MINUS","MULT","DIVIDE","MOD",
"ASSIGN","ASGNOP","ADDEQ","SUBEQ","MULTEQ","DIVEQ","MODEQ","POWEQ","PRINT",
"PRINTF","SPRINTF","ELSE","INTEST","CONDEXPR","POSTINCR","PREINCR","POSTDECR",
"PREDECR","VAR","IVAR","VARNF","CALL","NUMBER","STRING","REGEXPR","GETLINE",
"RETURN","SPLIT","SUBSTR","WHILE","CAT","NOT","UMINUS","UPLUS","POWER","DECR",
"INCR","INDIRECT","LASTTOKEN","$accept","program","pas","pattern","ppattern",
"plist","pplist","patlist","prarg","term","re","pa_pat","pa_stat","pa_stats",
"reg_expr","simple_stmt","opt_simple_stmt","stmt","stmtlist","var","varname",
"funcname","varlist","for","if","else","while","do","st","pst","opt_pst",
"lbrace","rbrace","rparen","comma","nl","opt_nl","and","bor","subop","print",
"string","$$1","$$2","$$3","$$4","$$5","$$6","$$7","$$8","illegal-symbol",
};
static const char *const yyrule[] = {
"$accept : program",
"program : pas",
"program : error",
"and : AND",
"and : and NL",
"bor : BOR",
"bor : bor NL",
"comma : ','",
"comma : comma NL",
"do : DO",
"do : do NL",
"else : ELSE",
"else : else NL",
"$$1 :",
"for : FOR '(' opt_simple_stmt ';' opt_nl pattern ';' opt_nl opt_simple_stmt rparen $$1 stmt",
"$$2 :",
"for : FOR '(' opt_simple_stmt ';' ';' opt_nl opt_simple_stmt rparen $$2 stmt",
"$$3 :",
"for : FOR '(' varname IN varname rparen $$3 stmt",
"funcname : VAR",
"funcname : CALL",
"if : IF '(' pattern rparen",
"lbrace : '{'",
"lbrace : lbrace NL",
"nl : NL",
"nl : nl NL",
"opt_nl :",
"opt_nl : nl",
"opt_pst :",
"opt_pst : pst",
"opt_simple_stmt :",
"opt_simple_stmt : simple_stmt",
"pas : opt_pst",
"pas : opt_pst pa_stats opt_pst",
"pa_pat : pattern",
"pa_stat : pa_pat",
"pa_stat : pa_pat lbrace stmtlist '}'",
"pa_stat : pa_pat ',' opt_nl pa_pat",
"pa_stat : pa_pat ',' opt_nl pa_pat lbrace stmtlist '}'",
"pa_stat : lbrace stmtlist '}'",
"pa_stat : XBEGIN lbrace stmtlist '}'",
"pa_stat : XEND lbrace stmtlist '}'",
"$$4 :",
"pa_stat : FUNC funcname '(' varlist rparen $$4 lbrace stmtlist '}'",
"pa_stats : pa_stat",
"pa_stats : pa_stats opt_pst pa_stat",
"patlist : pattern",
"patlist : patlist comma pattern",
"ppattern : var ASGNOP ppattern",
"ppattern : ppattern '?' ppattern ':' ppattern",
"ppattern : ppattern bor ppattern",
"ppattern : ppattern and ppattern",
"ppattern : ppattern MATCHOP reg_expr",
"ppattern : ppattern MATCHOP ppattern",
"ppattern : ppattern IN varname",
"ppattern : '(' plist ')' IN varname",
"ppattern : ppattern term",
"ppattern : re",
"ppattern : term",
"pattern : var ASGNOP pattern",
"pattern : pattern '?' pattern ':' pattern",
"pattern : pattern bor pattern",
"pattern : pattern and pattern",
"pattern : pattern EQ pattern",
"pattern : pattern GE pattern",
"pattern : pattern GT pattern",
"pattern : pattern LE pattern",
"pattern : pattern LT pattern",
"pattern : pattern NE pattern",
"pattern : pattern MATCHOP reg_expr",
"pattern : pattern MATCHOP pattern",
"pattern : pattern IN varname",
"pattern : '(' plist ')' IN varname",
"pattern : pattern '|' GETLINE var",
"pattern : pattern '|' GETLINE",
"pattern : pattern term",
"pattern : re",
"pattern : term",
"plist : pattern comma pattern",
"plist : plist comma pattern",
"pplist : ppattern",
"pplist : pplist comma ppattern",
"prarg :",
"prarg : pplist",
"prarg : '(' plist ')'",
"print : PRINT",
"print : PRINTF",
"pst : NL",
"pst : ';'",
"pst : pst NL",
"pst : pst ';'",
"rbrace : '}'",
"rbrace : rbrace NL",
"re : reg_expr",
"re : NOT re",
"$$5 :",
"reg_expr : '/' $$5 REGEXPR '/'",
"rparen : ')'",
"rparen : rparen NL",
"simple_stmt : print prarg '|' term",
"simple_stmt : print prarg APPEND term",
"simple_stmt : print prarg GT term",
"simple_stmt : print prarg",
"simple_stmt : DELETE varname '[' patlist ']'",
"simple_stmt : DELETE varname",
"simple_stmt : pattern",
"simple_stmt : error",
"st : nl",
"st : ';' opt_nl",
"stmt : BREAK st",
"stmt : CONTINUE st",
"$$6 :",
"$$7 :",
"stmt : do $$6 stmt $$7 WHILE '(' pattern ')' st",
"stmt : EXIT pattern st",
"stmt : EXIT st",
"stmt : for",
"stmt : if stmt else stmt",
"stmt : if stmt",
"stmt : lbrace stmtlist rbrace",
"stmt : NEXT st",
"stmt : NEXTFILE st",
"stmt : RETURN pattern st",
"stmt : RETURN st",
"stmt : simple_stmt st",
"$$8 :",
"stmt : while $$8 stmt",
"stmt : ';' opt_nl",
"stmtlist : stmt",
"stmtlist : stmtlist stmt",
"subop : SUB",
"subop : GSUB",
"string : STRING",
"string : string STRING",
"term : term '/' ASGNOP term",
"term : term '+' term",
"term : term '-' term",
"term : term '*' term",
"term : term '/' term",
"term : term '%' term",
"term : term POWER term",
"term : '-' term",
"term : '+' term",
"term : NOT term",
"term : BLTIN '(' ')'",
"term : BLTIN '(' patlist ')'",
"term : BLTIN",
"term : CALL '(' ')'",
"term : CALL '(' patlist ')'",
"term : CLOSE term",
"term : DECR var",
"term : INCR var",
"term : var DECR",
"term : var INCR",
"term : GENSUB '(' reg_expr comma pattern comma pattern ')'",
"term : GENSUB '(' pattern comma pattern comma pattern ')'",
"term : GENSUB '(' reg_expr comma pattern comma pattern comma pattern ')'",
"term : GENSUB '(' pattern comma pattern comma pattern comma pattern ')'",
"term : GETLINE var LT term",
"term : GETLINE LT term",
"term : GETLINE var",
"term : GETLINE",
"term : INDEX '(' pattern comma pattern ')'",
"term : INDEX '(' pattern comma reg_expr ')'",
"term : '(' pattern ')'",
"term : MATCHFCN '(' pattern comma reg_expr ')'",
"term : MATCHFCN '(' pattern comma pattern ')'",
"term : NUMBER",
"term : SPLIT '(' pattern comma varname comma pattern ')'",
"term : SPLIT '(' pattern comma varname comma reg_expr ')'",
"term : SPLIT '(' pattern comma varname ')'",
"term : SPRINTF '(' patlist ')'",
"term : string",
"term : subop '(' reg_expr comma pattern ')'",
"term : subop '(' pattern comma pattern ')'",
"term : subop '(' reg_expr comma pattern comma var ')'",
"term : subop '(' pattern comma pattern comma var ')'",
"term : SUBSTR '(' pattern comma pattern comma pattern ')'",
"term : SUBSTR '(' pattern comma pattern ')'",
"term : var",
"var : varname",
"var : varname '[' patlist ']'",
"var : IVAR",
"var : INDIRECT term",
"varlist :",
"varlist : VAR",
"varlist : varlist comma VAR",
"varname : VAR",
"varname : ARG",
"varname : VARNF",
"while : WHILE '(' pattern rparen",

};
#endif

#if YYDEBUG
int      yydebug;
#endif

int      yyerrflag;
int      yychar;
YYSTYPE  yyval;
YYSTYPE  yylval;
int      yynerrs;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
YYLTYPE  yyloc; /* position returned by actions */
YYLTYPE  yylloc; /* position from the lexer */
#endif

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
#ifndef YYLLOC_DEFAULT
#define YYLLOC_DEFAULT(loc, rhs, n) \
do \
{ \
    if (n == 0) \
    { \
        (loc).first_line   = YYRHSLOC(rhs, 0).last_line; \
        (loc).first_column = YYRHSLOC(rhs, 0).last_column; \
        (loc).last_line    = YYRHSLOC(rhs, 0).last_line; \
        (loc).last_column  = YYRHSLOC(rhs, 0).last_column; \
    } \
    else \
    { \
        (loc).first_line   = YYRHSLOC(rhs, 1).first_line; \
        (loc).first_column = YYRHSLOC(rhs, 1).first_column; \
        (loc).last_line    = YYRHSLOC(rhs, n).last_line; \
        (loc).last_column  = YYRHSLOC(rhs, n).last_column; \
    } \
} while (0)
#endif /* YYLLOC_DEFAULT */
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#if YYBTYACC

#ifndef YYLVQUEUEGROWTH
#define YYLVQUEUEGROWTH 32
#endif
#endif /* YYBTYACC */

/* define the initial stack-sizes */
#ifdef YYSTACKSIZE
#undef YYMAXDEPTH
#define YYMAXDEPTH  YYSTACKSIZE
#else
#ifdef YYMAXDEPTH
#define YYSTACKSIZE YYMAXDEPTH
#else
#define YYSTACKSIZE 10000
#define YYMAXDEPTH  10000
#endif
#endif

#ifndef YYINITSTACKSIZE
#define YYINITSTACKSIZE 200
#endif

typedef struct {
    unsigned stacksize;
    YYINT    *s_base;
    YYINT    *s_mark;
    YYINT    *s_last;
    YYSTYPE  *l_base;
    YYSTYPE  *l_mark;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE  *p_base;
    YYLTYPE  *p_mark;
#endif
} YYSTACKDATA;
#if YYBTYACC

struct YYParseState_s
{
    struct YYParseState_s *save;    /* Previously saved parser state */
    YYSTACKDATA            yystack; /* saved parser stack */
    int                    state;   /* saved parser state */
    int                    errflag; /* saved error recovery status */
    int                    lexeme;  /* saved index of the conflict lexeme in the lexical queue */
    YYINT                  ctry;    /* saved index in yyctable[] for this conflict */
};
typedef struct YYParseState_s YYParseState;
#endif /* YYBTYACC */
/* variables for the parser stack */
static YYSTACKDATA yystack;
#if YYBTYACC

/* Current parser state */
static YYParseState *yyps = 0;

/* yypath != NULL: do the full parse, starting at *yypath parser state. */
static YYParseState *yypath = 0;

/* Base of the lexical value queue */
static YYSTYPE *yylvals = 0;

/* Current position at lexical value queue */
static YYSTYPE *yylvp = 0;

/* End position of lexical value queue */
static YYSTYPE *yylve = 0;

/* The last allocated position at the lexical value queue */
static YYSTYPE *yylvlim = 0;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
/* Base of the lexical position queue */
static YYLTYPE *yylpsns = 0;

/* Current position at lexical position queue */
static YYLTYPE *yylpp = 0;

/* End position of lexical position queue */
static YYLTYPE *yylpe = 0;

/* The last allocated position at the lexical position queue */
static YYLTYPE *yylplim = 0;
#endif

/* Current position at lexical token queue */
static YYINT  *yylexp = 0;

static YYINT  *yylexemes = 0;
#endif /* YYBTYACC */
#line 472 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"

void setfname(Cell *p)
{
	if (isarr(p))
		SYNTAX("%s is an array, not a function", p->nval);
	else if (isfcn(p))
		SYNTAX("you can't define function %s more than once", p->nval);
	curfname = p->nval;
}

int constnode(Node *p)
{
	return isvalue(p) && ((Cell *) (p->narg[0]))->csub == CCON;
}

char *strnode(Node *p)
{
	return ((Cell *)(p->narg[0]))->sval;
}

Node *notnull(Node *n)
{
	switch (n->nobj) {
	case LE: case LT: case EQ: case NE: case GT: case GE:
	case BOR: case AND: case NOT:
		return n;
	default:
		return op2(NE, n, nullnode);
	}
}

void checkdup(Node *vl, Cell *cp)	/* check if name already in list */
{
	char *s = cp->nval;
	for ( ; vl; vl = vl->nnext) {
		if (strcmp(s, ((Cell *)(vl->narg[0]))->nval) == 0) {
			SYNTAX("duplicate argument %s", s);
			break;
		}
	}
}
#line 3869 "awkgram.c"

/* For use in generated program */
#define yydepth (int)(yystack.s_mark - yystack.s_base)
#if YYBTYACC
#define yytrial (yyps->save)
#endif /* YYBTYACC */

#if YYDEBUG
#include <stdio.h>	/* needed for printf */
#endif

#include <stdlib.h>	/* needed for malloc, etc */
#include <string.h>	/* needed for memset */

/* allocate initial stack or double stack size, up to YYMAXDEPTH */
static int yygrowstack(YYSTACKDATA *data)
{
    int i;
    unsigned newsize;
    YYINT *newss;
    YYSTYPE *newvs;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE *newps;
#endif

    if ((newsize = data->stacksize) == 0)
        newsize = YYINITSTACKSIZE;
    else if (newsize >= YYMAXDEPTH)
        return YYENOMEM;
    else if ((newsize *= 2) > YYMAXDEPTH)
        newsize = YYMAXDEPTH;

    i = (int) (data->s_mark - data->s_base);
    newss = (YYINT *)realloc(data->s_base, newsize * sizeof(*newss));
    if (newss == 0)
        return YYENOMEM;

    data->s_base = newss;
    data->s_mark = newss + i;

    newvs = (YYSTYPE *)realloc(data->l_base, newsize * sizeof(*newvs));
    if (newvs == 0)
        return YYENOMEM;

    data->l_base = newvs;
    data->l_mark = newvs + i;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    newps = (YYLTYPE *)realloc(data->p_base, newsize * sizeof(*newps));
    if (newps == 0)
        return YYENOMEM;

    data->p_base = newps;
    data->p_mark = newps + i;
#endif

    data->stacksize = newsize;
    data->s_last = data->s_base + newsize - 1;

#if YYDEBUG
    if (yydebug)
        fprintf(stderr, "%sdebug: stack size increased to %d\n", YYPREFIX, newsize);
#endif
    return 0;
}

#if YYPURE || defined(YY_NO_LEAKS)
static void yyfreestack(YYSTACKDATA *data)
{
    free(data->s_base);
    free(data->l_base);
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    free(data->p_base);
#endif
    memset(data, 0, sizeof(*data));
}
#else
#define yyfreestack(data) /* nothing */
#endif /* YYPURE || defined(YY_NO_LEAKS) */
#if YYBTYACC

static YYParseState *
yyNewState(unsigned size)
{
    YYParseState *p = (YYParseState *) malloc(sizeof(YYParseState));
    if (p == NULL) return NULL;

    p->yystack.stacksize = size;
    if (size == 0)
    {
        p->yystack.s_base = NULL;
        p->yystack.l_base = NULL;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        p->yystack.p_base = NULL;
#endif
        return p;
    }
    p->yystack.s_base    = (YYINT *) malloc(size * sizeof(YYINT));
    if (p->yystack.s_base == NULL) return NULL;
    p->yystack.l_base    = (YYSTYPE *) malloc(size * sizeof(YYSTYPE));
    if (p->yystack.l_base == NULL) return NULL;
    memset(p->yystack.l_base, 0, size * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    p->yystack.p_base    = (YYLTYPE *) malloc(size * sizeof(YYLTYPE));
    if (p->yystack.p_base == NULL) return NULL;
    memset(p->yystack.p_base, 0, size * sizeof(YYLTYPE));
#endif

    return p;
}

static void
yyFreeState(YYParseState *p)
{
    yyfreestack(&p->yystack);
    free(p);
}
#endif /* YYBTYACC */

#define YYABORT  goto yyabort
#define YYREJECT goto yyabort
#define YYACCEPT goto yyaccept
#define YYERROR  goto yyerrlab
#if YYBTYACC
#define YYVALID        do { if (yyps->save)            goto yyvalid; } while(0)
#define YYVALID_NESTED do { if (yyps->save && \
                                yyps->save->save == 0) goto yyvalid; } while(0)
#endif /* YYBTYACC */

int
YYPARSE_DECL()
{
    int yym, yyn, yystate, yyresult;
#if YYBTYACC
    int yynewerrflag;
    YYParseState *yyerrctx = NULL;
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE  yyerror_loc_range[3]; /* position of error start/end (0 unused) */
#endif
#if YYDEBUG
    const char *yys;

    if ((yys = getenv("YYDEBUG")) != 0)
    {
        yyn = *yys;
        if (yyn >= '0' && yyn <= '9')
            yydebug = yyn - '0';
    }
    if (yydebug)
        fprintf(stderr, "%sdebug[<# of symbols on state stack>]\n", YYPREFIX);
#endif
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    memset(yyerror_loc_range, 0, sizeof(yyerror_loc_range));
#endif

#if YYBTYACC
    yyps = yyNewState(0); if (yyps == 0) goto yyenomem;
    yyps->save = 0;
#endif /* YYBTYACC */
    yym = 0;
    yyn = 0;
    yynerrs = 0;
    yyerrflag = 0;
    yychar = YYEMPTY;
    yystate = 0;

#if YYPURE
    memset(&yystack, 0, sizeof(yystack));
#endif

    if (yystack.s_base == NULL && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
    yystack.s_mark = yystack.s_base;
    yystack.l_mark = yystack.l_base;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark = yystack.p_base;
#endif
    yystate = 0;
    *yystack.s_mark = 0;

yyloop:
    if ((yyn = yydefred[yystate]) != 0) goto yyreduce;
    if (yychar < 0)
    {
#if YYBTYACC
        do {
        if (yylvp < yylve)
        {
            /* we're currently re-reading tokens */
            yylval = *yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylloc = *yylpp++;
#endif
            yychar = *yylexp++;
            break;
        }
        if (yyps->save)
        {
            /* in trial mode; save scanner results for future parse attempts */
            if (yylvp == yylvlim)
            {   /* Enlarge lexical value queue */
                size_t p = (size_t) (yylvp - yylvals);
                size_t s = (size_t) (yylvlim - yylvals);

                s += YYLVQUEUEGROWTH;
                if ((yylexemes = (YYINT *)realloc(yylexemes, s * sizeof(YYINT))) == NULL) goto yyenomem;
                if ((yylvals   = (YYSTYPE *)realloc(yylvals, s * sizeof(YYSTYPE))) == NULL) goto yyenomem;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                if ((yylpsns   = (YYLTYPE *)realloc(yylpsns, s * sizeof(YYLTYPE))) == NULL) goto yyenomem;
#endif
                yylvp   = yylve = yylvals + p;
                yylvlim = yylvals + s;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp   = yylpe = yylpsns + p;
                yylplim = yylpsns + s;
#endif
                yylexp  = yylexemes + p;
            }
            *yylexp = (YYINT) YYLEX;
            *yylvp++ = yylval;
            yylve++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            *yylpp++ = yylloc;
            yylpe++;
#endif
            yychar = *yylexp++;
            break;
        }
        /* normal operation, no conflict encountered */
#endif /* YYBTYACC */
        yychar = YYLEX;
#if YYBTYACC
        } while (0);
#endif /* YYBTYACC */
        if (yychar < 0) yychar = YYEOF;
#if YYDEBUG
        if (yydebug)
        {
            if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
            fprintf(stderr, "%s[%d]: state %d, reading token %d (%s)",
                            YYDEBUGSTR, yydepth, yystate, yychar, yys);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
            if (!yytrial)
#endif /* YYBTYACC */
                fprintf(stderr, " <%s>", YYSTYPE_TOSTRING(yychar, yylval));
#endif
            fputc('\n', stderr);
        }
#endif
    }
#if YYBTYACC

    /* Do we have a conflict? */
    if (((yyn = yycindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
        yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
        YYINT ctry;

        if (yypath)
        {
            YYParseState *save;
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%s[%d]: CONFLICT in state %d: following successful trial parse\n",
                                YYDEBUGSTR, yydepth, yystate);
#endif
            /* Switch to the next conflict context */
            save = yypath;
            yypath = save->save;
            save->save = NULL;
            ctry = save->ctry;
            if (save->state != yystate) YYABORT;
            yyFreeState(save);

        }
        else
        {

            /* Unresolved conflict - start/continue trial parse */
            YYParseState *save;
#if YYDEBUG
            if (yydebug)
            {
                fprintf(stderr, "%s[%d]: CONFLICT in state %d. ", YYDEBUGSTR, yydepth, yystate);
                if (yyps->save)
                    fputs("ALREADY in conflict, continuing trial parse.\n", stderr);
                else
                    fputs("Starting trial parse.\n", stderr);
            }
#endif
            save                  = yyNewState((unsigned)(yystack.s_mark - yystack.s_base + 1));
            if (save == NULL) goto yyenomem;
            save->save            = yyps->save;
            save->state           = yystate;
            save->errflag         = yyerrflag;
            save->yystack.s_mark  = save->yystack.s_base + (yystack.s_mark - yystack.s_base);
            memcpy (save->yystack.s_base, yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            save->yystack.l_mark  = save->yystack.l_base + (yystack.l_mark - yystack.l_base);
            memcpy (save->yystack.l_base, yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            save->yystack.p_mark  = save->yystack.p_base + (yystack.p_mark - yystack.p_base);
            memcpy (save->yystack.p_base, yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            ctry                  = yytable[yyn];
            if (yyctable[ctry] == -1)
            {
#if YYDEBUG
                if (yydebug && yychar >= YYEOF)
                    fprintf(stderr, "%s[%d]: backtracking 1 token\n", YYDEBUGSTR, yydepth);
#endif
                ctry++;
            }
            save->ctry = ctry;
            if (yyps->save == NULL)
            {
                /* If this is a first conflict in the stack, start saving lexemes */
                if (!yylexemes)
                {
                    yylexemes = (YYINT *) malloc((YYLVQUEUEGROWTH) * sizeof(YYINT));
                    if (yylexemes == NULL) goto yyenomem;
                    yylvals   = (YYSTYPE *) malloc((YYLVQUEUEGROWTH) * sizeof(YYSTYPE));
                    if (yylvals == NULL) goto yyenomem;
                    yylvlim   = yylvals + YYLVQUEUEGROWTH;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpsns   = (YYLTYPE *) malloc((YYLVQUEUEGROWTH) * sizeof(YYLTYPE));
                    if (yylpsns == NULL) goto yyenomem;
                    yylplim   = yylpsns + YYLVQUEUEGROWTH;
#endif
                }
                if (yylvp == yylve)
                {
                    yylvp  = yylve = yylvals;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpp  = yylpe = yylpsns;
#endif
                    yylexp = yylexemes;
                    if (yychar >= YYEOF)
                    {
                        *yylve++ = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                        *yylpe++ = yylloc;
#endif
                        *yylexp  = (YYINT) yychar;
                        yychar   = YYEMPTY;
                    }
                }
            }
            if (yychar >= YYEOF)
            {
                yylvp--;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp--;
#endif
                yylexp--;
                yychar = YYEMPTY;
            }
            save->lexeme = (int) (yylvp - yylvals);
            yyps->save   = save;
        }
        if (yytable[yyn] == ctry)
        {
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%s[%d]: state %d, shifting to state %d\n",
                                YYDEBUGSTR, yydepth, yystate, yyctable[ctry]);
#endif
            if (yychar < 0)
            {
                yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp++;
#endif
                yylexp++;
            }
            if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM)
                goto yyoverflow;
            yystate = yyctable[ctry];
            *++yystack.s_mark = (YYINT) yystate;
            *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            *++yystack.p_mark = yylloc;
#endif
            yychar  = YYEMPTY;
            if (yyerrflag > 0) --yyerrflag;
            goto yyloop;
        }
        else
        {
            yyn = yyctable[ctry];
            goto yyreduce;
        }
    } /* End of code dealing with conflicts */
#endif /* YYBTYACC */
    if (((yyn = yysindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
#if YYDEBUG
        if (yydebug)
            fprintf(stderr, "%s[%d]: state %d, shifting to state %d\n",
                            YYDEBUGSTR, yydepth, yystate, yytable[yyn]);
#endif
        if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
        yystate = yytable[yyn];
        *++yystack.s_mark = yytable[yyn];
        *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        *++yystack.p_mark = yylloc;
#endif
        yychar = YYEMPTY;
        if (yyerrflag > 0)  --yyerrflag;
        goto yyloop;
    }
    if (((yyn = yyrindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
        yyn = yytable[yyn];
        goto yyreduce;
    }
    if (yyerrflag != 0) goto yyinrecovery;
#if YYBTYACC

    yynewerrflag = 1;
    goto yyerrhandler;
    goto yyerrlab; /* redundant goto avoids 'unused label' warning */

yyerrlab:
    /* explicit YYERROR from an action -- pop the rhs of the rule reduced
     * before looking for error recovery */
    yystack.s_mark -= yym;
    yystate = *yystack.s_mark;
    yystack.l_mark -= yym;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark -= yym;
#endif

    yynewerrflag = 0;
yyerrhandler:
    while (yyps->save)
    {
        int ctry;
        YYParseState *save = yyps->save;
#if YYDEBUG
        if (yydebug)
            fprintf(stderr, "%s[%d]: ERROR in state %d, CONFLICT BACKTRACKING to state %d, %d tokens\n",
                            YYDEBUGSTR, yydepth, yystate, yyps->save->state,
                    (int)(yylvp - yylvals - yyps->save->lexeme));
#endif
        /* Memorize most forward-looking error state in case it's really an error. */
        if (yyerrctx == NULL || yyerrctx->lexeme < yylvp - yylvals)
        {
            /* Free old saved error context state */
            if (yyerrctx) yyFreeState(yyerrctx);
            /* Create and fill out new saved error context state */
            yyerrctx                 = yyNewState((unsigned)(yystack.s_mark - yystack.s_base + 1));
            if (yyerrctx == NULL) goto yyenomem;
            yyerrctx->save           = yyps->save;
            yyerrctx->state          = yystate;
            yyerrctx->errflag        = yyerrflag;
            yyerrctx->yystack.s_mark = yyerrctx->yystack.s_base + (yystack.s_mark - yystack.s_base);
            memcpy (yyerrctx->yystack.s_base, yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            yyerrctx->yystack.l_mark = yyerrctx->yystack.l_base + (yystack.l_mark - yystack.l_base);
            memcpy (yyerrctx->yystack.l_base, yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yyerrctx->yystack.p_mark = yyerrctx->yystack.p_base + (yystack.p_mark - yystack.p_base);
            memcpy (yyerrctx->yystack.p_base, yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            yyerrctx->lexeme         = (int) (yylvp - yylvals);
        }
        yylvp          = yylvals   + save->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        yylpp          = yylpsns   + save->lexeme;
#endif
        yylexp         = yylexemes + save->lexeme;
        yychar         = YYEMPTY;
        yystack.s_mark = yystack.s_base + (save->yystack.s_mark - save->yystack.s_base);
        memcpy (yystack.s_base, save->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
        yystack.l_mark = yystack.l_base + (save->yystack.l_mark - save->yystack.l_base);
        memcpy (yystack.l_base, save->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        yystack.p_mark = yystack.p_base + (save->yystack.p_mark - save->yystack.p_base);
        memcpy (yystack.p_base, save->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
        ctry           = ++save->ctry;
        yystate        = save->state;
        /* We tried shift, try reduce now */
        if ((yyn = yyctable[ctry]) >= 0) goto yyreduce;
        yyps->save     = save->save;
        save->save     = NULL;
        yyFreeState(save);

        /* Nothing left on the stack -- error */
        if (!yyps->save)
        {
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%sdebug[%d,trial]: trial parse FAILED, entering ERROR mode\n",
                                YYPREFIX, yydepth);
#endif
            /* Restore state as it was in the most forward-advanced error */
            yylvp          = yylvals   + yyerrctx->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylpp          = yylpsns   + yyerrctx->lexeme;
#endif
            yylexp         = yylexemes + yyerrctx->lexeme;
            yychar         = yylexp[-1];
            yylval         = yylvp[-1];
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylloc         = yylpp[-1];
#endif
            yystack.s_mark = yystack.s_base + (yyerrctx->yystack.s_mark - yyerrctx->yystack.s_base);
            memcpy (yystack.s_base, yyerrctx->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            yystack.l_mark = yystack.l_base + (yyerrctx->yystack.l_mark - yyerrctx->yystack.l_base);
            memcpy (yystack.l_base, yyerrctx->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yystack.p_mark = yystack.p_base + (yyerrctx->yystack.p_mark - yyerrctx->yystack.p_base);
            memcpy (yystack.p_base, yyerrctx->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            yystate        = yyerrctx->state;
            yyFreeState(yyerrctx);
            yyerrctx       = NULL;
        }
        yynewerrflag = 1;
    }
    if (yynewerrflag == 0) goto yyinrecovery;
#endif /* YYBTYACC */

    YYERROR_CALL("syntax error");
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yyerror_loc_range[1] = yylloc; /* lookahead position is error start position */
#endif

#if !YYBTYACC
    goto yyerrlab; /* redundant goto avoids 'unused label' warning */
yyerrlab:
#endif
    ++yynerrs;

yyinrecovery:
    if (yyerrflag < 3)
    {
        yyerrflag = 3;
        for (;;)
        {
            if (((yyn = yysindex[*yystack.s_mark]) != 0) && (yyn += YYERRCODE) >= 0 &&
                    yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) YYERRCODE)
            {
#if YYDEBUG
                if (yydebug)
                    fprintf(stderr, "%s[%d]: state %d, error recovery shifting to state %d\n",
                                    YYDEBUGSTR, yydepth, *yystack.s_mark, yytable[yyn]);
#endif
                if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
                yystate = yytable[yyn];
                *++yystack.s_mark = yytable[yyn];
                *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                /* lookahead position is error end position */
                yyerror_loc_range[2] = yylloc;
                YYLLOC_DEFAULT(yyloc, yyerror_loc_range, 2); /* position of error span */
                *++yystack.p_mark = yyloc;
#endif
                goto yyloop;
            }
            else
            {
#if YYDEBUG
                if (yydebug)
                    fprintf(stderr, "%s[%d]: error recovery discarding state %d\n",
                                    YYDEBUGSTR, yydepth, *yystack.s_mark);
#endif
                if (yystack.s_mark <= yystack.s_base) goto yyabort;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                /* the current TOS position is the error start position */
                yyerror_loc_range[1] = *yystack.p_mark;
#endif
#if defined(YYDESTRUCT_CALL)
#if YYBTYACC
                if (!yytrial)
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    YYDESTRUCT_CALL("error: discarding state",
                                    yystos[*yystack.s_mark], yystack.l_mark, yystack.p_mark);
#else
                    YYDESTRUCT_CALL("error: discarding state",
                                    yystos[*yystack.s_mark], yystack.l_mark);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#endif /* defined(YYDESTRUCT_CALL) */
                --yystack.s_mark;
                --yystack.l_mark;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                --yystack.p_mark;
#endif
            }
        }
    }
    else
    {
        if (yychar == YYEOF) goto yyabort;
#if YYDEBUG
        if (yydebug)
        {
            if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
            fprintf(stderr, "%s[%d]: state %d, error recovery discarding token %d (%s)\n",
                            YYDEBUGSTR, yydepth, yystate, yychar, yys);
        }
#endif
#if defined(YYDESTRUCT_CALL)
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            YYDESTRUCT_CALL("error: discarding token", yychar, &yylval, &yylloc);
#else
            YYDESTRUCT_CALL("error: discarding token", yychar, &yylval);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#endif /* defined(YYDESTRUCT_CALL) */
        yychar = YYEMPTY;
        goto yyloop;
    }

yyreduce:
    yym = yylen[yyn];
#if YYDEBUG
    if (yydebug)
    {
        fprintf(stderr, "%s[%d]: state %d, reducing by rule %d (%s)",
                        YYDEBUGSTR, yydepth, yystate, yyn, yyrule[yyn]);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
            if (yym > 0)
            {
                int i;
                fputc('<', stderr);
                for (i = yym; i > 0; i--)
                {
                    if (i != yym) fputs(", ", stderr);
                    fputs(YYSTYPE_TOSTRING(yystos[yystack.s_mark[1-i]],
                                           yystack.l_mark[1-i]), stderr);
                }
                fputc('>', stderr);
            }
#endif
        fputc('\n', stderr);
    }
#endif
    if (yym > 0)
        yyval = yystack.l_mark[1-yym];
    else
        memset(&yyval, 0, sizeof yyval);
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)

    /* Perform position reduction */
    memset(&yyloc, 0, sizeof(yyloc));
#if YYBTYACC
    if (!yytrial)
#endif /* YYBTYACC */
    {
        YYLLOC_DEFAULT(yyloc, &yystack.p_mark[-yym], yym);
        /* just in case YYERROR is invoked within the action, save
           the start of the rhs as the error start position */
        yyerror_loc_range[1] = yystack.p_mark[1-yym];
    }
#endif

    switch (yyn)
    {
case 1:
#line 103 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (errorflag==0)
			winner = (Node *)stat3(PROGRAM, beginloc, yystack.l_mark[0].p, endloc); }
#line 1 ""
break;
case 2:
#line 105 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyclearin; bracecheck(); SYNTAX("bailing out"); }
#line 1 ""
break;
case 13:
#line 129 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{inloop++;}
#line 1 ""
break;
case 14:
#line 130 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ --inloop; yyval.p = stat4(FOR, yystack.l_mark[-9].p, notnull(yystack.l_mark[-6].p), yystack.l_mark[-3].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 15:
#line 131 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{inloop++;}
#line 1 ""
break;
case 16:
#line 132 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ --inloop; yyval.p = stat4(FOR, yystack.l_mark[-7].p, NIL, yystack.l_mark[-3].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 17:
#line 133 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{inloop++;}
#line 1 ""
break;
case 18:
#line 134 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ --inloop; yyval.p = stat3(IN, yystack.l_mark[-5].p, makearr(yystack.l_mark[-3].p), yystack.l_mark[0].p); }
#line 1 ""
break;
case 19:
#line 138 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ setfname(yystack.l_mark[0].cp); }
#line 1 ""
break;
case 20:
#line 139 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ setfname(yystack.l_mark[0].cp); }
#line 1 ""
break;
case 21:
#line 143 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = notnull(yystack.l_mark[-1].p); }
#line 1 ""
break;
case 26:
#line 155 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.i = 0; }
#line 1 ""
break;
case 28:
#line 160 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.i = 0; }
#line 1 ""
break;
case 30:
#line 166 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = 0; }
#line 1 ""
break;
case 32:
#line 171 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = 0; }
#line 1 ""
break;
case 33:
#line 172 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = yystack.l_mark[-1].p; }
#line 1 ""
break;
case 34:
#line 176 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = notnull(yystack.l_mark[0].p); }
#line 1 ""
break;
case 35:
#line 180 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat2(PASTAT, yystack.l_mark[0].p, stat2(PRINT, rectonode(), NIL)); }
#line 1 ""
break;
case 36:
#line 181 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat2(PASTAT, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 37:
#line 182 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = pa2stat(yystack.l_mark[-3].p, yystack.l_mark[0].p, stat2(PRINT, rectonode(), NIL)); }
#line 1 ""
break;
case 38:
#line 183 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = pa2stat(yystack.l_mark[-6].p, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 39:
#line 184 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat2(PASTAT, NIL, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 40:
#line 186 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ beginloc = linkum(beginloc, yystack.l_mark[-1].p); yyval.p = 0; }
#line 1 ""
break;
case 41:
#line 188 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ endloc = linkum(endloc, yystack.l_mark[-1].p); yyval.p = 0; }
#line 1 ""
break;
case 42:
#line 189 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{infunc = true;}
#line 1 ""
break;
case 43:
#line 190 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ infunc = false; curfname=0; defn((Cell *)yystack.l_mark[-7].p, yystack.l_mark[-5].p, yystack.l_mark[-1].p); yyval.p = 0; }
#line 1 ""
break;
case 45:
#line 195 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = linkum(yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 47:
#line 200 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = linkum(yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 48:
#line 204 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 49:
#line 206 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(CONDEXPR, notnull(yystack.l_mark[-4].p), yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 50:
#line 208 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(BOR, notnull(yystack.l_mark[-2].p), notnull(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 51:
#line 210 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(AND, notnull(yystack.l_mark[-2].p), notnull(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 52:
#line 211 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(yystack.l_mark[-1].i, NIL, yystack.l_mark[-2].p, (Node*)makedfa(yystack.l_mark[0].s, 0)); }
#line 1 ""
break;
case 53:
#line 213 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[0].p))
			yyval.p = op3(yystack.l_mark[-1].i, NIL, yystack.l_mark[-2].p, (Node*)makedfa(strnode(yystack.l_mark[0].p), 0));
		  else
			yyval.p = op3(yystack.l_mark[-1].i, (Node *)1, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 54:
#line 217 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(INTEST, yystack.l_mark[-2].p, makearr(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 55:
#line 218 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(INTEST, yystack.l_mark[-3].p, makearr(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 56:
#line 219 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(CAT, yystack.l_mark[-1].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 59:
#line 225 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 60:
#line 227 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(CONDEXPR, notnull(yystack.l_mark[-4].p), yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 61:
#line 229 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(BOR, notnull(yystack.l_mark[-2].p), notnull(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 62:
#line 231 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(AND, notnull(yystack.l_mark[-2].p), notnull(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 63:
#line 232 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 64:
#line 233 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 65:
#line 234 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 66:
#line 235 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 67:
#line 236 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 68:
#line 237 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(yystack.l_mark[-1].i, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 69:
#line 238 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(yystack.l_mark[-1].i, NIL, yystack.l_mark[-2].p, (Node*)makedfa(yystack.l_mark[0].s, 0)); }
#line 1 ""
break;
case 70:
#line 240 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[0].p))
			yyval.p = op3(yystack.l_mark[-1].i, NIL, yystack.l_mark[-2].p, (Node*)makedfa(strnode(yystack.l_mark[0].p), 0));
		  else
			yyval.p = op3(yystack.l_mark[-1].i, (Node *)1, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 71:
#line 244 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(INTEST, yystack.l_mark[-2].p, makearr(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 72:
#line 245 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(INTEST, yystack.l_mark[-3].p, makearr(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 73:
#line 246 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{
			if (safe) SYNTAX("cmd | getline is unsafe");
			else yyval.p = op3(GETLINE, yystack.l_mark[0].p, itonp(yystack.l_mark[-2].i), yystack.l_mark[-3].p); }
#line 1 ""
break;
case 74:
#line 249 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{
			if (safe) SYNTAX("cmd | getline is unsafe");
			else yyval.p = op3(GETLINE, (Node*)0, itonp(yystack.l_mark[-1].i), yystack.l_mark[-2].p); }
#line 1 ""
break;
case 75:
#line 252 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(CAT, yystack.l_mark[-1].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 78:
#line 258 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = linkum(yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 79:
#line 259 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = linkum(yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 81:
#line 264 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = linkum(yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 82:
#line 268 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = rectonode(); }
#line 1 ""
break;
case 84:
#line 270 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = yystack.l_mark[-1].p; }
#line 1 ""
break;
case 93:
#line 287 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(MATCH, NIL, rectonode(), (Node*)makedfa(yystack.l_mark[0].s, 0)); }
#line 1 ""
break;
case 94:
#line 288 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(NOT, notnull(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 95:
#line 292 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{startreg();}
#line 1 ""
break;
case 96:
#line 292 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.s = yystack.l_mark[-1].s; }
#line 1 ""
break;
case 99:
#line 300 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{
			if (safe) SYNTAX("print | is unsafe");
			else yyval.p = stat3(yystack.l_mark[-3].i, yystack.l_mark[-2].p, itonp(yystack.l_mark[-1].i), yystack.l_mark[0].p); }
#line 1 ""
break;
case 100:
#line 303 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{
			if (safe) SYNTAX("print >> is unsafe");
			else yyval.p = stat3(yystack.l_mark[-3].i, yystack.l_mark[-2].p, itonp(yystack.l_mark[-1].i), yystack.l_mark[0].p); }
#line 1 ""
break;
case 101:
#line 306 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{
			if (safe) SYNTAX("print > is unsafe");
			else yyval.p = stat3(yystack.l_mark[-3].i, yystack.l_mark[-2].p, itonp(yystack.l_mark[-1].i), yystack.l_mark[0].p); }
#line 1 ""
break;
case 102:
#line 309 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat3(yystack.l_mark[-1].i, yystack.l_mark[0].p, NIL, NIL); }
#line 1 ""
break;
case 103:
#line 310 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat2(DELETE, makearr(yystack.l_mark[-3].p), yystack.l_mark[-1].p); }
#line 1 ""
break;
case 104:
#line 311 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat2(DELETE, makearr(yystack.l_mark[0].p), 0); }
#line 1 ""
break;
case 105:
#line 312 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = exptostat(yystack.l_mark[0].p); }
#line 1 ""
break;
case 106:
#line 313 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyclearin; SYNTAX("illegal statement"); }
#line 1 ""
break;
case 109:
#line 322 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (!inloop) SYNTAX("break illegal outside of loops");
				  yyval.p = stat1(BREAK, NIL); }
#line 1 ""
break;
case 110:
#line 324 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{  if (!inloop) SYNTAX("continue illegal outside of loops");
				  yyval.p = stat1(CONTINUE, NIL); }
#line 1 ""
break;
case 111:
#line 326 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{inloop++;}
#line 1 ""
break;
case 112:
#line 326 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{--inloop;}
#line 1 ""
break;
case 113:
#line 327 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat2(DO, yystack.l_mark[-6].p, notnull(yystack.l_mark[-2].p)); }
#line 1 ""
break;
case 114:
#line 328 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat1(EXIT, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 115:
#line 329 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat1(EXIT, NIL); }
#line 1 ""
break;
case 117:
#line 331 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat3(IF, yystack.l_mark[-3].p, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 118:
#line 332 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat3(IF, yystack.l_mark[-1].p, yystack.l_mark[0].p, NIL); }
#line 1 ""
break;
case 119:
#line 333 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = yystack.l_mark[-1].p; }
#line 1 ""
break;
case 120:
#line 334 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (infunc)
				SYNTAX("next is illegal inside a function");
			  yyval.p = stat1(NEXT, NIL); }
#line 1 ""
break;
case 121:
#line 337 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (infunc)
				SYNTAX("nextfile is illegal inside a function");
			  yyval.p = stat1(NEXTFILE, NIL); }
#line 1 ""
break;
case 122:
#line 340 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat1(RETURN, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 123:
#line 341 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = stat1(RETURN, NIL); }
#line 1 ""
break;
case 125:
#line 343 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{inloop++;}
#line 1 ""
break;
case 126:
#line 343 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ --inloop; yyval.p = stat2(WHILE, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 127:
#line 344 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = 0; }
#line 1 ""
break;
case 129:
#line 349 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = linkum(yystack.l_mark[-1].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 133:
#line 358 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.cp = catstr(yystack.l_mark[-1].cp, yystack.l_mark[0].cp); }
#line 1 ""
break;
case 134:
#line 362 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(DIVEQ, yystack.l_mark[-3].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 135:
#line 363 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(ADD, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 136:
#line 364 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(MINUS, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 137:
#line 365 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(MULT, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 138:
#line 366 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(DIVIDE, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 139:
#line 367 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(MOD, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 140:
#line 368 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(POWER, yystack.l_mark[-2].p, yystack.l_mark[0].p); }
#line 1 ""
break;
case 141:
#line 369 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(UMINUS, yystack.l_mark[0].p); }
#line 1 ""
break;
case 142:
#line 370 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(UPLUS, yystack.l_mark[0].p); }
#line 1 ""
break;
case 143:
#line 371 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(NOT, notnull(yystack.l_mark[0].p)); }
#line 1 ""
break;
case 144:
#line 372 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(BLTIN, itonp(yystack.l_mark[-2].i), rectonode()); }
#line 1 ""
break;
case 145:
#line 373 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(BLTIN, itonp(yystack.l_mark[-3].i), yystack.l_mark[-1].p); }
#line 1 ""
break;
case 146:
#line 374 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(BLTIN, itonp(yystack.l_mark[0].i), rectonode()); }
#line 1 ""
break;
case 147:
#line 375 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(CALL, celltonode(yystack.l_mark[-2].cp,CVAR), NIL); }
#line 1 ""
break;
case 148:
#line 376 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(CALL, celltonode(yystack.l_mark[-3].cp,CVAR), yystack.l_mark[-1].p); }
#line 1 ""
break;
case 149:
#line 377 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(CLOSE, yystack.l_mark[0].p); }
#line 1 ""
break;
case 150:
#line 378 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(PREDECR, yystack.l_mark[0].p); }
#line 1 ""
break;
case 151:
#line 379 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(PREINCR, yystack.l_mark[0].p); }
#line 1 ""
break;
case 152:
#line 380 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(POSTDECR, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 153:
#line 381 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(POSTINCR, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 154:
#line 383 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op5(GENSUB, NIL, (Node*)makedfa(yystack.l_mark[-5].s, 1), yystack.l_mark[-3].p, yystack.l_mark[-1].p, rectonode()); }
#line 1 ""
break;
case 155:
#line 385 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[-5].p))
			yyval.p = op5(GENSUB, NIL, (Node *)makedfa(strnode(yystack.l_mark[-5].p), 1), yystack.l_mark[-3].p, yystack.l_mark[-1].p, rectonode());
		  else
			yyval.p = op5(GENSUB, (Node *)1, yystack.l_mark[-5].p, yystack.l_mark[-3].p, yystack.l_mark[-1].p, rectonode());
		}
#line 1 ""
break;
case 156:
#line 391 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op5(GENSUB, NIL, (Node*)makedfa(yystack.l_mark[-7].s, 1), yystack.l_mark[-5].p, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 157:
#line 393 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[-7].p))
			yyval.p = op5(GENSUB, NIL, (Node *)makedfa(strnode(yystack.l_mark[-7].p),1), yystack.l_mark[-5].p,yystack.l_mark[-3].p,yystack.l_mark[-1].p);
		  else
			yyval.p = op5(GENSUB, (Node *)1, yystack.l_mark[-7].p, yystack.l_mark[-5].p, yystack.l_mark[-3].p, yystack.l_mark[-1].p);
		}
#line 1 ""
break;
case 158:
#line 398 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(GETLINE, yystack.l_mark[-2].p, itonp(yystack.l_mark[-1].i), yystack.l_mark[0].p); }
#line 1 ""
break;
case 159:
#line 399 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(GETLINE, NIL, itonp(yystack.l_mark[-1].i), yystack.l_mark[0].p); }
#line 1 ""
break;
case 160:
#line 400 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(GETLINE, yystack.l_mark[0].p, NIL, NIL); }
#line 1 ""
break;
case 161:
#line 401 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(GETLINE, NIL, NIL, NIL); }
#line 1 ""
break;
case 162:
#line 403 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(INDEX, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 163:
#line 405 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ SYNTAX("index() doesn't permit regular expressions");
		  yyval.p = op2(INDEX, yystack.l_mark[-3].p, (Node*)yystack.l_mark[-1].s); }
#line 1 ""
break;
case 164:
#line 407 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = yystack.l_mark[-1].p; }
#line 1 ""
break;
case 165:
#line 409 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(MATCHFCN, NIL, yystack.l_mark[-3].p, (Node*)makedfa(yystack.l_mark[-1].s, 1)); }
#line 1 ""
break;
case 166:
#line 411 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[-1].p))
			yyval.p = op3(MATCHFCN, NIL, yystack.l_mark[-3].p, (Node*)makedfa(strnode(yystack.l_mark[-1].p), 1));
		  else
			yyval.p = op3(MATCHFCN, (Node *)1, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 167:
#line 415 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = celltonode(yystack.l_mark[0].cp, CCON); }
#line 1 ""
break;
case 168:
#line 417 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op4(SPLIT, yystack.l_mark[-5].p, makearr(yystack.l_mark[-3].p), yystack.l_mark[-1].p, (Node*)STRING); }
#line 1 ""
break;
case 169:
#line 419 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op4(SPLIT, yystack.l_mark[-5].p, makearr(yystack.l_mark[-3].p), (Node*)makedfa(yystack.l_mark[-1].s, 1), (Node *)REGEXPR); }
#line 1 ""
break;
case 170:
#line 421 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op4(SPLIT, yystack.l_mark[-3].p, makearr(yystack.l_mark[-1].p), NIL, (Node*)STRING); }
#line 1 ""
break;
case 171:
#line 422 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(yystack.l_mark[-3].i, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 172:
#line 423 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = celltonode(yystack.l_mark[0].cp, CCON); }
#line 1 ""
break;
case 173:
#line 425 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op4(yystack.l_mark[-5].i, NIL, (Node*)makedfa(yystack.l_mark[-3].s, 1), yystack.l_mark[-1].p, rectonode()); }
#line 1 ""
break;
case 174:
#line 427 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[-3].p))
			yyval.p = op4(yystack.l_mark[-5].i, NIL, (Node*)makedfa(strnode(yystack.l_mark[-3].p), 1), yystack.l_mark[-1].p, rectonode());
		  else
			yyval.p = op4(yystack.l_mark[-5].i, (Node *)1, yystack.l_mark[-3].p, yystack.l_mark[-1].p, rectonode()); }
#line 1 ""
break;
case 175:
#line 432 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op4(yystack.l_mark[-7].i, NIL, (Node*)makedfa(yystack.l_mark[-5].s, 1), yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 176:
#line 434 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ if (constnode(yystack.l_mark[-5].p))
			yyval.p = op4(yystack.l_mark[-7].i, NIL, (Node*)makedfa(strnode(yystack.l_mark[-5].p), 1), yystack.l_mark[-3].p, yystack.l_mark[-1].p);
		  else
			yyval.p = op4(yystack.l_mark[-7].i, (Node *)1, yystack.l_mark[-5].p, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 177:
#line 439 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(SUBSTR, yystack.l_mark[-5].p, yystack.l_mark[-3].p, yystack.l_mark[-1].p); }
#line 1 ""
break;
case 178:
#line 441 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op3(SUBSTR, yystack.l_mark[-3].p, yystack.l_mark[-1].p, NIL); }
#line 1 ""
break;
case 181:
#line 447 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op2(ARRAY, makearr(yystack.l_mark[-3].p), yystack.l_mark[-1].p); }
#line 1 ""
break;
case 182:
#line 448 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(INDIRECT, celltonode(yystack.l_mark[0].cp, CVAR)); }
#line 1 ""
break;
case 183:
#line 449 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(INDIRECT, yystack.l_mark[0].p); }
#line 1 ""
break;
case 184:
#line 453 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ arglist = yyval.p = 0; }
#line 1 ""
break;
case 185:
#line 454 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ arglist = yyval.p = celltonode(yystack.l_mark[0].cp,CVAR); }
#line 1 ""
break;
case 186:
#line 455 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{
			checkdup(yystack.l_mark[-2].p, yystack.l_mark[0].cp);
			arglist = yyval.p = linkum(yystack.l_mark[-2].p,celltonode(yystack.l_mark[0].cp,CVAR)); }
#line 1 ""
break;
case 187:
#line 461 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = celltonode(yystack.l_mark[0].cp, CVAR); }
#line 1 ""
break;
case 188:
#line 462 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(ARG, itonp(yystack.l_mark[0].i)); }
#line 1 ""
break;
case 189:
#line 463 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = op1(VARNF, (Node *) yystack.l_mark[0].cp); }
#line 1 ""
break;
case 190:
#line 468 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/awk/../../external/historical/nawk/bin/../dist/awkgram.y"
	{ yyval.p = notnull(yystack.l_mark[-1].p); }
#line 1 ""
break;
#line 5307 "awkgram.c"
    default:
        break;
    }
    yystack.s_mark -= yym;
    yystate = *yystack.s_mark;
    yystack.l_mark -= yym;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark -= yym;
#endif
    yym = yylhs[yyn];
    if (yystate == 0 && yym == 0)
    {
#if YYDEBUG
        if (yydebug)
        {
            fprintf(stderr, "%s[%d]: after reduction, ", YYDEBUGSTR, yydepth);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
            if (!yytrial)
#endif /* YYBTYACC */
                fprintf(stderr, "result is <%s>, ", YYSTYPE_TOSTRING(yystos[YYFINAL], yyval));
#endif
            fprintf(stderr, "shifting from state 0 to final state %d\n", YYFINAL);
        }
#endif
        yystate = YYFINAL;
        *++yystack.s_mark = YYFINAL;
        *++yystack.l_mark = yyval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        *++yystack.p_mark = yyloc;
#endif
        if (yychar < 0)
        {
#if YYBTYACC
            do {
            if (yylvp < yylve)
            {
                /* we're currently re-reading tokens */
                yylval = *yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylloc = *yylpp++;
#endif
                yychar = *yylexp++;
                break;
            }
            if (yyps->save)
            {
                /* in trial mode; save scanner results for future parse attempts */
                if (yylvp == yylvlim)
                {   /* Enlarge lexical value queue */
                    size_t p = (size_t) (yylvp - yylvals);
                    size_t s = (size_t) (yylvlim - yylvals);

                    s += YYLVQUEUEGROWTH;
                    if ((yylexemes = (YYINT *)realloc(yylexemes, s * sizeof(YYINT))) == NULL)
                        goto yyenomem;
                    if ((yylvals   = (YYSTYPE *)realloc(yylvals, s * sizeof(YYSTYPE))) == NULL)
                        goto yyenomem;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    if ((yylpsns   = (YYLTYPE *)realloc(yylpsns, s * sizeof(YYLTYPE))) == NULL)
                        goto yyenomem;
#endif
                    yylvp   = yylve = yylvals + p;
                    yylvlim = yylvals + s;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpp   = yylpe = yylpsns + p;
                    yylplim = yylpsns + s;
#endif
                    yylexp  = yylexemes + p;
                }
                *yylexp = (YYINT) YYLEX;
                *yylvp++ = yylval;
                yylve++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                *yylpp++ = yylloc;
                yylpe++;
#endif
                yychar = *yylexp++;
                break;
            }
            /* normal operation, no conflict encountered */
#endif /* YYBTYACC */
            yychar = YYLEX;
#if YYBTYACC
            } while (0);
#endif /* YYBTYACC */
            if (yychar < 0) yychar = YYEOF;
#if YYDEBUG
            if (yydebug)
            {
                if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
                fprintf(stderr, "%s[%d]: state %d, reading token %d (%s)\n",
                                YYDEBUGSTR, yydepth, YYFINAL, yychar, yys);
            }
#endif
        }
        if (yychar == YYEOF) goto yyaccept;
        goto yyloop;
    }
    if (((yyn = yygindex[yym]) != 0) && (yyn += yystate) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yystate)
        yystate = yytable[yyn];
    else
        yystate = yydgoto[yym];
#if YYDEBUG
    if (yydebug)
    {
        fprintf(stderr, "%s[%d]: after reduction, ", YYDEBUGSTR, yydepth);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
            fprintf(stderr, "result is <%s>, ", YYSTYPE_TOSTRING(yystos[yystate], yyval));
#endif
        fprintf(stderr, "shifting from state %d to state %d\n", *yystack.s_mark, yystate);
    }
#endif
    if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
    *++yystack.s_mark = (YYINT) yystate;
    *++yystack.l_mark = yyval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    *++yystack.p_mark = yyloc;
#endif
    goto yyloop;
#if YYBTYACC

    /* Reduction declares that this path is valid. Set yypath and do a full parse */
yyvalid:
    if (yypath) YYABORT;
    while (yyps->save)
    {
        YYParseState *save = yyps->save;
        yyps->save = save->save;
        save->save = yypath;
        yypath = save;
    }
#if YYDEBUG
    if (yydebug)
        fprintf(stderr, "%s[%d]: state %d, CONFLICT trial successful, backtracking to state %d, %d tokens\n",
                        YYDEBUGSTR, yydepth, yystate, yypath->state, (int)(yylvp - yylvals - yypath->lexeme));
#endif
    if (yyerrctx)
    {
        yyFreeState(yyerrctx);
        yyerrctx = NULL;
    }
    yylvp          = yylvals + yypath->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yylpp          = yylpsns + yypath->lexeme;
#endif
    yylexp         = yylexemes + yypath->lexeme;
    yychar         = YYEMPTY;
    yystack.s_mark = yystack.s_base + (yypath->yystack.s_mark - yypath->yystack.s_base);
    memcpy (yystack.s_base, yypath->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
    yystack.l_mark = yystack.l_base + (yypath->yystack.l_mark - yypath->yystack.l_base);
    memcpy (yystack.l_base, yypath->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark = yystack.p_base + (yypath->yystack.p_mark - yypath->yystack.p_base);
    memcpy (yystack.p_base, yypath->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
    yystate        = yypath->state;
    goto yyloop;
#endif /* YYBTYACC */

yyoverflow:
    YYERROR_CALL("yacc stack overflow");
#if YYBTYACC
    goto yyabort_nomem;
yyenomem:
    YYERROR_CALL("memory exhausted");
yyabort_nomem:
#endif /* YYBTYACC */
    yyresult = 2;
    goto yyreturn;

yyabort:
    yyresult = 1;
    goto yyreturn;

yyaccept:
#if YYBTYACC
    if (yyps->save) goto yyvalid;
#endif /* YYBTYACC */
    yyresult = 0;

yyreturn:
#if defined(YYDESTRUCT_CALL)
    if (yychar != YYEOF && yychar != YYEMPTY)
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        YYDESTRUCT_CALL("cleanup: discarding token", yychar, &yylval, &yylloc);
#else
        YYDESTRUCT_CALL("cleanup: discarding token", yychar, &yylval);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */

    {
        YYSTYPE *pv;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        YYLTYPE *pp;

        for (pv = yystack.l_base, pp = yystack.p_base; pv <= yystack.l_mark; ++pv, ++pp)
             YYDESTRUCT_CALL("cleanup: discarding state",
                             yystos[*(yystack.s_base + (pv - yystack.l_base))], pv, pp);
#else
        for (pv = yystack.l_base; pv <= yystack.l_mark; ++pv)
             YYDESTRUCT_CALL("cleanup: discarding state",
                             yystos[*(yystack.s_base + (pv - yystack.l_base))], pv);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
    }
#endif /* defined(YYDESTRUCT_CALL) */

#if YYBTYACC
    if (yyerrctx)
    {
        yyFreeState(yyerrctx);
        yyerrctx = NULL;
    }
    while (yyps)
    {
        YYParseState *save = yyps;
        yyps = save->save;
        save->save = NULL;
        yyFreeState(save);
    }
    while (yypath)
    {
        YYParseState *save = yypath;
        yypath = save->save;
        save->save = NULL;
        yyFreeState(save);
    }
#endif /* YYBTYACC */
    yyfreestack(&yystack);
    return (yyresult);
}
