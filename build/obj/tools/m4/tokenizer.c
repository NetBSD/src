/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/m4/bootstrap/tokenizer.c