/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/gmp/../../external/lgpl3/gmp/dist/mpn/x86_64/div_qr_2u_pi1.asm