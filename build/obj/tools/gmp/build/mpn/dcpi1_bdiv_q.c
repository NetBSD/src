/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/gmp/../../external/lgpl3/gmp/dist/mpn/generic/dcpi1_bdiv_q.c