/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/gmp/../../external/lgpl3/gmp/dist/mpn/generic/toom_interpolate_5pts.c