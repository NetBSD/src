#if HAVE_NBTOOL_CONFIG_H
#include "nbtool_config.h"
#endif
/* original parser id follows */
/* yysccsid[] = "@(#)yaccpar	1.9 (Berkeley) 02/21/93" */
/* (use YYMAJOR/YYMINOR for ifdefs dependent on parser version) */

#define YYBYACC 1
#define YYMAJOR 2
#define YYMINOR 0

#define YYEMPTY        (-1)
#define yyclearin      (yychar = YYEMPTY)
#define yyerrok        (yyerrflag = 0)
#define YYRECOVERING() (yyerrflag != 0)
#define YYENOMEM       (-2)
#define YYEOF          0
#undef YYBTYACC
#define YYBTYACC 0
#define YYDEBUGSTR YYPREFIX "debug"
#define YYPREFIX "yy"

#define YYPURE 0

#line 2 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
/* $NetBSD: cgram.y,v 1.436 2023/05/22 17:47:27 rillig Exp $ */

/*
 * Copyright (c) 1996 Christopher G. Demetriou.  All Rights Reserved.
 * Copyright (c) 1994, 1995 Jochen Pohl
 * All Rights Reserved.
 *
 * Redistribution and use in source and binary forms, with or without
 * modification, are permitted provided that the following conditions
 * are met:
 * 1. Redistributions of source code must retain the above copyright
 *    notice, this list of conditions and the following disclaimer.
 * 2. Redistributions in binary form must reproduce the above copyright
 *    notice, this list of conditions and the following disclaimer in the
 *    documentation and/or other materials provided with the distribution.
 * 3. All advertising materials mentioning features or use of this software
 *    must display the following acknowledgement:
 *      This product includes software developed by Jochen Pohl for
 *	The NetBSD Project.
 * 4. The name of the author may not be used to endorse or promote products
 *    derived from this software without specific prior written permission.
 *
 * THIS SOFTWARE IS PROVIDED BY THE AUTHOR ``AS IS'' AND ANY EXPRESS OR
 * IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE IMPLIED WARRANTIES
 * OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE DISCLAIMED.
 * IN NO EVENT SHALL THE AUTHOR BE LIABLE FOR ANY DIRECT, INDIRECT,
 * INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES (INCLUDING, BUT
 * NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES; LOSS OF USE,
 * DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED AND ON ANY
 * THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY, OR TORT
 * (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE OF
 * THIS SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.
 */

#include <sys/cdefs.h>
#if defined(__RCSID)
__RCSID("$NetBSD: cgram.y,v 1.436 2023/05/22 17:47:27 rillig Exp $");
#endif

#include <limits.h>
#include <stdlib.h>
#include <string.h>

#include "lint1.h"

extern char *yytext;

/*
 * Contains the level of current declaration, used for symbol table entries.
 * 0 is the top-level, > 0 is inside a function body.
 */
int	block_level;

/*
 * level for memory allocation. Normally the same as block_level.
 * An exception is the declaration of arguments in prototypes. Memory
 * for these can't be freed after the declaration, but symbols must
 * be removed from the symbol table after the declaration.
 */
size_t	mem_block_level;

/*
 * Save the no-warns state and restore it to avoid the problem where
 * if (expr) { stmt } / * NOLINT * / stmt;
 */
#define LWARN_NOTHING_SAVED (-3)
static int saved_lwarn = LWARN_NOTHING_SAVED;

static	void	cgram_declare(sym_t *, bool, sbuf_t *);
static	void	read_until_rparen(void);
static	sym_t	*symbolrename(sym_t *, sbuf_t *);


/* ARGSUSED */
static void
clear_warning_flags_loc(const char *file, size_t line)
{
	debug_step("%s:%zu: clearing flags", file, line);
	clear_warn_flags();
	saved_lwarn = LWARN_NOTHING_SAVED;
}

/* ARGSUSED */
static void
save_warning_flags_loc(const char *file, size_t line)
{
	/*
	 * There used to be an assertion that saved_lwarn is
	 * LWARN_NOTHING_SAVED here, but that triggered for the following
	 * code:
	 *
	 * void function(int x) { if (x > 0) if (x > 1) return; }
	 *
	 * It didn't trigger if the inner 'if' was enclosed in braces though.
	 *
	 * TODO: If actually needed, add support for nested suppression of
	 *  warnings.
	 */
	debug_step("%s:%zu: saving flags %d", file, line, lwarn);
	saved_lwarn = lwarn;
}

/* ARGSUSED */
static void
restore_warning_flags_loc(const char *file, size_t line)
{
	if (saved_lwarn != LWARN_NOTHING_SAVED) {
		lwarn = saved_lwarn;
		debug_step("%s:%zu: restoring flags %d", file, line, lwarn);
		/*
		 * Do not set 'saved_lwarn = LWARN_NOTHING_SAVED' here, to
		 * avoid triggering the assertion in save_warning_flags_loc.
		 */
	} else
		clear_warning_flags_loc(file, line);
}

#define clear_warning_flags()	clear_warning_flags_loc(__FILE__, __LINE__)
#define save_warning_flags()	save_warning_flags_loc(__FILE__, __LINE__)
#define restore_warning_flags()	restore_warning_flags_loc(__FILE__, __LINE__)

/* unbind the anonymous struct members from the struct */
static void
anonymize(sym_t *s)
{
	for ( ; s != NULL; s = s->s_next)
		s->u.s_member.sm_sou_type = NULL;
}

static bool
is_either(const char *s, const char *a, const char *b)
{
	return strcmp(s, a) == 0 || strcmp(s, b) == 0;
}

#if YYDEBUG && (YYBYACC || YYBISON)
#define YYSTYPE_TOSTRING cgram_to_string
#endif
#if YYDEBUG && YYBISON
#define YYPRINT cgram_print
#endif

#ifdef YYSTYPE
#undef  YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#endif
#ifndef YYSTYPE_IS_DECLARED
#define YYSTYPE_IS_DECLARED 1
#line 148 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
typedef union {
	val_t	*y_val;
	sbuf_t	*y_name;
	sym_t	*y_sym;
	op_t	y_op;
	scl_t	y_scl;
	tspec_t	y_tspec;
	tqual_t	y_tqual;
	type_t	*y_type;
	tnode_t	*y_tnode;
	range_t	y_range;
	strg_t	*y_string;
	qual_ptr *y_qual_ptr;
	bool	y_seen_statement;
	struct generic_association *y_generic;
	struct array_size y_array_size;
	bool	y_in_system_header;
} YYSTYPE;
#endif /* !YYSTYPE_IS_DECLARED */
#line 332 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
#if YYDEBUG && YYBISON
static inline void cgram_print(FILE *, int, YYSTYPE);
#endif
#line 196 "cgram.c"

/* compatibility with bison */
#ifdef YYPARSE_PARAM
/* compatibility with FreeBSD */
# ifdef YYPARSE_PARAM_TYPE
#  define YYPARSE_DECL() yyparse(YYPARSE_PARAM_TYPE YYPARSE_PARAM)
# else
#  define YYPARSE_DECL() yyparse(void *YYPARSE_PARAM)
# endif
#else
# define YYPARSE_DECL() yyparse(void)
#endif

/* Parameters sent to lex. */
#ifdef YYLEX_PARAM
# define YYLEX_DECL() yylex(void *YYLEX_PARAM)
# define YYLEX yylex(YYLEX_PARAM)
#else
# define YYLEX_DECL() yylex(void)
# define YYLEX yylex()
#endif

#if !(defined(yylex) || defined(YYSTATE))
int YYLEX_DECL();
#endif

/* Parameters sent to yyerror. */
#ifndef YYERROR_DECL
#define YYERROR_DECL() yyerror(const char *s)
#endif
#ifndef YYERROR_CALL
#define YYERROR_CALL(msg) yyerror(msg)
#endif

extern int YYPARSE_DECL();

#define T_LBRACE 257
#define T_RBRACE 258
#define T_LBRACK 259
#define T_RBRACK 260
#define T_LPAREN 261
#define T_RPAREN 262
#define T_POINT 263
#define T_ARROW 264
#define T_COMPLEMENT 265
#define T_LOGNOT 266
#define T_INCDEC 267
#define T_SIZEOF 268
#define T_BUILTIN_OFFSETOF 269
#define T_TYPEOF 270
#define T_EXTENSION 271
#define T_ALIGNAS 272
#define T_ALIGNOF 273
#define T_ASTERISK 274
#define T_MULTIPLICATIVE 275
#define T_ADDITIVE 276
#define T_SHIFT 277
#define T_RELATIONAL 278
#define T_EQUALITY 279
#define T_AMPER 280
#define T_BITXOR 281
#define T_BITOR 282
#define T_LOGAND 283
#define T_LOGOR 284
#define T_QUEST 285
#define T_COLON 286
#define T_ASSIGN 287
#define T_OPASSIGN 288
#define T_COMMA 289
#define T_SEMI 290
#define T_ELLIPSIS 291
#define T_REAL 292
#define T_IMAG 293
#define T_GENERIC 294
#define T_NORETURN 295
#define T_SCLASS 296
#define T_TYPE 297
#define T_QUAL 298
#define T_ATOMIC 299
#define T_STRUCT_OR_UNION 300
#define T_ASM 301
#define T_BREAK 302
#define T_CASE 303
#define T_CONTINUE 304
#define T_DEFAULT 305
#define T_DO 306
#define T_ELSE 307
#define T_ENUM 308
#define T_FOR 309
#define T_GOTO 310
#define T_IF 311
#define T_PACKED 312
#define T_RETURN 313
#define T_SWITCH 314
#define T_SYMBOLRENAME 315
#define T_WHILE 316
#define T_STATIC_ASSERT 317
#define T_ATTRIBUTE 318
#define T_THEN 319
#define T_NAME 320
#define T_TYPENAME 321
#define T_CON 322
#define T_STRING 323
#define YYERRCODE 256
typedef int YYINT;
static const YYINT yylhs[] = {                           -1,
    0,    0,    1,    2,    2,    3,    3,    4,    4,    4,
    4,    4,    4,    5,    6,    6,    7,    7,    8,    8,
    8,    8,    8,    8,   74,    8,   79,   81,    8,   76,
   76,    9,    9,   10,   10,   10,   11,   11,   12,   12,
   13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
   13,   13,   13,   13,   14,   14,   17,   17,   15,   15,
   15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
   15,   16,   16,   16,   18,   18,   19,   82,   82,   84,
   84,   84,   84,   84,   88,   88,   88,   88,   88,   85,
   85,   85,   94,   94,   95,   95,   95,   95,   95,   20,
   20,   97,   97,   92,   92,   92,   98,   98,   96,   96,
   99,   99,   91,   91,   91,   91,   91,   93,   86,   21,
   21,   22,   22,   22,   22,   22,   23,   24,  102,   24,
  103,   24,   24,   25,   25,   26,  104,   27,   27,   28,
   28,  105,   29,  106,   29,   29,   29,   29,   29,   30,
  107,   30,   31,  108,   31,   32,   32,  109,   32,   33,
   33,  110,   33,   34,  113,   34,  114,   34,   34,  111,
   35,  115,   36,   36,   37,   37,   37,   38,   38,   39,
   39,  101,   40,   40,   41,   42,   42,   43,   43,   44,
   87,   87,   89,   89,  116,  118,  116,  117,  120,  117,
   45,   45,   46,   46,   47,   47,   47,   47,   47,   48,
   48,   48,   48,   48,   49,   49,   50,   50,   51,   51,
   51,   51,   51,   52,   52,   52,   52,   53,   53,  121,
   54,   54,   54,   55,   55,   55,   56,   56,   56,  122,
   57,   58,   58,   58,   58,   59,   59,   59,   59,   59,
   60,   60,   60,   60,   60,   60,   61,   61,   61,  123,
   62,   62,   62,   63,   63,   64,   64,   64,   64,   64,
   64,  119,  119,  119,  119,   75,   75,  124,  124,  125,
  125,  126,  127,  127,  128,  128,   90,   90,   65,   65,
   73,   77,   66,   66,   66,  129,  129,   83,   83,   83,
   83,   83,   83,   83,  131,  137,  137,  137,  137,  132,
  132,   78,   80,   67,   67,   68,   68,  130,  130,  133,
  139,  133,  133,  133,  133,  138,  138,  141,  140,  134,
  134,  134,  134,  134,  134,  142,  143,  144,   69,  146,
  145,  145,  135,  135,  135,  135,  135,  135,  147,  136,
  136,  136,  148,   72,   72,  149,  149,  149,  149,  151,
  151,  151,  151,  153,  154,  150,   70,   70,   70,  152,
  152,  155,  155,  155,  156,  156,  156,  156,  156,  156,
  112,  112,  157,  157,  159,  160,  100,  158,  158,  161,
  161,  161,  161,  161,  162,  162,   71,
};
static const YYINT yylen[] = {                            2,
    0,    1,    1,    1,    1,    1,    2,    1,    1,    1,
    3,    1,    6,    6,    1,    3,    3,    3,    1,    5,
    4,    5,    4,    3,    0,    8,    0,    0,    7,    0,
    1,    1,    2,    1,    1,    2,    1,    1,    1,    3,
    1,    3,    3,    3,    3,    3,    3,    3,    3,    2,
    2,    4,    2,    4,    1,    4,    0,    1,    1,    4,
    4,    4,    4,    4,    4,    4,    4,    4,    4,    4,
    7,    1,    4,    4,    1,    4,    1,    1,    2,    3,
    4,    3,    4,    1,    1,    2,    2,    2,    2,    2,
    2,    2,    1,    2,    1,    2,    2,    2,    2,    2,
    2,    2,    2,    1,    1,    1,    0,    1,    1,    2,
    0,    1,    1,    4,    4,    1,    1,    0,    0,    1,
    1,    1,    4,    1,    1,    1,    4,    2,    0,    4,
    0,    3,    2,    1,    2,    2,    1,    2,    1,    1,
    2,    0,    6,    0,    6,    4,    4,    1,    2,    1,
    0,    4,    1,    0,    4,    1,    3,    0,    3,    1,
    3,    0,    3,    3,    0,    5,    0,    4,    2,    1,
    3,    1,    1,    2,    1,    3,    1,    2,    4,    1,
    1,    1,    2,    3,    1,    0,    1,    1,    2,    1,
    1,    3,    1,    3,    2,    0,    5,    2,    0,    5,
    1,    2,    1,    2,    2,    4,    4,    3,    2,    2,
    4,    4,    3,    2,    1,    2,    1,    2,    2,    1,
    3,    5,    3,    1,    3,    4,    3,    3,    1,    1,
    0,    1,    1,    3,    1,    1,    1,    3,    2,    0,
    2,    2,    2,    3,    3,    1,    1,    2,    2,    3,
    3,    3,    4,    2,    3,    2,    3,    4,    4,    1,
    1,    3,    1,    1,    3,    2,    2,    3,    3,    3,
    3,    1,    2,    4,    1,    1,    3,    2,    1,    3,
    2,    0,    1,    2,    3,    2,    7,    5,    1,    3,
    1,    1,    0,    5,    5,    1,    1,    2,    1,    1,
    1,    1,    1,    1,    3,    2,    3,    5,    2,    2,
    3,    1,    1,    1,    2,    1,    1,    2,    1,    1,
    0,    4,    3,    2,    2,    2,    2,    4,    4,    2,
    2,    2,    2,    2,    2,    4,    2,    1,    5,    2,
    9,    7,    3,    3,    2,    2,    3,    4,    1,    4,
    5,    2,    0,    1,    2,    1,    1,    1,    1,    4,
    1,    2,    2,    0,    0,    5,    3,    3,    3,    0,
    1,    1,    2,    1,    3,    4,    3,    4,    2,    2,
    0,    1,    1,    2,    0,    0,    8,    1,    3,    0,
    1,    3,    4,    1,    1,    3,    0,
};
static const YYINT yydefred[] = {                         0,
    0,    0,  359,  117,    0,  116,    0,    0,    0,   85,
  364,    0,  361,    0,    0,   84,    0,    0,  113,  358,
  354,  356,  357,  363,  362,    0,  352,  353,  180,  182,
    0,  181,    0,    0,    0,  355,    0,  105,  122,  134,
  170,  121,   86,  120,  124,  125,    0,  126,  104,    0,
  109,   92,    0,    0,    0,   89,    0,   88,    0,    0,
    0,   91,  101,  100,   90,    0,    0,  397,  397,  397,
    0,    0,    0,    0,  397,  397,  397,  397,  397,    0,
    8,    9,    6,    0,   19,   12,    0,   55,   59,    0,
    0,    0,    0,    0,  353,    0,  385,  374,    0,    0,
  365,    0,  372,    0,  133,    4,    5,    0,    3,  135,
    0,  185,   80,    0,    0,    0,    0,    0,    0,    0,
  191,  110,  240,  169,  383,    0,    0,   82,    0,    0,
    0,    0,    0,  193,    0,    0,  312,    0,    0,   75,
    0,    0,   27,    0,    0,    0,    0,    0,   51,  240,
   50,    0,   53,    0,    0,    0,    0,    0,    0,    7,
  397,  397,   37,   38,  397,  397,  397,  397,  397,  397,
  397,  397,  397,  397,  397,  397,  397,  397,  115,  114,
  350,    0,    0,    0,    0,  379,    0,  380,    0,    0,
  373,    0,    0,  137,  132,    0,    0,  190,    0,    0,
  188,    0,    0,    0,    0,    0,    0,  229,  209,    0,
    0,    0,   81,    0,  205,    0,    0,    0,  384,    0,
    0,    0,    0,  214,    0,   83,    0,  210,  360,  397,
  397,   11,  397,    0,    0,   95,  241,    0,  119,    0,
    0,    0,   46,   47,    0,   42,    0,    0,    0,   44,
   45,   43,   48,   49,    0,    0,    0,   24,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  351,  288,    0,    0,  394,    0,  388,  375,    0,
    0,  377,    0,    0,    0,  366,  123,  130,    0,  139,
  136,    0,  140,  148,  119,    0,  184,  189,    0,    0,
    0,    0,  236,    0,    0,    0,  233,  208,  237,    0,
    0,    0,  263,    0,    0,  264,    0,    0,  192,    0,
  127,    0,  172,  168,    0,    0,    0,  213,  194,    0,
    0,    0,    0,   56,    0,    0,    0,    0,    0,    0,
  338,    0,  349,    0,  397,    0,    0,    0,    0,   32,
    0,   34,   35,   78,    0,    0,    0,  299,  300,  301,
  302,  303,  304,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,  102,    0,   98,   97,   99,    0,    0,
   96,  103,    0,    0,    0,    0,    0,    0,    0,   21,
    0,   39,   23,   60,   61,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,  376,
  378,  313,  319,    0,    0,  314,  310,  316,  297,  317,
  296,  149,  138,  141,    0,    0,    0,    0,    0,    0,
  207,  239,  228,    0,    0,  112,  257,    0,    0,    0,
    0,  206,  166,  177,    0,    0,    0,  175,    0,  212,
  211,   73,   74,   76,  291,    0,   79,  346,    0,  345,
  309,  340,    0,    0,    0,    0,  306,   33,    0,   36,
    0,    0,  298,    0,    0,  325,    0,  324,  327,  326,
  331,  330,    0,  332,  333,  337,  335,  334,    0,    0,
    0,    0,    0,    0,    0,    0,  245,    0,    0,    0,
  244,   25,    0,    0,    0,   15,    0,   20,   22,    0,
  397,  287,  392,  395,    0,  389,    0,  318,  315,  311,
    0,    0,    0,    0,    0,    0,  275,  272,    0,  197,
  234,  238,  259,  258,  262,  265,    0,  224,    0,  268,
    0,  270,    0,    0,    0,  269,    0,  271,    0,  171,
    0,  200,    0,    0,    0,  279,  276,    0,    0,  307,
    0,    0,  347,    0,    0,    0,    0,  305,  323,    0,
    0,    0,    0,  344,  343,    0,    0,    0,    0,    0,
  260,    0,    0,  254,    0,   13,    0,   14,    0,    0,
   40,    0,  393,    0,  387,  147,    0,  153,    0,    0,
  146,    0,  150,    0,    0,  294,  295,  292,    0,  273,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  176,  281,    0,    0,  278,    0,    0,    0,  283,    0,
  328,  348,  329,  336,   29,  322,    0,    0,    0,  252,
  251,    0,    0,  255,   18,   16,   17,    0,  396,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  225,    0,
  227,  221,    0,  223,  179,  277,   26,    0,    0,  286,
  280,  284,  308,    0,    0,    0,  253,  145,    0,  161,
  163,  143,    0,  157,  159,  274,  226,    0,    0,  285,
  339,    0,    0,  155,  152,  222,  290,  342,    0,    0,
  341,
};
#if defined(YYDESTRUCT_CALL) || defined(YYSTYPE_TOSTRING)
static const YYINT yystos[] = {                           0,
  256,  272,  290,  295,  301,  312,  317,  318,  325,  345,
  395,  397,  409,  410,  413,  415,  416,  418,  425,  461,
  474,  475,  476,  258,  290,  261,  256,  261,  298,  299,
  364,  426,  261,  261,  478,  474,  270,  296,  297,  300,
  308,  321,  346,  347,  348,  349,  350,  359,  364,  411,
  416,  417,  421,  426,  436,  347,  411,  417,  410,  413,
  418,  296,  321,  347,  364,  411,  261,  265,  266,  267,
  268,  269,  271,  273,  274,  276,  280,  292,  293,  294,
  320,  322,  323,  328,  329,  330,  333,  338,  339,  340,
  344,  346,  426,  473,  261,  344,  261,  256,  410,  413,
  477,  480,  481,  261,  256,  320,  321,  326,  327,  416,
  428,  274,  290,  365,  366,  370,  372,  412,  421,  423,
  441,  416,  261,  256,  425,  437,  482,  290,  365,  371,
  373,  414,  423,  442,  370,  412,  257,  338,  340,  341,
  343,  382,  403,  447,  396,  396,  396,  261,  338,  261,
  339,  261,  338,  396,  396,  396,  396,  396,  261,  323,
  259,  261,  263,  264,  267,  336,  274,  275,  276,  277,
  278,  279,  280,  281,  282,  283,  284,  285,  262,  262,
  290,  473,  262,  289,  484,  256,  411,  256,  411,  479,
  481,  343,  427,  257,  351,  429,  372,  364,  367,  368,
  369,  301,  315,  391,  259,  261,  378,  386,  416,  446,
  448,  289,  290,  261,  320,  382,  326,  439,  425,  373,
  391,  259,  378,  416,  289,  290,  261,  327,  290,  287,
  288,  262,  289,  262,  404,  345,  383,  418,  419,  420,
  421,  422,  339,  339,  261,  338,  382,  382,  382,  339,
  339,  339,  339,  339,  341,  396,  396,  396,  396,  396,
  396,  396,  396,  396,  396,  396,  396,  396,  396,  396,
  396,  290,  290,  323,  320,  364,  483,  486,  290,  370,
  412,  290,  371,  414,  403,  457,  262,  351,  256,  258,
  352,  353,  354,  415,  419,  422,  365,  369,  261,  261,
  443,  274,  344,  364,  367,  379,  380,  391,  320,  381,
  256,  262,  291,  387,  388,  389,  410,  413,  442,  371,
  262,  438,  257,  360,  440,  445,  379,  391,  442,  371,
  396,  396,  396,  339,  399,  256,  302,  303,  304,  305,
  306,  309,  310,  311,  313,  314,  316,  320,  334,  335,
  343,  407,  408,  409,  410,  413,  425,  456,  457,  458,
  459,  460,  461,  462,  463,  465,  466,  467,  468,  469,
  470,  471,  472,  364,  411,  347,  364,  416,  420,  422,
  346,  364,  411,  382,  262,  289,  262,  289,  343,  262,
  337,  341,  320,  340,  340,  340,  340,  340,  340,  340,
  340,  340,  340,  340,  343,  262,  261,  289,  485,  290,
  290,  258,  290,  343,  392,  393,  405,  407,  408,  454,
  455,  290,  258,  354,  411,  411,  323,  320,  287,  296,
  260,  256,  262,  289,  262,  416,  424,  262,  289,  411,
  411,  262,  360,  256,  326,  361,  362,  363,  287,  260,
  262,  341,  341,  341,  257,  398,  290,  290,  344,  290,
  286,  261,  261,  396,  261,  261,  286,  335,  406,  290,
  411,  411,  290,  437,  307,  256,  425,  454,  256,  454,
  256,  454,  316,  394,  256,  454,  256,  454,  342,  343,
  413,  256,  327,  259,  261,  365,  384,  385,  386,  421,
  384,  262,  327,  305,  331,  332,  382,  260,  262,  289,
  286,  290,  262,  344,  487,  486,  262,  290,  393,  405,
  424,  431,  424,  430,  262,  262,  256,  341,  398,  444,
  344,  320,  424,  424,  291,  389,  261,  327,  365,  375,
  377,  384,  261,  327,  365,  374,  376,  384,  437,  258,
  289,  444,  320,  327,  400,  444,  449,  450,  451,  286,
  291,  343,  290,  343,  343,  343,  405,  454,  256,  464,
  261,  290,  411,  290,  290,  379,  384,  385,  421,  259,
  261,  386,  421,  391,  385,  262,  286,  262,  289,  286,
  341,  396,  262,  289,  262,  290,  356,  358,  371,  435,
  290,  355,  357,  370,  434,  437,  437,  258,  400,  402,
  375,  377,  259,  378,  375,  421,  376,  259,  378,  287,
  363,  286,  289,  401,  444,  259,  263,  452,  453,  344,
  262,  290,  262,  262,  262,  454,  343,  342,  412,  260,
  262,  385,  379,  391,  341,  332,  341,  340,  344,  424,
  433,  286,  286,  424,  432,  286,  286,  401,  262,  379,
  391,  262,  379,  391,  344,  449,  402,  344,  390,  327,
  287,  453,  286,  262,  290,  290,  260,  290,  289,  344,
  344,  290,  289,  344,  344,  402,  260,  260,  291,  260,
  290,  342,  342,  358,  358,  437,  344,  262,  290,  342,
  262,
};
#endif /* YYDESTRUCT_CALL || YYSTYPE_TOSTRING */
static const YYINT yydgoto[] = {                          9,
  445,  109,   84,   85,   86,  505,  506,   87,  349,  350,
  166,  391,  138,   89,  139,  140,  489,  414,  303,   10,
   43,   44,   45,   46,   47,  195,  291,  292,  293,  602,
  597,  603,  598,   48,  324,  446,  447,  448,   49,  129,
  115,  305,  200,  201,  280,  283,  117,  131,  546,  540,
  547,  541,  207,  306,  307,  310,  507,  237,  577,  498,
  499,  314,  315,  316,  669,  204,  415,  416,  484,   11,
  154,   12,  529,  335,  555,  624,  610,  285,  235,  417,
  469,  352,  419,  354,  355,   50,  118,  356,  132,   16,
   51,   58,   61,  295,  240,  119,  296,  133,  437,   19,
   54,  193,  111,  196,  524,  522,  655,  651,  605,  600,
   55,  126,  322,  218,  325,  121,  134,  301,  556,  326,
  210,  144,  211,  557,  558,  559,  628,  629,  420,  421,
  358,  359,  360,  361,  362,  363,  364,  365,  570,  366,
  367,  368,  369,  370,  371,  372,  373,   94,   21,   22,
   23,  101,   35,  190,  102,  103,  127,  277,  185,  409,
  278,  515,
};
static const YYINT yysindex[] = {                       454,
 -209, -192,    0,    0,   18,    0, -174, -102,    0,    0,
    0,  454,    0, 3257, 3374,    0,   -5, 3321,    0,    0,
    0,    0,    0,    0,    0, 2324,    0,    0,    0,    0,
  -67,    0, 2559,  -38,   62,    0,   32,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  126,    0,    0,  145,
    0,    0,   -5,   48, -229,    0,  545,    0, 3257, 3374,
 3321,    0,    0,    0,    0,  155, 1609,    0,    0,    0,
 2593,   61, 2559, 2627,    0,    0,    0,    0,    0,  105,
    0,    0,    0,  -50,    0,    0,  626,    0,    0, 3500,
  113,  137,   48,  115,    0, -205,    0,    0, 2209, 2331,
    0,   -5,    0, 2559,    0,    0,    0,    0,    0,    0,
  173,    0,    0,   -5,   86, -160,  888,  147,   -5, -169,
    0,    0,    0,    0,    0,  231,  124,    0,   -5, -160,
  956,  267, -173,    0, -160,  335,    0,  480, 3500,    0,
  -84,  186,    0,   -5, 2559, 2559, 2661, 1609,    0,    0,
    0, 1609,    0, 2559, 2559, 2559, 2559, 2559, 2559,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  166,  175,  157,  -40,    0,  736,    0, 1912,  234,
    0,  -58,  173,    0,    0, 1786,  888,    0,  221,   86,
    0,  265,  272,    0, 2422,    0, -160,    0,    0,  222,
    9,  155,    0,  155,    0,  300,    0,  319,    0,  956,
    0, 2422, -160,    0,  155,    0,  155,    0,    0,    0,
    0,    0,    0, 2559,  953,    0,    0, 3273,    0, 2887,
   -5, 3340,    0,    0, 1609,    0,  320,  301,  337,    0,
    0,    0,    0,    0,  315, 2559, 2457,    0,  290, 2559,
 2559, 2559, 2559, 2559, 2559, 2559, 2559, 2559, 2559, 2559,
 2559,    0,    0,  352,  373,    0,  351,    0,    0, -160,
  503,    0, -160,  532,  885,    0,    0,    0,  360,    0,
    0, 1797,    0,    0,    0, 3340,    0,    0,  330,  344,
  370,    0,    0,    0,  375,  409,    0,    0,    0, -203,
  413,   -5,    0,  419,  390,    0, 3257, 3374,    0,  433,
    0,  319,    0,    0, -159,  422,  486,    0,    0,  472,
 2559, 2559, 2559,    0,  523,  525,  534, 2559,  536,  542,
    0,  578,    0,  582,    0,  593,  597,  581,  953,    0,
  541,    0,    0,    0, 3257, 3374,  574,    0,    0,    0,
    0,    0,    0,  124,  506, 1021, 1089, 1157,  564, 1225,
 1293, 2387, -156,    0,  417,    0,    0,    0, 2887, 3340,
    0,    0,  417,  607,    0,  231,    0,  573,  -80,    0,
    8,    0,    0,    0,    0,  562,  501,  786,  648,  657,
  823,  744,  892,  960,  188,  598, 2491,  -40,  610,    0,
    0,    0,    0,  552,  885,    0,    0,    0,    0,    0,
    0,    0,    0,    0,   -5,   -5,  630,  632,  773, 2559,
    0,    0,    0,  576,   -5,    0,    0,   -5,  447, 1690,
 2216,    0,    0,    0,  124,  642,  614,    0,  773,    0,
    0,    0,    0,    0,    0, 1395,    0,    0,  -91,    0,
    0,    0, 2559, 2525, 2559, 2559,    0,    0,  652,    0,
  145,  545,    0, 1429,  660,    0,  574,    0,    0,    0,
    0,    0,  658,    0,    0,    0,    0,    0,  628,  639,
 3374,  649,  651, 2422,  417, 1024,    0, 1092, -160, 1024,
    0,    0,  682,  686,   14,    0,  687,    0,    0, 2559,
    0,    0,    0,    0,   43,    0,  689,    0,    0,    0,
  678,  155,  685,  155,  124,  124,    0,    0, 1361,    0,
    0,    0,    0,    0,    0,    0, 1690,    0,  625,    0,
  164,    0, 1690,   -5,  756,    0,  401,    0,  692,    0,
  231,    0,    0,  696,  709,    0,    0,  773,  104,    0,
 2559,   88,    0,  557,  114,  129,  747,    0,    0, 1429,
 2559, 2559,  155,    0,    0,  767,  754, 1092, 1024, 2422,
    0, -160,   -5,    0, 1092,    0, 2559,    0,  573, 2559,
    0, 2559,    0, 2559,    0,    0,   -5,    0,  746,  749,
    0,   -5,    0,  750,  751,    0,    0,    0,  709,    0,
  771,  164, 2422, -160,  781,   -5,  401, 2422, -160, 2559,
    0,    0, 1395,  787,    0, 2559,  231,  -70,    0,  764,
    0,    0,    0,    0,    0,    0,  171,  762,  586,    0,
    0, 1092,  796,    0,    0,    0,    0, 3500,    0,  768,
  775, 2559, 2559,  779,  800, 2559, 2559,  787,    0,  797,
    0,    0,  831,    0,    0,    0,    0,  830,  845,    0,
    0,    0,    0,  839, 2559, 2559,    0,    0,  155,    0,
    0,    0,  155,    0,    0,    0,    0,  124, 2559,    0,
    0,  871,  848,    0,    0,    0,    0,    0, 2559,  877,
    0,
};
static const YYINT yyrindex[] = {                       512,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  553,    0,  394,  260,    0, 3335,  220,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0, 1622,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  887,    0,    0, -151,
    0,    0, 2109, 1776, -213,    0,  -37,    0,    0,  327,
    0,    0,    0,    0,    0, -151, 3304,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0, 2843,    0,    0, 2888,    0,    0, 3181,
    0,    0,    0,    0,    0,    0,    0,    0,  394,  260,
    0, 2246,    0,    0,    0,    0,    0,  609,    0,    0,
    0,    0,    0, -151, 2700, 1901, 2124,    0,  -34,    0,
    0,    0,    0,    0,    0,  891,  691,    0,  -37, 1936,
 1981,    0,    0,    0, 2016,    0,    0, 3419,  680,    0,
    0,    0,    0, 3354,    0,    0,    0, 3304,    0,    0,
    0, 3304,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  200,    0, -151,    0,  -37,    0,
    0,    0,    0,    0,    0, 3354, 2170,    0, 1980, 2684,
    0,    0,    0,   65, -221, 2202, 1821,    0,    0,    0,
 3335,  -37,    0,  -37,    0,    0, 1638,    0,    0, 2061,
  403, -221, 1731,    0,  -37,    0,  -37,    0,    0,    0,
    0,    0,    0,  898, 3335,    0,    0,    0,    0, 2126,
 3354, 3228,    0,    0, 3304,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  210,    0,  883,    0,    0,  494,
    0,    0,  494,    0, 3335,    0,    0,    0,    0,    0,
    0, 3354,    0,    0,    0,  467,    0,    0,    0,    0,
    0, 2290,    0,    3,    0,    0,    0,    0,    0,    0,
    0, 1866,    0,    0,  900,    0,  -88,   69,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0, 3483, 1716,    0,
    0,    0,    0,    0,  394,  260, 3288,    0,    0,    0,
    0,    0,    0, 1549,  814,    0,    0,    0,    0,    0,
    0, 2278,    0,    0,   -1,    0,    0,    0, 2677,    0,
    0,    0,   83,    0, 2751,    0, 2796, 3304,    0,    0,
    0,    0,    0,    0,    0, 2931, 2973, 3014, 3055, 3071,
 3110, 3126, 3165, 3173,    0,    0,    0,  200,    0,    0,
    0,    0,    0,    0, 3335,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  180,  253,    0,    0,    0,    0,
    0,    0,    0,    0, 1866,    0,    0, 1866, 3335,  463,
  481,    0,    0,    0, -217,    0,  905,    0,    0,    0,
    0,    0,    0,    0,    0,  165,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
 -151,  -37,    0,    0, 1489,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0, -188,
 -197,    0,    0, -221,  424,  172,    0,  236, 2060,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  -95,    0, -226, 1683, 1683,    0,    0,  165,    0,
    0,    0,    0,    0,    0,    0, 3251,    0,  485,    0,
  489,    0, 3251,  269,  485,    0,  527,    0, -204,    0,
  906,    0, 3452,    0,  918,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  894, -151,    0,    0,    0,    0,  396,    0, -221,
    0, 2060,  441,    0,  415,    0,    0,    0, 3304,    0,
    0,    0,    0,    0,    0,    0,  623,    0, 2223,    0,
    0,  665,    0, 2704,    0,    0,    0,    0,  918,    0,
    0,  556, -221,  286,    0,  302,  567, -221,  286,    0,
    0,    0,  102,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  474,    0,    0,    0,    0,    0, 3220,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,  921,    0,    0,
    0,    0,    0,    0,  920,  894,    0,    0,  -95,    0,
    0,    0,  -95,    0,    0,    0,    0,  347,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  920,    0,
    0,
};
#if YYBTYACC
static const YYINT yycindex[] = {                         0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0,
};
#endif
static const YYINT yygindex[] = {                         0,
  -11,  211,    0,    0,    0,    0,  596,    0,    0,  843,
    0,    0,  -26,  -12,  -15, -103, -550,  -53,  -24,  -28,
  -21,   22,    0,    0,    0, 1000,    0,    0,  912,    0,
    0,    0, -240,    0,  889,    0,    0,  661,  264,   12,
    0, 1098,    0, 1016,  -42,  -44, 1109, 1101,    0, -356,
  699,  693, -127, -216,    0,    0,  -47,    0, -225, -382,
   71,    0,    0,  792,    0, -111,    0,  834,    0,    0,
  629,    0,  915,    0,  723,  644, -578,  -35,    0, -342,
    0, -275, -210,   67,  294,   53,  -63,  298, 1071, -181,
  476,    7,   16, 1117, 1031,   76, -132,  -49, -383,  -29,
  151,    0,    0,    0,    0,    0,    0,    0,    0,    0,
    0, -341,    0,    0,    0,    0, -162,    0, -391,    0,
    0,    0,    0,  656,    0,    0,    0,  653, -337,    0,
    0, 1090,    0,    0,    0,  277,    0,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0, 1189, 1279,    0,
    0,    0,    0,    0,    0, 1191,    0,    0,    0,    0,
  890,    0,
};
#define YYTABLESIZE 3785
static const YYINT yytable[] = {                         88,
  120,   91,  136,  223,   92,  327,   88,  116,   96,  418,
   90,  242,  130,  141,  294,   18,  120,   90,  221,  142,
   52,  638,  474,  135,  353,  125,  124,   18,  478,  480,
  482,  143,  486,  488,  107,  108,   56,  530,  231,   64,
  381,  521,  523,  381,  149,  667,   88,  153,   24,  319,
  192,  533,  432,  178,  534,  255,  183,  552,  433,  158,
  151,  114,  329,  119,  120,   52,   13,   57,   26,  381,
   66,  381,  520,   58,  186,  216,  119,  114,   13,  686,
   25,   56,   64,  184,  178,  434,   33,  227,    8,   53,
   53,  214,  223,  107,  141,  308,  444,  219,  141,  492,
  247,   58,  248,  549,  249,   52,  381,  381,  380,  107,
  294,  328,  143,  578,  217,  236,  143,  585,   88,   88,
  246,   56,  119,  281,  692,  693,  567,   88,   88,   88,
   88,   88,  243,  244,   53,   53,  568,  120,  353,  418,
  202,  250,  251,  252,  253,  254,  106,  107,  700,  497,
  215,  187,  189,  392,  203,   32,  578,  501,   34,  238,
  106,  107,  578,  106,  107,  107,  625,  236,  107,  320,
  119,  221,  119,  119,   53,   53,   93,  232,   88,  508,
  611,  351,  330,  606,  607,  119,  615,  208,  626,   90,
  162,  141,  627,   95,  560,   88,  642,  384,  114,  561,
  119,  208,  389,  287,  233,  357,   90,   88,  233,  143,
  297,  238,  236,  650,  542,  548,  671,  405,  654,  241,
  381,  334,   97,  107,  107,  107,  108,  452,  453,  454,
  233,  119,  636,   88,   88,   88,   88,   88,   88,   88,
   88,   88,   88,   88,  394,  395,  396,  397,  398,  399,
  400,  401,  402,  403,  404,  357,  238,   29,   30,   64,
  243,  376,  235,  236,  311,   32,    2,  208,   31,  509,
  312,  241,  160,   27,  381,  588,   20,  576,   28,  275,
    2,   65,  107,  107,  243,  108,  108,  243,   20,    4,
  208,  375,  104,   14,  383,  351,  510,   15,  190,  313,
  190,  190,  589,    4,  593,   14,    6,  238,  123,   15,
   59,   88,    8,  459,   60,   29,   30,   98,  490,  357,
    6,  150,   90,   52,   65,  528,    8,  119,   99,  119,
  119,  594,  100,    2,  125,   32,  477,  477,  477,   56,
  477,  477,  119,  228,  242,  528,  696,  425,  426,  631,
   32,  196,  528,  195,  195,   32,    4,  119,  381,   31,
  282,   52,  626,  643,  282,  159,  627,  241,  242,  440,
  441,  242,   32,    6,  179,  633,  233,   56,  198,    8,
   88,  105,  514,   29,   30,  357,  496,  584,  119,  119,
  634,   90,   53,   53,  496,   99,  660,    2,  180,  100,
  376,  663,  233,   88,  181,  531,  591,  471,  472,  562,
  564,  565,  566,  614,   90,  125,    2,  233,  112,  619,
    4,  120,  613,  282,  206,  528,    2,  282,  112,  194,
   53,   53,  674,  246,  113,  212,  213,    6,  694,    4,
  144,    8,  695,    8,  477,  106,  107,  234,  276,    4,
  500,  539,  545,  144,  528,  272,    6,  246,  500,  233,
  246,  390,    8,  198,  273,  144,    6,   88,  304,  111,
  644,  391,    8,  511,  120,   17,  233,  599,   90,  274,
  119,  604,  114,  645,  614,  304,  647,   17,  390,  619,
  137,  119,   17,  119,  112,  125,  125,  247,  391,  144,
  144,  374,  661,  377,  317,  382,  496,  664,  318,  639,
   17,    1,   56,  142,  119,  500,  500,  637,  490,  528,
  119,  247,  110,  120,  247,  299,  142,  220,  122,  220,
  220,  119,  300,  119,   88,  114,  630,  119,  142,  119,
  477,  309,  111,  573,  293,   90,  293,  293,  539,  119,
  106,  107,    2,   88,  539,  225,  226,  220,   32,  382,
  219,  321,  219,  219,   90,   88,   53,   88,  582,  649,
  500,  579,  142,  583,  293,  323,  648,   17,   90,  119,
  119,  385,   87,  493,  114,   87,   88,   87,   87,  386,
  219,   88,  209,   88,  122,  665,  503,   90,  387,   88,
   87,  668,   90,  388,   90,  381,  224,  381,  381,  393,
   90,  208,  500,  406,  579,   87,   87,  208,  500,  616,
  579,  490,  490,  212,  229,   88,   88,  680,  681,   88,
   88,  684,  685,  407,  599,  381,   90,   90,  599,  408,
   90,   90,  377,  382,   32,  490,   87,   87,  582,  422,
  538,  544,  427,  583,  119,  582,  429,  248,  125,  618,
  583,  206,   88,  428,  697,   59,  554,  119,  431,  491,
  430,  276,  209,   90,  435,  494,  249,  495,  439,  260,
  438,  248,  208,  119,  248,  260,   17,  208,    2,  199,
  112,  198,  198,  260,  442,  224,  145,  146,  147,  256,
  249,  256,  256,  249,  155,  156,  157,  158,  449,    1,
   17,    4,  582,  119,  260,  378,  122,  583,    2,  260,
  260,  260,  260,  260,  266,    2,  256,  119,    6,  256,
   32,  260,  317,  451,    8,  250,  318,  535,  119,  554,
  119,    4,  267,    3,  260,  450,  246,  538,    4,  538,
  217,  266,  119,  538,    5,  544,  119,  304,    6,  250,
   17,  119,  250,   32,    8,    6,  230,  231,   32,  267,
    7,    8,  118,  246,  167,  168,  169,  217,  119,  455,
  293,  118,  293,  293,  119,  118,  119,  436,  215,  256,
  257,  212,  410,  258,  259,  260,  261,  262,  263,  264,
  265,  266,  267,  268,  269,  270,  271,  118,  118,  118,
  118,  118,  475,  118,  457,  215,    2,  218,  112,  118,
  225,  411,  118,  458,   17,  460,  118,  461,  216,  233,
  470,  118,  118,  554,  128,  167,  168,  670,  462,    4,
  233,  518,  463,  304,  218,  233,  632,   17,  118,  118,
  118,  118,  118,  465,  378,  216,    6,  466,  331,  332,
  118,  333,    8,  473,  128,  129,  467,  128,  502,  128,
  128,  517,  118,  118,  212,  676,  304,  504,  128,  483,
  128,  304,  128,  494,  161,  537,  162,  512,  163,  164,
   17,  525,  165,  526,  128,  532,    2,  128,  128,  550,
  436,  436,  551,  128,  128,  128,  128,  128,  128,  412,
  436,  154,  111,  436,   17,  569,  128,  572,  571,    4,
  128,  167,  168,  169,  170,  171,  128,  233,  128,  128,
  167,  168,  169,  170,  171,  172,    6,   72,  574,   72,
  575,   72,    8,  586,  106,  107,  382,  382,  382,  382,
  595,  382,  382,  151,  111,  382,  382,  382,  382,  382,
  382,  382,  382,  382,  382,   72,  382,  596,   72,   72,
  382,  587,  590,  464,  601,  122,  382,  382,  620,  382,
  382,  622,  382,  382,  382,  382,  382,  382,  382,  382,
  382,  382,  382,  382,  382,  382,  382,  623,  382,  382,
  382,  382,  382,  382,  382,  382,  382,    2,  635,  112,
  382,  382,  382,  382,  494,  641,  543,  167,  168,  169,
  170,  171,  172,  173,  174,  279,  640,    2,  527,  455,
    4,  652,  659,   67,  653,  656,  657,   68,   69,   70,
   71,   72,  662,   73,  608,   74,   75,    6,   76,  673,
    4,  675,   77,    8,  122,  677,  687,  678,  122,  167,
  168,  169,  170,  679,   78,   79,   80,    6,  682,  320,
  320,  320,  436,    8,  320,  106,  107,  436,  320,  320,
  320,  320,  320,  320,  320,  320,  320,  320,  683,  320,
  688,  122,   81,  320,   82,   83,  167,  168,  169,  170,
  171,  172,  173,  320,  690,  320,  320,  320,  320,  320,
  320,  320,  320,  320,  320,  320,  320,  320,  320,  320,
  689,  320,  320,  320,  320,  320,  320,  320,  691,  320,
  320,  320,  698,  320,  320,  320,  320,  699,  701,  592,
  336,  137,  412,  131,  386,   67,  205,  167,  206,   68,
   69,   70,   71,   72,   25,   73,    2,   74,   75,    2,
   76,  261,  173,  174,   77,  167,  168,  169,  170,  171,
  172,  173,  174,  175,  413,   30,   78,   79,   80,    4,
  289,   57,    4,   57,  646,    5,  337,  338,  339,  340,
  341,  468,  288,  342,  343,  344,    6,  345,  346,    6,
  347,    7,    8,  424,  348,    8,   82,   83,  336,  137,
  443,  621,  199,   67,  222,  298,  206,   68,   69,   70,
   71,   72,  197,   73,    2,   74,   75,    2,   76,  220,
  536,  612,   77,  167,  168,  169,  170,  171,  172,  173,
  174,  175,  176,  617,   78,   79,   80,    4,  519,  456,
    4,  609,  658,    5,  337,  338,  339,  340,  341,  284,
  239,  342,  343,  344,    6,  345,  346,    6,  347,    7,
    8,  379,  348,    8,   82,   83,  476,  137,  666,  286,
  672,   67,  494,  182,  495,   68,   69,   70,   71,   72,
   36,   73,  191,   74,   75,    2,   76,  516,    0,    0,
   77,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  413,    0,   78,   79,   80,    0,    0,    0,    4,    0,
    0,    5,  337,  338,  339,  340,  341,    0,    0,  342,
  343,  344,    0,  345,  346,    6,  347,    0,    8,    0,
  348,    8,   82,   83,  479,  137,    0,    0,    0,   67,
  580,    0,  581,   68,   69,   70,   71,   72,    0,   73,
    0,   74,   75,    2,   76,    0,    0,    0,   77,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  413,    0,
   78,   79,   80,    0,    0,    0,    4,    0,    0,    5,
  337,  338,  339,  340,  341,    0,    0,  342,  343,  344,
    0,  345,  346,    6,  347,    0,    8,    0,  348,    8,
   82,   83,  481,  137,    0,    0,    0,   67,    0,    0,
    0,   68,   69,   70,   71,   72,    0,   73,    0,   74,
   75,    0,   76,    0,    0,    0,   77,    0,    0,    0,
    0,    0,    0,    0,    0,    0,  413,    0,   78,   79,
   80,    0,    0,    0,    0,    0,    0,    5,  337,  338,
  339,  340,  341,    0,    0,  342,  343,  344,    0,  345,
  346,    0,  347,    0,    8,    0,  348,    0,   82,   83,
  485,  137,    0,    0,    0,   67,    0,    0,    0,   68,
   69,   70,   71,   72,    0,   73,    0,   74,   75,    0,
   76,    0,    0,    0,   77,    0,    0,    0,    0,    0,
    0,    0,    0,    0,  413,    0,   78,   79,   80,    0,
    0,    0,    0,    0,    0,    5,  337,  338,  339,  340,
  341,    0,    0,  342,  343,  344,    0,  345,  346,    0,
  347,    0,    8,    0,  348,    0,   82,   83,  487,  137,
    0,    0,    0,   67,    0,    0,    0,   68,   69,   70,
   71,   72,    0,   73,    0,   74,   75,    0,   76,    0,
    0,    0,   77,    0,    0,    0,    0,    0,    0,    0,
    0,    0,  413,    0,   78,   79,   80,    0,    0,    0,
    0,    0,    0,    5,  337,  338,  339,  340,  341,    0,
    0,  342,  343,  344,    0,  345,  346,    0,  347,    0,
    8,    0,  348,    0,   82,   83,  527,  455,  608,    0,
    0,   67,    0,    0,    0,   68,   69,   70,   71,   72,
    0,   73,    0,   74,   75,    0,   76,    0,    0,    0,
   77,    0,    0,    0,    0,    0,    0,    0,    0,    0,
  527,  455,   78,   79,   80,   67,    0,    0,    0,   68,
   69,   70,   71,   72,    0,   73,    0,   74,   75,    0,
   76,    0,    0,    0,   77,    0,    0,    0,    0,    0,
  553,  107,   82,   83,    0,  137,   78,   79,   80,   67,
    0,    0,    0,   68,   69,   70,   71,   72,    0,   73,
    0,   74,   75,    0,   76,    0,    0,    0,   77,    0,
    0,    0,    0,    0,  553,  107,   82,   83,  413,    0,
   78,   79,   80,    0,    0,    0,    0,    0,    0,    5,
  337,  338,  339,  340,  341,    0,    0,  342,  343,  344,
    0,  345,  346,    0,  347,  321,    8,    0,  348,  321,
   82,   83,    0,  321,  321,  321,  321,  321,    0,  321,
    0,  321,  321,    0,  321,    0,    0,    0,  321,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  321,    0,
  321,  321,  321,    0,    0,    0,    0,    0,    0,  321,
  321,  321,  321,  321,  321,    0,    0,  321,  321,  321,
    0,  321,  321,    0,  321,  381,  321,    0,  321,  381,
  321,  321,    0,  381,  381,  381,  381,  381,    0,  381,
    0,  381,  381,    0,  381,    0,    0,    0,  381,    0,
    0,    0,    0,    0,    0,    0,    0,    0,  381,    0,
  381,  381,  381,    0,    0,    0,    0,    0,    0,  381,
  381,  381,  381,  381,  381,    0,    0,  381,  381,  381,
    0,  381,  381,    0,  381,  137,    0,    0,  381,   67,
  381,  381,    0,   68,   69,   70,   71,   72,  370,   73,
    0,   74,   75,    0,   76,    0,    0,    0,   77,    0,
    0,  118,    0,  164,  165,    0,  164,    0,  164,  164,
   78,   79,   80,    0,    0,    0,    0,  164,    0,  164,
    0,  164,    0,    0,    0,    0,    0,  118,  118,  118,
  118,  118,    0,  164,    0,    0,  164,  164,   81,  118,
   82,   83,  164,  164,  164,  164,  164,  164,  381,  381,
    0,  381,  118,  381,  381,  164,    0,    0,  494,  164,
  537,    0,  381,    0,  381,  164,    0,  164,  164,    0,
    0,    2,    0,  112,    0,    0,    0,    0,  381,  381,
    0,  381,  381,   28,    0,    0,    0,  381,  381,  381,
  381,  381,  381,  381,    4,  118,  293,  293,    0,  293,
  381,  293,  293,    0,  381,    0,    0,  381,    0,    0,
  293,    6,  293,  381,    0,    0,    0,    8,    0,  106,
  107,  118,  118,  118,  118,  118,  293,  293,    0,  293,
  293,    0,    0,  118,    0,  293,  293,  293,  293,  293,
  293,  181,    0,    0,  181,    0,  118,  181,  293,    0,
    0,  289,  293,  290,    0,  181,    0,  181,  293,  181,
    0,  293,  289,    0,  423,    0,    0,    2,    0,    0,
    0,  181,    0,    0,  181,  181,    0,    0,    2,    0,
  181,  181,  181,  181,  181,  181,  293,  293,    0,  293,
    4,  293,    0,  181,    0,    0,    0,  181,    0,    0,
  293,    4,  293,  181,    0,  181,  181,    6,    0,    0,
    0,    0,    7,    8,    0,    0,  293,  293,    6,  293,
  293,    0,    0,    7,    8,  293,  293,  293,  293,  293,
  293,  111,  111,    0,  111,    0,  111,  111,  293,    0,
    0,    0,  293,    0,    0,  111,    0,    0,  293,    0,
    0,  293,    0,    0,    0,    0,    0,    0,    0,    0,
    0,  111,  111,    0,  111,  111,  368,  368,    0,    0,
    0,  111,  111,  111,  111,  111,  111,    0,    0,    0,
  368,    0,  368,  111,    0,    0,    0,    0,    0,    0,
  111,    0,    0,    2,    0,  112,  111,  293,    0,  293,
  293,  369,  369,    0,    0,  368,  368,  368,  368,  368,
  368,  282,    0,    0,    0,  369,    4,  369,  368,    0,
    0,    0,  368,    0,    0,    0,    0,    0,  368,    0,
    0,  368,  293,    6,  293,  293,    0,    0,    0,    8,
  369,  369,  369,  369,  369,  369,  203,  203,  183,    0,
  183,  183,  203,  369,    0,    0,    0,  369,    0,    0,
  203,  183,    0,  369,    0,    0,  369,    0,    0,    0,
    0,    0,    0,    0,    0,  183,  203,  203,  183,  203,
  203,  367,  367,    0,  183,    0,  203,  203,  203,  203,
  203,  203,    0,    0,    0,  367,    0,  367,  203,    0,
    0,  183,    0,    0,    0,  203,    0,  183,    0,  183,
  183,  203,  293,    0,  293,  293,    0,    0,    0,    0,
  367,  367,  367,  367,  367,  367,  204,  204,  293,    0,
  293,  293,  204,  367,    0,    0,    0,  367,    0,    0,
  204,  293,    0,  367,    0,    0,  367,    0,    0,    0,
    0,    0,    0,    0,    0,  293,  204,  204,  293,  204,
  204,    0,    0,    0,  293,    0,  204,  204,  204,  204,
  204,  204,    0,    0,  106,    0,    0,  106,  204,  106,
  106,  293,    0,    0,    0,  204,    0,  293,  106,  201,
  201,  204,  106,    0,   93,    0,   93,   93,    0,    0,
    0,    0,    0,  201,    0,    0,    0,  106,  106,   93,
    0,    0,    0,    0,  106,  106,  106,  106,  106,  201,
  201,   93,  201,  201,   93,   93,  106,    0,    0,  201,
  201,  201,  201,  201,  201,  202,  202,    0,  106,  106,
    0,  201,    0,    0,    0,    0,    0,    0,  201,  202,
    0,    0,    0,    0,  201,   93,   93,    0,    0,    0,
    0,    0,    0,    0,    0,  202,  202,  260,  202,  202,
    0,    0,    0,  260,  186,  202,  202,  202,  202,  202,
  202,  260,    0,  260,  494,    0,  543,  202,   37,    0,
    2,    0,    0,    0,  202,    0,    0,    2,    0,  112,
  202,    0,  260,    0,  160,    0,  260,  260,  260,  260,
  260,  260,  371,    4,   38,   39,   29,   30,   40,  260,
    4,  160,  160,  260,    0,  118,   41,  160,    0,  260,
    6,  230,  260,    0,    0,    0,    8,    6,    0,   42,
    0,    0,    0,    8,  160,  106,  107,    0,    0,    0,
  160,  118,  118,  118,  118,  118,    0,  118,    0,  232,
  397,    0,    0,  118,  397,  397,  397,  397,  397,    0,
  397,    0,  397,  397,    0,  397,  118,   57,    0,  397,
    0,    0,    0,  118,  118,  118,  118,  118,    0,    0,
    0,  397,  397,  397,   67,  118,  188,    0,   68,   69,
   70,   71,   72,   37,   73,    0,   74,   75,  118,   76,
   37,    0,    2,   77,    0,    0,    0,    0,    0,  397,
    0,  397,  397,    0,    0,   78,   79,   80,    0,    0,
   39,    0,   30,   40,    0,    4,   38,   39,   29,   30,
   40,   41,    0,    0,    0,    0,    0,    0,   41,    0,
    0,    0,    6,   81,   42,   82,   83,   67,    8,    0,
    0,   68,   69,   70,   71,   72,    0,   73,    2,   74,
   75,    0,   76,    0,    0,    0,   77,    0,    0,    0,
    0,    0,    0,    0,    0,    0,    0,    0,   78,   79,
   80,    4,   67,    0,    0,    0,   68,   69,   70,   71,
   72,    0,   73,    0,   74,  302,    0,   76,    6,    0,
    0,   77,    0,    0,    8,    0,   81,    0,   82,   83,
    0,    0,    0,   78,   79,   80,    0,   67,  390,   29,
   30,   68,   69,   70,   71,   72,    0,   73,    0,   74,
   75,    0,   76,    0,    0,    0,   77,    0,    0,    0,
    0,   81,    0,   82,   83,    0,    0,    0,   78,   79,
   80,   67,  513,    0,    0,   68,   69,   70,   71,   72,
    0,   73,    0,   74,   75,    0,   76,    0,    0,    0,
   77,    0,    0,    0,    0,    0,   81,    0,   82,   83,
    0,    0,   78,   79,   80,   67,    0,    0,    0,   68,
   69,   70,   71,   72,    0,   73,    0,   74,   75,    0,
   76,    0,    0,    0,   77,    0,    0,    0,    0,    0,
   81,    0,   82,   83,  563,    0,   78,   79,   80,   67,
    0,    0,    0,   68,   69,   70,   71,   72,    0,   73,
    0,   74,   75,    0,   76,    0,    0,    0,   77,    0,
    0,    0,    0,    0,   81,    0,   82,   83,    0,    0,
   78,   79,   80,  148,    0,    0,    0,   68,   69,   70,
   71,   72,    0,   73,    0,   74,   75,    0,   76,    0,
    0,    0,   77,    0,    0,    0,    0,    0,   81,    0,
   82,   83,    0,    0,   78,   79,   80,  152,    0,    0,
    0,   68,   69,   70,   71,   72,    0,   73,    0,   74,
   75,    0,   76,    0,    0,    0,   77,    0,    0,    0,
    0,    0,   81,    0,   82,   83,    0,    0,   78,   79,
   80,  245,    0,    0,    0,   68,   69,   70,   71,   72,
    0,   73,    0,   74,   75,   94,   76,   94,   94,    0,
   77,    0,  187,    0,  187,  187,   81,    0,   82,   83,
   94,    0,   78,   79,   80,  187,    0,  187,  186,    0,
  186,  186,   94,    0,    0,   94,   94,    0,    0,  187,
    0,  186,  187,  186,    0,  156,    0,    0,  187,  187,
   81,    0,   82,   83,    0,  186,    0,    0,  186,    0,
    0,    0,  156,  156,  186,  187,   94,   94,  156,    0,
    0,  187,    0,  187,  187,    0,    0,   25,   52,    0,
   52,  186,   52,    0,    0,  156,    0,  186,    0,  186,
  186,  156,   52,    0,   52,   52,   52,   52,   52,   52,
   52,   52,   52,   52,   52,   52,   52,   52,   52,   52,
   52,   52,    0,    0,    0,   52,    0,    0,    0,    0,
    0,    0,   25,   54,    0,   54,    0,   54,    0,    0,
    0,    0,   52,    0,    0,    0,    0,   54,   52,   54,
   54,   54,   54,   54,   54,   54,   54,   54,   54,   54,
   54,   54,   54,   54,   54,   54,   54,    0,    0,    0,
   54,    0,    0,    0,    0,    0,    0,    0,    0,    0,
   10,   10,   10,   10,   10,   10,   10,   54,    0,   10,
    0,    0,    0,   54,   10,    0,   10,   10,   10,   10,
   10,   10,   10,   10,   10,   10,   10,   10,   10,   10,
   10,   10,   10,   10,    0,    0,    0,   10,    0,    0,
    0,    0,    0,    0,    0,   41,    0,   41,    0,   41,
    0,    0,    0,    0,   10,    0,   37,    0,    2,   41,
   10,   41,   41,   41,   41,   41,   41,   41,   41,   41,
   41,   41,   41,   41,   41,   41,   41,   41,   41,    0,
    0,    4,   41,   39,   29,   30,   40,    0,   62,    0,
   62,    0,   62,    0,   41,    0,    0,    0,    6,   41,
    0,    0,   62,    0,    8,   41,   62,   62,   62,   62,
   62,   62,   62,   62,   62,   62,   62,    0,    0,   62,
   62,   62,    0,    0,    0,   62,    0,    0,    0,    0,
   63,    0,   63,    0,   63,    0,    0,    0,    0,    0,
    0,    0,   62,    0,   63,    0,    0,    0,   62,   63,
   63,   63,   63,   63,   63,   63,   63,   63,   63,    0,
    0,   63,   63,   63,    0,    0,    0,   63,    0,    0,
    0,   64,    0,   64,    0,   64,    0,    0,    0,    0,
    0,    0,    0,    0,   63,   64,    0,    0,    0,    0,
   63,   64,   64,   64,   64,   64,   64,   64,   64,   64,
    0,    0,   64,   64,   64,    0,    0,    0,   64,    0,
    0,    0,   65,    0,   65,    0,   65,    0,    0,    0,
    0,    0,    0,    0,    0,   64,   65,    0,   66,    0,
   66,   64,   66,   65,   65,   65,   65,   65,   65,   65,
   65,    0,   66,   65,   65,   65,    0,    0,    0,   65,
   66,   66,   66,   66,   66,   66,   66,    0,    0,   66,
   66,   66,    0,    0,    0,   66,   65,   67,    0,   67,
    0,   67,   65,    0,    0,    0,    0,    0,    0,    0,
    0,   67,   66,   68,    0,   68,    0,   68,   66,    0,
   67,   67,   67,   67,   67,   67,    0,   68,   67,   67,
   67,    0,    0,    0,   67,    0,    0,   68,   68,   68,
   68,   68,    0,    0,   68,   68,   68,    0,    0,    0,
   68,   67,   69,    0,   69,    0,   69,   67,    0,    0,
   70,    0,   70,    0,   70,    0,   69,   68,   77,    0,
   77,    0,   77,   68,   70,    0,    0,   69,   69,   69,
   69,    0,   77,   69,   69,   69,   70,   70,   70,   69,
    0,   70,   70,   70,    0,    0,   77,   70,    0,   77,
   77,   77,    0,    0,    0,   77,   69,   71,    0,   71,
    0,   71,   69,    0,   70,    0,  119,    0,  119,  119,
   70,   71,   77,    0,    0,    0,    0,    0,   77,  119,
    0,  119,    0,    0,    0,   71,  260,    0,   71,   71,
   71,    0,  260,  119,   71,    0,  119,    0,    0,    0,
  260,    0,  119,    0,    0,    0,   37,    0,    2,    0,
    0,   71,    0,    0,    0,    0,    0,   71,    0,  119,
    0,  260,   37,    0,    0,  119,  260,  260,  260,  260,
  260,    4,   38,   39,   29,   30,   40,  113,  260,  113,
    0,    0,    0,    0,   41,    0,    0,    0,    6,   39,
   29,   30,   40,  240,    8,  240,    0,   42,    0,    0,
   41,    0,  113,  113,  113,  113,  113,  113,    0,    0,
   37,    0,    0,   63,    0,  113,    0,    0,  240,  113,
  240,  240,  240,  240,  118,  113,    0,    0,  113,   37,
    0,  240,    0,    0,    0,  240,   62,   39,   29,   30,
   40,  240,    0,  118,  240,    0,    0,    0,   41,    0,
  118,  118,  118,  118,  118,    0,   39,   29,   30,   40,
    0,   63,  118,   37,    0,    2,    0,   41,    0,    0,
  118,  118,  118,  118,    0,  118,    0,    0,    0,    0,
   42,  118,    0,    0,    0,    0,    0,    0,    4,   38,
   39,   29,   30,   40,  118,    0,   55,    0,   55,    0,
   55,   41,    0,    0,    0,    6,    0,    0,    0,    0,
    0,    8,   55,   55,   55,   55,   55,   55,   55,   55,
   55,   55,   55,   55,   55,    0,    0,   55,   55,    8,
    8,    0,    8,    0,    8,    8,    0,    0,    8,    0,
    0,    0,    0,    0,    0,    8,    8,    8,    8,    8,
    8,    8,    8,    8,    8,    8,    8,    4,    8,    8,
    8,    8,    0,    8,    0,    8,    8,    0,    0,    8,
    0,    0,    0,    0,    0,    0,    8,    8,    8,    8,
    8,    8,    8,    8,    8,    8,    8,    8,    0,    8,
    8,    8,    8,  167,  168,  169,  170,  171,  172,  173,
  174,  175,  176,  177,  178,
};
static const YYINT yycheck[] = {                         26,
   50,   26,   66,  131,   26,  222,   33,   50,   33,  285,
   26,  144,   57,   67,  196,    0,   66,   33,  130,   67,
   14,  572,  364,   66,  235,   55,  256,   12,  366,  367,
  368,   67,  370,  371,  261,   47,   15,  429,  260,   18,
  258,  425,  426,  257,   71,  624,   73,   74,  258,  212,
  104,  435,  256,  258,  438,  159,  262,  449,  262,  286,
   73,   50,  225,  261,  114,   59,    0,   15,  261,  287,
   18,  289,  415,  262,  296,  123,  274,   66,   12,  658,
  290,   60,   61,  289,  289,  289,  261,  261,  318,   14,
   15,  261,  220,  320,  148,  207,  256,  127,  152,  256,
  148,  290,  150,  445,  152,   99,  320,  321,  241,  261,
  292,  223,  148,  496,  126,  144,  152,  500,  145,  146,
  147,  100,  320,  187,  675,  676,  469,  154,  155,  156,
  157,  158,  145,  146,   59,   60,  474,  187,  349,  415,
  301,  154,  155,  156,  157,  158,  320,  321,  699,  375,
  320,   99,  100,  257,  315,    5,  539,  383,  261,  144,
  320,  321,  545,  320,  321,  261,  558,  196,  320,  214,
  259,  283,  261,  262,   99,  100,   26,  262,  205,  260,
  537,  235,  227,  525,  526,  274,  543,  117,  259,  205,
  286,  245,  263,  261,  286,  222,  579,  245,  187,  291,
  289,  131,  256,  262,  289,  235,  222,  234,  289,  245,
  199,  196,  241,  597,  440,  441,  287,  271,  602,  144,
  242,  234,  261,  261,  320,  321,  261,  331,  332,  333,
  289,  320,  570,  260,  261,  262,  263,  264,  265,  266,
  267,  268,  269,  270,  260,  261,  262,  263,  264,  265,
  266,  267,  268,  269,  270,  285,  241,  298,  299,  238,
  262,  240,  260,  292,  256,  115,  272,  197,    5,  262,
  262,  196,  323,  256,  296,  262,    0,  494,  261,  320,
  272,   18,  320,  321,  286,  320,  321,  289,   12,  295,
  220,  239,  261,    0,  242,  349,  289,    0,  296,  291,
  298,  299,  289,  295,  262,   12,  312,  292,  261,   12,
   17,  338,  318,  338,   17,  298,  299,  256,  372,  349,
  312,  261,  338,  317,   61,  429,  318,  259,   35,  261,
  262,  289,   35,  272,  364,  185,  366,  367,  368,  318,
  370,  371,  274,  133,  262,  449,  688,  295,  296,  262,
  200,  287,  456,  289,  290,  205,  295,  289,  380,  258,
  259,  355,  259,  580,  263,  261,  263,  292,  286,  317,
  318,  289,  222,  312,  262,  262,  289,  356,  115,  318,
  407,  256,  407,  298,  299,  415,  375,  499,  320,  321,
  262,  407,  317,  318,  383,  102,  613,  272,  262,  102,
  379,  618,  289,  430,  290,  430,  510,  355,  356,  463,
  464,  465,  466,  541,  430,  445,  272,  289,  274,  547,
  295,  471,  259,  259,  261,  529,  272,  263,  274,  257,
  355,  356,  262,  262,  290,  289,  290,  312,  679,  295,
  261,  318,  683,  318,  474,  320,  321,  262,  185,  295,
  375,  440,  441,  274,  558,  290,  312,  286,  383,  289,
  289,  262,  318,  200,  290,  286,  312,  494,  205,  290,
  582,  262,  318,  286,  524,    0,  289,  522,  494,  323,
  261,  524,  471,  587,  612,  222,  590,   12,  289,  617,
  257,  272,   17,  274,  274,  525,  526,  262,  289,  320,
  321,  238,  614,  240,  211,  242,  495,  619,  211,  573,
   35,    0,  491,  261,  295,  440,  441,  571,  572,  623,
  261,  286,   47,  573,  289,  261,  274,  259,   53,  261,
  262,  312,  261,  274,  561,  524,  561,  318,  286,  320,
  570,  320,  290,  491,  259,  561,  261,  262,  537,  290,
  320,  321,    0,  580,  543,  289,  290,  289,  408,  296,
  259,  262,  261,  262,  580,  592,  491,  594,  498,  594,
  495,  496,  320,  498,  289,  257,  592,  102,  594,  320,
  321,  262,  256,  373,  573,  259,  613,  261,  262,  289,
  289,  618,  117,  620,  119,  620,  386,  613,  262,  626,
  274,  626,  618,  289,  620,  259,  131,  261,  262,  320,
  626,  541,  537,  262,  539,  289,  290,  547,  543,  544,
  545,  675,  676,  289,  290,  652,  653,  652,  653,  656,
  657,  656,  657,  261,  679,  289,  652,  653,  683,  289,
  656,  657,  379,  380,  494,  699,  320,  321,  578,  290,
  440,  441,  323,  578,  261,  585,  287,  262,  688,  259,
  585,  261,  689,  320,  689,  372,  456,  274,  260,  372,
  296,  408,  197,  689,  262,  259,  262,  261,  289,  256,
  262,  286,  612,  290,  289,  262,  211,  617,  272,  287,
  274,  289,  290,  270,  262,  220,   68,   69,   70,  259,
  286,  261,  262,  289,   76,   77,   78,   79,  287,  256,
  235,  295,  642,  320,  291,  240,  241,  642,  272,  296,
  297,  298,  299,  300,  262,  272,  286,  261,  312,  289,
  580,  308,  439,  262,  318,  262,  439,  291,  272,  529,
  274,  295,  262,  290,  321,  260,  262,  537,  295,  539,
  262,  289,  286,  543,  301,  545,  290,  494,  312,  286,
  285,  295,  289,  613,  318,  312,  287,  288,  618,  289,
  317,  318,  261,  289,  274,  275,  276,  289,  312,  257,
  287,  270,  289,  290,  318,  274,  320,  312,  262,  161,
  162,  289,  290,  165,  166,  167,  168,  169,  170,  171,
  172,  173,  174,  175,  176,  177,  178,  296,  297,  298,
  299,  300,  307,  261,  290,  289,  272,  262,  274,  308,
  289,  290,  270,  290,  349,  290,  274,  286,  262,  289,
  290,  320,  321,  623,  290,  274,  275,  627,  261,  295,
  289,  290,  261,  580,  289,  289,  290,  372,  296,  297,
  298,  299,  300,  261,  379,  289,  312,  261,  230,  231,
  308,  233,  318,  290,  256,  257,  286,  259,  262,  261,
  262,  262,  320,  321,  289,  290,  613,  305,  270,  316,
  272,  618,  274,  259,  259,  261,  261,  290,  263,  264,
  415,  262,  267,  262,  286,  320,  272,  289,  290,  258,
  425,  426,  289,  295,  296,  297,  298,  299,  300,  258,
  435,  289,  290,  438,  439,  256,  308,  290,  261,  295,
  312,  274,  275,  276,  277,  278,  318,  289,  320,  321,
  274,  275,  276,  277,  278,  279,  312,  258,  290,  260,
  290,  262,  318,  262,  320,  321,  256,  257,  258,  259,
  262,  261,  262,  289,  290,  265,  266,  267,  268,  269,
  270,  271,  272,  273,  274,  286,  276,  290,  289,  290,
  280,  286,  286,  345,  290,  500,  286,  287,  287,  289,
  290,  286,  292,  293,  294,  295,  296,  297,  298,  299,
  300,  301,  302,  303,  304,  305,  306,  289,  308,  309,
  310,  311,  312,  313,  314,  315,  316,  272,  262,  274,
  320,  321,  322,  323,  259,  262,  261,  274,  275,  276,
  277,  278,  279,  280,  281,  290,  260,  272,  256,  257,
  295,  286,  262,  261,  286,  286,  286,  265,  266,  267,
  268,  269,  262,  271,  258,  273,  274,  312,  276,  286,
  295,  290,  280,  318,  579,  260,  260,  290,  583,  274,
  275,  276,  277,  289,  292,  293,  294,  312,  290,  256,
  257,  258,  597,  318,  261,  320,  321,  602,  265,  266,
  267,  268,  269,  270,  271,  272,  273,  274,  289,  276,
  260,  616,  320,  280,  322,  323,  274,  275,  276,  277,
  278,  279,  280,  290,  260,  292,  293,  294,  295,  296,
  297,  298,  299,  300,  301,  302,  303,  304,  305,  306,
  291,  308,  309,  310,  311,  312,  313,  314,  290,  316,
  317,  318,  262,  320,  321,  322,  323,  290,  262,  511,
  256,  257,  258,  257,  262,  261,  259,  257,  261,  265,
  266,  267,  268,  269,  257,  271,  272,  273,  274,  272,
  276,  262,  258,  258,  280,  274,  275,  276,  277,  278,
  279,  280,  281,  282,  290,  258,  292,  293,  294,  295,
  260,  262,  295,  290,  589,  301,  302,  303,  304,  305,
  306,  349,  193,  309,  310,  311,  312,  313,  314,  312,
  316,  317,  318,  292,  320,  318,  322,  323,  256,  257,
  322,  551,  115,  261,  259,  200,  261,  265,  266,  267,
  268,  269,  114,  271,  272,  273,  274,  272,  276,  129,
  439,  539,  280,  274,  275,  276,  277,  278,  279,  280,
  281,  282,  283,  545,  292,  293,  294,  295,  415,  335,
  295,  529,  609,  301,  302,  303,  304,  305,  306,  189,
  144,  309,  310,  311,  312,  313,  314,  312,  316,  317,
  318,  241,  320,  318,  322,  323,  256,  257,  623,  190,
  628,  261,  259,   95,  261,  265,  266,  267,  268,  269,
   12,  271,  102,  273,  274,  272,  276,  408,   -1,   -1,
  280,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  290,   -1,  292,  293,  294,   -1,   -1,   -1,  295,   -1,
   -1,  301,  302,  303,  304,  305,  306,   -1,   -1,  309,
  310,  311,   -1,  313,  314,  312,  316,   -1,  318,   -1,
  320,  318,  322,  323,  256,  257,   -1,   -1,   -1,  261,
  259,   -1,  261,  265,  266,  267,  268,  269,   -1,  271,
   -1,  273,  274,  272,  276,   -1,   -1,   -1,  280,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  290,   -1,
  292,  293,  294,   -1,   -1,   -1,  295,   -1,   -1,  301,
  302,  303,  304,  305,  306,   -1,   -1,  309,  310,  311,
   -1,  313,  314,  312,  316,   -1,  318,   -1,  320,  318,
  322,  323,  256,  257,   -1,   -1,   -1,  261,   -1,   -1,
   -1,  265,  266,  267,  268,  269,   -1,  271,   -1,  273,
  274,   -1,  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,  290,   -1,  292,  293,
  294,   -1,   -1,   -1,   -1,   -1,   -1,  301,  302,  303,
  304,  305,  306,   -1,   -1,  309,  310,  311,   -1,  313,
  314,   -1,  316,   -1,  318,   -1,  320,   -1,  322,  323,
  256,  257,   -1,   -1,   -1,  261,   -1,   -1,   -1,  265,
  266,  267,  268,  269,   -1,  271,   -1,  273,  274,   -1,
  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  290,   -1,  292,  293,  294,   -1,
   -1,   -1,   -1,   -1,   -1,  301,  302,  303,  304,  305,
  306,   -1,   -1,  309,  310,  311,   -1,  313,  314,   -1,
  316,   -1,  318,   -1,  320,   -1,  322,  323,  256,  257,
   -1,   -1,   -1,  261,   -1,   -1,   -1,  265,  266,  267,
  268,  269,   -1,  271,   -1,  273,  274,   -1,  276,   -1,
   -1,   -1,  280,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  290,   -1,  292,  293,  294,   -1,   -1,   -1,
   -1,   -1,   -1,  301,  302,  303,  304,  305,  306,   -1,
   -1,  309,  310,  311,   -1,  313,  314,   -1,  316,   -1,
  318,   -1,  320,   -1,  322,  323,  256,  257,  258,   -1,
   -1,  261,   -1,   -1,   -1,  265,  266,  267,  268,  269,
   -1,  271,   -1,  273,  274,   -1,  276,   -1,   -1,   -1,
  280,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  256,  257,  292,  293,  294,  261,   -1,   -1,   -1,  265,
  266,  267,  268,  269,   -1,  271,   -1,  273,  274,   -1,
  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,   -1,   -1,
  320,  321,  322,  323,   -1,  257,  292,  293,  294,  261,
   -1,   -1,   -1,  265,  266,  267,  268,  269,   -1,  271,
   -1,  273,  274,   -1,  276,   -1,   -1,   -1,  280,   -1,
   -1,   -1,   -1,   -1,  320,  321,  322,  323,  290,   -1,
  292,  293,  294,   -1,   -1,   -1,   -1,   -1,   -1,  301,
  302,  303,  304,  305,  306,   -1,   -1,  309,  310,  311,
   -1,  313,  314,   -1,  316,  257,  318,   -1,  320,  261,
  322,  323,   -1,  265,  266,  267,  268,  269,   -1,  271,
   -1,  273,  274,   -1,  276,   -1,   -1,   -1,  280,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  290,   -1,
  292,  293,  294,   -1,   -1,   -1,   -1,   -1,   -1,  301,
  302,  303,  304,  305,  306,   -1,   -1,  309,  310,  311,
   -1,  313,  314,   -1,  316,  257,  318,   -1,  320,  261,
  322,  323,   -1,  265,  266,  267,  268,  269,   -1,  271,
   -1,  273,  274,   -1,  276,   -1,   -1,   -1,  280,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  290,   -1,
  292,  293,  294,   -1,   -1,   -1,   -1,   -1,   -1,  301,
  302,  303,  304,  305,  306,   -1,   -1,  309,  310,  311,
   -1,  313,  314,   -1,  316,  257,   -1,   -1,  320,  261,
  322,  323,   -1,  265,  266,  267,  268,  269,  257,  271,
   -1,  273,  274,   -1,  276,   -1,   -1,   -1,  280,   -1,
   -1,  270,   -1,  256,  257,   -1,  259,   -1,  261,  262,
  292,  293,  294,   -1,   -1,   -1,   -1,  270,   -1,  272,
   -1,  274,   -1,   -1,   -1,   -1,   -1,  296,  297,  298,
  299,  300,   -1,  286,   -1,   -1,  289,  290,  320,  308,
  322,  323,  295,  296,  297,  298,  299,  300,  256,  257,
   -1,  259,  321,  261,  262,  308,   -1,   -1,  259,  312,
  261,   -1,  270,   -1,  272,  318,   -1,  320,  321,   -1,
   -1,  272,   -1,  274,   -1,   -1,   -1,   -1,  286,  287,
   -1,  289,  290,  258,   -1,   -1,   -1,  295,  296,  297,
  298,  299,  300,  301,  295,  270,  256,  257,   -1,  259,
  308,  261,  262,   -1,  312,   -1,   -1,  315,   -1,   -1,
  270,  312,  272,  321,   -1,   -1,   -1,  318,   -1,  320,
  321,  296,  297,  298,  299,  300,  286,  287,   -1,  289,
  290,   -1,   -1,  308,   -1,  295,  296,  297,  298,  299,
  300,  256,   -1,   -1,  259,   -1,  321,  262,  308,   -1,
   -1,  256,  312,  258,   -1,  270,   -1,  272,  318,  274,
   -1,  321,  256,   -1,  258,   -1,   -1,  272,   -1,   -1,
   -1,  286,   -1,   -1,  289,  290,   -1,   -1,  272,   -1,
  295,  296,  297,  298,  299,  300,  256,  257,   -1,  259,
  295,  261,   -1,  308,   -1,   -1,   -1,  312,   -1,   -1,
  270,  295,  272,  318,   -1,  320,  321,  312,   -1,   -1,
   -1,   -1,  317,  318,   -1,   -1,  286,  287,  312,  289,
  290,   -1,   -1,  317,  318,  295,  296,  297,  298,  299,
  300,  256,  257,   -1,  259,   -1,  261,  262,  308,   -1,
   -1,   -1,  312,   -1,   -1,  270,   -1,   -1,  318,   -1,
   -1,  321,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  286,  287,   -1,  289,  290,  256,  257,   -1,   -1,
   -1,  296,  297,  298,  299,  300,  301,   -1,   -1,   -1,
  270,   -1,  272,  308,   -1,   -1,   -1,   -1,   -1,   -1,
  315,   -1,   -1,  272,   -1,  274,  321,  287,   -1,  289,
  290,  256,  257,   -1,   -1,  295,  296,  297,  298,  299,
  300,  290,   -1,   -1,   -1,  270,  295,  272,  308,   -1,
   -1,   -1,  312,   -1,   -1,   -1,   -1,   -1,  318,   -1,
   -1,  321,  287,  312,  289,  290,   -1,   -1,   -1,  318,
  295,  296,  297,  298,  299,  300,  256,  257,  259,   -1,
  261,  262,  262,  308,   -1,   -1,   -1,  312,   -1,   -1,
  270,  272,   -1,  318,   -1,   -1,  321,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  286,  286,  287,  289,  289,
  290,  256,  257,   -1,  295,   -1,  296,  297,  298,  299,
  300,  301,   -1,   -1,   -1,  270,   -1,  272,  308,   -1,
   -1,  312,   -1,   -1,   -1,  315,   -1,  318,   -1,  320,
  321,  321,  287,   -1,  289,  290,   -1,   -1,   -1,   -1,
  295,  296,  297,  298,  299,  300,  256,  257,  259,   -1,
  261,  262,  262,  308,   -1,   -1,   -1,  312,   -1,   -1,
  270,  272,   -1,  318,   -1,   -1,  321,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  286,  286,  287,  289,  289,
  290,   -1,   -1,   -1,  295,   -1,  296,  297,  298,  299,
  300,  301,   -1,   -1,  256,   -1,   -1,  259,  308,  261,
  262,  312,   -1,   -1,   -1,  315,   -1,  318,  270,  256,
  257,  321,  274,   -1,  259,   -1,  261,  262,   -1,   -1,
   -1,   -1,   -1,  270,   -1,   -1,   -1,  289,  290,  274,
   -1,   -1,   -1,   -1,  296,  297,  298,  299,  300,  286,
  287,  286,  289,  290,  289,  290,  308,   -1,   -1,  296,
  297,  298,  299,  300,  301,  256,  257,   -1,  320,  321,
   -1,  308,   -1,   -1,   -1,   -1,   -1,   -1,  315,  270,
   -1,   -1,   -1,   -1,  321,  320,  321,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  286,  287,  256,  289,  290,
   -1,   -1,   -1,  262,  256,  296,  297,  298,  299,  300,
  301,  270,   -1,  272,  259,   -1,  261,  308,  270,   -1,
  272,   -1,   -1,   -1,  315,   -1,   -1,  272,   -1,  274,
  321,   -1,  291,   -1,  272,   -1,  295,  296,  297,  298,
  299,  300,  257,  295,  296,  297,  298,  299,  300,  308,
  295,  289,  290,  312,   -1,  270,  308,  295,   -1,  318,
  312,  320,  321,   -1,   -1,   -1,  318,  312,   -1,  321,
   -1,   -1,   -1,  318,  312,  320,  321,   -1,   -1,   -1,
  318,  296,  297,  298,  299,  300,   -1,  270,   -1,  260,
  261,   -1,   -1,  308,  265,  266,  267,  268,  269,   -1,
  271,   -1,  273,  274,   -1,  276,  321,  290,   -1,  280,
   -1,   -1,   -1,  296,  297,  298,  299,  300,   -1,   -1,
   -1,  292,  293,  294,  261,  308,  256,   -1,  265,  266,
  267,  268,  269,  270,  271,   -1,  273,  274,  321,  276,
  270,   -1,  272,  280,   -1,   -1,   -1,   -1,   -1,  320,
   -1,  322,  323,   -1,   -1,  292,  293,  294,   -1,   -1,
  297,   -1,  299,  300,   -1,  295,  296,  297,  298,  299,
  300,  308,   -1,   -1,   -1,   -1,   -1,   -1,  308,   -1,
   -1,   -1,  312,  320,  321,  322,  323,  261,  318,   -1,
   -1,  265,  266,  267,  268,  269,   -1,  271,  272,  273,
  274,   -1,  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,  292,  293,
  294,  295,  261,   -1,   -1,   -1,  265,  266,  267,  268,
  269,   -1,  271,   -1,  273,  274,   -1,  276,  312,   -1,
   -1,  280,   -1,   -1,  318,   -1,  320,   -1,  322,  323,
   -1,   -1,   -1,  292,  293,  294,   -1,  261,  262,  298,
  299,  265,  266,  267,  268,  269,   -1,  271,   -1,  273,
  274,   -1,  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,
   -1,  320,   -1,  322,  323,   -1,   -1,   -1,  292,  293,
  294,  261,  262,   -1,   -1,  265,  266,  267,  268,  269,
   -1,  271,   -1,  273,  274,   -1,  276,   -1,   -1,   -1,
  280,   -1,   -1,   -1,   -1,   -1,  320,   -1,  322,  323,
   -1,   -1,  292,  293,  294,  261,   -1,   -1,   -1,  265,
  266,  267,  268,  269,   -1,  271,   -1,  273,  274,   -1,
  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,   -1,   -1,
  320,   -1,  322,  323,  290,   -1,  292,  293,  294,  261,
   -1,   -1,   -1,  265,  266,  267,  268,  269,   -1,  271,
   -1,  273,  274,   -1,  276,   -1,   -1,   -1,  280,   -1,
   -1,   -1,   -1,   -1,  320,   -1,  322,  323,   -1,   -1,
  292,  293,  294,  261,   -1,   -1,   -1,  265,  266,  267,
  268,  269,   -1,  271,   -1,  273,  274,   -1,  276,   -1,
   -1,   -1,  280,   -1,   -1,   -1,   -1,   -1,  320,   -1,
  322,  323,   -1,   -1,  292,  293,  294,  261,   -1,   -1,
   -1,  265,  266,  267,  268,  269,   -1,  271,   -1,  273,
  274,   -1,  276,   -1,   -1,   -1,  280,   -1,   -1,   -1,
   -1,   -1,  320,   -1,  322,  323,   -1,   -1,  292,  293,
  294,  261,   -1,   -1,   -1,  265,  266,  267,  268,  269,
   -1,  271,   -1,  273,  274,  259,  276,  261,  262,   -1,
  280,   -1,  259,   -1,  261,  262,  320,   -1,  322,  323,
  274,   -1,  292,  293,  294,  272,   -1,  274,  259,   -1,
  261,  262,  286,   -1,   -1,  289,  290,   -1,   -1,  286,
   -1,  272,  289,  274,   -1,  272,   -1,   -1,  295,  296,
  320,   -1,  322,  323,   -1,  286,   -1,   -1,  289,   -1,
   -1,   -1,  289,  290,  295,  312,  320,  321,  295,   -1,
   -1,  318,   -1,  320,  321,   -1,   -1,  257,  258,   -1,
  260,  312,  262,   -1,   -1,  312,   -1,  318,   -1,  320,
  321,  318,  272,   -1,  274,  275,  276,  277,  278,  279,
  280,  281,  282,  283,  284,  285,  286,  287,  288,  289,
  290,  291,   -1,   -1,   -1,  295,   -1,   -1,   -1,   -1,
   -1,   -1,  257,  258,   -1,  260,   -1,  262,   -1,   -1,
   -1,   -1,  312,   -1,   -1,   -1,   -1,  272,  318,  274,
  275,  276,  277,  278,  279,  280,  281,  282,  283,  284,
  285,  286,  287,  288,  289,  290,  291,   -1,   -1,   -1,
  295,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
  258,  259,  260,  261,  262,  263,  264,  312,   -1,  267,
   -1,   -1,   -1,  318,  272,   -1,  274,  275,  276,  277,
  278,  279,  280,  281,  282,  283,  284,  285,  286,  287,
  288,  289,  290,  291,   -1,   -1,   -1,  295,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  258,   -1,  260,   -1,  262,
   -1,   -1,   -1,   -1,  312,   -1,  270,   -1,  272,  272,
  318,  274,  275,  276,  277,  278,  279,  280,  281,  282,
  283,  284,  285,  286,  287,  288,  289,  290,  291,   -1,
   -1,  295,  295,  297,  298,  299,  300,   -1,  258,   -1,
  260,   -1,  262,   -1,  308,   -1,   -1,   -1,  312,  312,
   -1,   -1,  272,   -1,  318,  318,  276,  277,  278,  279,
  280,  281,  282,  283,  284,  285,  286,   -1,   -1,  289,
  290,  291,   -1,   -1,   -1,  295,   -1,   -1,   -1,   -1,
  258,   -1,  260,   -1,  262,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,  312,   -1,  272,   -1,   -1,   -1,  318,  277,
  278,  279,  280,  281,  282,  283,  284,  285,  286,   -1,
   -1,  289,  290,  291,   -1,   -1,   -1,  295,   -1,   -1,
   -1,  258,   -1,  260,   -1,  262,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,  312,  272,   -1,   -1,   -1,   -1,
  318,  278,  279,  280,  281,  282,  283,  284,  285,  286,
   -1,   -1,  289,  290,  291,   -1,   -1,   -1,  295,   -1,
   -1,   -1,  258,   -1,  260,   -1,  262,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,  312,  272,   -1,  258,   -1,
  260,  318,  262,  279,  280,  281,  282,  283,  284,  285,
  286,   -1,  272,  289,  290,  291,   -1,   -1,   -1,  295,
  280,  281,  282,  283,  284,  285,  286,   -1,   -1,  289,
  290,  291,   -1,   -1,   -1,  295,  312,  258,   -1,  260,
   -1,  262,  318,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,  272,  312,  258,   -1,  260,   -1,  262,  318,   -1,
  281,  282,  283,  284,  285,  286,   -1,  272,  289,  290,
  291,   -1,   -1,   -1,  295,   -1,   -1,  282,  283,  284,
  285,  286,   -1,   -1,  289,  290,  291,   -1,   -1,   -1,
  295,  312,  258,   -1,  260,   -1,  262,  318,   -1,   -1,
  258,   -1,  260,   -1,  262,   -1,  272,  312,  258,   -1,
  260,   -1,  262,  318,  272,   -1,   -1,  283,  284,  285,
  286,   -1,  272,  289,  290,  291,  284,  285,  286,  295,
   -1,  289,  290,  291,   -1,   -1,  286,  295,   -1,  289,
  290,  291,   -1,   -1,   -1,  295,  312,  258,   -1,  260,
   -1,  262,  318,   -1,  312,   -1,  259,   -1,  261,  262,
  318,  272,  312,   -1,   -1,   -1,   -1,   -1,  318,  272,
   -1,  274,   -1,   -1,   -1,  286,  256,   -1,  289,  290,
  291,   -1,  262,  286,  295,   -1,  289,   -1,   -1,   -1,
  270,   -1,  295,   -1,   -1,   -1,  270,   -1,  272,   -1,
   -1,  312,   -1,   -1,   -1,   -1,   -1,  318,   -1,  312,
   -1,  291,  270,   -1,   -1,  318,  296,  297,  298,  299,
  300,  295,  296,  297,  298,  299,  300,  270,  308,  272,
   -1,   -1,   -1,   -1,  308,   -1,   -1,   -1,  312,  297,
  298,  299,  300,  270,  318,  272,   -1,  321,   -1,   -1,
  308,   -1,  295,  296,  297,  298,  299,  300,   -1,   -1,
  270,   -1,   -1,  321,   -1,  308,   -1,   -1,  295,  312,
  297,  298,  299,  300,  270,  318,   -1,   -1,  321,  270,
   -1,  308,   -1,   -1,   -1,  312,  296,  297,  298,  299,
  300,  318,   -1,  270,  321,   -1,   -1,   -1,  308,   -1,
  296,  297,  298,  299,  300,   -1,  297,  298,  299,  300,
   -1,  321,  308,  270,   -1,  272,   -1,  308,   -1,   -1,
  297,  298,  299,  300,   -1,  321,   -1,   -1,   -1,   -1,
  321,  308,   -1,   -1,   -1,   -1,   -1,   -1,  295,  296,
  297,  298,  299,  300,  321,   -1,  258,   -1,  260,   -1,
  262,  308,   -1,   -1,   -1,  312,   -1,   -1,   -1,   -1,
   -1,  318,  274,  275,  276,  277,  278,  279,  280,  281,
  282,  283,  284,  285,  286,   -1,   -1,  289,  290,  258,
  259,   -1,  261,   -1,  263,  264,   -1,   -1,  267,   -1,
   -1,   -1,   -1,   -1,   -1,  274,  275,  276,  277,  278,
  279,  280,  281,  282,  283,  284,  285,  286,  287,  288,
  289,  259,   -1,  261,   -1,  263,  264,   -1,   -1,  267,
   -1,   -1,   -1,   -1,   -1,   -1,  274,  275,  276,  277,
  278,  279,  280,  281,  282,  283,  284,  285,   -1,  287,
  288,  289,  290,  274,  275,  276,  277,  278,  279,  280,
  281,  282,  283,  284,  285,
};
#if YYBTYACC
static const YYINT yyctable[] = {                        -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,   -1,
   -1,   -1,   -1,   -1,
};
#endif
#define YYFINAL 9
#ifndef YYDEBUG
#define YYDEBUG 0
#endif
#define YYMAXTOKEN 323
#define YYUNDFTOKEN 488
#define YYTRANSLATE(a) ((a) > YYMAXTOKEN ? YYUNDFTOKEN : (a))
#if YYDEBUG
static const char *const yyname[] = {

"$end",0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,"error","T_LBRACE","T_RBRACE","T_LBRACK",
"T_RBRACK","T_LPAREN","T_RPAREN","T_POINT","T_ARROW","T_COMPLEMENT","T_LOGNOT",
"T_INCDEC","T_SIZEOF","T_BUILTIN_OFFSETOF","T_TYPEOF","T_EXTENSION","T_ALIGNAS",
"T_ALIGNOF","T_ASTERISK","T_MULTIPLICATIVE","T_ADDITIVE","T_SHIFT",
"T_RELATIONAL","T_EQUALITY","T_AMPER","T_BITXOR","T_BITOR","T_LOGAND","T_LOGOR",
"T_QUEST","T_COLON","T_ASSIGN","T_OPASSIGN","T_COMMA","T_SEMI","T_ELLIPSIS",
"T_REAL","T_IMAG","T_GENERIC","T_NORETURN","T_SCLASS","T_TYPE","T_QUAL",
"T_ATOMIC","T_STRUCT_OR_UNION","T_ASM","T_BREAK","T_CASE","T_CONTINUE",
"T_DEFAULT","T_DO","T_ELSE","T_ENUM","T_FOR","T_GOTO","T_IF","T_PACKED",
"T_RETURN","T_SWITCH","T_SYMBOLRENAME","T_WHILE","T_STATIC_ASSERT",
"T_ATTRIBUTE","T_THEN","T_NAME","T_TYPENAME","T_CON","T_STRING","$accept",
"program","identifier_sym","identifier","string","primary_expression",
"generic_selection","generic_assoc_list","generic_association",
"postfix_expression","gcc_statement_expr_list","gcc_statement_expr_item",
"point_or_arrow","argument_expression_list","unary_expression",
"cast_expression","conditional_expression","assignment_expression",
"expression_opt","expression","constant_expr","begin_type_typespec",
"type_specifier","notype_type_specifier","atomic_type_specifier",
"struct_or_union_specifier","struct_or_union","braced_struct_declaration_list",
"struct_declaration_list_with_rbrace","struct_declaration_list",
"struct_declaration","notype_struct_declarators","type_struct_declarators",
"notype_struct_declarator","type_struct_declarator","enum_specifier",
"enum_declaration","enums_with_opt_comma","enumerator_list","enumerator",
"type_qualifier","pointer","asterisk","type_qualifier_list_opt",
"type_qualifier_list","type_qualifier_list_elem","notype_declarator",
"type_declarator","notype_direct_declarator","type_direct_declarator",
"type_param_declarator","notype_param_declarator","direct_param_declarator",
"direct_notype_param_declarator","param_list","array_size_opt","array_size",
"identifier_list","type_name","abstract_declaration","abstract_declarator",
"direct_abstract_declarator","abstract_decl_param_list",
"vararg_parameter_type_list","parameter_type_list","parameter_declaration",
"range","asm_or_symbolrename_opt","block_item_list","block_item",
"do_while_expr","func_declarator","sys","translation_unit","init_lbrace","$$1",
"initializer_list","comma_opt","init_rbrace","compound_statement_lbrace","$$2",
"compound_statement_rbrace","$$3","declaration_or_error","non_expr_statement",
"declaration","begin_type_declmods","end_type","notype_init_declarators",
"begin_type_declaration_specifiers","type_init_declarators",
"static_assert_declaration","type_attribute","declmod","begin_type",
"begin_type_specifier_qualifier_list",
"begin_type_specifier_qualifier_list_postfix","type_attribute_list",
"begin_type_qualifier_list","type_attribute_list_opt","type_attribute_opt",
"gcc_attribute_specifier","atomic","$$4","$$5","struct_declaration_lbrace",
"$$6","$$7","$$8","$$9","$$10","$$11","enum","gcc_attribute_specifier_list_opt",
"$$12","$$13","enum_decl_lbrace","notype_init_declarator",
"type_init_declarator","$$14","initializer","$$15","id_list_lparen","$$16",
"abstract_decl_lparen","initializer_list_item","designation",
"begin_designation","designator_list","designator","statement",
"expression_statement","labeled_statement","compound_statement",
"selection_statement","iteration_statement","jump_statement","asm_statement",
"label","if_without_else","$$17","switch_expr","if_expr","while_expr",
"do_statement","do","for_exprs","for_start","goto","read_until_rparen",
"external_declaration","function_definition","top_level_declaration",
"arg_declaration_list_opt","$$18","$$19","arg_declaration_list",
"arg_declaration","gcc_attribute_specifier_list","gcc_attribute_list","$$20",
"$$21","gcc_attribute","gcc_attribute_parameters","illegal-symbol",
};
static const char *const yyrule[] = {
"$accept : program",
"program :",
"program : translation_unit",
"identifier_sym : identifier",
"identifier : T_NAME",
"identifier : T_TYPENAME",
"string : T_STRING",
"string : string T_STRING",
"primary_expression : T_NAME",
"primary_expression : T_CON",
"primary_expression : string",
"primary_expression : T_LPAREN expression T_RPAREN",
"primary_expression : generic_selection",
"primary_expression : T_BUILTIN_OFFSETOF T_LPAREN type_name T_COMMA identifier T_RPAREN",
"generic_selection : T_GENERIC T_LPAREN assignment_expression T_COMMA generic_assoc_list T_RPAREN",
"generic_assoc_list : generic_association",
"generic_assoc_list : generic_assoc_list T_COMMA generic_association",
"generic_association : type_name T_COLON assignment_expression",
"generic_association : T_DEFAULT T_COLON assignment_expression",
"postfix_expression : primary_expression",
"postfix_expression : postfix_expression T_LBRACK sys expression T_RBRACK",
"postfix_expression : postfix_expression T_LPAREN sys T_RPAREN",
"postfix_expression : postfix_expression T_LPAREN sys argument_expression_list T_RPAREN",
"postfix_expression : postfix_expression point_or_arrow sys T_NAME",
"postfix_expression : postfix_expression T_INCDEC sys",
"$$1 :",
"postfix_expression : T_LPAREN type_name T_RPAREN $$1 init_lbrace initializer_list comma_opt init_rbrace",
"$$2 :",
"$$3 :",
"postfix_expression : T_LPAREN compound_statement_lbrace $$2 gcc_statement_expr_list $$3 compound_statement_rbrace T_RPAREN",
"comma_opt :",
"comma_opt : T_COMMA",
"gcc_statement_expr_list : gcc_statement_expr_item",
"gcc_statement_expr_list : gcc_statement_expr_list gcc_statement_expr_item",
"gcc_statement_expr_item : declaration_or_error",
"gcc_statement_expr_item : non_expr_statement",
"gcc_statement_expr_item : expression T_SEMI",
"point_or_arrow : T_POINT",
"point_or_arrow : T_ARROW",
"argument_expression_list : assignment_expression",
"argument_expression_list : argument_expression_list T_COMMA assignment_expression",
"unary_expression : postfix_expression",
"unary_expression : T_INCDEC sys unary_expression",
"unary_expression : T_AMPER sys cast_expression",
"unary_expression : T_ASTERISK sys cast_expression",
"unary_expression : T_ADDITIVE sys cast_expression",
"unary_expression : T_COMPLEMENT sys cast_expression",
"unary_expression : T_LOGNOT sys cast_expression",
"unary_expression : T_REAL sys cast_expression",
"unary_expression : T_IMAG sys cast_expression",
"unary_expression : T_EXTENSION cast_expression",
"unary_expression : T_SIZEOF unary_expression",
"unary_expression : T_SIZEOF T_LPAREN type_name T_RPAREN",
"unary_expression : T_ALIGNOF unary_expression",
"unary_expression : T_ALIGNOF T_LPAREN type_name T_RPAREN",
"cast_expression : unary_expression",
"cast_expression : T_LPAREN type_name T_RPAREN cast_expression",
"expression_opt :",
"expression_opt : expression",
"conditional_expression : cast_expression",
"conditional_expression : conditional_expression T_ASTERISK sys conditional_expression",
"conditional_expression : conditional_expression T_MULTIPLICATIVE sys conditional_expression",
"conditional_expression : conditional_expression T_ADDITIVE sys conditional_expression",
"conditional_expression : conditional_expression T_SHIFT sys conditional_expression",
"conditional_expression : conditional_expression T_RELATIONAL sys conditional_expression",
"conditional_expression : conditional_expression T_EQUALITY sys conditional_expression",
"conditional_expression : conditional_expression T_AMPER sys conditional_expression",
"conditional_expression : conditional_expression T_BITXOR sys conditional_expression",
"conditional_expression : conditional_expression T_BITOR sys conditional_expression",
"conditional_expression : conditional_expression T_LOGAND sys conditional_expression",
"conditional_expression : conditional_expression T_LOGOR sys conditional_expression",
"conditional_expression : conditional_expression T_QUEST sys expression T_COLON sys conditional_expression",
"assignment_expression : conditional_expression",
"assignment_expression : unary_expression T_ASSIGN sys assignment_expression",
"assignment_expression : unary_expression T_OPASSIGN sys assignment_expression",
"expression : assignment_expression",
"expression : expression T_COMMA sys assignment_expression",
"constant_expr : conditional_expression",
"declaration_or_error : declaration",
"declaration_or_error : error T_SEMI",
"declaration : begin_type_declmods end_type T_SEMI",
"declaration : begin_type_declmods end_type notype_init_declarators T_SEMI",
"declaration : begin_type_declaration_specifiers end_type T_SEMI",
"declaration : begin_type_declaration_specifiers end_type type_init_declarators T_SEMI",
"declaration : static_assert_declaration",
"begin_type_declaration_specifiers : begin_type_typespec",
"begin_type_declaration_specifiers : begin_type_declmods type_specifier",
"begin_type_declaration_specifiers : type_attribute begin_type_declaration_specifiers",
"begin_type_declaration_specifiers : begin_type_declaration_specifiers declmod",
"begin_type_declaration_specifiers : begin_type_declaration_specifiers notype_type_specifier",
"begin_type_declmods : begin_type type_qualifier",
"begin_type_declmods : begin_type T_SCLASS",
"begin_type_declmods : begin_type_declmods declmod",
"begin_type_specifier_qualifier_list : begin_type_specifier_qualifier_list_postfix",
"begin_type_specifier_qualifier_list : type_attribute_list begin_type_specifier_qualifier_list_postfix",
"begin_type_specifier_qualifier_list_postfix : begin_type_typespec",
"begin_type_specifier_qualifier_list_postfix : begin_type_qualifier_list type_specifier",
"begin_type_specifier_qualifier_list_postfix : begin_type_specifier_qualifier_list_postfix type_qualifier",
"begin_type_specifier_qualifier_list_postfix : begin_type_specifier_qualifier_list_postfix notype_type_specifier",
"begin_type_specifier_qualifier_list_postfix : begin_type_specifier_qualifier_list_postfix type_attribute",
"begin_type_typespec : begin_type notype_type_specifier",
"begin_type_typespec : begin_type T_TYPENAME",
"begin_type_qualifier_list : begin_type type_qualifier",
"begin_type_qualifier_list : begin_type_qualifier_list type_qualifier",
"declmod : type_qualifier",
"declmod : T_SCLASS",
"declmod : type_attribute_list",
"type_attribute_list_opt :",
"type_attribute_list_opt : type_attribute_list",
"type_attribute_list : type_attribute",
"type_attribute_list : type_attribute_list type_attribute",
"type_attribute_opt :",
"type_attribute_opt : type_attribute",
"type_attribute : gcc_attribute_specifier",
"type_attribute : T_ALIGNAS T_LPAREN type_specifier T_RPAREN",
"type_attribute : T_ALIGNAS T_LPAREN constant_expr T_RPAREN",
"type_attribute : T_PACKED",
"type_attribute : T_NORETURN",
"begin_type :",
"end_type :",
"type_specifier : notype_type_specifier",
"type_specifier : T_TYPENAME",
"notype_type_specifier : T_TYPE",
"notype_type_specifier : T_TYPEOF T_LPAREN expression T_RPAREN",
"notype_type_specifier : atomic_type_specifier",
"notype_type_specifier : struct_or_union_specifier",
"notype_type_specifier : enum_specifier",
"atomic_type_specifier : atomic T_LPAREN type_name T_RPAREN",
"struct_or_union_specifier : struct_or_union identifier_sym",
"$$4 :",
"struct_or_union_specifier : struct_or_union identifier_sym $$4 braced_struct_declaration_list",
"$$5 :",
"struct_or_union_specifier : struct_or_union $$5 braced_struct_declaration_list",
"struct_or_union_specifier : struct_or_union error",
"struct_or_union : T_STRUCT_OR_UNION",
"struct_or_union : struct_or_union type_attribute",
"braced_struct_declaration_list : struct_declaration_lbrace struct_declaration_list_with_rbrace",
"struct_declaration_lbrace : T_LBRACE",
"struct_declaration_list_with_rbrace : struct_declaration_list T_RBRACE",
"struct_declaration_list_with_rbrace : T_RBRACE",
"struct_declaration_list : struct_declaration",
"struct_declaration_list : struct_declaration_list struct_declaration",
"$$6 :",
"struct_declaration : begin_type_qualifier_list end_type $$6 notype_struct_declarators type_attribute_opt T_SEMI",
"$$7 :",
"struct_declaration : begin_type_specifier_qualifier_list end_type $$7 type_struct_declarators type_attribute_opt T_SEMI",
"struct_declaration : begin_type_qualifier_list end_type type_attribute_opt T_SEMI",
"struct_declaration : begin_type_specifier_qualifier_list end_type type_attribute_opt T_SEMI",
"struct_declaration : static_assert_declaration",
"struct_declaration : error T_SEMI",
"notype_struct_declarators : notype_struct_declarator",
"$$8 :",
"notype_struct_declarators : notype_struct_declarators $$8 T_COMMA type_struct_declarator",
"type_struct_declarators : type_struct_declarator",
"$$9 :",
"type_struct_declarators : type_struct_declarators $$9 T_COMMA type_struct_declarator",
"notype_struct_declarator : notype_declarator",
"notype_struct_declarator : notype_declarator T_COLON constant_expr",
"$$10 :",
"notype_struct_declarator : $$10 T_COLON constant_expr",
"type_struct_declarator : type_declarator",
"type_struct_declarator : type_declarator T_COLON constant_expr",
"$$11 :",
"type_struct_declarator : $$11 T_COLON constant_expr",
"enum_specifier : enum gcc_attribute_specifier_list_opt identifier_sym",
"$$12 :",
"enum_specifier : enum gcc_attribute_specifier_list_opt identifier_sym $$12 enum_declaration",
"$$13 :",
"enum_specifier : enum gcc_attribute_specifier_list_opt $$13 enum_declaration",
"enum_specifier : enum error",
"enum : T_ENUM",
"enum_declaration : enum_decl_lbrace enums_with_opt_comma T_RBRACE",
"enum_decl_lbrace : T_LBRACE",
"enums_with_opt_comma : enumerator_list",
"enums_with_opt_comma : enumerator_list T_COMMA",
"enumerator_list : enumerator",
"enumerator_list : enumerator_list T_COMMA enumerator",
"enumerator_list : error",
"enumerator : identifier_sym gcc_attribute_specifier_list_opt",
"enumerator : identifier_sym gcc_attribute_specifier_list_opt T_ASSIGN constant_expr",
"type_qualifier : T_QUAL",
"type_qualifier : atomic",
"atomic : T_ATOMIC",
"pointer : asterisk type_qualifier_list_opt",
"pointer : asterisk type_qualifier_list_opt pointer",
"asterisk : T_ASTERISK",
"type_qualifier_list_opt :",
"type_qualifier_list_opt : type_qualifier_list",
"type_qualifier_list : type_qualifier_list_elem",
"type_qualifier_list : type_qualifier_list type_qualifier_list_elem",
"type_qualifier_list_elem : type_qualifier",
"notype_init_declarators : notype_init_declarator",
"notype_init_declarators : notype_init_declarators T_COMMA type_init_declarator",
"type_init_declarators : type_init_declarator",
"type_init_declarators : type_init_declarators T_COMMA type_init_declarator",
"notype_init_declarator : notype_declarator asm_or_symbolrename_opt",
"$$14 :",
"notype_init_declarator : notype_declarator asm_or_symbolrename_opt $$14 T_ASSIGN initializer",
"type_init_declarator : type_declarator asm_or_symbolrename_opt",
"$$15 :",
"type_init_declarator : type_declarator asm_or_symbolrename_opt $$15 T_ASSIGN initializer",
"notype_declarator : notype_direct_declarator",
"notype_declarator : pointer notype_direct_declarator",
"type_declarator : type_direct_declarator",
"type_declarator : pointer type_direct_declarator",
"notype_direct_declarator : type_attribute_list_opt T_NAME",
"notype_direct_declarator : type_attribute_list_opt T_LPAREN type_declarator T_RPAREN",
"notype_direct_declarator : notype_direct_declarator T_LBRACK array_size_opt T_RBRACK",
"notype_direct_declarator : notype_direct_declarator param_list asm_or_symbolrename_opt",
"notype_direct_declarator : notype_direct_declarator type_attribute",
"type_direct_declarator : type_attribute_list_opt identifier",
"type_direct_declarator : type_attribute_list_opt T_LPAREN type_declarator T_RPAREN",
"type_direct_declarator : type_direct_declarator T_LBRACK array_size_opt T_RBRACK",
"type_direct_declarator : type_direct_declarator param_list asm_or_symbolrename_opt",
"type_direct_declarator : type_direct_declarator type_attribute",
"type_param_declarator : direct_param_declarator",
"type_param_declarator : pointer direct_param_declarator",
"notype_param_declarator : direct_notype_param_declarator",
"notype_param_declarator : pointer direct_notype_param_declarator",
"direct_param_declarator : identifier type_attribute_list",
"direct_param_declarator : identifier",
"direct_param_declarator : T_LPAREN notype_param_declarator T_RPAREN",
"direct_param_declarator : direct_param_declarator T_LBRACK array_size_opt T_RBRACK gcc_attribute_specifier_list_opt",
"direct_param_declarator : direct_param_declarator param_list asm_or_symbolrename_opt",
"direct_notype_param_declarator : identifier",
"direct_notype_param_declarator : T_LPAREN notype_param_declarator T_RPAREN",
"direct_notype_param_declarator : direct_notype_param_declarator T_LBRACK array_size_opt T_RBRACK",
"direct_notype_param_declarator : direct_notype_param_declarator param_list asm_or_symbolrename_opt",
"param_list : id_list_lparen identifier_list T_RPAREN",
"param_list : abstract_decl_param_list",
"id_list_lparen : T_LPAREN",
"array_size_opt :",
"array_size_opt : T_ASTERISK",
"array_size_opt : array_size",
"array_size : type_qualifier_list_opt T_SCLASS constant_expr",
"array_size : type_qualifier",
"array_size : constant_expr",
"identifier_list : T_NAME",
"identifier_list : identifier_list T_COMMA T_NAME",
"identifier_list : identifier_list error",
"$$16 :",
"type_name : $$16 abstract_declaration",
"abstract_declaration : begin_type_qualifier_list end_type",
"abstract_declaration : begin_type_specifier_qualifier_list end_type",
"abstract_declaration : begin_type_qualifier_list end_type abstract_declarator",
"abstract_declaration : begin_type_specifier_qualifier_list end_type abstract_declarator",
"abstract_declarator : pointer",
"abstract_declarator : direct_abstract_declarator",
"abstract_declarator : pointer direct_abstract_declarator",
"abstract_declarator : type_attribute_list direct_abstract_declarator",
"abstract_declarator : pointer type_attribute_list direct_abstract_declarator",
"direct_abstract_declarator : T_LPAREN abstract_declarator T_RPAREN",
"direct_abstract_declarator : T_LBRACK array_size_opt T_RBRACK",
"direct_abstract_declarator : direct_abstract_declarator T_LBRACK array_size_opt T_RBRACK",
"direct_abstract_declarator : abstract_decl_param_list asm_or_symbolrename_opt",
"direct_abstract_declarator : direct_abstract_declarator abstract_decl_param_list asm_or_symbolrename_opt",
"direct_abstract_declarator : direct_abstract_declarator type_attribute_list",
"abstract_decl_param_list : abstract_decl_lparen T_RPAREN type_attribute_opt",
"abstract_decl_param_list : abstract_decl_lparen vararg_parameter_type_list T_RPAREN type_attribute_opt",
"abstract_decl_param_list : abstract_decl_lparen error T_RPAREN type_attribute_opt",
"abstract_decl_lparen : T_LPAREN",
"vararg_parameter_type_list : parameter_type_list",
"vararg_parameter_type_list : parameter_type_list T_COMMA T_ELLIPSIS",
"vararg_parameter_type_list : T_ELLIPSIS",
"parameter_type_list : parameter_declaration",
"parameter_type_list : parameter_type_list T_COMMA parameter_declaration",
"parameter_declaration : begin_type_declmods end_type",
"parameter_declaration : begin_type_declaration_specifiers end_type",
"parameter_declaration : begin_type_declmods end_type notype_param_declarator",
"parameter_declaration : begin_type_declaration_specifiers end_type type_param_declarator",
"parameter_declaration : begin_type_declmods end_type abstract_declarator",
"parameter_declaration : begin_type_declaration_specifiers end_type abstract_declarator",
"initializer : assignment_expression",
"initializer : init_lbrace init_rbrace",
"initializer : init_lbrace initializer_list comma_opt init_rbrace",
"initializer : error",
"initializer_list : initializer_list_item",
"initializer_list : initializer_list T_COMMA initializer_list_item",
"initializer_list_item : designation initializer",
"initializer_list_item : initializer",
"designation : begin_designation designator_list T_ASSIGN",
"designation : identifier T_COLON",
"begin_designation :",
"designator_list : designator",
"designator_list : designator_list designator",
"designator : T_LBRACK range T_RBRACK",
"designator : T_POINT identifier",
"static_assert_declaration : T_STATIC_ASSERT T_LPAREN constant_expr T_COMMA T_STRING T_RPAREN T_SEMI",
"static_assert_declaration : T_STATIC_ASSERT T_LPAREN constant_expr T_RPAREN T_SEMI",
"range : constant_expr",
"range : constant_expr T_ELLIPSIS constant_expr",
"init_lbrace : T_LBRACE",
"init_rbrace : T_RBRACE",
"asm_or_symbolrename_opt :",
"asm_or_symbolrename_opt : T_ASM T_LPAREN T_STRING T_RPAREN gcc_attribute_specifier_list_opt",
"asm_or_symbolrename_opt : T_SYMBOLRENAME T_LPAREN T_NAME T_RPAREN gcc_attribute_specifier_list_opt",
"statement : expression_statement",
"statement : non_expr_statement",
"non_expr_statement : gcc_attribute_specifier T_SEMI",
"non_expr_statement : labeled_statement",
"non_expr_statement : compound_statement",
"non_expr_statement : selection_statement",
"non_expr_statement : iteration_statement",
"non_expr_statement : jump_statement",
"non_expr_statement : asm_statement",
"labeled_statement : label gcc_attribute_specifier_list_opt statement",
"label : T_NAME T_COLON",
"label : T_CASE constant_expr T_COLON",
"label : T_CASE constant_expr T_ELLIPSIS constant_expr T_COLON",
"label : T_DEFAULT T_COLON",
"compound_statement : compound_statement_lbrace compound_statement_rbrace",
"compound_statement : compound_statement_lbrace block_item_list compound_statement_rbrace",
"compound_statement_lbrace : T_LBRACE",
"compound_statement_rbrace : T_RBRACE",
"block_item_list : block_item",
"block_item_list : block_item_list block_item",
"block_item : declaration_or_error",
"block_item : statement",
"expression_statement : expression T_SEMI",
"expression_statement : T_SEMI",
"selection_statement : if_without_else",
"$$17 :",
"selection_statement : if_without_else T_ELSE $$17 statement",
"selection_statement : if_without_else T_ELSE error",
"selection_statement : switch_expr statement",
"selection_statement : switch_expr error",
"if_without_else : if_expr statement",
"if_without_else : if_expr error",
"if_expr : T_IF T_LPAREN expression T_RPAREN",
"switch_expr : T_SWITCH T_LPAREN expression T_RPAREN",
"iteration_statement : while_expr statement",
"iteration_statement : while_expr error",
"iteration_statement : do_statement do_while_expr",
"iteration_statement : do error",
"iteration_statement : for_exprs statement",
"iteration_statement : for_exprs error",
"while_expr : T_WHILE T_LPAREN expression T_RPAREN",
"do_statement : do statement",
"do : T_DO",
"do_while_expr : T_WHILE T_LPAREN expression T_RPAREN T_SEMI",
"for_start : T_FOR T_LPAREN",
"for_exprs : for_start begin_type_declaration_specifiers end_type notype_init_declarators T_SEMI expression_opt T_SEMI expression_opt T_RPAREN",
"for_exprs : for_start expression_opt T_SEMI expression_opt T_SEMI expression_opt T_RPAREN",
"jump_statement : goto identifier T_SEMI",
"jump_statement : goto error T_SEMI",
"jump_statement : T_CONTINUE T_SEMI",
"jump_statement : T_BREAK T_SEMI",
"jump_statement : T_RETURN sys T_SEMI",
"jump_statement : T_RETURN sys expression T_SEMI",
"goto : T_GOTO",
"asm_statement : T_ASM T_LPAREN read_until_rparen T_SEMI",
"asm_statement : T_ASM type_qualifier T_LPAREN read_until_rparen T_SEMI",
"asm_statement : T_ASM error",
"read_until_rparen :",
"translation_unit : external_declaration",
"translation_unit : translation_unit external_declaration",
"external_declaration : function_definition",
"external_declaration : top_level_declaration",
"external_declaration : asm_statement",
"external_declaration : T_SEMI",
"top_level_declaration : begin_type end_type notype_init_declarators T_SEMI",
"top_level_declaration : declaration",
"top_level_declaration : error T_SEMI",
"top_level_declaration : error T_RBRACE",
"$$18 :",
"$$19 :",
"function_definition : func_declarator $$18 arg_declaration_list_opt $$19 compound_statement",
"func_declarator : begin_type end_type notype_declarator",
"func_declarator : begin_type_declmods end_type notype_declarator",
"func_declarator : begin_type_declaration_specifiers end_type type_declarator",
"arg_declaration_list_opt :",
"arg_declaration_list_opt : arg_declaration_list",
"arg_declaration_list : arg_declaration",
"arg_declaration_list : arg_declaration_list arg_declaration",
"arg_declaration_list : error",
"arg_declaration : begin_type_declmods end_type T_SEMI",
"arg_declaration : begin_type_declmods end_type notype_init_declarators T_SEMI",
"arg_declaration : begin_type_declaration_specifiers end_type T_SEMI",
"arg_declaration : begin_type_declaration_specifiers end_type type_init_declarators T_SEMI",
"arg_declaration : begin_type_declmods error",
"arg_declaration : begin_type_declaration_specifiers error",
"gcc_attribute_specifier_list_opt :",
"gcc_attribute_specifier_list_opt : gcc_attribute_specifier_list",
"gcc_attribute_specifier_list : gcc_attribute_specifier",
"gcc_attribute_specifier_list : gcc_attribute_specifier_list gcc_attribute_specifier",
"$$20 :",
"$$21 :",
"gcc_attribute_specifier : T_ATTRIBUTE T_LPAREN T_LPAREN $$20 gcc_attribute_list $$21 T_RPAREN T_RPAREN",
"gcc_attribute_list : gcc_attribute",
"gcc_attribute_list : gcc_attribute_list T_COMMA gcc_attribute",
"gcc_attribute :",
"gcc_attribute : T_NAME",
"gcc_attribute : T_NAME T_LPAREN T_RPAREN",
"gcc_attribute : T_NAME T_LPAREN gcc_attribute_parameters T_RPAREN",
"gcc_attribute : type_qualifier",
"gcc_attribute_parameters : constant_expr",
"gcc_attribute_parameters : gcc_attribute_parameters T_COMMA constant_expr",
"sys :",

};
#endif

#if YYDEBUG
int      yydebug;
#endif

int      yyerrflag;
int      yychar;
YYSTYPE  yyval;
YYSTYPE  yylval;
int      yynerrs;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
YYLTYPE  yyloc; /* position returned by actions */
YYLTYPE  yylloc; /* position from the lexer */
#endif

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
#ifndef YYLLOC_DEFAULT
#define YYLLOC_DEFAULT(loc, rhs, n) \
do \
{ \
    if (n == 0) \
    { \
        (loc).first_line   = YYRHSLOC(rhs, 0).last_line; \
        (loc).first_column = YYRHSLOC(rhs, 0).last_column; \
        (loc).last_line    = YYRHSLOC(rhs, 0).last_line; \
        (loc).last_column  = YYRHSLOC(rhs, 0).last_column; \
    } \
    else \
    { \
        (loc).first_line   = YYRHSLOC(rhs, 1).first_line; \
        (loc).first_column = YYRHSLOC(rhs, 1).first_column; \
        (loc).last_line    = YYRHSLOC(rhs, n).last_line; \
        (loc).last_column  = YYRHSLOC(rhs, n).last_column; \
    } \
} while (0)
#endif /* YYLLOC_DEFAULT */
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#if YYBTYACC

#ifndef YYLVQUEUEGROWTH
#define YYLVQUEUEGROWTH 32
#endif
#endif /* YYBTYACC */

/* define the initial stack-sizes */
#ifdef YYSTACKSIZE
#undef YYMAXDEPTH
#define YYMAXDEPTH  YYSTACKSIZE
#else
#ifdef YYMAXDEPTH
#define YYSTACKSIZE YYMAXDEPTH
#else
#define YYSTACKSIZE 10000
#define YYMAXDEPTH  10000
#endif
#endif

#ifndef YYINITSTACKSIZE
#define YYINITSTACKSIZE 200
#endif

typedef struct {
    unsigned stacksize;
    YYINT    *s_base;
    YYINT    *s_mark;
    YYINT    *s_last;
    YYSTYPE  *l_base;
    YYSTYPE  *l_mark;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE  *p_base;
    YYLTYPE  *p_mark;
#endif
} YYSTACKDATA;
#if YYBTYACC

struct YYParseState_s
{
    struct YYParseState_s *save;    /* Previously saved parser state */
    YYSTACKDATA            yystack; /* saved parser stack */
    int                    state;   /* saved parser state */
    int                    errflag; /* saved error recovery status */
    int                    lexeme;  /* saved index of the conflict lexeme in the lexical queue */
    YYINT                  ctry;    /* saved index in yyctable[] for this conflict */
};
typedef struct YYParseState_s YYParseState;
#endif /* YYBTYACC */
/* variables for the parser stack */
static YYSTACKDATA yystack;
#if YYBTYACC

/* Current parser state */
static YYParseState *yyps = 0;

/* yypath != NULL: do the full parse, starting at *yypath parser state. */
static YYParseState *yypath = 0;

/* Base of the lexical value queue */
static YYSTYPE *yylvals = 0;

/* Current position at lexical value queue */
static YYSTYPE *yylvp = 0;

/* End position of lexical value queue */
static YYSTYPE *yylve = 0;

/* The last allocated position at the lexical value queue */
static YYSTYPE *yylvlim = 0;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
/* Base of the lexical position queue */
static YYLTYPE *yylpsns = 0;

/* Current position at lexical position queue */
static YYLTYPE *yylpp = 0;

/* End position of lexical position queue */
static YYLTYPE *yylpe = 0;

/* The last allocated position at the lexical position queue */
static YYLTYPE *yylplim = 0;
#endif

/* Current position at lexical token queue */
static YYINT  *yylexp = 0;

static YYINT  *yylexemes = 0;
#endif /* YYBTYACC */
#line 2104 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"

/* ARGSUSED */
int
yyerror(const char *msg)
{
	/* syntax error '%s' */
	error(249, yytext);
	if (++sytxerr >= 5)
		norecover();
	return 0;
}

#if YYDEBUG && (YYBYACC || YYBISON)
static const char *
cgram_to_string(int token, YYSTYPE val)
{

	switch (token) {
	case T_INCDEC:
	case T_MULTIPLICATIVE:
	case T_ADDITIVE:
	case T_SHIFT:
	case T_RELATIONAL:
	case T_EQUALITY:
	case T_OPASSIGN:
		return modtab[val.y_op].m_name;
	case T_SCLASS:
		return scl_name(val.y_scl);
	case T_TYPE:
	case T_STRUCT_OR_UNION:
		return tspec_name(val.y_tspec);
	case T_QUAL:
		return tqual_name(val.y_tqual);
	case T_NAME:
		return val.y_name->sb_name;
	default:
		return "<none>";
	}
}
#endif

#if YYDEBUG && YYBISON
static inline void
cgram_print(FILE *output, int token, YYSTYPE val)
{
	(void)fprintf(output, "%s", cgram_to_string(token, val));
}
#endif

static void
cgram_declare(sym_t *decl, bool has_initializer, sbuf_t *renaming)
{
	declare(decl, has_initializer, renaming);
	if (renaming != NULL)
		freeyyv(&renaming, T_NAME);
}

/*
 * Discard all input tokens up to and including the next
 * unmatched right paren
 */
static void
read_until_rparen(void)
{
	int	level;

	if (yychar < 0)
		yychar = yylex();
	freeyyv(&yylval, yychar);

	level = 1;
	while (yychar > 0) {
		if (yychar == T_LPAREN)
			level++;
		if (yychar == T_RPAREN && --level == 0)
			break;
		freeyyv(&yylval, yychar = yylex());
	}

	yyclearin;
}

static	sym_t *
symbolrename(sym_t *s, sbuf_t *sb)
{
	if (sb != NULL)
		s->s_rename = sb->sb_name;
	return s;
}
#line 2631 "cgram.c"

/* For use in generated program */
#define yydepth (int)(yystack.s_mark - yystack.s_base)
#if YYBTYACC
#define yytrial (yyps->save)
#endif /* YYBTYACC */

#if YYDEBUG
#include <stdio.h>	/* needed for printf */
#endif

#include <stdlib.h>	/* needed for malloc, etc */
#include <string.h>	/* needed for memset */

/* allocate initial stack or double stack size, up to YYMAXDEPTH */
static int yygrowstack(YYSTACKDATA *data)
{
    int i;
    unsigned newsize;
    YYINT *newss;
    YYSTYPE *newvs;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE *newps;
#endif

    if ((newsize = data->stacksize) == 0)
        newsize = YYINITSTACKSIZE;
    else if (newsize >= YYMAXDEPTH)
        return YYENOMEM;
    else if ((newsize *= 2) > YYMAXDEPTH)
        newsize = YYMAXDEPTH;

    i = (int) (data->s_mark - data->s_base);
    newss = (YYINT *)realloc(data->s_base, newsize * sizeof(*newss));
    if (newss == 0)
        return YYENOMEM;

    data->s_base = newss;
    data->s_mark = newss + i;

    newvs = (YYSTYPE *)realloc(data->l_base, newsize * sizeof(*newvs));
    if (newvs == 0)
        return YYENOMEM;

    data->l_base = newvs;
    data->l_mark = newvs + i;

#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    newps = (YYLTYPE *)realloc(data->p_base, newsize * sizeof(*newps));
    if (newps == 0)
        return YYENOMEM;

    data->p_base = newps;
    data->p_mark = newps + i;
#endif

    data->stacksize = newsize;
    data->s_last = data->s_base + newsize - 1;

#if YYDEBUG
    if (yydebug)
        fprintf(stderr, "%sdebug: stack size increased to %d\n", YYPREFIX, newsize);
#endif
    return 0;
}

#if YYPURE || defined(YY_NO_LEAKS)
static void yyfreestack(YYSTACKDATA *data)
{
    free(data->s_base);
    free(data->l_base);
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    free(data->p_base);
#endif
    memset(data, 0, sizeof(*data));
}
#else
#define yyfreestack(data) /* nothing */
#endif /* YYPURE || defined(YY_NO_LEAKS) */
#if YYBTYACC

static YYParseState *
yyNewState(unsigned size)
{
    YYParseState *p = (YYParseState *) malloc(sizeof(YYParseState));
    if (p == NULL) return NULL;

    p->yystack.stacksize = size;
    if (size == 0)
    {
        p->yystack.s_base = NULL;
        p->yystack.l_base = NULL;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        p->yystack.p_base = NULL;
#endif
        return p;
    }
    p->yystack.s_base    = (YYINT *) malloc(size * sizeof(YYINT));
    if (p->yystack.s_base == NULL) return NULL;
    p->yystack.l_base    = (YYSTYPE *) malloc(size * sizeof(YYSTYPE));
    if (p->yystack.l_base == NULL) return NULL;
    memset(p->yystack.l_base, 0, size * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    p->yystack.p_base    = (YYLTYPE *) malloc(size * sizeof(YYLTYPE));
    if (p->yystack.p_base == NULL) return NULL;
    memset(p->yystack.p_base, 0, size * sizeof(YYLTYPE));
#endif

    return p;
}

static void
yyFreeState(YYParseState *p)
{
    yyfreestack(&p->yystack);
    free(p);
}
#endif /* YYBTYACC */

#define YYABORT  goto yyabort
#define YYREJECT goto yyabort
#define YYACCEPT goto yyaccept
#define YYERROR  goto yyerrlab
#if YYBTYACC
#define YYVALID        do { if (yyps->save)            goto yyvalid; } while(0)
#define YYVALID_NESTED do { if (yyps->save && \
                                yyps->save->save == 0) goto yyvalid; } while(0)
#endif /* YYBTYACC */

int
YYPARSE_DECL()
{
    int yym, yyn, yystate, yyresult;
#if YYBTYACC
    int yynewerrflag;
    YYParseState *yyerrctx = NULL;
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    YYLTYPE  yyerror_loc_range[3]; /* position of error start/end (0 unused) */
#endif
#if YYDEBUG
    const char *yys;

    if ((yys = getenv("YYDEBUG")) != 0)
    {
        yyn = *yys;
        if (yyn >= '0' && yyn <= '9')
            yydebug = yyn - '0';
    }
    if (yydebug)
        fprintf(stderr, "%sdebug[<# of symbols on state stack>]\n", YYPREFIX);
#endif
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    memset(yyerror_loc_range, 0, sizeof(yyerror_loc_range));
#endif

#if YYBTYACC
    yyps = yyNewState(0); if (yyps == 0) goto yyenomem;
    yyps->save = 0;
#endif /* YYBTYACC */
    yym = 0;
    yyn = 0;
    yynerrs = 0;
    yyerrflag = 0;
    yychar = YYEMPTY;
    yystate = 0;

#if YYPURE
    memset(&yystack, 0, sizeof(yystack));
#endif

    if (yystack.s_base == NULL && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
    yystack.s_mark = yystack.s_base;
    yystack.l_mark = yystack.l_base;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark = yystack.p_base;
#endif
    yystate = 0;
    *yystack.s_mark = 0;

yyloop:
    if ((yyn = yydefred[yystate]) != 0) goto yyreduce;
    if (yychar < 0)
    {
#if YYBTYACC
        do {
        if (yylvp < yylve)
        {
            /* we're currently re-reading tokens */
            yylval = *yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylloc = *yylpp++;
#endif
            yychar = *yylexp++;
            break;
        }
        if (yyps->save)
        {
            /* in trial mode; save scanner results for future parse attempts */
            if (yylvp == yylvlim)
            {   /* Enlarge lexical value queue */
                size_t p = (size_t) (yylvp - yylvals);
                size_t s = (size_t) (yylvlim - yylvals);

                s += YYLVQUEUEGROWTH;
                if ((yylexemes = (YYINT *)realloc(yylexemes, s * sizeof(YYINT))) == NULL) goto yyenomem;
                if ((yylvals   = (YYSTYPE *)realloc(yylvals, s * sizeof(YYSTYPE))) == NULL) goto yyenomem;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                if ((yylpsns   = (YYLTYPE *)realloc(yylpsns, s * sizeof(YYLTYPE))) == NULL) goto yyenomem;
#endif
                yylvp   = yylve = yylvals + p;
                yylvlim = yylvals + s;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp   = yylpe = yylpsns + p;
                yylplim = yylpsns + s;
#endif
                yylexp  = yylexemes + p;
            }
            *yylexp = (YYINT) YYLEX;
            *yylvp++ = yylval;
            yylve++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            *yylpp++ = yylloc;
            yylpe++;
#endif
            yychar = *yylexp++;
            break;
        }
        /* normal operation, no conflict encountered */
#endif /* YYBTYACC */
        yychar = YYLEX;
#if YYBTYACC
        } while (0);
#endif /* YYBTYACC */
        if (yychar < 0) yychar = YYEOF;
#if YYDEBUG
        if (yydebug)
        {
            if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
            fprintf(stderr, "%s[%d]: state %d, reading token %d (%s)",
                            YYDEBUGSTR, yydepth, yystate, yychar, yys);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
            if (!yytrial)
#endif /* YYBTYACC */
                fprintf(stderr, " <%s>", YYSTYPE_TOSTRING(yychar, yylval));
#endif
            fputc('\n', stderr);
        }
#endif
    }
#if YYBTYACC

    /* Do we have a conflict? */
    if (((yyn = yycindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
        yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
        YYINT ctry;

        if (yypath)
        {
            YYParseState *save;
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%s[%d]: CONFLICT in state %d: following successful trial parse\n",
                                YYDEBUGSTR, yydepth, yystate);
#endif
            /* Switch to the next conflict context */
            save = yypath;
            yypath = save->save;
            save->save = NULL;
            ctry = save->ctry;
            if (save->state != yystate) YYABORT;
            yyFreeState(save);

        }
        else
        {

            /* Unresolved conflict - start/continue trial parse */
            YYParseState *save;
#if YYDEBUG
            if (yydebug)
            {
                fprintf(stderr, "%s[%d]: CONFLICT in state %d. ", YYDEBUGSTR, yydepth, yystate);
                if (yyps->save)
                    fputs("ALREADY in conflict, continuing trial parse.\n", stderr);
                else
                    fputs("Starting trial parse.\n", stderr);
            }
#endif
            save                  = yyNewState((unsigned)(yystack.s_mark - yystack.s_base + 1));
            if (save == NULL) goto yyenomem;
            save->save            = yyps->save;
            save->state           = yystate;
            save->errflag         = yyerrflag;
            save->yystack.s_mark  = save->yystack.s_base + (yystack.s_mark - yystack.s_base);
            memcpy (save->yystack.s_base, yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            save->yystack.l_mark  = save->yystack.l_base + (yystack.l_mark - yystack.l_base);
            memcpy (save->yystack.l_base, yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            save->yystack.p_mark  = save->yystack.p_base + (yystack.p_mark - yystack.p_base);
            memcpy (save->yystack.p_base, yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            ctry                  = yytable[yyn];
            if (yyctable[ctry] == -1)
            {
#if YYDEBUG
                if (yydebug && yychar >= YYEOF)
                    fprintf(stderr, "%s[%d]: backtracking 1 token\n", YYDEBUGSTR, yydepth);
#endif
                ctry++;
            }
            save->ctry = ctry;
            if (yyps->save == NULL)
            {
                /* If this is a first conflict in the stack, start saving lexemes */
                if (!yylexemes)
                {
                    yylexemes = (YYINT *) malloc((YYLVQUEUEGROWTH) * sizeof(YYINT));
                    if (yylexemes == NULL) goto yyenomem;
                    yylvals   = (YYSTYPE *) malloc((YYLVQUEUEGROWTH) * sizeof(YYSTYPE));
                    if (yylvals == NULL) goto yyenomem;
                    yylvlim   = yylvals + YYLVQUEUEGROWTH;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpsns   = (YYLTYPE *) malloc((YYLVQUEUEGROWTH) * sizeof(YYLTYPE));
                    if (yylpsns == NULL) goto yyenomem;
                    yylplim   = yylpsns + YYLVQUEUEGROWTH;
#endif
                }
                if (yylvp == yylve)
                {
                    yylvp  = yylve = yylvals;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpp  = yylpe = yylpsns;
#endif
                    yylexp = yylexemes;
                    if (yychar >= YYEOF)
                    {
                        *yylve++ = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                        *yylpe++ = yylloc;
#endif
                        *yylexp  = (YYINT) yychar;
                        yychar   = YYEMPTY;
                    }
                }
            }
            if (yychar >= YYEOF)
            {
                yylvp--;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp--;
#endif
                yylexp--;
                yychar = YYEMPTY;
            }
            save->lexeme = (int) (yylvp - yylvals);
            yyps->save   = save;
        }
        if (yytable[yyn] == ctry)
        {
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%s[%d]: state %d, shifting to state %d\n",
                                YYDEBUGSTR, yydepth, yystate, yyctable[ctry]);
#endif
            if (yychar < 0)
            {
                yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylpp++;
#endif
                yylexp++;
            }
            if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM)
                goto yyoverflow;
            yystate = yyctable[ctry];
            *++yystack.s_mark = (YYINT) yystate;
            *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            *++yystack.p_mark = yylloc;
#endif
            yychar  = YYEMPTY;
            if (yyerrflag > 0) --yyerrflag;
            goto yyloop;
        }
        else
        {
            yyn = yyctable[ctry];
            goto yyreduce;
        }
    } /* End of code dealing with conflicts */
#endif /* YYBTYACC */
    if (((yyn = yysindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
#if YYDEBUG
        if (yydebug)
            fprintf(stderr, "%s[%d]: state %d, shifting to state %d\n",
                            YYDEBUGSTR, yydepth, yystate, yytable[yyn]);
#endif
        if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
        yystate = yytable[yyn];
        *++yystack.s_mark = yytable[yyn];
        *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        *++yystack.p_mark = yylloc;
#endif
        yychar = YYEMPTY;
        if (yyerrflag > 0)  --yyerrflag;
        goto yyloop;
    }
    if (((yyn = yyrindex[yystate]) != 0) && (yyn += yychar) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yychar)
    {
        yyn = yytable[yyn];
        goto yyreduce;
    }
    if (yyerrflag != 0) goto yyinrecovery;
#if YYBTYACC

    yynewerrflag = 1;
    goto yyerrhandler;
    goto yyerrlab; /* redundant goto avoids 'unused label' warning */

yyerrlab:
    /* explicit YYERROR from an action -- pop the rhs of the rule reduced
     * before looking for error recovery */
    yystack.s_mark -= yym;
    yystate = *yystack.s_mark;
    yystack.l_mark -= yym;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark -= yym;
#endif

    yynewerrflag = 0;
yyerrhandler:
    while (yyps->save)
    {
        int ctry;
        YYParseState *save = yyps->save;
#if YYDEBUG
        if (yydebug)
            fprintf(stderr, "%s[%d]: ERROR in state %d, CONFLICT BACKTRACKING to state %d, %d tokens\n",
                            YYDEBUGSTR, yydepth, yystate, yyps->save->state,
                    (int)(yylvp - yylvals - yyps->save->lexeme));
#endif
        /* Memorize most forward-looking error state in case it's really an error. */
        if (yyerrctx == NULL || yyerrctx->lexeme < yylvp - yylvals)
        {
            /* Free old saved error context state */
            if (yyerrctx) yyFreeState(yyerrctx);
            /* Create and fill out new saved error context state */
            yyerrctx                 = yyNewState((unsigned)(yystack.s_mark - yystack.s_base + 1));
            if (yyerrctx == NULL) goto yyenomem;
            yyerrctx->save           = yyps->save;
            yyerrctx->state          = yystate;
            yyerrctx->errflag        = yyerrflag;
            yyerrctx->yystack.s_mark = yyerrctx->yystack.s_base + (yystack.s_mark - yystack.s_base);
            memcpy (yyerrctx->yystack.s_base, yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            yyerrctx->yystack.l_mark = yyerrctx->yystack.l_base + (yystack.l_mark - yystack.l_base);
            memcpy (yyerrctx->yystack.l_base, yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yyerrctx->yystack.p_mark = yyerrctx->yystack.p_base + (yystack.p_mark - yystack.p_base);
            memcpy (yyerrctx->yystack.p_base, yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            yyerrctx->lexeme         = (int) (yylvp - yylvals);
        }
        yylvp          = yylvals   + save->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        yylpp          = yylpsns   + save->lexeme;
#endif
        yylexp         = yylexemes + save->lexeme;
        yychar         = YYEMPTY;
        yystack.s_mark = yystack.s_base + (save->yystack.s_mark - save->yystack.s_base);
        memcpy (yystack.s_base, save->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
        yystack.l_mark = yystack.l_base + (save->yystack.l_mark - save->yystack.l_base);
        memcpy (yystack.l_base, save->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        yystack.p_mark = yystack.p_base + (save->yystack.p_mark - save->yystack.p_base);
        memcpy (yystack.p_base, save->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
        ctry           = ++save->ctry;
        yystate        = save->state;
        /* We tried shift, try reduce now */
        if ((yyn = yyctable[ctry]) >= 0) goto yyreduce;
        yyps->save     = save->save;
        save->save     = NULL;
        yyFreeState(save);

        /* Nothing left on the stack -- error */
        if (!yyps->save)
        {
#if YYDEBUG
            if (yydebug)
                fprintf(stderr, "%sdebug[%d,trial]: trial parse FAILED, entering ERROR mode\n",
                                YYPREFIX, yydepth);
#endif
            /* Restore state as it was in the most forward-advanced error */
            yylvp          = yylvals   + yyerrctx->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylpp          = yylpsns   + yyerrctx->lexeme;
#endif
            yylexp         = yylexemes + yyerrctx->lexeme;
            yychar         = yylexp[-1];
            yylval         = yylvp[-1];
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yylloc         = yylpp[-1];
#endif
            yystack.s_mark = yystack.s_base + (yyerrctx->yystack.s_mark - yyerrctx->yystack.s_base);
            memcpy (yystack.s_base, yyerrctx->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
            yystack.l_mark = yystack.l_base + (yyerrctx->yystack.l_mark - yyerrctx->yystack.l_base);
            memcpy (yystack.l_base, yyerrctx->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            yystack.p_mark = yystack.p_base + (yyerrctx->yystack.p_mark - yyerrctx->yystack.p_base);
            memcpy (yystack.p_base, yyerrctx->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
            yystate        = yyerrctx->state;
            yyFreeState(yyerrctx);
            yyerrctx       = NULL;
        }
        yynewerrflag = 1;
    }
    if (yynewerrflag == 0) goto yyinrecovery;
#endif /* YYBTYACC */

    YYERROR_CALL("syntax error");
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yyerror_loc_range[1] = yylloc; /* lookahead position is error start position */
#endif

#if !YYBTYACC
    goto yyerrlab; /* redundant goto avoids 'unused label' warning */
yyerrlab:
#endif
    ++yynerrs;

yyinrecovery:
    if (yyerrflag < 3)
    {
        yyerrflag = 3;
        for (;;)
        {
            if (((yyn = yysindex[*yystack.s_mark]) != 0) && (yyn += YYERRCODE) >= 0 &&
                    yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) YYERRCODE)
            {
#if YYDEBUG
                if (yydebug)
                    fprintf(stderr, "%s[%d]: state %d, error recovery shifting to state %d\n",
                                    YYDEBUGSTR, yydepth, *yystack.s_mark, yytable[yyn]);
#endif
                if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
                yystate = yytable[yyn];
                *++yystack.s_mark = yytable[yyn];
                *++yystack.l_mark = yylval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                /* lookahead position is error end position */
                yyerror_loc_range[2] = yylloc;
                YYLLOC_DEFAULT(yyloc, yyerror_loc_range, 2); /* position of error span */
                *++yystack.p_mark = yyloc;
#endif
                goto yyloop;
            }
            else
            {
#if YYDEBUG
                if (yydebug)
                    fprintf(stderr, "%s[%d]: error recovery discarding state %d\n",
                                    YYDEBUGSTR, yydepth, *yystack.s_mark);
#endif
                if (yystack.s_mark <= yystack.s_base) goto yyabort;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                /* the current TOS position is the error start position */
                yyerror_loc_range[1] = *yystack.p_mark;
#endif
#if defined(YYDESTRUCT_CALL)
#if YYBTYACC
                if (!yytrial)
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    YYDESTRUCT_CALL("error: discarding state",
                                    yystos[*yystack.s_mark], yystack.l_mark, yystack.p_mark);
#else
                    YYDESTRUCT_CALL("error: discarding state",
                                    yystos[*yystack.s_mark], yystack.l_mark);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#endif /* defined(YYDESTRUCT_CALL) */
                --yystack.s_mark;
                --yystack.l_mark;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                --yystack.p_mark;
#endif
            }
        }
    }
    else
    {
        if (yychar == YYEOF) goto yyabort;
#if YYDEBUG
        if (yydebug)
        {
            if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
            fprintf(stderr, "%s[%d]: state %d, error recovery discarding token %d (%s)\n",
                            YYDEBUGSTR, yydepth, yystate, yychar, yys);
        }
#endif
#if defined(YYDESTRUCT_CALL)
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
            YYDESTRUCT_CALL("error: discarding token", yychar, &yylval, &yylloc);
#else
            YYDESTRUCT_CALL("error: discarding token", yychar, &yylval);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
#endif /* defined(YYDESTRUCT_CALL) */
        yychar = YYEMPTY;
        goto yyloop;
    }

yyreduce:
    yym = yylen[yyn];
#if YYDEBUG
    if (yydebug)
    {
        fprintf(stderr, "%s[%d]: state %d, reducing by rule %d (%s)",
                        YYDEBUGSTR, yydepth, yystate, yyn, yyrule[yyn]);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
            if (yym > 0)
            {
                int i;
                fputc('<', stderr);
                for (i = yym; i > 0; i--)
                {
                    if (i != yym) fputs(", ", stderr);
                    fputs(YYSTYPE_TOSTRING(yystos[yystack.s_mark[1-i]],
                                           yystack.l_mark[1-i]), stderr);
                }
                fputc('>', stderr);
            }
#endif
        fputc('\n', stderr);
    }
#endif
    if (yym > 0)
        yyval = yystack.l_mark[1-yym];
    else
        memset(&yyval, 0, sizeof yyval);
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)

    /* Perform position reduction */
    memset(&yyloc, 0, sizeof(yyloc));
#if YYBTYACC
    if (!yytrial)
#endif /* YYBTYACC */
    {
        YYLLOC_DEFAULT(yyloc, &yystack.p_mark[-yym], yym);
        /* just in case YYERROR is invoked within the action, save
           the start of the rhs as the error start position */
        yyerror_loc_range[1] = yystack.p_mark[1-yym];
    }
#endif

    switch (yyn)
    {
case 1:
#line 340 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* TODO: Make this an error in C99 mode as well. */
		if (!allow_trad && !allow_c99) {
			/* empty translation unit */
			error(272);
		} else if (allow_c90) {
			/* empty translation unit */
			warning(272);
		}
	  }
#line 1 ""
break;
case 3:
#line 354 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = getsym(yystack.l_mark[0].y_name);
	  }
#line 1 ""
break;
case 4:
#line 361 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		debug_step("cgram: name '%s'", yystack.l_mark[0].y_name->sb_name);
		yyval.y_name = yystack.l_mark[0].y_name;
	  }
#line 1 ""
break;
case 5:
#line 365 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		debug_step("cgram: typename '%s'", yystack.l_mark[0].y_name->sb_name);
		yyval.y_name = yystack.l_mark[0].y_name;
	  }
#line 1 ""
break;
case 7:
#line 374 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_c90) {
			/* concatenated strings are illegal in traditional C */
			warning(219);
		}
		yyval.y_string = cat_strings(yystack.l_mark[-1].y_string, yystack.l_mark[0].y_string);
	  }
#line 1 ""
break;
case 8:
#line 385 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		bool sys_name, sys_next;
		sys_name = in_system_header;
		if (yychar < 0)
			yychar = yylex();
		sys_next = in_system_header;
		in_system_header = sys_name;
		yyval.y_tnode = build_name(getsym(yystack.l_mark[0].y_name), yychar == T_LPAREN);
		in_system_header = sys_next;
	  }
#line 1 ""
break;
case 9:
#line 395 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_constant(gettyp(yystack.l_mark[0].y_val->v_tspec), yystack.l_mark[0].y_val);
	  }
#line 1 ""
break;
case 10:
#line 398 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_string(yystack.l_mark[0].y_string);
	  }
#line 1 ""
break;
case 11:
#line 401 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (yystack.l_mark[-1].y_tnode != NULL)
			yystack.l_mark[-1].y_tnode->tn_parenthesized = true;
		yyval.y_tnode = yystack.l_mark[-1].y_tnode;
	  }
#line 1 ""
break;
case 13:
#line 408 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FMEMBER;
		yyval.y_tnode = build_offsetof(yystack.l_mark[-3].y_type, getsym(yystack.l_mark[-1].y_name));
	  }
#line 1 ""
break;
case 14:
#line 417 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* generic selection requires C11 or later */
		c11ism(345);
		yyval.y_tnode = build_generic_selection(yystack.l_mark[-3].y_tnode, yystack.l_mark[-1].y_generic);
	  }
#line 1 ""
break;
case 16:
#line 427 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yystack.l_mark[0].y_generic->ga_prev = yystack.l_mark[-2].y_generic;
		yyval.y_generic = yystack.l_mark[0].y_generic;
	  }
#line 1 ""
break;
case 17:
#line 435 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_generic = block_zero_alloc(sizeof(*yyval.y_generic));
		yyval.y_generic->ga_arg = yystack.l_mark[-2].y_type;
		yyval.y_generic->ga_result = yystack.l_mark[0].y_tnode;
	  }
#line 1 ""
break;
case 18:
#line 440 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_generic = block_zero_alloc(sizeof(*yyval.y_generic));
		yyval.y_generic->ga_arg = NULL;
		yyval.y_generic->ga_result = yystack.l_mark[0].y_tnode;
	  }
#line 1 ""
break;
case 20:
#line 450 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(INDIR, yystack.l_mark[-2].y_in_system_header, build_binary(yystack.l_mark[-4].y_tnode, PLUS, yystack.l_mark[-2].y_in_system_header, yystack.l_mark[-1].y_tnode));
	  }
#line 1 ""
break;
case 21:
#line 453 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_function_call(yystack.l_mark[-3].y_tnode, yystack.l_mark[-1].y_in_system_header, NULL);
	  }
#line 1 ""
break;
case 22:
#line 456 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_function_call(yystack.l_mark[-4].y_tnode, yystack.l_mark[-2].y_in_system_header, yystack.l_mark[-1].y_tnode);
	  }
#line 1 ""
break;
case 23:
#line 459 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_member_access(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_name);
	  }
#line 1 ""
break;
case 24:
#line 462 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(yystack.l_mark[-1].y_op == INC ? INCAFT : DECAFT, yystack.l_mark[0].y_in_system_header, yystack.l_mark[-2].y_tnode);
	  }
#line 1 ""
break;
case 25:
#line 465 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{	/* C99 6.5.2.5 "Compound literals" */
		sym_t *tmp = mktempsym(yystack.l_mark[-1].y_type);
		begin_initialization(tmp);
		cgram_declare(tmp, true, NULL);
	  }
#line 1 ""
break;
case 26:
#line 469 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_c99)
			 /* compound literals are a C99/GCC extension */
			 gnuism(319);
		yyval.y_tnode = build_name(current_initsym(), false);
		end_initialization();
	  }
#line 1 ""
break;
case 27:
#line 476 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		begin_statement_expr();
	  }
#line 1 ""
break;
case 28:
#line 478 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do_statement_expr(yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 29:
#line 480 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = end_statement_expr();
	  }
#line 1 ""
break;
case 33:
#line 497 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = yystack.l_mark[0].y_tnode;
	  }
#line 1 ""
break;
case 34:
#line 503 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		yyval.y_tnode = NULL;
	  }
#line 1 ""
break;
case 35:
#line 507 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = expr_alloc_tnode();
		yyval.y_tnode->tn_type = gettyp(VOID);
	  }
#line 1 ""
break;
case 36:
#line 511 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (yystack.l_mark[-1].y_tnode == NULL) {	/* in case of syntax errors */
			yyval.y_tnode = expr_alloc_tnode();
			yyval.y_tnode->tn_type = gettyp(VOID);
		} else {
			/* XXX: do that only on the last name */
			if (yystack.l_mark[-1].y_tnode->tn_op == NAME)
				yystack.l_mark[-1].y_tnode->tn_sym->s_used = true;
			expr(yystack.l_mark[-1].y_tnode, false, false, false, false);
			seen_fallthrough = false;
			yyval.y_tnode = yystack.l_mark[-1].y_tnode;
		}
	  }
#line 1 ""
break;
case 37:
#line 527 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FMEMBER;
		yyval.y_op = POINT;
	  }
#line 1 ""
break;
case 38:
#line 531 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FMEMBER;
		yyval.y_op = ARROW;
	  }
#line 1 ""
break;
case 39:
#line 539 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_function_argument(NULL, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 40:
#line 542 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_function_argument(yystack.l_mark[-2].y_tnode, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 42:
#line 550 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(yystack.l_mark[-2].y_op == INC ? INCBEF : DECBEF, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 43:
#line 553 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(ADDR, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 44:
#line 556 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(INDIR, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 45:
#line 559 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_c90 && yystack.l_mark[-2].y_op == PLUS) {
			/* unary '+' is illegal in traditional C */
			warning(100);
		}
		yyval.y_tnode = build_unary(yystack.l_mark[-2].y_op == PLUS ? UPLUS : UMINUS, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 46:
#line 566 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(COMPL, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 47:
#line 569 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_unary(NOT, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 48:
#line 572 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{	/* GCC c_parser_unary_expression */
		yyval.y_tnode = build_unary(REAL, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 49:
#line 575 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{	/* GCC c_parser_unary_expression */
		yyval.y_tnode = build_unary(IMAG, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 50:
#line 578 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{	/* GCC c_parser_unary_expression */
		yyval.y_tnode = yystack.l_mark[0].y_tnode;
	  }
#line 1 ""
break;
case 51:
#line 581 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = yystack.l_mark[0].y_tnode == NULL ? NULL : build_sizeof(yystack.l_mark[0].y_tnode->tn_type);
		if (yyval.y_tnode != NULL)
			check_expr_misc(yystack.l_mark[0].y_tnode,
			    false, false, false, false, false, true);
	  }
#line 1 ""
break;
case 52:
#line 587 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_sizeof(yystack.l_mark[-1].y_type);
	  }
#line 1 ""
break;
case 53:
#line 590 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* non type argument to alignof is a GCC extension */
		gnuism(349);
		lint_assert(yystack.l_mark[0].y_tnode != NULL);
		yyval.y_tnode = build_alignof(yystack.l_mark[0].y_tnode->tn_type);
	  }
#line 1 ""
break;
case 54:
#line 597 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* TODO: c11ism */
		yyval.y_tnode = build_alignof(yystack.l_mark[-1].y_type);
	  }
#line 1 ""
break;
case 56:
#line 608 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = cast(yystack.l_mark[0].y_tnode, yystack.l_mark[-2].y_type);
	  }
#line 1 ""
break;
case 57:
#line 614 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = NULL;
	  }
#line 1 ""
break;
case 60:
#line 633 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, MULT, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 61:
#line 636 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 62:
#line 639 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 63:
#line 642 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 64:
#line 645 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 65:
#line 648 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 66:
#line 651 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, BITAND, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 67:
#line 654 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, BITXOR, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 68:
#line 657 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, BITOR, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 69:
#line 660 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, LOGAND, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 70:
#line 663 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, LOGOR, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 71:
#line 667 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-6].y_tnode, QUEST, yystack.l_mark[-4].y_in_system_header,
		    build_binary(yystack.l_mark[-3].y_tnode, COLON, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode));
	  }
#line 1 ""
break;
case 73:
#line 676 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, ASSIGN, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 74:
#line 679 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, yystack.l_mark[-2].y_op, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 76:
#line 687 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = build_binary(yystack.l_mark[-3].y_tnode, COMMA, yystack.l_mark[-1].y_in_system_header, yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 80:
#line 702 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (dcs->d_scl == TYPEDEF) {
			/* typedef declares no type name */
			warning(72);
		} else {
			/* empty declaration */
			warning(2);
		}
	  }
#line 1 ""
break;
case 81:
#line 711 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (dcs->d_scl == TYPEDEF) {
			/* syntax error '%s' */
			error(249, "missing base type for typedef");
		} else {
			/* old-style declaration; add 'int' */
			error(1);
		}
	  }
#line 1 ""
break;
case 82:
#line 720 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (dcs->d_scl == TYPEDEF) {
			/* typedef declares no type name */
			warning(72);
		} else if (!dcs->d_nonempty_decl) {
			/* empty declaration */
			warning(2);
		}
	  }
#line 1 ""
break;
case 85:
#line 735 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_type(yystack.l_mark[0].y_type);
	  }
#line 1 ""
break;
case 86:
#line 738 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_type(yystack.l_mark[0].y_type);
	  }
#line 1 ""
break;
case 89:
#line 743 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_type(yystack.l_mark[0].y_type);
	  }
#line 1 ""
break;
case 90:
#line 749 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_qualifier(yystack.l_mark[0].y_tqual);
	  }
#line 1 ""
break;
case 91:
#line 752 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_storage_class(yystack.l_mark[0].y_scl);
	  }
#line 1 ""
break;
case 95:
#line 764 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_type(yystack.l_mark[0].y_type);
	  }
#line 1 ""
break;
case 96:
#line 767 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_type(yystack.l_mark[0].y_type);
	  }
#line 1 ""
break;
case 97:
#line 770 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_qualifier(yystack.l_mark[0].y_tqual);
	  }
#line 1 ""
break;
case 98:
#line 773 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_type(yystack.l_mark[0].y_type);
	  }
#line 1 ""
break;
case 100:
#line 780 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = yystack.l_mark[0].y_type;
	  }
#line 1 ""
break;
case 101:
#line 783 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = getsym(yystack.l_mark[0].y_name)->s_type;
	  }
#line 1 ""
break;
case 102:
#line 789 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_qualifier(yystack.l_mark[0].y_tqual);
	  }
#line 1 ""
break;
case 103:
#line 792 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_qualifier(yystack.l_mark[0].y_tqual);
	  }
#line 1 ""
break;
case 104:
#line 798 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_qualifier(yystack.l_mark[0].y_tqual);
	  }
#line 1 ""
break;
case 105:
#line 801 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_storage_class(yystack.l_mark[0].y_scl);
	  }
#line 1 ""
break;
case 116:
#line 826 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_add_packed();
	  }
#line 1 ""
break;
case 118:
#line 833 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_begin_type();
	  }
#line 1 ""
break;
case 119:
#line 839 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_end_type();
	  }
#line 1 ""
break;
case 121:
#line 846 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = getsym(yystack.l_mark[0].y_name)->s_type;
	  }
#line 1 ""
break;
case 122:
#line 852 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = gettyp(yystack.l_mark[0].y_tspec);
	  }
#line 1 ""
break;
case 123:
#line 855 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{	/* GCC extension */
		yyval.y_type = yystack.l_mark[-1].y_tnode != NULL ? block_dup_type(yystack.l_mark[-1].y_tnode->tn_type) : gettyp(INT);
		yyval.y_type->t_typeof = true;
	  }
#line 1 ""
break;
case 125:
#line 860 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		end_declaration_level();
		yyval.y_type = yystack.l_mark[0].y_type;
	  }
#line 1 ""
break;
case 126:
#line 864 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		end_declaration_level();
		yyval.y_type = yystack.l_mark[0].y_type;
	  }
#line 1 ""
break;
case 127:
#line 872 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = yystack.l_mark[-1].y_type;
	  }
#line 1 ""
break;
case 128:
#line 878 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/*
		 * STDC requires that "struct a;" always introduces
		 * a new tag if "a" is not declared at current level
		 *
		 * yychar is valid because otherwise the parser would not
		 * have been able to decide if it must shift or reduce
		 */
		yyval.y_type = make_tag_type(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_tspec, false, yychar == T_SEMI);
	  }
#line 1 ""
break;
case 129:
#line 888 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs->d_tagtyp = make_tag_type(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_tspec, true, false);
	  }
#line 1 ""
break;
case 130:
#line 890 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = complete_tag_struct_or_union(dcs->d_tagtyp, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 131:
#line 893 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs->d_tagtyp = make_tag_type(NULL, yystack.l_mark[0].y_tspec, true, false);
	  }
#line 1 ""
break;
case 132:
#line 895 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = complete_tag_struct_or_union(dcs->d_tagtyp, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 133:
#line 898 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		yyval.y_type = gettyp(INT);
	  }
#line 1 ""
break;
case 134:
#line 905 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FTAG;
		begin_declaration_level(yystack.l_mark[0].y_tspec == STRUCT
		    ? DK_STRUCT_MEMBER
		    : DK_UNION_MEMBER);
		dcs->d_offset_in_bits = 0;
		dcs->d_sou_align_in_bits = CHAR_SIZE;
		yyval.y_tspec = yystack.l_mark[0].y_tspec;
	  }
#line 1 ""
break;
case 136:
#line 918 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[0].y_sym;
	  }
#line 1 ""
break;
case 137:
#line 924 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
	  }
#line 1 ""
break;
case 139:
#line 931 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* XXX: This is not allowed by any C standard. */
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 141:
#line 939 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = concat_lists(yystack.l_mark[-1].y_sym, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 142:
#line 945 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* ^^ There is no check for the missing type-specifier. */
		/* too late, i know, but getsym() compensates it */
		symtyp = FMEMBER;
	  }
#line 1 ""
break;
case 143:
#line 949 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		yyval.y_sym = yystack.l_mark[-2].y_sym;
	  }
#line 1 ""
break;
case 144:
#line 953 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FMEMBER;
	  }
#line 1 ""
break;
case 145:
#line 955 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		yyval.y_sym = yystack.l_mark[-2].y_sym;
	  }
#line 1 ""
break;
case 146:
#line 959 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* syntax error '%s' */
		error(249, "member without type");
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 147:
#line 965 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		if (!allow_c11 && !allow_gcc)
			/* anonymous struct/union members is a C11 feature */
			warning(49);
		if (is_struct_or_union(dcs->d_type->t_tspec)) {
			yyval.y_sym = dcs->d_type->t_sou->sou_first_member;
			/* add all the members of the anonymous struct/union */
			anonymize(yyval.y_sym);
		} else {
			/* syntax error '%s' */
			error(249, "unnamed member");
			yyval.y_sym = NULL;
		}
	  }
#line 1 ""
break;
case 148:
#line 980 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 149:
#line 983 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 150:
#line 990 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_1_struct_union(yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 151:
#line 993 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FMEMBER;
	  }
#line 1 ""
break;
case 152:
#line 995 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = concat_lists(yystack.l_mark[-3].y_sym, declarator_1_struct_union(yystack.l_mark[0].y_sym));
	  }
#line 1 ""
break;
case 153:
#line 1001 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_1_struct_union(yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 154:
#line 1004 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FMEMBER;
	  }
#line 1 ""
break;
case 155:
#line 1006 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = concat_lists(yystack.l_mark[-3].y_sym, declarator_1_struct_union(yystack.l_mark[0].y_sym));
	  }
#line 1 ""
break;
case 157:
#line 1013 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{	/* C99 6.7.2.1 */
		yyval.y_sym = set_bit_field_width(yystack.l_mark[-2].y_sym, to_int_constant(yystack.l_mark[0].y_tnode, true));
	  }
#line 1 ""
break;
case 158:
#line 1016 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
	  }
#line 1 ""
break;
case 159:
#line 1018 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{			/* C99 6.7.2.1 */
		yyval.y_sym = set_bit_field_width(NULL, to_int_constant(yystack.l_mark[0].y_tnode, true));
	  }
#line 1 ""
break;
case 161:
#line 1025 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = set_bit_field_width(yystack.l_mark[-2].y_sym, to_int_constant(yystack.l_mark[0].y_tnode, true));
	  }
#line 1 ""
break;
case 162:
#line 1028 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
	  }
#line 1 ""
break;
case 163:
#line 1030 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = set_bit_field_width(NULL, to_int_constant(yystack.l_mark[0].y_tnode, true));
	  }
#line 1 ""
break;
case 164:
#line 1037 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = make_tag_type(yystack.l_mark[0].y_sym, ENUM, false, false);
	  }
#line 1 ""
break;
case 165:
#line 1040 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs->d_tagtyp = make_tag_type(yystack.l_mark[0].y_sym, ENUM, true, false);
	  }
#line 1 ""
break;
case 166:
#line 1042 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = complete_tag_enum(dcs->d_tagtyp, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 167:
#line 1045 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs->d_tagtyp = make_tag_type(NULL, ENUM, true, false);
	  }
#line 1 ""
break;
case 168:
#line 1047 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_type = complete_tag_enum(dcs->d_tagtyp, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 169:
#line 1050 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		yyval.y_type = gettyp(INT);
	  }
#line 1 ""
break;
case 170:
#line 1057 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FTAG;
		begin_declaration_level(DK_ENUM_CONSTANT);
	  }
#line 1 ""
break;
case 171:
#line 1064 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 172:
#line 1070 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
		enumval = 0;
	  }
#line 1 ""
break;
case 174:
#line 1078 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_c99 && !allow_trad) {
			/* trailing ',' prohibited in enum declaration */
			error(54);
		} else {
			/* trailing ',' prohibited in enum declaration */
			c99ism(54);
		}
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 176:
#line 1092 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = concat_lists(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 177:
#line 1095 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 178:
#line 1101 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = enumeration_constant(yystack.l_mark[-1].y_sym, enumval, true);
	  }
#line 1 ""
break;
case 179:
#line 1105 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = enumeration_constant(yystack.l_mark[-3].y_sym, to_int_constant(yystack.l_mark[0].y_tnode, true),
		    false);
	  }
#line 1 ""
break;
case 181:
#line 1113 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tqual = ATOMIC;
	  }
#line 1 ""
break;
case 182:
#line 1119 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* TODO: First fix c11ism, then use it here. */
		if (!allow_c11)
			/* '_Atomic' requires C11 or later */
			error(350);
	  }
#line 1 ""
break;
case 183:
#line 1128 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_qual_ptr = merge_qualified_pointer(yystack.l_mark[-1].y_qual_ptr, yystack.l_mark[0].y_qual_ptr);
	  }
#line 1 ""
break;
case 184:
#line 1131 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_qual_ptr = merge_qualified_pointer(yystack.l_mark[-2].y_qual_ptr, yystack.l_mark[-1].y_qual_ptr);
		yyval.y_qual_ptr = merge_qualified_pointer(yyval.y_qual_ptr, yystack.l_mark[0].y_qual_ptr);
	  }
#line 1 ""
break;
case 185:
#line 1138 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_qual_ptr = xcalloc(1, sizeof(*yyval.y_qual_ptr));
		yyval.y_qual_ptr->p_pointer = true;
	  }
#line 1 ""
break;
case 186:
#line 1145 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_qual_ptr = NULL;
	  }
#line 1 ""
break;
case 189:
#line 1153 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_qual_ptr = merge_qualified_pointer(yystack.l_mark[-1].y_qual_ptr, yystack.l_mark[0].y_qual_ptr);
	  }
#line 1 ""
break;
case 190:
#line 1159 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_qual_ptr = xcalloc(1, sizeof(*yyval.y_qual_ptr));
		if (yystack.l_mark[0].y_tqual == CONST)
			yyval.y_qual_ptr->p_const = true;
		if (yystack.l_mark[0].y_tqual == VOLATILE)
			yyval.y_qual_ptr->p_volatile = true;
	  }
#line 1 ""
break;
case 195:
#line 1184 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		cgram_declare(yystack.l_mark[-1].y_sym, false, yystack.l_mark[0].y_name);
		check_size(yystack.l_mark[-1].y_sym);
	  }
#line 1 ""
break;
case 196:
#line 1188 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		begin_initialization(yystack.l_mark[-1].y_sym);
		cgram_declare(yystack.l_mark[-1].y_sym, true, yystack.l_mark[0].y_name);
	  }
#line 1 ""
break;
case 197:
#line 1191 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		check_size(yystack.l_mark[-4].y_sym);
		end_initialization();
	  }
#line 1 ""
break;
case 198:
#line 1198 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		cgram_declare(yystack.l_mark[-1].y_sym, false, yystack.l_mark[0].y_name);
		check_size(yystack.l_mark[-1].y_sym);
	  }
#line 1 ""
break;
case 199:
#line 1202 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		begin_initialization(yystack.l_mark[-1].y_sym);
		cgram_declare(yystack.l_mark[-1].y_sym, true, yystack.l_mark[0].y_name);
	  }
#line 1 ""
break;
case 200:
#line 1205 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		check_size(yystack.l_mark[-4].y_sym);
		end_initialization();
	  }
#line 1 ""
break;
case 202:
#line 1213 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_qual_ptr);
	  }
#line 1 ""
break;
case 204:
#line 1220 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_qual_ptr);
	  }
#line 1 ""
break;
case 205:
#line 1226 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_name(getsym(yystack.l_mark[0].y_name));
	  }
#line 1 ""
break;
case 206:
#line 1229 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 207:
#line 1232 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_array(yystack.l_mark[-3].y_sym, yystack.l_mark[-1].y_array_size.has_dim, yystack.l_mark[-1].y_array_size.dim);
	  }
#line 1 ""
break;
case 208:
#line 1235 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_function(symbolrename(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_name), yystack.l_mark[-1].y_sym);
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 210:
#line 1244 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_name(getsym(yystack.l_mark[0].y_name));
	  }
#line 1 ""
break;
case 211:
#line 1247 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 212:
#line 1250 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_array(yystack.l_mark[-3].y_sym, yystack.l_mark[-1].y_array_size.has_dim, yystack.l_mark[-1].y_array_size.dim);
	  }
#line 1 ""
break;
case 213:
#line 1253 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_function(symbolrename(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_name), yystack.l_mark[-1].y_sym);
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 216:
#line 1270 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_qual_ptr);
	  }
#line 1 ""
break;
case 218:
#line 1277 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_qual_ptr);
	  }
#line 1 ""
break;
case 219:
#line 1283 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_name(getsym(yystack.l_mark[-1].y_name));
	  }
#line 1 ""
break;
case 220:
#line 1286 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_name(getsym(yystack.l_mark[0].y_name));
	  }
#line 1 ""
break;
case 221:
#line 1289 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 222:
#line 1293 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_array(yystack.l_mark[-4].y_sym, yystack.l_mark[-2].y_array_size.has_dim, yystack.l_mark[-2].y_array_size.dim);
	  }
#line 1 ""
break;
case 223:
#line 1296 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_function(symbolrename(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_name), yystack.l_mark[-1].y_sym);
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 224:
#line 1304 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declarator_name(getsym(yystack.l_mark[0].y_name));
	  }
#line 1 ""
break;
case 225:
#line 1307 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 226:
#line 1310 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_array(yystack.l_mark[-3].y_sym, yystack.l_mark[-1].y_array_size.has_dim, yystack.l_mark[-1].y_array_size.dim);
	  }
#line 1 ""
break;
case 227:
#line 1313 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_function(symbolrename(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_name), yystack.l_mark[-1].y_sym);
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 228:
#line 1321 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 230:
#line 1328 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		block_level++;
		begin_declaration_level(DK_PROTO_ARG);
	  }
#line 1 ""
break;
case 231:
#line 1335 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_array_size.has_dim = false;
		yyval.y_array_size.dim = 0;
	  }
#line 1 ""
break;
case 232:
#line 1339 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* since C99; variable length array of unspecified size */
		yyval.y_array_size.has_dim = false; /* TODO: maybe change to true */
		yyval.y_array_size.dim = 0;	/* just as a placeholder */
	  }
#line 1 ""
break;
case 233:
#line 1344 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_array_size.has_dim = true;
		yyval.y_array_size.dim = yystack.l_mark[0].y_tnode == NULL ? 0 : to_int_constant(yystack.l_mark[0].y_tnode, false);
	  }
#line 1 ""
break;
case 234:
#line 1351 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* C11 6.7.6.3p7 */
		if (yystack.l_mark[-1].y_scl != STATIC)
			yyerror("Bad attribute");
		/* static array size is a C11 extension */
		c11ism(343);
		yyval.y_tnode = yystack.l_mark[0].y_tnode;
	  }
#line 1 ""
break;
case 235:
#line 1359 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* C11 6.7.6.2 */
		if (yystack.l_mark[0].y_tqual != RESTRICT)
			yyerror("Bad attribute");
		yyval.y_tnode = NULL;
	  }
#line 1 ""
break;
case 237:
#line 1369 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = old_style_function_name(getsym(yystack.l_mark[0].y_name));
	  }
#line 1 ""
break;
case 238:
#line 1372 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = concat_lists(yystack.l_mark[-2].y_sym, old_style_function_name(getsym(yystack.l_mark[0].y_name)));
	  }
#line 1 ""
break;
case 240:
#line 1380 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		begin_declaration_level(DK_ABSTRACT);
	  }
#line 1 ""
break;
case 241:
#line 1382 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		end_declaration_level();
		yyval.y_type = yystack.l_mark[0].y_sym->s_type;
	  }
#line 1 ""
break;
case 242:
#line 1389 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_1_abstract(abstract_name());
	  }
#line 1 ""
break;
case 243:
#line 1392 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_1_abstract(abstract_name());
	  }
#line 1 ""
break;
case 244:
#line 1395 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_1_abstract(yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 245:
#line 1398 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_1_abstract(yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 246:
#line 1406 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(abstract_name(), yystack.l_mark[0].y_qual_ptr);
	  }
#line 1 ""
break;
case 248:
#line 1410 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(yystack.l_mark[0].y_sym, yystack.l_mark[-1].y_qual_ptr);
	  }
#line 1 ""
break;
case 249:
#line 1413 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[0].y_sym;
	  }
#line 1 ""
break;
case 250:
#line 1416 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_pointer(yystack.l_mark[0].y_sym, yystack.l_mark[-2].y_qual_ptr);
	  }
#line 1 ""
break;
case 251:
#line 1424 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[-1].y_sym;
	  }
#line 1 ""
break;
case 252:
#line 1427 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_array(abstract_name(), yystack.l_mark[-1].y_array_size.has_dim, yystack.l_mark[-1].y_array_size.dim);
	  }
#line 1 ""
break;
case 253:
#line 1430 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_array(yystack.l_mark[-3].y_sym, yystack.l_mark[-1].y_array_size.has_dim, yystack.l_mark[-1].y_array_size.dim);
	  }
#line 1 ""
break;
case 254:
#line 1433 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_function(symbolrename(abstract_name(), yystack.l_mark[0].y_name), yystack.l_mark[-1].y_sym);
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 255:
#line 1439 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = add_function(symbolrename(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_name), yystack.l_mark[-1].y_sym);
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 257:
#line 1448 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 258:
#line 1452 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs->d_proto = true;
		yyval.y_sym = yystack.l_mark[-2].y_sym;
	  }
#line 1 ""
break;
case 259:
#line 1456 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 260:
#line 1462 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		block_level++;
		begin_declaration_level(DK_PROTO_ARG);
	  }
#line 1 ""
break;
case 262:
#line 1470 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs->d_vararg = true;
		yyval.y_sym = yystack.l_mark[-2].y_sym;
	  }
#line 1 ""
break;
case 263:
#line 1474 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* TODO: C99 6.7.5 makes this an error as well. */
		if (!allow_trad && !allow_c99) {
			/* ANSI C requires formal parameter before '...' */
			error(84);
		} else if (allow_c90) {
			/* ANSI C requires formal parameter before '...' */
			warning(84);
		}
		dcs->d_vararg = true;
		yyval.y_sym = NULL;
	  }
#line 1 ""
break;
case 265:
#line 1491 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = concat_lists(yystack.l_mark[-2].y_sym, yystack.l_mark[0].y_sym);
	  }
#line 1 ""
break;
case 266:
#line 1498 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* ^^ There is no check for the missing type-specifier. */
		yyval.y_sym = declare_argument(abstract_name(), false);
	  }
#line 1 ""
break;
case 267:
#line 1502 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_argument(abstract_name(), false);
	  }
#line 1 ""
break;
case 268:
#line 1505 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* ^^ There is no check for the missing type-specifier. */
		yyval.y_sym = declare_argument(yystack.l_mark[0].y_sym, false);
	  }
#line 1 ""
break;
case 269:
#line 1516 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_argument(yystack.l_mark[0].y_sym, false);
	  }
#line 1 ""
break;
case 270:
#line 1519 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* ^^ There is no check for the missing type-specifier. */
		yyval.y_sym = declare_argument(yystack.l_mark[0].y_sym, false);
	  }
#line 1 ""
break;
case 271:
#line 1523 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = declare_argument(yystack.l_mark[0].y_sym, false);
	  }
#line 1 ""
break;
case 272:
#line 1529 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		init_expr(yystack.l_mark[0].y_tnode);
	  }
#line 1 ""
break;
case 273:
#line 1532 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* XXX: Empty braces are not covered by C99 6.7.8. */
	  }
#line 1 ""
break;
case 281:
#line 1552 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* GCC style struct or union member name in initializer */
		gnuism(315);
		begin_designation();
		add_designator_member(yystack.l_mark[-1].y_name);
	  }
#line 1 ""
break;
case 282:
#line 1561 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		begin_designation();
	  }
#line 1 ""
break;
case 285:
#line 1572 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_c99)
			/* array initializer with designators is a C99 ... */
			warning(321);
		add_designator_subscript(yystack.l_mark[-1].y_range);
	  }
#line 1 ""
break;
case 286:
#line 1578 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_c99)
			/* struct or union member name in initializer is ... */
			warning(313);
		add_designator_member(yystack.l_mark[0].y_name);
	  }
#line 1 ""
break;
case 289:
#line 1592 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_range.lo = to_int_constant(yystack.l_mark[0].y_tnode, true);
		yyval.y_range.hi = yyval.y_range.lo;
	  }
#line 1 ""
break;
case 290:
#line 1596 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_range.lo = to_int_constant(yystack.l_mark[-2].y_tnode, true);
		yyval.y_range.hi = to_int_constant(yystack.l_mark[0].y_tnode, true);
		/* initialization with '[a...b]' is a GCC extension */
		gnuism(340);
	  }
#line 1 ""
break;
case 291:
#line 1605 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		init_lbrace();
	  }
#line 1 ""
break;
case 292:
#line 1611 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		init_rbrace();
	  }
#line 1 ""
break;
case 293:
#line 1617 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_name = NULL;
	  }
#line 1 ""
break;
case 294:
#line 1620 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		freeyyv(&yystack.l_mark[-2].y_string, T_STRING);
		yyval.y_name = NULL;
	  }
#line 1 ""
break;
case 295:
#line 1625 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_name = yystack.l_mark[-2].y_name;
	  }
#line 1 ""
break;
case 303:
#line 1641 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		seen_fallthrough = false;
	  }
#line 1 ""
break;
case 306:
#line 1652 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FLABEL;
		named_label(getsym(yystack.l_mark[-1].y_name));
	  }
#line 1 ""
break;
case 307:
#line 1656 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		case_label(yystack.l_mark[-1].y_tnode);
		seen_fallthrough = true;
	  }
#line 1 ""
break;
case 308:
#line 1660 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* XXX: We don't fill all cases */
		case_label(yystack.l_mark[-3].y_tnode);
		seen_fallthrough = true;
	  }
#line 1 ""
break;
case 309:
#line 1665 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		default_label();
		seen_fallthrough = true;
	  }
#line 1 ""
break;
case 312:
#line 1677 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		block_level++;
		mem_block_level++;
		begin_declaration_level(DK_AUTO);
	  }
#line 1 ""
break;
case 313:
#line 1685 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		end_declaration_level();
		level_free_all(mem_block_level);
		mem_block_level--;
		block_level--;
		seen_fallthrough = false;
	  }
#line 1 ""
break;
case 315:
#line 1696 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (yystack.l_mark[-1].y_seen_statement && !yystack.l_mark[0].y_seen_statement)
			/* declarations after statements is a C99 feature */
			c99ism(327);
		yyval.y_seen_statement = yystack.l_mark[-1].y_seen_statement || yystack.l_mark[0].y_seen_statement;
	  }
#line 1 ""
break;
case 316:
#line 1705 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_seen_statement = false;
		restore_warning_flags();
	  }
#line 1 ""
break;
case 317:
#line 1709 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_seen_statement = true;
		restore_warning_flags();
	  }
#line 1 ""
break;
case 318:
#line 1716 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		expr(yystack.l_mark[-1].y_tnode, false, false, false, false);
		seen_fallthrough = false;
	  }
#line 1 ""
break;
case 319:
#line 1720 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		check_statement_reachable();
		seen_fallthrough = false;
	  }
#line 1 ""
break;
case 320:
#line 1727 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		save_warning_flags();
		if2();
		if3(false);
	  }
#line 1 ""
break;
case 321:
#line 1732 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		save_warning_flags();
		if2();
	  }
#line 1 ""
break;
case 322:
#line 1735 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		if3(true);
	  }
#line 1 ""
break;
case 323:
#line 1739 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		if3(false);
	  }
#line 1 ""
break;
case 324:
#line 1743 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		switch2();
	  }
#line 1 ""
break;
case 325:
#line 1747 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		switch2();
	  }
#line 1 ""
break;
case 328:
#line 1759 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if1(yystack.l_mark[-1].y_tnode);
		clear_warning_flags();
	  }
#line 1 ""
break;
case 329:
#line 1766 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		switch1(yystack.l_mark[-1].y_tnode);
		clear_warning_flags();
	  }
#line 1 ""
break;
case 330:
#line 1773 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		while2();
	  }
#line 1 ""
break;
case 331:
#line 1777 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		while2();
	  }
#line 1 ""
break;
case 332:
#line 1781 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do2(yystack.l_mark[0].y_tnode);
		seen_fallthrough = false;
	  }
#line 1 ""
break;
case 333:
#line 1785 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		do2(NULL);
	  }
#line 1 ""
break;
case 334:
#line 1789 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		for2();
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 335:
#line 1795 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
		for2();
		end_declaration_level();
		block_level--;
	  }
#line 1 ""
break;
case 336:
#line 1804 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		while1(yystack.l_mark[-1].y_tnode);
		clear_warning_flags();
	  }
#line 1 ""
break;
case 337:
#line 1811 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		clear_warning_flags();
	  }
#line 1 ""
break;
case 338:
#line 1817 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do1();
	  }
#line 1 ""
break;
case 339:
#line 1823 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_tnode = yystack.l_mark[-2].y_tnode;
	  }
#line 1 ""
break;
case 340:
#line 1829 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		begin_declaration_level(DK_AUTO);
		block_level++;
	  }
#line 1 ""
break;
case 341:
#line 1840 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* variable declaration in for loop */
		c99ism(325);
		for1(NULL, yystack.l_mark[-3].y_tnode, yystack.l_mark[-1].y_tnode);
		clear_warning_flags();
	    }
#line 1 ""
break;
case 342:
#line 1849 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		for1(yystack.l_mark[-5].y_tnode, yystack.l_mark[-3].y_tnode, yystack.l_mark[-1].y_tnode);
		clear_warning_flags();
	  }
#line 1 ""
break;
case 343:
#line 1856 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do_goto(getsym(yystack.l_mark[-1].y_name));
	  }
#line 1 ""
break;
case 344:
#line 1859 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FVFT;
	  }
#line 1 ""
break;
case 345:
#line 1862 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do_continue();
	  }
#line 1 ""
break;
case 346:
#line 1865 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do_break();
	  }
#line 1 ""
break;
case 347:
#line 1868 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do_return(yystack.l_mark[-1].y_in_system_header, NULL);
	  }
#line 1 ""
break;
case 348:
#line 1871 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		do_return(yystack.l_mark[-2].y_in_system_header, yystack.l_mark[-1].y_tnode);
	  }
#line 1 ""
break;
case 349:
#line 1877 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		symtyp = FLABEL;
	  }
#line 1 ""
break;
case 350:
#line 1883 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_set_asm();
	  }
#line 1 ""
break;
case 351:
#line 1886 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		dcs_set_asm();
	  }
#line 1 ""
break;
case 353:
#line 1893 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		read_until_rparen();
	  }
#line 1 ""
break;
case 356:
#line 1904 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		global_clean_up_decl(false);
		clear_warning_flags();
	  }
#line 1 ""
break;
case 357:
#line 1908 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		global_clean_up_decl(false);
		clear_warning_flags();
	  }
#line 1 ""
break;
case 359:
#line 1913 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{		/* GCC extension */
		/*
		 * TODO: Only allow this in GCC mode, not in plain C99.
		 * This is one of the top 10 warnings in the NetBSD build.
		 */
		if (!allow_trad && !allow_c99) {
			/* empty declaration */
			error(0);
		} else if (allow_c90) {
			/* empty declaration */
			warning(0);
		}
	  }
#line 1 ""
break;
case 360:
#line 1938 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* TODO: Make this an error in C99 mode as well. */
		if (!allow_trad && !allow_c99) {
			/* old-style declaration; add 'int' */
			error(1);
		} else if (allow_c90) {
			/* old-style declaration; add 'int' */
			warning(1);
		}
	  }
#line 1 ""
break;
case 362:
#line 1949 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		global_clean_up();
	  }
#line 1 ""
break;
case 363:
#line 1952 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		global_clean_up();
	  }
#line 1 ""
break;
case 364:
#line 1958 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (yystack.l_mark[0].y_sym->s_type->t_tspec != FUNC) {
			/* syntax error '%s' */
			error(249, yytext);
			YYERROR;
		}
		if (yystack.l_mark[0].y_sym->s_type->t_typedef) {
			/* ()-less function definition */
			error(64);
			YYERROR;
		}
		begin_function(yystack.l_mark[0].y_sym);
		block_level++;
		begin_declaration_level(DK_OLD_STYLE_ARG);
		if (lwarn == LWARN_NONE)
			yystack.l_mark[0].y_sym->s_used = true;
	  }
#line 1 ""
break;
case 365:
#line 1974 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		end_declaration_level();
		block_level--;
		check_func_lint_directives();
		check_func_old_style_arguments();
		begin_control_statement(CS_FUNCTION_BODY);
	  }
#line 1 ""
break;
case 366:
#line 1980 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		end_function();
		end_control_statement(CS_FUNCTION_BODY);
	  }
#line 1 ""
break;
case 367:
#line 1987 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_trad) {
			/* old-style declaration; add 'int' */
			error(1);
		}
		yyval.y_sym = yystack.l_mark[0].y_sym;
	  }
#line 1 ""
break;
case 368:
#line 1994 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!allow_trad) {
			/* old-style declaration; add 'int' */
			error(1);
		}
		yyval.y_sym = yystack.l_mark[0].y_sym;
	  }
#line 1 ""
break;
case 369:
#line 2001 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_sym = yystack.l_mark[0].y_sym;
	  }
#line 1 ""
break;
case 375:
#line 2023 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		/* empty declaration */
		warning(2);
	  }
#line 1 ""
break;
case 377:
#line 2028 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (!dcs->d_nonempty_decl) {
			/* empty declaration */
			warning(2);
		} else {
			/* '%s' declared in argument declaration list */
			warning(3, type_name(dcs->d_type));
		}
	  }
#line 1 ""
break;
case 378:
#line 2038 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (dcs->d_nonempty_decl) {
			/* '%s' declared in argument declaration list */
			warning(3, type_name(dcs->d_type));
		}
	  }
#line 1 ""
break;
case 385:
#line 2060 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		in_gcc_attribute = true;
	  }
#line 1 ""
break;
case 386:
#line 2062 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		in_gcc_attribute = false;
	  }
#line 1 ""
break;
case 391:
#line 2074 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		const char *name = yystack.l_mark[0].y_name->sb_name;
		if (is_either(name, "packed", "__packed__"))
			dcs_add_packed();
		else if (is_either(name, "used", "__used__") ||
		    is_either(name, "unused", "__unused__"))
			dcs_set_used();
		else if (is_either(name, "fallthrough", "__fallthrough__"))
			fallthru(1);
	}
#line 1 ""
break;
case 394:
#line 2086 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		if (yystack.l_mark[0].y_tqual != CONST)
			yyerror("Bad attribute");
	  }
#line 1 ""
break;
case 397:
#line 2098 "/Users/sidqian/Downloads/summer/L2S/netbsd-src/tools/lint1/../../usr.bin/xlint/lint1/cgram.y"
	{
		yyval.y_in_system_header = in_system_header;
	  }
#line 1 ""
break;
#line 5580 "cgram.c"
    default:
        break;
    }
    yystack.s_mark -= yym;
    yystate = *yystack.s_mark;
    yystack.l_mark -= yym;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark -= yym;
#endif
    yym = yylhs[yyn];
    if (yystate == 0 && yym == 0)
    {
#if YYDEBUG
        if (yydebug)
        {
            fprintf(stderr, "%s[%d]: after reduction, ", YYDEBUGSTR, yydepth);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
            if (!yytrial)
#endif /* YYBTYACC */
                fprintf(stderr, "result is <%s>, ", YYSTYPE_TOSTRING(yystos[YYFINAL], yyval));
#endif
            fprintf(stderr, "shifting from state 0 to final state %d\n", YYFINAL);
        }
#endif
        yystate = YYFINAL;
        *++yystack.s_mark = YYFINAL;
        *++yystack.l_mark = yyval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        *++yystack.p_mark = yyloc;
#endif
        if (yychar < 0)
        {
#if YYBTYACC
            do {
            if (yylvp < yylve)
            {
                /* we're currently re-reading tokens */
                yylval = *yylvp++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                yylloc = *yylpp++;
#endif
                yychar = *yylexp++;
                break;
            }
            if (yyps->save)
            {
                /* in trial mode; save scanner results for future parse attempts */
                if (yylvp == yylvlim)
                {   /* Enlarge lexical value queue */
                    size_t p = (size_t) (yylvp - yylvals);
                    size_t s = (size_t) (yylvlim - yylvals);

                    s += YYLVQUEUEGROWTH;
                    if ((yylexemes = (YYINT *)realloc(yylexemes, s * sizeof(YYINT))) == NULL)
                        goto yyenomem;
                    if ((yylvals   = (YYSTYPE *)realloc(yylvals, s * sizeof(YYSTYPE))) == NULL)
                        goto yyenomem;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    if ((yylpsns   = (YYLTYPE *)realloc(yylpsns, s * sizeof(YYLTYPE))) == NULL)
                        goto yyenomem;
#endif
                    yylvp   = yylve = yylvals + p;
                    yylvlim = yylvals + s;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                    yylpp   = yylpe = yylpsns + p;
                    yylplim = yylpsns + s;
#endif
                    yylexp  = yylexemes + p;
                }
                *yylexp = (YYINT) YYLEX;
                *yylvp++ = yylval;
                yylve++;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
                *yylpp++ = yylloc;
                yylpe++;
#endif
                yychar = *yylexp++;
                break;
            }
            /* normal operation, no conflict encountered */
#endif /* YYBTYACC */
            yychar = YYLEX;
#if YYBTYACC
            } while (0);
#endif /* YYBTYACC */
            if (yychar < 0) yychar = YYEOF;
#if YYDEBUG
            if (yydebug)
            {
                if ((yys = yyname[YYTRANSLATE(yychar)]) == NULL) yys = yyname[YYUNDFTOKEN];
                fprintf(stderr, "%s[%d]: state %d, reading token %d (%s)\n",
                                YYDEBUGSTR, yydepth, YYFINAL, yychar, yys);
            }
#endif
        }
        if (yychar == YYEOF) goto yyaccept;
        goto yyloop;
    }
    if (((yyn = yygindex[yym]) != 0) && (yyn += yystate) >= 0 &&
            yyn <= YYTABLESIZE && yycheck[yyn] == (YYINT) yystate)
        yystate = yytable[yyn];
    else
        yystate = yydgoto[yym];
#if YYDEBUG
    if (yydebug)
    {
        fprintf(stderr, "%s[%d]: after reduction, ", YYDEBUGSTR, yydepth);
#ifdef YYSTYPE_TOSTRING
#if YYBTYACC
        if (!yytrial)
#endif /* YYBTYACC */
            fprintf(stderr, "result is <%s>, ", YYSTYPE_TOSTRING(yystos[yystate], yyval));
#endif
        fprintf(stderr, "shifting from state %d to state %d\n", *yystack.s_mark, yystate);
    }
#endif
    if (yystack.s_mark >= yystack.s_last && yygrowstack(&yystack) == YYENOMEM) goto yyoverflow;
    *++yystack.s_mark = (YYINT) yystate;
    *++yystack.l_mark = yyval;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    *++yystack.p_mark = yyloc;
#endif
    goto yyloop;
#if YYBTYACC

    /* Reduction declares that this path is valid. Set yypath and do a full parse */
yyvalid:
    if (yypath) YYABORT;
    while (yyps->save)
    {
        YYParseState *save = yyps->save;
        yyps->save = save->save;
        save->save = yypath;
        yypath = save;
    }
#if YYDEBUG
    if (yydebug)
        fprintf(stderr, "%s[%d]: state %d, CONFLICT trial successful, backtracking to state %d, %d tokens\n",
                        YYDEBUGSTR, yydepth, yystate, yypath->state, (int)(yylvp - yylvals - yypath->lexeme));
#endif
    if (yyerrctx)
    {
        yyFreeState(yyerrctx);
        yyerrctx = NULL;
    }
    yylvp          = yylvals + yypath->lexeme;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yylpp          = yylpsns + yypath->lexeme;
#endif
    yylexp         = yylexemes + yypath->lexeme;
    yychar         = YYEMPTY;
    yystack.s_mark = yystack.s_base + (yypath->yystack.s_mark - yypath->yystack.s_base);
    memcpy (yystack.s_base, yypath->yystack.s_base, (size_t) (yystack.s_mark - yystack.s_base + 1) * sizeof(YYINT));
    yystack.l_mark = yystack.l_base + (yypath->yystack.l_mark - yypath->yystack.l_base);
    memcpy (yystack.l_base, yypath->yystack.l_base, (size_t) (yystack.l_mark - yystack.l_base + 1) * sizeof(YYSTYPE));
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
    yystack.p_mark = yystack.p_base + (yypath->yystack.p_mark - yypath->yystack.p_base);
    memcpy (yystack.p_base, yypath->yystack.p_base, (size_t) (yystack.p_mark - yystack.p_base + 1) * sizeof(YYLTYPE));
#endif
    yystate        = yypath->state;
    goto yyloop;
#endif /* YYBTYACC */

yyoverflow:
    YYERROR_CALL("yacc stack overflow");
#if YYBTYACC
    goto yyabort_nomem;
yyenomem:
    YYERROR_CALL("memory exhausted");
yyabort_nomem:
#endif /* YYBTYACC */
    yyresult = 2;
    goto yyreturn;

yyabort:
    yyresult = 1;
    goto yyreturn;

yyaccept:
#if YYBTYACC
    if (yyps->save) goto yyvalid;
#endif /* YYBTYACC */
    yyresult = 0;

yyreturn:
#if defined(YYDESTRUCT_CALL)
    if (yychar != YYEOF && yychar != YYEMPTY)
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        YYDESTRUCT_CALL("cleanup: discarding token", yychar, &yylval, &yylloc);
#else
        YYDESTRUCT_CALL("cleanup: discarding token", yychar, &yylval);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */

    {
        YYSTYPE *pv;
#if defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED)
        YYLTYPE *pp;

        for (pv = yystack.l_base, pp = yystack.p_base; pv <= yystack.l_mark; ++pv, ++pp)
             YYDESTRUCT_CALL("cleanup: discarding state",
                             yystos[*(yystack.s_base + (pv - yystack.l_base))], pv, pp);
#else
        for (pv = yystack.l_base; pv <= yystack.l_mark; ++pv)
             YYDESTRUCT_CALL("cleanup: discarding state",
                             yystos[*(yystack.s_base + (pv - yystack.l_base))], pv);
#endif /* defined(YYLTYPE) || defined(YYLTYPE_IS_DECLARED) */
    }
#endif /* defined(YYDESTRUCT_CALL) */

#if YYBTYACC
    if (yyerrctx)
    {
        yyFreeState(yyerrctx);
        yyerrctx = NULL;
    }
    while (yyps)
    {
        YYParseState *save = yyps;
        yyps = save->save;
        save->save = NULL;
        yyFreeState(save);
    }
    while (yypath)
    {
        YYParseState *save = yypath;
        yypath = save->save;
        save->save = NULL;
        yyFreeState(save);
    }
#endif /* YYBTYACC */
    yyfreestack(&yystack);
    return (yyresult);
}
