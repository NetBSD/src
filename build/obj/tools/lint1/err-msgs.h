#define MSG_0 "empty declaration"
#define MSG_1 "old-style declaration; add 'int'"
#define MSG_2 "empty declaration"
#define MSG_3 "'%s' declared in argument declaration list"
#define MSG_4 "illegal type combination"
#define MSG_5 "modifying typedef with '%s'; only qualifiers allowed"
#define MSG_6 "use 'double' instead of 'long float'"
#define MSG_7 "only one storage class allowed"
#define MSG_8 "illegal storage class"
#define MSG_9 "only register valid as formal parameter storage class"
#define MSG_10 "duplicate '%s'"
#define MSG_11 "bit-field initializer out of range"
#define MSG_12 "compiler takes size of function"
#define MSG_13 "incomplete enum type '%s'"
#define MSG_14 ""
#define MSG_15 "function returns illegal type '%s'"
#define MSG_16 "array of function is illegal"
#define MSG_17 "null dimension"
#define MSG_18 "illegal use of 'void'"
#define MSG_19 "void type for '%s'"
#define MSG_20 "negative array dimension (%d)"
#define MSG_21 "redeclaration of formal parameter '%s'"
#define MSG_22 "incomplete or misplaced function definition"
#define MSG_23 "undefined label '%s'"
#define MSG_24 "cannot initialize function '%s'"
#define MSG_25 "cannot initialize typedef '%s'"
#define MSG_26 "cannot initialize extern declaration '%s'"
#define MSG_27 "redeclaration of '%s'"
#define MSG_28 "redefinition of '%s'"
#define MSG_29 "'%s' was previously declared extern, becomes static"
#define MSG_30 "redeclaration of '%s'; ANSI C requires static"
#define MSG_31 "'%s' has incomplete type '%s'"
#define MSG_32 "type of argument '%s' defaults to 'int'"
#define MSG_33 "duplicate member name '%s'"
#define MSG_34 "nonportable bit-field type '%s'"
#define MSG_35 "illegal bit-field type '%s'"
#define MSG_36 "illegal bit-field size: %d"
#define MSG_37 "zero size bit-field"
#define MSG_38 "function illegal in structure or union"
#define MSG_39 "zero-sized array '%s' in struct is a C99 extension"
#define MSG_41 "bit-field in union is very unusual"
#define MSG_42 "forward reference to enum type"
#define MSG_43 "redefinition of '%s' hides earlier one"
#define MSG_44 "declaration of '%s %s' introduces new type in ANSI C"
#define MSG_45 "base type is really '%s %s'"
#define MSG_46 "%s tag '%s' redeclared as %s"
#define MSG_47 "zero sized %s is a C99 feature"
#define MSG_48 "enumeration value '%s' overflows"
#define MSG_49 "anonymous struct/union members is a C11 feature"
#define MSG_50 "argument '%s' has function type, should be pointer"
#define MSG_51 "parameter mismatch: %d declared, %d defined"
#define MSG_52 "cannot initialize parameter '%s'"
#define MSG_53 "declared argument '%s' is missing"
#define MSG_54 "trailing ',' prohibited in enum declaration"
#define MSG_55 "integral constant expression expected"
#define MSG_56 "integral constant too large"
#define MSG_57 "enumeration constant '%s' hides parameter"
#define MSG_58 "type of '%s' does not match prototype"
#define MSG_59 "formal parameter #%d lacks name"
#define MSG_60 "void must be sole parameter"
#define MSG_61 "void parameter '%s' cannot have name"
#define MSG_62 "function prototype parameters must have types"
#define MSG_63 "prototype does not match old-style definition"
#define MSG_64 "()-less function definition"
#define MSG_65 "'%s' has no named members"
#define MSG_66 ""
#define MSG_67 "cannot return incomplete type"
#define MSG_68 "typedef already qualified with '%s'"
#define MSG_69 "inappropriate qualifiers with 'void'"
#define MSG_71 "too many characters in character constant"
#define MSG_72 "typedef declares no type name"
#define MSG_73 "empty character constant"
#define MSG_74 "no hex digits follow \\x"
#define MSG_75 "overflow in hex escape"
#define MSG_76 "character escape does not fit in character"
#define MSG_77 "bad octal digit %c"
#define MSG_79 "dubious escape \\%c"
#define MSG_80 "dubious escape \\%o"
#define MSG_81 "\\a undefined in traditional C"
#define MSG_82 "\\x undefined in traditional C"
#define MSG_83 "storage class after type is obsolescent"
#define MSG_84 "ANSI C requires formal parameter before '...'"
#define MSG_85 "dubious tag declaration '%s %s'"
#define MSG_86 "automatic '%s' hides external declaration"
#define MSG_87 "static '%s' hides external declaration"
#define MSG_88 "typedef '%s' hides external declaration"
#define MSG_89 "typedef '%s' redeclared"
#define MSG_90 "inconsistent redeclaration of extern '%s'"
#define MSG_91 "declaration of '%s' hides parameter"
#define MSG_92 "inconsistent redeclaration of static '%s'"
#define MSG_93 "dubious static function '%s' at block level"
#define MSG_94 "function '%s' has illegal storage class"
#define MSG_95 "declaration of '%s' hides earlier one"
#define MSG_96 "cannot dereference non-pointer type '%s'"
#define MSG_97 "suffix U is illegal in traditional C"
#define MSG_98 "suffixes F and L are illegal in traditional C"
#define MSG_99 "'%s' undefined"
#define MSG_100 "unary '+' is illegal in traditional C"
#define MSG_101 "type '%s' does not have member '%s'"
#define MSG_102 "illegal use of member '%s'"
#define MSG_103 "left operand of '.' must be struct or union, not '%s'"
#define MSG_104 "left operand of '->' must be pointer to struct or union, not '%s'"
#define MSG_105 "non-unique member requires struct/union %s"
#define MSG_106 "left operand of '->' must be pointer"
#define MSG_107 "operands of '%s' have incompatible types '%s' and '%s'"
#define MSG_108 "operand of '%s' has invalid type '%s'"
#define MSG_109 "void type illegal in expression"
#define MSG_110 "pointer to function is not allowed here"
#define MSG_111 "unacceptable operand of '%s'"
#define MSG_112 "cannot take address of bit-field"
#define MSG_113 "cannot take address of register '%s'"
#define MSG_114 "%soperand of '%s' must be lvalue"
#define MSG_115 "%soperand of '%s' must be modifiable lvalue"
#define MSG_116 "illegal pointer subtraction"
#define MSG_117 "bitwise '%s' on signed value possibly nonportable"
#define MSG_118 "semantics of '%s' change in ANSI C; use explicit cast"
#define MSG_119 "conversion of '%s' to '%s' is out of range"
#define MSG_120 "bitwise '%s' on signed value nonportable"
#define MSG_121 "negative shift"
#define MSG_122 "shift amount %llu is greater than bit-size %llu of '%s'"
#define MSG_123 "illegal combination of %s '%s' and %s '%s', op '%s'"
#define MSG_124 "illegal combination of '%s' and '%s', op '%s'"
#define MSG_125 "ANSI C forbids ordered comparisons of pointers to functions"
#define MSG_126 "incompatible types '%s' and '%s' in conditional"
#define MSG_127 "'&' before array or function: ignored"
#define MSG_128 "operands of '%s' have incompatible pointer types to '%s' and '%s'"
#define MSG_129 "expression has null effect"
#define MSG_130 "enum type mismatch: '%s' '%s' '%s'"
#define MSG_131 "conversion to '%s' may sign-extend incorrectly"
#define MSG_132 "conversion from '%s' to '%s' may lose accuracy"
#define MSG_133 "conversion of pointer to '%s' loses bits"
#define MSG_134 "conversion of pointer to '%s' may lose bits"
#define MSG_135 "converting '%s' to '%s' increases alignment from %u to %u"
#define MSG_136 "cannot do pointer arithmetic on operand of unknown size"
#define MSG_138 "unknown operand size, op '%s'"
#define MSG_139 "division by 0"
#define MSG_140 "modulus by 0"
#define MSG_141 "integer overflow detected, op '%s'"
#define MSG_142 "floating point overflow on operator '%s'"
#define MSG_143 "cannot take size/alignment of incomplete type"
#define MSG_144 "cannot take size/alignment of function type '%s'"
#define MSG_145 "cannot take size/alignment of bit-field"
#define MSG_146 "cannot take size/alignment of void"
#define MSG_147 "invalid cast from '%s' to '%s'"
#define MSG_148 "improper cast of void expression"
#define MSG_149 "cannot call '%s', must be a function"
#define MSG_150 "argument mismatch: %d %s passed, %d expected"
#define MSG_151 "void expressions may not be arguments, arg #%d"
#define MSG_152 "argument cannot have unknown size, arg #%d"
#define MSG_153 "converting '%s' to incompatible '%s' for argument %d"
#define MSG_154 "illegal combination of %s '%s' and %s '%s', arg #%d"
#define MSG_155 "passing '%s' to incompatible '%s', arg #%d"
#define MSG_156 "function expects '%s', passing '%s' for arg #%d"
#define MSG_157 "ANSI C treats constant as unsigned"
#define MSG_158 "'%s' may be used before set"
#define MSG_159 "assignment in conditional context"
#define MSG_160 "operator '==' found where '=' was expected"
#define MSG_161 "constant in conditional context"
#define MSG_162 "operator '%s' compares '%s' with '%s'"
#define MSG_163 "a cast does not yield an lvalue"
#define MSG_164 "assignment of negative constant to unsigned type"
#define MSG_165 "constant truncated by assignment"
#define MSG_166 "precision lost in bit-field assignment"
#define MSG_167 "array subscript cannot be negative: %ld"
#define MSG_168 "array subscript cannot be > %d: %ld"
#define MSG_169 "precedence confusion possible: parenthesize!"
#define MSG_170 "first operand must have scalar type, op ? :"
#define MSG_171 "cannot assign to '%s' from '%s'"
#define MSG_172 "too many struct/union initializers"
#define MSG_173 "too many array initializers, expected %d"
#define MSG_174 "too many initializers"
#define MSG_175 "initialization of incomplete type '%s'"
#define MSG_177 "non-constant initializer"
#define MSG_178 "initializer does not fit"
#define MSG_179 "cannot initialize struct/union with no named member"
#define MSG_180 "bit-field initializer does not fit"
#define MSG_181 "{}-enclosed initializer required"
#define MSG_182 "incompatible pointer types to '%s' and '%s'"
#define MSG_183 "illegal combination of %s '%s' and %s '%s'"
#define MSG_184 "illegal combination of '%s' and '%s'"
#define MSG_185 "cannot initialize '%s' from '%s'"
#define MSG_186 "bit-field initialization is illegal in traditional C"
#define MSG_187 "string literal too long (%lu) for target array (%lu)"
#define MSG_188 "no automatic aggregate initialization in traditional C"
#define MSG_190 "empty array declaration for '%s'"
#define MSG_191 "'%s' set but not used in function '%s'"
#define MSG_192 "'%s' unused in function '%s'"
#define MSG_193 "statement not reached"
#define MSG_194 "label '%s' redefined"
#define MSG_195 "case not in switch"
#define MSG_196 "case label affected by conversion"
#define MSG_197 "non-constant case expression"
#define MSG_198 "non-integral case expression"
#define MSG_199 "duplicate case in switch: %ld"
#define MSG_200 "duplicate case in switch: %lu"
#define MSG_201 "default outside switch"
#define MSG_202 "duplicate default in switch"
#define MSG_203 "case label must be of type 'int' in traditional C"
#define MSG_204 "controlling expressions must have scalar type"
#define MSG_205 "switch expression must have integral type"
#define MSG_206 "enumeration value(s) not handled in switch"
#define MSG_207 "loop not entered at top"
#define MSG_208 "break outside loop or switch"
#define MSG_209 "continue outside loop"
#define MSG_210 "enum type mismatch between '%s' and '%s' in initialization"
#define MSG_211 "function has return type '%s' but returns '%s'"
#define MSG_212 "cannot return incomplete type"
#define MSG_213 "void function '%s' cannot return value"
#define MSG_214 "function '%s' expects to return value"
#define MSG_215 "function '%s' implicitly declared to return int"
#define MSG_216 "function '%s' has 'return expr' and 'return'"
#define MSG_217 "function '%s' falls off bottom without returning value"
#define MSG_218 "ANSI C treats constant as unsigned, op '%s'"
#define MSG_219 "concatenated strings are illegal in traditional C"
#define MSG_220 "fallthrough on case statement"
#define MSG_221 "initialization of unsigned with negative constant"
#define MSG_222 "conversion of negative constant to unsigned type"
#define MSG_223 "end-of-loop code not reached"
#define MSG_224 "cannot recover from previous errors"
#define MSG_225 "static function '%s' called but not defined"
#define MSG_226 "static variable '%s' unused"
#define MSG_227 "const object '%s' should have initializer"
#define MSG_228 "function cannot return const or volatile object"
#define MSG_229 "converting '%s' to '%s' is questionable"
#define MSG_230 "nonportable character comparison '%s'"
#define MSG_231 "argument '%s' unused in function '%s'"
#define MSG_232 "label '%s' unused in function '%s'"
#define MSG_233 "struct '%s' never defined"
#define MSG_234 "union '%s' never defined"
#define MSG_235 "enum '%s' never defined"
#define MSG_236 "static function '%s' unused"
#define MSG_237 "redeclaration of formal parameter '%s'"
#define MSG_238 "initialization of union is illegal in traditional C"
#define MSG_239 "constant argument to '!'"
#define MSG_241 "dubious operation on enum, op '%s'"
#define MSG_242 "combination of '%s' and '%s', op '%s'"
#define MSG_243 "dubious comparison of enums, op '%s'"
#define MSG_244 "illegal structure pointer combination"
#define MSG_245 "incompatible structure pointers: '%s' '%s' '%s'"
#define MSG_246 "dubious conversion of enum to '%s'"
#define MSG_247 "pointer cast from '%s' to '%s' may be troublesome"
#define MSG_248 "floating-point constant out of range"
#define MSG_249 "syntax error '%s'"
#define MSG_250 "unknown character \\%o"
#define MSG_251 "malformed integer constant"
#define MSG_252 "integer constant out of range"
#define MSG_253 "unterminated character constant"
#define MSG_254 "newline in string or char constant"
#define MSG_255 "undefined or invalid # directive"
#define MSG_256 "unterminated comment"
#define MSG_257 "extra characters in lint comment"
#define MSG_258 "unterminated string constant"
#define MSG_259 "argument #%d is converted from '%s' to '%s' due to prototype"
#define MSG_260 "previous declaration of '%s'"
#define MSG_261 "previous definition of '%s'"
#define MSG_262 "\\\" inside character constants undefined in traditional C"
#define MSG_263 "\\? undefined in traditional C"
#define MSG_264 "\\v undefined in traditional C"
#define MSG_265 "%s does not support 'long long'"
#define MSG_266 "'long double' is illegal in traditional C"
#define MSG_267 "shift amount %u equals bit-size of '%s'"
#define MSG_268 "variable '%s' declared inline"
#define MSG_269 "argument '%s' declared inline"
#define MSG_270 "function prototypes are illegal in traditional C"
#define MSG_271 "switch expression must be of type 'int' in traditional C"
#define MSG_272 "empty translation unit"
#define MSG_273 "bit-field type '%s' invalid in ANSI C"
#define MSG_274 "ANSI C forbids comparison of %s with %s"
#define MSG_275 "cast discards 'const' from type '%s'"
#define MSG_276 "'__%s__' is illegal for type '%s'"
#define MSG_277 "initialization of '%s' with '%s'"
#define MSG_278 "combination of '%s' and '%s', arg #%d"
#define MSG_279 "combination of '%s' and '%s' in return"
#define MSG_280 "comment /* %s */ must be outside function"
#define MSG_281 "duplicate comment /* %s */"
#define MSG_282 "comment /* %s */ must precede function definition"
#define MSG_283 "argument number mismatch with directive /* %s */"
#define MSG_284 "fallthrough on default statement"
#define MSG_285 "prototype declaration"
#define MSG_286 "function definition is not a prototype"
#define MSG_287 "function declaration is not a prototype"
#define MSG_288 "dubious use of /* VARARGS */ with /* %s */"
#define MSG_289 "can't be used together: /* PRINTFLIKE */ /* SCANFLIKE */"
#define MSG_290 "static function '%s' declared but not defined"
#define MSG_291 "invalid multibyte character"
#define MSG_292 "cannot concatenate wide and regular string literals"
#define MSG_293 "argument %d must be 'char *' for PRINTFLIKE/SCANFLIKE"
#define MSG_294 "multi-character character constant"
#define MSG_295 "conversion of '%s' to '%s' is out of range, arg #%d"
#define MSG_296 "conversion of negative constant to unsigned type, arg #%d"
#define MSG_297 "conversion to '%s' may sign-extend incorrectly, arg #%d"
#define MSG_298 "conversion from '%s' to '%s' may lose accuracy, arg #%d"
#define MSG_299 "prototype does not match old-style definition, arg #%d"
#define MSG_300 "old-style definition"
#define MSG_301 "array of incomplete type"
#define MSG_302 "'%s' returns pointer to automatic object"
#define MSG_303 "ANSI C forbids conversion of %s to %s"
#define MSG_304 "ANSI C forbids conversion of %s to %s, arg #%d"
#define MSG_305 "ANSI C forbids conversion of %s to %s, op %s"
#define MSG_306 "constant truncated by conversion, op '%s'"
#define MSG_307 "static variable '%s' set but not used"
#define MSG_308 "invalid type for _Complex"
#define MSG_309 "extra bits set to 0 in conversion of '%s' to '%s', op '%s'"
#define MSG_310 "symbol renaming can't be used on function arguments"
#define MSG_311 "symbol renaming can't be used on automatic variables"
#define MSG_312 "%s does not support // comments"
#define MSG_313 "struct or union member name in initializer is a C99 feature"
#define MSG_315 "GCC style struct or union member name in initializer"
#define MSG_316 "__FUNCTION__/__PRETTY_FUNCTION__ is a GCC extension"
#define MSG_317 "__func__ is a C99 feature"
#define MSG_318 "variable array dimension is a C99/GCC extension"
#define MSG_319 "compound literals are a C99/GCC extension"
#define MSG_320 "({ }) is a GCC extension"
#define MSG_321 "array initializer with designators is a C99 feature"
#define MSG_322 "zero sized array is a C99 extension"
#define MSG_323 "continue in 'do ... while (0)' loop"
#define MSG_324 "suggest cast from '%s' to '%s' on op '%s' to avoid overflow"
#define MSG_325 "variable declaration in for loop"
#define MSG_326 "attribute '%s' ignored for '%s'"
#define MSG_327 "declarations after statements is a C99 feature"
#define MSG_328 "union cast is a GCC extension"
#define MSG_329 "type '%s' is not a member of '%s'"
#define MSG_330 "operand of '%s' must be bool, not '%s'"
#define MSG_331 "left operand of '%s' must be bool, not '%s'"
#define MSG_332 "right operand of '%s' must be bool, not '%s'"
#define MSG_333 "controlling expression must be bool, not '%s'"
#define MSG_334 "argument #%d expects '%s', gets passed '%s'"
#define MSG_335 "operand of '%s' must not be bool"
#define MSG_336 "left operand of '%s' must not be bool"
#define MSG_337 "right operand of '%s' must not be bool"
#define MSG_338 "option '%c' should be handled in the switch"
#define MSG_339 "option '%c' should be listed in the options string"
#define MSG_340 "initialization with '[a...b]' is a GCC extension"
#define MSG_341 "argument to '%s' must be 'unsigned char' or EOF, not '%s'"
#define MSG_342 "argument to '%s' must be cast to 'unsigned char', not to '%s'"
#define MSG_343 "static array size is a C11 extension"
#define MSG_344 "bit-field of type plain 'int' has implementation-defined signedness"
#define MSG_345 "generic selection requires C11 or later"
#define MSG_346 "call to '%s' effectively discards 'const' from argument"
#define MSG_347 "redeclaration of '%s' with type '%s', expected '%s'"
#define MSG_348 "maximum value %d of '%s' does not match maximum array index %d"
#define MSG_349 "non type argument to alignof is a GCC extension"
#define MSG_350 "'_Atomic' requires C11 or later"
#define MSG_351 "missing%s header declaration for '%s'"
#define MSG_352 "nested 'extern' declaration of '%s'"
#define MSG_Q1 "implicit conversion from floating point '%s' to integer '%s'"
#define MSG_Q2 "cast from floating point '%s' to integer '%s'"
#define MSG_Q3 "implicit conversion changes sign from '%s' to '%s'"
#define MSG_Q4 "usual arithmetic conversion for '%s' from '%s' to '%s'"
#define MSG_Q5 "pointer addition has integer on the left-hand side"
#define MSG_Q6 "no-op cast from '%s' to '%s'"
#define MSG_Q7 "redundant cast from '%s' to '%s' before assignment"
#define MSG_Q8 "octal number '%.*s'"
#define MSG_Q9 "parenthesized return value"
#define MSG_Q10 "chained assignment with '%s' and '%s'"
