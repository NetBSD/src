#	$NetBSD: Makefile.inc,v 1.1.1.1 2003/09/11 18:37:07 lukem Exp $

NOLINT=         1
NOPIC=          1
NOPROFILE=      1

libinstall::
