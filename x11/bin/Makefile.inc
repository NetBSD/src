#	$NetBSD: Makefile.inc,v 1.1.1.1 2003/09/12 04:44:37 lukem Exp $

.include "../Makefile.inc"
