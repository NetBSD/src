#	$NetBSD: Makefile.inc,v 1.1.1.1 2003/09/11 18:37:06 lukem Exp $

.include "../Makefile.inc"
