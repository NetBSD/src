#	$NetBSD: Makefile.inc,v 1.1.1.1 2003/09/11 18:37:05 lukem Exp $

.include "../Makefile.inc"
