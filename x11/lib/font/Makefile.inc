#	$NetBSD: Makefile.inc,v 1.1.1.1 2003/09/12 04:49:23 lukem Exp $

.include "../Makefile.inc"
