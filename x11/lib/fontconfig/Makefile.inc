#	$NetBSD: Makefile.inc,v 1.1.1.1 2003/09/12 04:47:39 lukem Exp $

.include "../Makefile.inc"
