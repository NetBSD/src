#	$NetBSD: Makefile.inc,v 1.2.26.1 2009/05/13 19:20:06 jym Exp $

# WARNS?=	0
BINDIR?=/usr/bin

#.include "../Makefile.inc"
