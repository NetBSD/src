#	$NetBSD: Makefile.inc,v 1.1 1997/10/19 04:11:51 lukem Exp $

.if exists(${.CURDIR}/../../Makefile.inc)
.include "${.CURDIR}/../../Makefile.inc"
.endif
