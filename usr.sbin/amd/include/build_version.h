/* $NetBSD: build_version.h,v 1.1.1.1 2000/11/20 00:16:18 wiz Exp $ */

/* do not edit this file by hand */
/* auto-generated by update_build_version script */
#define AMU_BUILD_VERSION 1
