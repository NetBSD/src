/*	$NetBSD: build_version.h,v 1.2 1998/01/09 08:08:57 perry Exp $	*/

/* do not edit this file by hand */
/* auto-generated by update_build_version script */
#define AMU_BUILD_VERSION 1
