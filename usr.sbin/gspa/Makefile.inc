#	$NetBSD: Makefile.inc,v 1.3 1997/10/18 06:42:47 lukem Exp $
#	from: @(#)Makefile.inc	5.1 (Berkeley) 5/11/90

.if exists(${.CURDIR}/../../Makefile.inc)
.include "${.CURDIR}/../../Makefile.inc"
.endif
