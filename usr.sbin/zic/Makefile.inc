
CPPFLAGS+=-DREPORT_BUGS_TO=\"gnats@netbsd.org\" -DPKGVERSION=\"tzcode-2013a\"
