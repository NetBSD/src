#	$NetBSD: Makefile.inc,v 1.1 2000/12/16 18:57:34 thorpej Exp $

.if exists(${.CURDIR}/../../Makefile.inc)
.include "${.CURDIR}/../../Makefile.inc"
.endif
