# $NetBSD: Makefile.inc,v 1.1.1.1 1998/10/05 18:01:58 tron Exp $

.PATH: ${.CURDIR}/nameser

SRCS+=	ns_parse.c ns_print.c ns_netint.c ns_ttl.c ns_name.c
