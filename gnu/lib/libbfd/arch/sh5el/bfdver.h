/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-binutils,v 1.3 2003/12/04 14:38:00 mrg Exp  */

#define BFD_VERSION_DATE 20030612
#define BFD_VERSION 214000000
#define BFD_VERSION_STRING "2.14 20030612"
