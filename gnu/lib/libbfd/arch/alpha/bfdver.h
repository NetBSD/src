/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-binutils,v 1.4 2004/12/10 13:57:08 mrg Exp  */

#define BFD_VERSION_DATE 20051220
#define BFD_VERSION 216010000
#define BFD_VERSION_STRING "2.16.1 20051220"
