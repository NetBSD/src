/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-binutils,v 1.5 2006/02/02 20:06:04 skrll Exp  */

#define BFD_VERSION_DATE 20050612
#define BFD_VERSION 216010000
#define BFD_VERSION_STRING "2.16.1"
