/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-binutils,v 1.4 2004/12/10 13:57:08 mrg Exp  */

#define BFD_VERSION_DATE 20040517
#define BFD_VERSION 215000000
#define BFD_VERSION_STRING "2.15"
