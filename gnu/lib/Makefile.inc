# $NetBSD: Makefile.inc,v 1.1.2.1 2013/12/18 18:41:39 matt Exp $

GCC_MACHINE_ARCH=${MACHINE_ARCH:S/armv7/arm/}
