/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.45 2009/12/17 15:48:13 uebayasi Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

/* Generated automatically by the program `build/gcov-iov'
   from `4.1.3 (4 1) and prerelease (p)'.  */

#define GCOV_VERSION ((gcov_unsigned_t)0x34303170)  /* 401p */
