#	$NetBSD: Makefile.inc,v 1.2.6.2 2012/11/20 18:53:19 matt Exp $

BINDIR?=	/usr/sbin
WARNS?=		1
