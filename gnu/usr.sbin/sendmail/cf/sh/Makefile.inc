#	$NetBSD: Makefile.inc,v 1.1 2003/03/24 15:04:05 atatat Exp $

CF_SH_FILES=	makeinfo.sh
