#	$NetBSD: Makefile.inc,v 1.1 2003/03/24 15:04:06 atatat Exp $

CF_SITECONFIG_FILES= \
		uucp.cogsci.m4 uucp.old.arpa.m4 uucp.ucbarpa.m4 \
		uucp.ucbvax.m4
