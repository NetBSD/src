#	$NetBSD: Makefile.inc,v 1.1 2003/03/24 15:04:04 atatat Exp $

CF_MAILER_FILES= \
		cyrus.m4 cyrusv2.m4 fax.m4 local.m4 mail11.m4 phquery.m4 \
		pop.m4 procmail.m4 qpage.m4 smtp.m4 usenet.m4 uucp.m4
