#	$NetBSD: Makefile.inc,v 1.1 2003/03/24 15:04:03 atatat Exp $

CF_DOMAIN_FILES= \
		Berkeley.EDU.m4 CS.Berkeley.EDU.m4 \
		EECS.Berkeley.EDU.m4 S2K.Berkeley.EDU.m4 \
		berkeley-only.m4 generic.m4
