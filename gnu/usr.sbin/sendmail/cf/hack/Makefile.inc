#	$NetBSD: Makefile.inc,v 1.1 2003/03/24 15:04:04 atatat Exp $

CF_HACK_FILES=	cssubdomain.m4
