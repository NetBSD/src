#	from: @(#)Makefile.inc	5.1 (Berkeley) 5/11/90
#	$NetBSD: Makefile.inc,v 1.3 2004/06/30 03:26:27 jmc Exp $

BINDIR?=	/usr/libexec
