/* This file is automatically generated by ia64-gen.  Do not edit!  */
static const char * const ia64_strings[] = {
  "", "0", "1", "a", "acq", "add", "addl", "addp4", "adds", "alloc", "and",
  "andcm", "b", "bias", "br", "break", "brl", "brp", "bsw", "c", "call",
  "cexit", "chk", "cloop", "clr", "clrrrb", "cmp", "cmp4", "cmp8xchg16",
  "cmpxchg1", "cmpxchg2", "cmpxchg4", "cmpxchg8", "cond", "cover", "ctop",
  "czx1", "czx2", "d", "dep", "dpnt", "dptk", "e", "epc", "eq", "excl",
  "exit", "exp", "extr", "f", "fabs", "fadd", "famax", "famin", "fand",
  "fandcm", "fault", "fc", "fchkf", "fclass", "fclrf", "fcmp", "fcvt",
  "fetchadd4", "fetchadd8", "few", "fill", "flushrs", "fma", "fmax",
  "fmerge", "fmin", "fmix", "fmpy", "fms", "fneg", "fnegabs", "fnma",
  "fnmpy", "fnorm", "for", "fpabs", "fpack", "fpamax", "fpamin", "fpcmp",
  "fpcvt", "fpma", "fpmax", "fpmerge", "fpmin", "fpmpy", "fpms", "fpneg",
  "fpnegabs", "fpnma", "fpnmpy", "fprcpa", "fprsqrta", "frcpa", "frsqrta",
  "fselect", "fsetc", "fsub", "fswap", "fsxt", "fwb", "fx", "fxor", "fxu",
  "g", "ga", "ge", "getf", "geu", "gt", "gtu", "h", "hint", "hu", "i", "ia",
  "imp", "invala", "itc", "itr", "l", "ld1", "ld16", "ld2", "ld4", "ld8",
  "ldf", "ldf8", "ldfd", "ldfe", "ldfp8", "ldfpd", "ldfps", "ldfs", "le",
  "leu", "lfetch", "loadrs", "loop", "lr", "lt", "ltu", "lu", "m", "many",
  "mf", "mix1", "mix2", "mix4", "mov", "movl", "mux1", "mux2", "nc", "ne",
  "neq", "nge", "ngt", "nl", "nle", "nlt", "nm", "nop", "nr", "ns", "nt1",
  "nt2", "nta", "nz", "or", "orcm", "ord", "pack2", "pack4", "padd1",
  "padd2", "padd4", "pavg1", "pavg2", "pavgsub1", "pavgsub2", "pcmp1",
  "pcmp2", "pcmp4", "pmax1", "pmax2", "pmin1", "pmin2", "pmpy2", "pmpyshr2",
  "popcnt", "pr", "probe", "psad1", "pshl2", "pshl4", "pshladd2", "pshr2",
  "pshr4", "pshradd2", "psub1", "psub2", "psub4", "ptc", "ptr", "r", "raz",
  "rel", "ret", "rfi", "rsm", "rum", "rw", "s", "s0", "s1", "s2", "s3",
  "sa", "se", "setf", "shl", "shladd", "shladdp4", "shr", "shrp", "sig",
  "spill", "spnt", "sptk", "srlz", "ssm", "sss", "st1", "st16", "st2",
  "st4", "st8", "stf", "stf8", "stfd", "stfe", "stfs", "sub", "sum", "sxt1",
  "sxt2", "sxt4", "sync", "tak", "tbit", "thash", "tnat", "tpa", "trunc",
  "ttag", "u", "unc", "unord", "unpack1", "unpack2", "unpack4", "uss",
  "uus", "uuu", "w", "wexit", "wtop", "x", "xchg1", "xchg2", "xchg4",
  "xchg8", "xf", "xma", "xmpy", "xor", "xuf", "z", "zxt1", "zxt2", "zxt4",
};

static const struct ia64_dependency
dependencies[] = {
  { "ALAT", 0, 0, 0, -1, NULL, },
  { "AR[BSP]", 26, 0, 2, 17, NULL, },
  { "AR[BSPSTORE]", 26, 0, 2, 18, NULL, },
  { "AR[CFLG]", 26, 0, 2, 27, NULL, },
  { "AR[CCV]", 26, 0, 2, 32, NULL, },
  { "AR[CSD]", 26, 0, 2, 25, NULL, },
  { "AR[EC]", 26, 0, 2, 66, NULL, },
  { "AR[EFLAG]", 26, 0, 2, 24, NULL, },
  { "AR[FCR]", 26, 0, 2, 21, NULL, },
  { "AR[FDR]", 26, 0, 2, 30, NULL, },
  { "AR[FIR]", 26, 0, 2, 29, NULL, },
  { "AR[FPSR].sf0.controls", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf1.controls", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf2.controls", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf3.controls", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf0.flags", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf1.flags", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf2.flags", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].sf3.flags", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].traps", 30, 0, 2, -1, NULL, },
  { "AR[FPSR].rv", 30, 0, 2, -1, NULL, },
  { "AR[FSR]", 26, 0, 2, 28, NULL, },
  { "AR[ITC]", 26, 0, 2, 44, NULL, },
  { "AR[K%], % in 0 - 7", 1, 0, 2, -1, NULL, },
  { "AR[LC]", 26, 0, 2, 65, NULL, },
  { "AR[PFS]", 26, 0, 2, 64, NULL, },
  { "AR[PFS]", 26, 0, 2, 64, NULL, },
  { "AR[PFS]", 26, 0, 0, 64, NULL, },
  { "AR[RNAT]", 26, 0, 2, 19, NULL, },
  { "AR[RSC]", 26, 0, 2, 16, NULL, },
  { "AR[SSD]", 26, 0, 2, 26, NULL, },
  { "AR[UNAT]{%}, % in 0 - 63", 2, 0, 2, -1, NULL, },
  { "AR%, % in 8-15, 20, 22-23, 31, 33-35, 37-39, 41-43, 45-47, 67-111", 3, 0, 0, -1, NULL, },
  { "AR%, % in 48-63, 112-127", 4, 0, 2, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 0, 2, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 0, 0, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 0, 2, -1, NULL, },
  { "CFM", 6, 0, 2, -1, NULL, },
  { "CFM", 6, 0, 2, -1, NULL, },
  { "CFM", 6, 0, 2, -1, NULL, },
  { "CFM", 6, 0, 2, -1, NULL, },
  { "CFM", 6, 0, 0, -1, NULL, },
  { "CPUID#", 7, 0, 5, -1, NULL, },
  { "CR[CMCV]", 27, 0, 3, 74, NULL, },
  { "CR[DCR]", 27, 0, 3, 0, NULL, },
  { "CR[EOI]", 27, 0, 7, 67, "SC Section 10.8.3.4", },
  { "CR[GPTA]", 27, 0, 3, 9, NULL, },
  { "CR[IFA]", 27, 0, 1, 20, NULL, },
  { "CR[IFA]", 27, 0, 3, 20, NULL, },
  { "CR[IFS]", 27, 0, 3, 23, NULL, },
  { "CR[IFS]", 27, 0, 1, 23, NULL, },
  { "CR[IFS]", 27, 0, 1, 23, NULL, },
  { "CR[IHA]", 27, 0, 3, 25, NULL, },
  { "CR[IIM]", 27, 0, 3, 24, NULL, },
  { "CR[IIP]", 27, 0, 3, 19, NULL, },
  { "CR[IIP]", 27, 0, 1, 19, NULL, },
  { "CR[IIPA]", 27, 0, 3, 22, NULL, },
  { "CR[IPSR]", 27, 0, 3, 16, NULL, },
  { "CR[IPSR]", 27, 0, 1, 16, NULL, },
  { "CR[IRR%], % in 0 - 3", 8, 0, 3, -1, NULL, },
  { "CR[ISR]", 27, 0, 3, 17, NULL, },
  { "CR[ITIR]", 27, 0, 3, 21, NULL, },
  { "CR[ITIR]", 27, 0, 1, 21, NULL, },
  { "CR[ITM]", 27, 0, 3, 1, NULL, },
  { "CR[ITV]", 27, 0, 3, 72, NULL, },
  { "CR[IVA]", 27, 0, 4, 2, NULL, },
  { "CR[IVR]", 27, 0, 7, 65, "SC Section 10.8.3.2", },
  { "CR[LID]", 27, 0, 7, 64, "SC Section 10.8.3.1", },
  { "CR[LRR%], % in 0 - 1", 9, 0, 3, -1, NULL, },
  { "CR[PMV]", 27, 0, 3, 73, NULL, },
  { "CR[PTA]", 27, 0, 3, 8, NULL, },
  { "CR[TPR]", 27, 0, 3, 66, NULL, },
  { "CR[TPR]", 27, 0, 7, 66, "SC Section 10.8.3.3", },
  { "CR%, % in 3-7, 10-15, 18, 26-63, 75-79, 82-127", 10, 0, 0, -1, NULL, },
  { "DBR#", 11, 0, 2, -1, NULL, },
  { "DBR#", 11, 0, 3, -1, NULL, },
  { "DTC", 0, 0, 3, -1, NULL, },
  { "DTC", 0, 0, 2, -1, NULL, },
  { "DTC", 0, 0, 0, -1, NULL, },
  { "DTC", 0, 0, 2, -1, NULL, },
  { "DTC_LIMIT*", 0, 0, 2, -1, NULL, },
  { "DTR", 0, 0, 3, -1, NULL, },
  { "DTR", 0, 0, 2, -1, NULL, },
  { "DTR", 0, 0, 3, -1, NULL, },
  { "DTR", 0, 0, 0, -1, NULL, },
  { "DTR", 0, 0, 2, -1, NULL, },
  { "FR%, % in 0 - 1", 12, 0, 0, -1, NULL, },
  { "FR%, % in 2 - 127", 13, 0, 2, -1, NULL, },
  { "FR%, % in 2 - 127", 13, 0, 0, -1, NULL, },
  { "GR0", 14, 0, 0, -1, NULL, },
  { "GR%, % in 1 - 127", 15, 0, 0, -1, NULL, },
  { "GR%, % in 1 - 127", 15, 0, 2, -1, NULL, },
  { "IBR#", 16, 0, 2, -1, NULL, },
  { "InService*", 17, 0, 3, -1, NULL, },
  { "InService*", 17, 0, 2, -1, NULL, },
  { "InService*", 17, 0, 2, -1, NULL, },
  { "IP", 0, 0, 0, -1, NULL, },
  { "ITC", 0, 0, 4, -1, NULL, },
  { "ITC", 0, 0, 2, -1, NULL, },
  { "ITC", 0, 0, 0, -1, NULL, },
  { "ITC", 0, 0, 4, -1, NULL, },
  { "ITC", 0, 0, 2, -1, NULL, },
  { "ITC_LIMIT*", 0, 0, 2, -1, NULL, },
  { "ITR", 0, 0, 2, -1, NULL, },
  { "ITR", 0, 0, 4, -1, NULL, },
  { "ITR", 0, 0, 2, -1, NULL, },
  { "ITR", 0, 0, 0, -1, NULL, },
  { "ITR", 0, 0, 4, -1, NULL, },
  { "memory", 0, 0, 0, -1, NULL, },
  { "MSR#", 18, 0, 5, -1, NULL, },
  { "PKR#", 19, 0, 3, -1, NULL, },
  { "PKR#", 19, 0, 0, -1, NULL, },
  { "PKR#", 19, 0, 2, -1, NULL, },
  { "PKR#", 19, 0, 2, -1, NULL, },
  { "PMC#", 20, 0, 2, -1, NULL, },
  { "PMC#", 20, 0, 7, -1, "SC+3 Section 12.1.1", },
  { "PMD#", 21, 0, 2, -1, NULL, },
  { "PR0", 0, 0, 0, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 0, 2, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 0, 2, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 0, 0, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 0, 2, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 0, 2, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 0, 0, -1, NULL, },
  { "PR63", 24, 0, 2, -1, NULL, },
  { "PR63", 24, 0, 2, -1, NULL, },
  { "PR63", 24, 0, 0, -1, NULL, },
  { "PSR.ac", 28, 0, 1, 3, NULL, },
  { "PSR.ac", 28, 0, 3, 3, NULL, },
  { "PSR.ac", 28, 0, 2, 3, NULL, },
  { "PSR.be", 28, 0, 1, 1, NULL, },
  { "PSR.be", 28, 0, 3, 1, NULL, },
  { "PSR.be", 28, 0, 2, 1, NULL, },
  { "PSR.bn", 28, 0, 2, 44, NULL, },
  { "PSR.cpl", 28, 0, 1, 32, NULL, },
  { "PSR.da", 28, 0, 3, 38, NULL, },
  { "PSR.db", 28, 0, 3, 24, NULL, },
  { "PSR.db", 28, 0, 2, 24, NULL, },
  { "PSR.db", 28, 0, 3, 24, NULL, },
  { "PSR.dd", 28, 0, 3, 39, NULL, },
  { "PSR.dfh", 28, 0, 3, 19, NULL, },
  { "PSR.dfh", 28, 0, 2, 19, NULL, },
  { "PSR.dfl", 28, 0, 3, 18, NULL, },
  { "PSR.dfl", 28, 0, 2, 18, NULL, },
  { "PSR.di", 28, 0, 3, 22, NULL, },
  { "PSR.di", 28, 0, 2, 22, NULL, },
  { "PSR.dt", 28, 0, 3, 17, NULL, },
  { "PSR.dt", 28, 0, 2, 17, NULL, },
  { "PSR.ed", 28, 0, 3, 43, NULL, },
  { "PSR.i", 28, 0, 2, 14, NULL, },
  { "PSR.i", 28, 0, 3, 14, NULL, },
  { "PSR.ia", 28, 0, 0, 14, NULL, },
  { "PSR.ic", 28, 0, 2, 13, NULL, },
  { "PSR.ic", 28, 0, 3, 13, NULL, },
  { "PSR.id", 28, 0, 0, 14, NULL, },
  { "PSR.is", 28, 0, 0, 14, NULL, },
  { "PSR.it", 28, 0, 3, 14, NULL, },
  { "PSR.lp", 28, 0, 2, 25, NULL, },
  { "PSR.lp", 28, 0, 3, 25, NULL, },
  { "PSR.lp", 28, 0, 3, 25, NULL, },
  { "PSR.mc", 28, 0, 0, 35, NULL, },
  { "PSR.mfh", 28, 0, 2, 5, NULL, },
  { "PSR.mfl", 28, 0, 2, 4, NULL, },
  { "PSR.pk", 28, 0, 3, 15, NULL, },
  { "PSR.pk", 28, 0, 2, 15, NULL, },
  { "PSR.pp", 28, 0, 2, 21, NULL, },
  { "PSR.ri", 28, 0, 0, 41, NULL, },
  { "PSR.rt", 28, 0, 2, 27, NULL, },
  { "PSR.rt", 28, 0, 3, 27, NULL, },
  { "PSR.rt", 28, 0, 3, 27, NULL, },
  { "PSR.si", 28, 0, 2, 23, NULL, },
  { "PSR.si", 28, 0, 3, 23, NULL, },
  { "PSR.sp", 28, 0, 2, 20, NULL, },
  { "PSR.sp", 28, 0, 3, 20, NULL, },
  { "PSR.ss", 28, 0, 3, 40, NULL, },
  { "PSR.tb", 28, 0, 3, 26, NULL, },
  { "PSR.tb", 28, 0, 2, 26, NULL, },
  { "PSR.up", 28, 0, 2, 2, NULL, },
  { "RR#", 25, 0, 3, -1, NULL, },
  { "RR#", 25, 0, 2, -1, NULL, },
  { "RSE", 29, 0, 2, -1, NULL, },
  { "ALAT", 0, 1, 0, -1, NULL, },
  { "AR[BSP]", 26, 1, 2, 17, NULL, },
  { "AR[BSPSTORE]", 26, 1, 2, 18, NULL, },
  { "AR[CCV]", 26, 1, 2, 32, NULL, },
  { "AR[CFLG]", 26, 1, 2, 27, NULL, },
  { "AR[CSD]", 26, 1, 2, 25, NULL, },
  { "AR[EC]", 26, 1, 2, 66, NULL, },
  { "AR[EFLAG]", 26, 1, 2, 24, NULL, },
  { "AR[FCR]", 26, 1, 2, 21, NULL, },
  { "AR[FDR]", 26, 1, 2, 30, NULL, },
  { "AR[FIR]", 26, 1, 2, 29, NULL, },
  { "AR[FPSR].sf0.controls", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf1.controls", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf2.controls", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf3.controls", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf0.flags", 30, 1, 0, -1, NULL, },
  { "AR[FPSR].sf0.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf0.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf1.flags", 30, 1, 0, -1, NULL, },
  { "AR[FPSR].sf1.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf1.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf2.flags", 30, 1, 0, -1, NULL, },
  { "AR[FPSR].sf2.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf2.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf3.flags", 30, 1, 0, -1, NULL, },
  { "AR[FPSR].sf3.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].sf3.flags", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].rv", 30, 1, 2, -1, NULL, },
  { "AR[FPSR].traps", 30, 1, 2, -1, NULL, },
  { "AR[FSR]", 26, 1, 2, 28, NULL, },
  { "AR[ITC]", 26, 1, 2, 44, NULL, },
  { "AR[K%], % in 0 - 7", 1, 1, 2, -1, NULL, },
  { "AR[LC]", 26, 1, 2, 65, NULL, },
  { "AR[PFS]", 26, 1, 0, 64, NULL, },
  { "AR[PFS]", 26, 1, 2, 64, NULL, },
  { "AR[PFS]", 26, 1, 2, 64, NULL, },
  { "AR[RNAT]", 26, 1, 2, 19, NULL, },
  { "AR[RSC]", 26, 1, 2, 16, NULL, },
  { "AR[UNAT]{%}, % in 0 - 63", 2, 1, 2, -1, NULL, },
  { "AR%, % in 8-15, 20, 22-23, 31, 33-35, 37-39, 41-43, 45-47, 67-111", 3, 1, 0, -1, NULL, },
  { "AR%, % in 48 - 63, 112-127", 4, 1, 2, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 1, 2, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 1, 2, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 1, 2, -1, NULL, },
  { "BR%, % in 0 - 7", 5, 1, 0, -1, NULL, },
  { "CFM", 6, 1, 2, -1, NULL, },
  { "CPUID#", 7, 1, 0, -1, NULL, },
  { "CR[CMCV]", 27, 1, 2, 74, NULL, },
  { "CR[DCR]", 27, 1, 2, 0, NULL, },
  { "CR[EOI]", 27, 1, 7, 67, "SC Section 10.8.3.4", },
  { "CR[GPTA]", 27, 1, 2, 9, NULL, },
  { "CR[IFA]", 27, 1, 2, 20, NULL, },
  { "CR[IFS]", 27, 1, 2, 23, NULL, },
  { "CR[IHA]", 27, 1, 2, 25, NULL, },
  { "CR[IIM]", 27, 1, 2, 24, NULL, },
  { "CR[IIP]", 27, 1, 2, 19, NULL, },
  { "CR[IIPA]", 27, 1, 2, 22, NULL, },
  { "CR[IPSR]", 27, 1, 2, 16, NULL, },
  { "CR[IRR%], % in 0 - 3", 8, 1, 2, -1, NULL, },
  { "CR[ISR]", 27, 1, 2, 17, NULL, },
  { "CR[ITIR]", 27, 1, 2, 21, NULL, },
  { "CR[ITM]", 27, 1, 2, 1, NULL, },
  { "CR[ITV]", 27, 1, 2, 72, NULL, },
  { "CR[IVA]", 27, 1, 2, 2, NULL, },
  { "CR[IVR]", 27, 1, 7, 65, "SC", },
  { "CR[LID]", 27, 1, 7, 64, "SC", },
  { "CR[LRR%], % in 0 - 1", 9, 1, 2, -1, NULL, },
  { "CR[PMV]", 27, 1, 2, 73, NULL, },
  { "CR[PTA]", 27, 1, 2, 8, NULL, },
  { "CR[TPR]", 27, 1, 2, 66, NULL, },
  { "CR%, % in 3-7, 10-15, 18, 26-63, 75-79, 82-127", 10, 1, 0, -1, NULL, },
  { "DBR#", 11, 1, 2, -1, NULL, },
  { "DTC", 0, 1, 0, -1, NULL, },
  { "DTC", 0, 1, 2, -1, NULL, },
  { "DTC", 0, 1, 2, -1, NULL, },
  { "DTC_LIMIT*", 0, 1, 2, -1, NULL, },
  { "DTR", 0, 1, 2, -1, NULL, },
  { "DTR", 0, 1, 2, -1, NULL, },
  { "DTR", 0, 1, 2, -1, NULL, },
  { "DTR", 0, 1, 0, -1, NULL, },
  { "FR%, % in 0 - 1", 12, 1, 0, -1, NULL, },
  { "FR%, % in 2 - 127", 13, 1, 2, -1, NULL, },
  { "GR0", 14, 1, 0, -1, NULL, },
  { "GR%, % in 1 - 127", 15, 1, 2, -1, NULL, },
  { "IBR#", 16, 1, 2, -1, NULL, },
  { "InService*", 17, 1, 7, -1, "SC", },
  { "IP", 0, 1, 0, -1, NULL, },
  { "ITC", 0, 1, 0, -1, NULL, },
  { "ITC", 0, 1, 2, -1, NULL, },
  { "ITC", 0, 1, 2, -1, NULL, },
  { "ITR", 0, 1, 2, -1, NULL, },
  { "ITR", 0, 1, 2, -1, NULL, },
  { "ITR", 0, 1, 0, -1, NULL, },
  { "memory", 0, 1, 0, -1, NULL, },
  { "MSR#", 18, 1, 7, -1, "SC", },
  { "PKR#", 19, 1, 0, -1, NULL, },
  { "PKR#", 19, 1, 0, -1, NULL, },
  { "PKR#", 19, 1, 2, -1, NULL, },
  { "PMC#", 20, 1, 2, -1, NULL, },
  { "PMD#", 21, 1, 2, -1, NULL, },
  { "PR0", 0, 1, 0, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 1, 0, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 1, 0, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 1, 2, -1, NULL, },
  { "PR%, % in 1 - 15", 22, 1, 2, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 1, 0, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 1, 0, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 1, 2, -1, NULL, },
  { "PR%, % in 16 - 62", 23, 1, 2, -1, NULL, },
  { "PR63", 24, 1, 0, -1, NULL, },
  { "PR63", 24, 1, 0, -1, NULL, },
  { "PR63", 24, 1, 2, -1, NULL, },
  { "PR63", 24, 1, 2, -1, NULL, },
  { "PSR.ac", 28, 1, 2, 3, NULL, },
  { "PSR.be", 28, 1, 2, 1, NULL, },
  { "PSR.bn", 28, 1, 2, 44, NULL, },
  { "PSR.cpl", 28, 1, 2, 32, NULL, },
  { "PSR.da", 28, 1, 2, 38, NULL, },
  { "PSR.db", 28, 1, 2, 24, NULL, },
  { "PSR.dd", 28, 1, 2, 39, NULL, },
  { "PSR.dfh", 28, 1, 2, 19, NULL, },
  { "PSR.dfl", 28, 1, 2, 18, NULL, },
  { "PSR.di", 28, 1, 2, 22, NULL, },
  { "PSR.dt", 28, 1, 2, 17, NULL, },
  { "PSR.ed", 28, 1, 2, 43, NULL, },
  { "PSR.i", 28, 1, 2, 14, NULL, },
  { "PSR.ia", 28, 1, 2, 14, NULL, },
  { "PSR.ic", 28, 1, 2, 13, NULL, },
  { "PSR.id", 28, 1, 2, 14, NULL, },
  { "PSR.is", 28, 1, 2, 14, NULL, },
  { "PSR.it", 28, 1, 2, 14, NULL, },
  { "PSR.lp", 28, 1, 2, 25, NULL, },
  { "PSR.mc", 28, 1, 2, 35, NULL, },
  { "PSR.mfh", 28, 1, 0, 5, NULL, },
  { "PSR.mfh", 28, 1, 2, 5, NULL, },
  { "PSR.mfh", 28, 1, 2, 5, NULL, },
  { "PSR.mfl", 28, 1, 0, 4, NULL, },
  { "PSR.mfl", 28, 1, 2, 4, NULL, },
  { "PSR.mfl", 28, 1, 2, 4, NULL, },
  { "PSR.pk", 28, 1, 2, 15, NULL, },
  { "PSR.pp", 28, 1, 2, 21, NULL, },
  { "PSR.ri", 28, 1, 2, 41, NULL, },
  { "PSR.rt", 28, 1, 2, 27, NULL, },
  { "PSR.si", 28, 1, 2, 23, NULL, },
  { "PSR.sp", 28, 1, 2, 20, NULL, },
  { "PSR.ss", 28, 1, 2, 40, NULL, },
  { "PSR.tb", 28, 1, 2, 26, NULL, },
  { "PSR.up", 28, 1, 2, 2, NULL, },
  { "RR#", 25, 1, 2, -1, NULL, },
  { "RSE", 29, 1, 2, -1, NULL, },
  { "PR63", 24, 2, 6, -1, NULL, },
};

static const unsigned short dep0[] = {
  96, 267, 2139, 2312, 
};

static const unsigned short dep1[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 4135, 
  20613, 
};

static const unsigned short dep2[] = {
  96, 267, 2165, 2166, 2168, 2169, 2171, 2172, 2174, 2329, 2332, 2333, 2336, 
  2337, 2340, 2341, 
};

static const unsigned short dep3[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2329, 2332, 
  2333, 2336, 2337, 2340, 2341, 4135, 20613, 
};

static const unsigned short dep4[] = {
  96, 267, 22645, 22646, 22648, 22649, 22651, 22652, 22654, 22809, 22812, 22813, 
  22816, 22817, 22820, 22821, 
};

static const unsigned short dep5[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
  22809, 22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep6[] = {
  96, 267, 2165, 2166, 2168, 2169, 2171, 2172, 2174, 2329, 2330, 2332, 2334, 
  2336, 2338, 2340, 
};

static const unsigned short dep7[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2329, 2330, 
  2333, 2334, 2337, 2338, 2341, 4135, 20613, 
};

static const unsigned short dep8[] = {
  96, 267, 2165, 2166, 2168, 2169, 2171, 2172, 2174, 2329, 2331, 2333, 2335, 
  2337, 2339, 2341, 
};

static const unsigned short dep9[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2329, 2331, 
  2332, 2335, 2336, 2339, 2340, 4135, 20613, 
};

static const unsigned short dep10[] = {
  96, 267, 2165, 2166, 2168, 2169, 2171, 2172, 2174, 2329, 2330, 2331, 2332, 
  2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 2341, 
};

static const unsigned short dep11[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2329, 2330, 
  2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 2341, 4135, 20613, 
  
};

static const unsigned short dep12[] = {
  96, 267, 2379, 
};

static const unsigned short dep13[] = {
  40, 41, 96, 156, 174, 175, 267, 2082, 2083, 2165, 2167, 2168, 2170, 2171, 
  2173, 2174, 4135, 
};

static const unsigned short dep14[] = {
  96, 155, 267, 310, 2379, 28852, 29002, 
};

static const unsigned short dep15[] = {
  1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 
  22, 23, 24, 25, 26, 28, 29, 30, 31, 32, 33, 40, 41, 96, 144, 156, 174, 175, 
  267, 310, 2082, 2083, 2165, 2167, 2168, 2170, 2171, 2173, 2174, 4135, 28852, 
  29002, 
};

static const unsigned short dep16[] = {
  1, 6, 40, 96, 134, 182, 187, 226, 267, 297, 2379, 28852, 29002, 
};

static const unsigned short dep17[] = {
  1, 25, 27, 38, 40, 41, 96, 156, 158, 159, 174, 175, 182, 187, 226, 267, 297, 
  2082, 2083, 2165, 2167, 2168, 2170, 2171, 2173, 2174, 4135, 28852, 29002, 
  
};

static const unsigned short dep18[] = {
  1, 40, 51, 96, 182, 226, 233, 267, 28852, 29002, 
};

static const unsigned short dep19[] = {
  1, 38, 40, 41, 96, 153, 174, 182, 226, 233, 267, 4135, 28852, 29002, 
};

static const unsigned short dep20[] = {
  40, 96, 226, 267, 
};

static const unsigned short dep21[] = {
  96, 174, 226, 267, 
};

static const unsigned short dep22[] = {
  1, 40, 96, 128, 129, 131, 132, 133, 134, 135, 138, 139, 140, 141, 142, 143, 
  144, 145, 146, 147, 148, 150, 151, 152, 153, 154, 155, 156, 159, 160, 161, 
  162, 163, 164, 165, 166, 169, 170, 171, 172, 173, 174, 175, 176, 177, 182, 
  226, 267, 294, 295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 
  307, 308, 309, 310, 311, 312, 313, 315, 316, 318, 319, 320, 321, 322, 323, 
  324, 325, 326, 327, 328, 28852, 29002, 
};

static const unsigned short dep23[] = {
  1, 38, 40, 41, 50, 51, 55, 58, 72, 96, 134, 174, 182, 226, 267, 294, 295, 
  296, 297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
  311, 312, 313, 315, 316, 318, 319, 320, 321, 322, 323, 324, 325, 326, 327, 
  328, 4135, 28852, 29002, 
};

static const unsigned short dep24[] = {
  96, 133, 267, 296, 
};

static const unsigned short dep25[] = {
  96, 134, 174, 267, 296, 
};

static const unsigned short dep26[] = {
  96, 134, 267, 297, 
};

static const unsigned short dep27[] = {
  25, 26, 96, 97, 100, 104, 107, 134, 156, 174, 267, 297, 
};

static const unsigned short dep28[] = {
  40, 41, 96, 174, 267, 2165, 2167, 2168, 2170, 2171, 2173, 2174, 4135, 
};

static const unsigned short dep29[] = {
  1, 25, 40, 96, 182, 214, 215, 226, 267, 2082, 2270, 2273, 2379, 28852, 29002, 
  
};

static const unsigned short dep30[] = {
  1, 6, 38, 40, 41, 96, 134, 156, 174, 175, 182, 214, 216, 226, 267, 2082, 2083, 
  2165, 2167, 2168, 2170, 2171, 2173, 2174, 2271, 2273, 4135, 28852, 29002, 
  
};

static const unsigned short dep31[] = {
  96, 267, 
};

static const unsigned short dep32[] = {
  96, 174, 267, 2082, 2084, 
};

static const unsigned short dep33[] = {
  40, 41, 96, 156, 174, 175, 267, 2165, 2167, 2168, 2170, 2171, 2173, 2174, 
  4135, 
};

static const unsigned short dep34[] = {
  6, 37, 38, 39, 96, 124, 125, 187, 226, 267, 292, 293, 2379, 
};

static const unsigned short dep35[] = {
  6, 37, 40, 41, 96, 156, 174, 175, 187, 226, 267, 292, 293, 331, 2165, 2167, 
  2168, 2170, 2171, 2173, 2174, 4135, 
};

static const unsigned short dep36[] = {
  24, 96, 213, 267, 2379, 
};

static const unsigned short dep37[] = {
  24, 40, 41, 96, 156, 174, 175, 213, 267, 2165, 2167, 2168, 2170, 2171, 2173, 
  2174, 4135, 
};

static const unsigned short dep38[] = {
  6, 24, 37, 38, 39, 96, 124, 125, 187, 213, 226, 267, 292, 293, 2379, 
};

static const unsigned short dep39[] = {
  6, 24, 37, 40, 41, 96, 156, 174, 175, 187, 213, 226, 267, 292, 293, 331, 2165, 
  2167, 2168, 2170, 2171, 2173, 2174, 4135, 
};

static const unsigned short dep40[] = {
  1, 6, 38, 40, 41, 96, 134, 156, 174, 175, 182, 214, 216, 226, 267, 2165, 2167, 
  2168, 2170, 2171, 2173, 2174, 2271, 2273, 4135, 28852, 29002, 
};

static const unsigned short dep41[] = {
  96, 174, 267, 
};

static const unsigned short dep42[] = {
  15, 96, 196, 197, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 22812, 22813, 22816, 
  22817, 22820, 22821, 
};

static const unsigned short dep43[] = {
  11, 19, 20, 40, 41, 96, 174, 196, 198, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 22809, 22812, 
  22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep44[] = {
  15, 16, 17, 18, 96, 196, 197, 199, 200, 202, 203, 205, 206, 267, 2135, 2310, 
  18593, 18594, 18746, 18747, 18749, 18750, 22645, 22646, 22647, 22649, 22650, 
  22652, 22653, 22809, 22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep45[] = {
  11, 12, 13, 14, 19, 20, 40, 41, 96, 174, 196, 198, 199, 201, 202, 204, 205, 
  207, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2310, 4135, 16524, 16526, 
  18746, 18748, 18749, 18751, 22809, 22812, 22813, 22816, 22817, 22820, 22821, 
  
};

static const unsigned short dep46[] = {
  16, 96, 199, 200, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 22812, 22813, 22816, 
  22817, 22820, 22821, 
};

static const unsigned short dep47[] = {
  12, 19, 20, 40, 41, 96, 174, 199, 201, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 22809, 22812, 
  22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep48[] = {
  17, 96, 202, 203, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 22812, 22813, 22816, 
  22817, 22820, 22821, 
};

static const unsigned short dep49[] = {
  13, 19, 20, 40, 41, 96, 174, 202, 204, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 22809, 22812, 
  22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep50[] = {
  18, 96, 205, 206, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 22812, 22813, 22816, 
  22817, 22820, 22821, 
};

static const unsigned short dep51[] = {
  14, 19, 20, 40, 41, 96, 174, 205, 207, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 22809, 22812, 
  22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep52[] = {
  15, 96, 196, 197, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  
};

static const unsigned short dep53[] = {
  11, 19, 20, 40, 41, 96, 174, 196, 198, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 
};

static const unsigned short dep54[] = {
  15, 16, 17, 18, 96, 196, 197, 199, 200, 202, 203, 205, 206, 267, 2135, 2310, 
  18593, 18594, 18746, 18747, 18749, 18750, 
};

static const unsigned short dep55[] = {
  11, 12, 13, 14, 19, 20, 40, 41, 96, 174, 196, 198, 199, 201, 202, 204, 205, 
  207, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2310, 4135, 16524, 16526, 
  18746, 18748, 18749, 18751, 
};

static const unsigned short dep56[] = {
  16, 96, 199, 200, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  
};

static const unsigned short dep57[] = {
  12, 19, 20, 40, 41, 96, 174, 199, 201, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 
};

static const unsigned short dep58[] = {
  17, 96, 202, 203, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  
};

static const unsigned short dep59[] = {
  13, 19, 20, 40, 41, 96, 174, 202, 204, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 
};

static const unsigned short dep60[] = {
  18, 96, 205, 206, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
  
};

static const unsigned short dep61[] = {
  14, 19, 20, 40, 41, 96, 174, 205, 207, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 
};

static const unsigned short dep62[] = {
  96, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
};

static const unsigned short dep63[] = {
  40, 41, 96, 174, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2310, 4135, 
  16524, 16526, 18746, 18748, 18749, 18751, 
};

static const unsigned short dep64[] = {
  11, 96, 192, 267, 
};

static const unsigned short dep65[] = {
  11, 40, 41, 96, 174, 192, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep66[] = {
  11, 40, 41, 96, 174, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep67[] = {
  12, 96, 193, 267, 
};

static const unsigned short dep68[] = {
  11, 40, 41, 96, 174, 193, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep69[] = {
  13, 96, 194, 267, 
};

static const unsigned short dep70[] = {
  11, 40, 41, 96, 174, 194, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep71[] = {
  14, 96, 195, 267, 
};

static const unsigned short dep72[] = {
  11, 40, 41, 96, 174, 195, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep73[] = {
  15, 96, 197, 198, 267, 
};

static const unsigned short dep74[] = {
  40, 41, 96, 174, 197, 198, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep75[] = {
  40, 41, 96, 174, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep76[] = {
  16, 96, 200, 201, 267, 
};

static const unsigned short dep77[] = {
  40, 41, 96, 174, 200, 201, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep78[] = {
  17, 96, 203, 204, 267, 
};

static const unsigned short dep79[] = {
  40, 41, 96, 174, 203, 204, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep80[] = {
  18, 96, 206, 207, 267, 
};

static const unsigned short dep81[] = {
  40, 41, 96, 174, 206, 207, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep82[] = {
  15, 19, 20, 40, 41, 96, 156, 174, 175, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep83[] = {
  15, 16, 19, 20, 40, 41, 96, 156, 174, 175, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep84[] = {
  15, 17, 19, 20, 40, 41, 96, 156, 174, 175, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep85[] = {
  15, 18, 19, 20, 40, 41, 96, 156, 174, 175, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep86[] = {
  15, 96, 196, 197, 267, 
};

static const unsigned short dep87[] = {
  11, 19, 20, 40, 41, 96, 174, 196, 198, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep88[] = {
  15, 16, 17, 18, 96, 196, 197, 199, 200, 202, 203, 205, 206, 267, 
};

static const unsigned short dep89[] = {
  11, 12, 13, 14, 19, 20, 40, 41, 96, 174, 196, 198, 199, 201, 202, 204, 205, 
  207, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep90[] = {
  16, 96, 199, 200, 267, 
};

static const unsigned short dep91[] = {
  12, 19, 20, 40, 41, 96, 174, 199, 201, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep92[] = {
  17, 96, 202, 203, 267, 
};

static const unsigned short dep93[] = {
  13, 19, 20, 40, 41, 96, 174, 202, 204, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep94[] = {
  18, 96, 205, 206, 267, 
};

static const unsigned short dep95[] = {
  14, 19, 20, 40, 41, 96, 174, 205, 207, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep96[] = {
  15, 96, 196, 197, 267, 2165, 2166, 2167, 2169, 2170, 2172, 2173, 2329, 2332, 
  2333, 2336, 2337, 2340, 2341, 
};

static const unsigned short dep97[] = {
  11, 19, 20, 40, 41, 96, 174, 196, 198, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2329, 2332, 2333, 2336, 2337, 2340, 2341, 4135, 16524, 16526, 
  
};

static const unsigned short dep98[] = {
  15, 16, 17, 18, 96, 196, 197, 199, 200, 202, 203, 205, 206, 267, 2165, 2166, 
  2167, 2169, 2170, 2172, 2173, 2329, 2332, 2333, 2336, 2337, 2340, 2341, 
};

static const unsigned short dep99[] = {
  11, 12, 13, 14, 19, 20, 40, 41, 96, 174, 196, 198, 199, 201, 202, 204, 205, 
  207, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2329, 2332, 2333, 2336, 
  2337, 2340, 2341, 4135, 16524, 16526, 
};

static const unsigned short dep100[] = {
  16, 96, 199, 200, 267, 2165, 2166, 2167, 2169, 2170, 2172, 2173, 2329, 2332, 
  2333, 2336, 2337, 2340, 2341, 
};

static const unsigned short dep101[] = {
  12, 19, 20, 40, 41, 96, 174, 199, 201, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2329, 2332, 2333, 2336, 2337, 2340, 2341, 4135, 16524, 16526, 
  
};

static const unsigned short dep102[] = {
  17, 96, 202, 203, 267, 2165, 2166, 2167, 2169, 2170, 2172, 2173, 2329, 2332, 
  2333, 2336, 2337, 2340, 2341, 
};

static const unsigned short dep103[] = {
  13, 19, 20, 40, 41, 96, 174, 202, 204, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2329, 2332, 2333, 2336, 2337, 2340, 2341, 4135, 16524, 16526, 
  
};

static const unsigned short dep104[] = {
  18, 96, 205, 206, 267, 2165, 2166, 2167, 2169, 2170, 2172, 2173, 2329, 2332, 
  2333, 2336, 2337, 2340, 2341, 
};

static const unsigned short dep105[] = {
  14, 19, 20, 40, 41, 96, 174, 205, 207, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 2329, 2332, 2333, 2336, 2337, 2340, 2341, 4135, 16524, 16526, 
  
};

static const unsigned short dep106[] = {
  15, 96, 196, 197, 267, 22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 
  22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep107[] = {
  11, 19, 20, 40, 41, 96, 174, 196, 198, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 4135, 16524, 16526, 22809, 22812, 22813, 22816, 22817, 22820, 
  22821, 
};

static const unsigned short dep108[] = {
  15, 16, 17, 18, 96, 196, 197, 199, 200, 202, 203, 205, 206, 267, 22645, 22646, 
  22647, 22649, 22650, 22652, 22653, 22809, 22812, 22813, 22816, 22817, 22820, 
  22821, 
};

static const unsigned short dep109[] = {
  11, 12, 13, 14, 19, 20, 40, 41, 96, 174, 196, 198, 199, 201, 202, 204, 205, 
  207, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 4135, 16524, 16526, 22809, 
  22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep110[] = {
  16, 96, 199, 200, 267, 22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 
  22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep111[] = {
  12, 19, 20, 40, 41, 96, 174, 199, 201, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 4135, 16524, 16526, 22809, 22812, 22813, 22816, 22817, 22820, 
  22821, 
};

static const unsigned short dep112[] = {
  17, 96, 202, 203, 267, 22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 
  22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep113[] = {
  13, 19, 20, 40, 41, 96, 174, 202, 204, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 4135, 16524, 16526, 22809, 22812, 22813, 22816, 22817, 22820, 
  22821, 
};

static const unsigned short dep114[] = {
  18, 96, 205, 206, 267, 22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 
  22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep115[] = {
  14, 19, 20, 40, 41, 96, 174, 205, 207, 267, 2134, 2135, 2136, 2165, 2166, 
  2169, 2172, 4135, 16524, 16526, 22809, 22812, 22813, 22816, 22817, 22820, 
  22821, 
};

static const unsigned short dep116[] = {
  96, 267, 2165, 2166, 2167, 2169, 2170, 2172, 2173, 2329, 2332, 2333, 2336, 
  2337, 2340, 2341, 
};

static const unsigned short dep117[] = {
  40, 41, 96, 174, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2329, 2332, 
  2333, 2336, 2337, 2340, 2341, 4135, 16524, 16526, 
};

static const unsigned short dep118[] = {
  96, 267, 22645, 22646, 22647, 22649, 22650, 22652, 22653, 22809, 22812, 22813, 
  22816, 22817, 22820, 22821, 
};

static const unsigned short dep119[] = {
  40, 41, 96, 174, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 4135, 16524, 
  16526, 22809, 22812, 22813, 22816, 22817, 22820, 22821, 
};

static const unsigned short dep120[] = {
  19, 20, 40, 41, 96, 174, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2310, 
  4135, 16524, 16526, 18746, 18748, 18749, 18751, 
};

static const unsigned short dep121[] = {
  40, 41, 96, 156, 174, 175, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  4135, 20613, 
};

static const unsigned short dep122[] = {
  96, 267, 2083, 2084, 2271, 2272, 
};

static const unsigned short dep123[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2270, 2272, 
  4135, 20613, 
};

static const unsigned short dep124[] = {
  40, 41, 96, 174, 267, 2082, 2084, 2165, 2166, 2169, 2172, 2312, 4135, 20613, 
  
};

static const unsigned short dep125[] = {
  96, 267, 14454, 14456, 14457, 14459, 14460, 14462, 14620, 14621, 14624, 14625, 
  14628, 14629, 
};

static const unsigned short dep126[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 4135, 14620, 14621, 14624, 14625, 
  14628, 14629, 20613, 24693, 24694, 24697, 24700, 
};

static const unsigned short dep127[] = {
  96, 121, 123, 124, 126, 267, 288, 289, 292, 293, 
};

static const unsigned short dep128[] = {
  40, 41, 96, 174, 267, 288, 289, 292, 293, 4135, 24693, 24694, 24697, 24700, 
  
};

static const unsigned short dep129[] = {
  40, 41, 96, 174, 267, 2165, 2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep130[] = {
  40, 41, 96, 118, 121, 124, 174, 267, 2312, 4135, 20613, 24693, 
};

static const unsigned short dep131[] = {
  6, 24, 26, 27, 96, 187, 213, 216, 267, 2081, 2269, 
};

static const unsigned short dep132[] = {
  40, 41, 96, 174, 187, 213, 215, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  2269, 4135, 20613, 
};

static const unsigned short dep133[] = {
  6, 24, 25, 26, 40, 41, 96, 174, 267, 2081, 2165, 2166, 2169, 2172, 2312, 4135, 
  20613, 
};

static const unsigned short dep134[] = {
  0, 40, 41, 96, 156, 174, 175, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep135[] = {
  0, 96, 181, 267, 
};

static const unsigned short dep136[] = {
  0, 40, 41, 96, 156, 174, 175, 181, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep137[] = {
  40, 41, 96, 174, 181, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep138[] = {
  2, 28, 96, 183, 217, 267, 28852, 29002, 
};

static const unsigned short dep139[] = {
  1, 2, 28, 29, 96, 168, 169, 174, 183, 217, 267, 28852, 29002, 
};

static const unsigned short dep140[] = {
  1, 28, 29, 38, 40, 41, 96, 168, 169, 174, 183, 217, 267, 4135, 28852, 29002, 
  
};

static const unsigned short dep141[] = {
  0, 40, 41, 96, 174, 181, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep142[] = {
  1, 2, 3, 4, 5, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 
  28, 29, 30, 31, 96, 182, 183, 184, 185, 186, 188, 189, 190, 191, 192, 193, 
  194, 195, 197, 198, 200, 201, 203, 204, 206, 207, 208, 209, 210, 211, 217, 
  218, 219, 267, 2071, 2081, 2260, 2269, 28852, 29002, 
};

static const unsigned short dep143[] = {
  29, 40, 41, 96, 134, 174, 182, 183, 184, 185, 186, 188, 189, 190, 191, 192, 
  193, 194, 195, 197, 198, 200, 201, 203, 204, 206, 207, 208, 209, 210, 211, 
  217, 218, 219, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2260, 2269, 
  4135, 20613, 28852, 29002, 
};

static const unsigned short dep144[] = {
  96, 267, 14463, 14465, 14466, 14468, 14497, 14498, 14513, 14630, 14631, 14651, 
  14652, 14654, 14655, 14664, 
};

static const unsigned short dep145[] = {
  40, 41, 96, 173, 174, 267, 2165, 2166, 2169, 2172, 4135, 14630, 14631, 14651, 
  14652, 14654, 14655, 14664, 
};

static const unsigned short dep146[] = {
  14463, 14465, 14466, 14468, 14497, 14498, 14513, 14630, 14631, 14651, 14652, 
  14654, 14655, 14664, 
};

static const unsigned short dep147[] = {
  173, 14630, 14631, 14651, 14652, 14654, 14655, 14664, 
};

static const unsigned short dep148[] = {
  96, 267, 14464, 14465, 14467, 14468, 14476, 14477, 14478, 14479, 14480, 14481, 
  14482, 14483, 14485, 14488, 14489, 14497, 14498, 14499, 14500, 14501, 14506, 
  14507, 14508, 14509, 14513, 14630, 14631, 14637, 14638, 14639, 14640, 14642, 
  14644, 14651, 14652, 14654, 14655, 14656, 14657, 14660, 14661, 14664, 
};

static const unsigned short dep149[] = {
  40, 41, 72, 96, 134, 174, 267, 2165, 2166, 2169, 2172, 4135, 14630, 14631, 
  14637, 14638, 14639, 14640, 14642, 14644, 14651, 14652, 14654, 14655, 14656, 
  14657, 14660, 14661, 14664, 
};

static const unsigned short dep150[] = {
  1, 2, 3, 4, 5, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 
  28, 29, 30, 31, 40, 41, 96, 134, 171, 174, 267, 2071, 2081, 2165, 2166, 2169, 
  2172, 2312, 4135, 20613, 28852, 
};

static const unsigned short dep151[] = {
  43, 44, 45, 46, 47, 48, 49, 50, 52, 53, 54, 55, 56, 57, 58, 60, 61, 62, 63, 
  64, 65, 67, 69, 70, 71, 72, 93, 95, 96, 228, 229, 230, 231, 232, 233, 234, 
  235, 236, 237, 238, 240, 241, 242, 243, 244, 246, 248, 249, 250, 266, 267, 
  2116, 2295, 
};

static const unsigned short dep152[] = {
  40, 41, 95, 96, 134, 153, 174, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
  237, 238, 240, 241, 242, 243, 244, 246, 248, 249, 250, 266, 267, 2137, 2138, 
  2139, 2165, 2166, 2169, 2172, 2295, 4135, 20613, 
};

static const unsigned short dep153[] = {
  59, 94, 96, 239, 266, 267, 2139, 2312, 
};

static const unsigned short dep154[] = {
  40, 41, 43, 44, 46, 48, 49, 51, 52, 53, 54, 56, 57, 60, 61, 63, 64, 65, 66, 
  67, 69, 70, 71, 93, 94, 96, 134, 153, 174, 239, 266, 267, 2107, 2116, 2165, 
  2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep155[] = {
  2, 28, 41, 96, 183, 217, 226, 267, 2139, 2312, 28852, 29002, 
};

static const unsigned short dep156[] = {
  2, 25, 26, 28, 29, 38, 40, 41, 96, 168, 169, 174, 183, 217, 226, 267, 2312, 
  4135, 20613, 28852, 29002, 
};

static const unsigned short dep157[] = {
  96, 128, 129, 131, 132, 136, 137, 140, 141, 142, 143, 144, 145, 146, 147, 
  149, 152, 153, 157, 158, 161, 162, 163, 164, 165, 167, 168, 170, 171, 172, 
  173, 175, 176, 177, 267, 294, 295, 299, 301, 302, 303, 304, 306, 308, 312, 
  315, 316, 318, 319, 320, 321, 323, 324, 325, 327, 328, 
};

static const unsigned short dep158[] = {
  40, 41, 72, 96, 134, 174, 267, 294, 295, 299, 301, 302, 303, 304, 306, 308, 
  312, 315, 316, 318, 319, 320, 321, 323, 324, 325, 327, 328, 2137, 2138, 2139, 
  2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep159[] = {
  96, 127, 129, 130, 132, 161, 162, 177, 267, 294, 295, 315, 316, 318, 319, 
  328, 
};

static const unsigned short dep160[] = {
  40, 41, 96, 173, 174, 267, 294, 295, 315, 316, 318, 319, 328, 2137, 2138, 
  2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep161[] = {
  40, 41, 96, 129, 132, 134, 137, 138, 141, 143, 145, 147, 149, 150, 152, 156, 
  157, 159, 160, 161, 162, 164, 165, 167, 169, 170, 172, 174, 176, 177, 267, 
  2165, 2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep162[] = {
  40, 41, 96, 129, 132, 161, 162, 174, 177, 267, 2165, 2166, 2169, 2172, 2312, 
  4135, 20613, 
};

static const unsigned short dep163[] = {
  40, 41, 75, 76, 81, 83, 96, 110, 134, 163, 174, 178, 267, 2137, 2138, 2139, 
  2165, 2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep164[] = {
  40, 41, 75, 76, 81, 83, 96, 110, 134, 135, 136, 138, 139, 163, 174, 178, 267, 
  2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep165[] = {
  76, 77, 96, 100, 101, 254, 255, 267, 269, 270, 
};

static const unsigned short dep166[] = {
  40, 41, 47, 62, 77, 79, 85, 96, 98, 101, 134, 153, 174, 178, 254, 255, 267, 
  269, 270, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep167[] = {
  40, 41, 47, 62, 77, 79, 96, 98, 101, 103, 105, 134, 153, 174, 178, 254, 255, 
  267, 269, 270, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep168[] = {
  96, 267, 12466, 12467, 12617, 
};

static const unsigned short dep169[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  12617, 20613, 
};

static const unsigned short dep170[] = {
  96, 267, 6218, 6219, 6396, 
};

static const unsigned short dep171[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  6396, 20613, 
};

static const unsigned short dep172[] = {
  96, 267, 6236, 6409, 
};

static const unsigned short dep173[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  6409, 20613, 
};

static const unsigned short dep174[] = {
  96, 267, 6254, 6255, 6256, 6257, 6420, 6422, 8469, 
};

static const unsigned short dep175[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  6257, 6421, 6422, 8303, 8468, 20613, 
};

static const unsigned short dep176[] = {
  96, 267, 6258, 6259, 6423, 
};

static const unsigned short dep177[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  6423, 20613, 
};

static const unsigned short dep178[] = {
  96, 267, 6260, 6424, 
};

static const unsigned short dep179[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  6424, 20613, 
};

static const unsigned short dep180[] = {
  96, 267, 10349, 10515, 
};

static const unsigned short dep181[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 
  10515, 20613, 
};

static const unsigned short dep182[] = {
  76, 77, 81, 82, 96, 100, 101, 254, 255, 257, 258, 267, 269, 270, 
};

static const unsigned short dep183[] = {
  40, 41, 47, 62, 77, 79, 82, 85, 96, 98, 101, 134, 153, 174, 178, 254, 255, 
  257, 259, 267, 269, 270, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
  
};

static const unsigned short dep184[] = {
  76, 77, 96, 100, 101, 103, 104, 254, 255, 267, 269, 270, 271, 272, 
};

static const unsigned short dep185[] = {
  40, 41, 47, 62, 77, 79, 96, 98, 101, 103, 105, 134, 153, 174, 178, 254, 255, 
  267, 269, 270, 271, 272, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
  
};

static const unsigned short dep186[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 12467, 20613, 
};

static const unsigned short dep187[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 6218, 20613, 
};

static const unsigned short dep188[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 6236, 20613, 
};

static const unsigned short dep189[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 6256, 8302, 20613, 
};

static const unsigned short dep190[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 6258, 20613, 
};

static const unsigned short dep191[] = {
  40, 41, 96, 134, 173, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  2312, 4135, 6259, 6260, 20613, 
};

static const unsigned short dep192[] = {
  40, 41, 96, 134, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 10349, 20613, 
};

static const unsigned short dep193[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 4135, 
  6186, 20613, 
};

static const unsigned short dep194[] = {
  76, 78, 79, 96, 97, 98, 99, 253, 254, 267, 268, 269, 
};

static const unsigned short dep195[] = {
  40, 41, 77, 78, 82, 84, 96, 99, 101, 103, 106, 134, 174, 178, 253, 255, 267, 
  268, 270, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep196[] = {
  76, 78, 79, 80, 96, 97, 98, 99, 102, 253, 254, 256, 267, 268, 269, 
};

static const unsigned short dep197[] = {
  40, 41, 77, 78, 80, 82, 84, 96, 99, 101, 102, 103, 106, 134, 174, 178, 253, 
  255, 256, 267, 268, 270, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
  
};

static const unsigned short dep198[] = {
  76, 78, 79, 83, 84, 85, 96, 97, 98, 99, 253, 254, 259, 260, 267, 268, 269, 
  
};

static const unsigned short dep199[] = {
  40, 41, 77, 78, 82, 84, 96, 99, 101, 134, 174, 178, 253, 255, 258, 260, 267, 
  268, 270, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep200[] = {
  76, 78, 79, 96, 97, 98, 99, 105, 106, 107, 253, 254, 267, 268, 269, 272, 273, 
  
};

static const unsigned short dep201[] = {
  40, 41, 77, 78, 96, 99, 101, 103, 106, 134, 174, 178, 253, 255, 267, 268, 
  270, 271, 273, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep202[] = {
  40, 41, 46, 70, 96, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  2312, 4135, 20613, 
};

static const unsigned short dep203[] = {
  40, 41, 96, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 20613, 
};

static const unsigned short dep204[] = {
  40, 41, 76, 81, 83, 96, 134, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 
  2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep205[] = {
  40, 41, 96, 156, 174, 175, 267, 2134, 2135, 2136, 2137, 2138, 2139, 2165, 
  2166, 2169, 2172, 4135, 16524, 16526, 20613, 
};

static const unsigned short dep206[] = {
  40, 41, 76, 81, 83, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  4135, 20613, 
};

static const unsigned short dep207[] = {
  40, 41, 77, 78, 96, 99, 134, 174, 253, 255, 267, 268, 270, 2137, 2138, 2139, 
  2165, 2166, 2169, 2172, 4135, 20613, 
};

static const unsigned short dep208[] = {
  40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2312, 
  4135, 20613, 
};

static const unsigned short dep209[] = {
  5, 96, 186, 267, 2139, 2312, 
};

static const unsigned short dep210[] = {
  40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 186, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  2312, 4135, 20613, 
};

static const unsigned short dep211[] = {
  40, 41, 44, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 148, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2312, 4135, 20613, 
};

static const unsigned short dep212[] = {
  0, 96, 181, 267, 2139, 2312, 
};

static const unsigned short dep213[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 163, 174, 178, 181, 267, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2312, 4135, 20613, 
};

static const unsigned short dep214[] = {
  0, 40, 41, 44, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 
  136, 138, 139, 146, 148, 163, 174, 178, 181, 267, 2137, 2138, 2139, 2165, 
  2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep215[] = {
  31, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  2312, 4135, 20613, 
};

static const unsigned short dep216[] = {
  0, 96, 181, 267, 2312, 26714, 
};

static const unsigned short dep217[] = {
  0, 96, 108, 181, 267, 274, 
};

static const unsigned short dep218[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 181, 267, 274, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 4135, 20613, 
};

static const unsigned short dep219[] = {
  0, 5, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 163, 174, 178, 181, 267, 274, 2137, 2138, 2139, 2165, 2166, 
  2169, 2172, 4135, 20613, 
};

static const unsigned short dep220[] = {
  0, 31, 96, 108, 181, 219, 267, 274, 
};

static const unsigned short dep221[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 181, 219, 267, 274, 2137, 2138, 2139, 2165, 2166, 
  2169, 2172, 4135, 20613, 
};

static const unsigned short dep222[] = {
  0, 96, 108, 181, 267, 274, 2139, 2312, 
};

static const unsigned short dep223[] = {
  0, 4, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 
  136, 138, 139, 146, 163, 174, 178, 181, 267, 274, 2137, 2138, 2139, 2165, 
  2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep224[] = {
  0, 4, 5, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 
  136, 138, 139, 146, 163, 174, 178, 181, 267, 274, 2137, 2138, 2139, 2165, 
  2166, 2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep225[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 163, 174, 178, 181, 267, 274, 2137, 2138, 2139, 2165, 2166, 
  2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep226[] = {
  40, 41, 96, 174, 267, 2134, 2135, 2136, 2165, 2166, 2169, 2172, 2312, 4135, 
  16524, 16526, 20613, 
};

static const unsigned short dep227[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 181, 267, 274, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2312, 4135, 20613, 
};

static const unsigned short dep228[] = {
  0, 31, 96, 108, 181, 219, 267, 274, 2139, 2312, 
};

static const unsigned short dep229[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 181, 219, 267, 274, 2137, 2138, 2139, 2165, 2166, 
  2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep230[] = {
  40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2310, 
  4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep231[] = {
  40, 41, 44, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 148, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep232[] = {
  0, 96, 181, 267, 2135, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
};

static const unsigned short dep233[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 163, 174, 178, 181, 267, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep234[] = {
  0, 40, 41, 44, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 
  136, 138, 139, 146, 148, 163, 174, 178, 181, 267, 2137, 2138, 2139, 2165, 
  2166, 2169, 2172, 2310, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
  
};

static const unsigned short dep235[] = {
  0, 96, 181, 267, 2136, 2310, 18593, 18594, 18746, 18747, 18749, 18750, 
};

static const unsigned short dep236[] = {
  96, 267, 2135, 2139, 2310, 2312, 18593, 18594, 18746, 18747, 18749, 18750, 
  
};

static const unsigned short dep237[] = {
  40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2310, 
  2312, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep238[] = {
  40, 41, 44, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 148, 163, 174, 178, 267, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2310, 2312, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep239[] = {
  0, 96, 181, 267, 2135, 2139, 2310, 2312, 18593, 18594, 18746, 18747, 18749, 
  18750, 
};

static const unsigned short dep240[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 136, 
  138, 139, 146, 163, 174, 178, 181, 267, 2137, 2138, 2139, 2165, 2166, 2169, 
  2172, 2310, 2312, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep241[] = {
  0, 40, 41, 44, 75, 76, 81, 83, 96, 108, 110, 127, 128, 130, 131, 134, 135, 
  136, 138, 139, 146, 148, 163, 174, 178, 181, 267, 2137, 2138, 2139, 2165, 
  2166, 2169, 2172, 2310, 2312, 4135, 16524, 16526, 18746, 18748, 18749, 18751, 
  20613, 
};

static const unsigned short dep242[] = {
  0, 96, 181, 267, 2136, 2139, 2310, 2312, 18593, 18594, 18746, 18747, 18749, 
  18750, 
};

static const unsigned short dep243[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 181, 267, 274, 2134, 2135, 2136, 2137, 2138, 2139, 
  2165, 2166, 2169, 2172, 4135, 16524, 16526, 20613, 
};

static const unsigned short dep244[] = {
  40, 41, 75, 96, 134, 148, 174, 267, 2165, 2166, 2169, 2172, 4135, 
};

static const unsigned short dep245[] = {
  40, 41, 75, 96, 134, 135, 139, 148, 174, 267, 2165, 2166, 2169, 2172, 4135, 
  
};

static const unsigned short dep246[] = {
  40, 41, 75, 96, 134, 148, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 
  2312, 4135, 20613, 
};

static const unsigned short dep247[] = {
  40, 41, 75, 96, 134, 135, 139, 148, 174, 267, 2137, 2138, 2139, 2165, 2166, 
  2169, 2172, 2312, 4135, 20613, 
};

static const unsigned short dep248[] = {
  40, 41, 96, 174, 267, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2310, 4135, 
  16524, 16526, 18746, 18748, 18749, 18751, 20613, 
};

static const unsigned short dep249[] = {
  0, 40, 41, 75, 76, 81, 83, 96, 110, 127, 128, 130, 131, 134, 135, 136, 138, 
  139, 146, 163, 174, 178, 181, 267, 274, 2134, 2135, 2136, 2137, 2138, 2139, 
  2165, 2166, 2169, 2172, 2312, 4135, 16524, 16526, 20613, 
};

static const unsigned short dep250[] = {
  1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 
  22, 24, 26, 27, 28, 29, 30, 31, 96, 182, 183, 184, 185, 186, 187, 188, 189, 
  190, 191, 192, 193, 194, 195, 197, 198, 200, 201, 203, 204, 206, 207, 208, 
  209, 210, 211, 213, 216, 217, 218, 219, 267, 2071, 2081, 2139, 2260, 2269, 
  2312, 28852, 29002, 
};

static const unsigned short dep251[] = {
  1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 
  22, 24, 25, 26, 28, 29, 30, 31, 40, 41, 96, 134, 171, 174, 182, 183, 184, 
  185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 197, 198, 200, 201, 
  203, 204, 206, 207, 208, 209, 210, 211, 213, 215, 217, 218, 219, 267, 2071, 
  2081, 2137, 2138, 2139, 2165, 2166, 2169, 2172, 2260, 2269, 2312, 4135, 20613, 
  28852, 29002, 
};

#define NELS(X) (sizeof(X)/sizeof(X[0]))
static const struct ia64_opcode_dependency
op_dependencies[] = {
  { NELS(dep1), dep1, NELS(dep0), dep0, },
  { NELS(dep3), dep3, NELS(dep2), dep2, },
  { NELS(dep5), dep5, NELS(dep4), dep4, },
  { NELS(dep7), dep7, NELS(dep6), dep6, },
  { NELS(dep9), dep9, NELS(dep8), dep8, },
  { NELS(dep11), dep11, NELS(dep10), dep10, },
  { NELS(dep13), dep13, NELS(dep12), dep12, },
  { NELS(dep15), dep15, NELS(dep14), dep14, },
  { NELS(dep17), dep17, NELS(dep16), dep16, },
  { NELS(dep19), dep19, NELS(dep18), dep18, },
  { NELS(dep21), dep21, NELS(dep20), dep20, },
  { NELS(dep23), dep23, NELS(dep22), dep22, },
  { NELS(dep25), dep25, NELS(dep24), dep24, },
  { NELS(dep27), dep27, NELS(dep26), dep26, },
  { NELS(dep28), dep28, NELS(dep12), dep12, },
  { NELS(dep30), dep30, NELS(dep29), dep29, },
  { NELS(dep32), dep32, NELS(dep31), dep31, },
  { NELS(dep33), dep33, NELS(dep12), dep12, },
  { NELS(dep35), dep35, NELS(dep34), dep34, },
  { NELS(dep37), dep37, NELS(dep36), dep36, },
  { NELS(dep39), dep39, NELS(dep38), dep38, },
  { NELS(dep40), dep40, NELS(dep29), dep29, },
  { NELS(dep41), dep41, NELS(dep31), dep31, },
  { NELS(dep43), dep43, NELS(dep42), dep42, },
  { NELS(dep45), dep45, NELS(dep44), dep44, },
  { NELS(dep47), dep47, NELS(dep46), dep46, },
  { NELS(dep49), dep49, NELS(dep48), dep48, },
  { NELS(dep51), dep51, NELS(dep50), dep50, },
  { NELS(dep53), dep53, NELS(dep52), dep52, },
  { NELS(dep55), dep55, NELS(dep54), dep54, },
  { NELS(dep57), dep57, NELS(dep56), dep56, },
  { NELS(dep59), dep59, NELS(dep58), dep58, },
  { NELS(dep61), dep61, NELS(dep60), dep60, },
  { NELS(dep63), dep63, NELS(dep62), dep62, },
  { NELS(dep65), dep65, NELS(dep64), dep64, },
  { NELS(dep66), dep66, NELS(dep31), dep31, },
  { NELS(dep68), dep68, NELS(dep67), dep67, },
  { NELS(dep70), dep70, NELS(dep69), dep69, },
  { NELS(dep72), dep72, NELS(dep71), dep71, },
  { NELS(dep74), dep74, NELS(dep73), dep73, },
  { NELS(dep75), dep75, NELS(dep31), dep31, },
  { NELS(dep77), dep77, NELS(dep76), dep76, },
  { NELS(dep79), dep79, NELS(dep78), dep78, },
  { NELS(dep81), dep81, NELS(dep80), dep80, },
  { NELS(dep82), dep82, NELS(dep31), dep31, },
  { NELS(dep83), dep83, NELS(dep31), dep31, },
  { NELS(dep84), dep84, NELS(dep31), dep31, },
  { NELS(dep85), dep85, NELS(dep31), dep31, },
  { NELS(dep87), dep87, NELS(dep86), dep86, },
  { NELS(dep89), dep89, NELS(dep88), dep88, },
  { NELS(dep91), dep91, NELS(dep90), dep90, },
  { NELS(dep93), dep93, NELS(dep92), dep92, },
  { NELS(dep95), dep95, NELS(dep94), dep94, },
  { NELS(dep97), dep97, NELS(dep96), dep96, },
  { NELS(dep99), dep99, NELS(dep98), dep98, },
  { NELS(dep101), dep101, NELS(dep100), dep100, },
  { NELS(dep103), dep103, NELS(dep102), dep102, },
  { NELS(dep105), dep105, NELS(dep104), dep104, },
  { NELS(dep107), dep107, NELS(dep106), dep106, },
  { NELS(dep109), dep109, NELS(dep108), dep108, },
  { NELS(dep111), dep111, NELS(dep110), dep110, },
  { NELS(dep113), dep113, NELS(dep112), dep112, },
  { NELS(dep115), dep115, NELS(dep114), dep114, },
  { NELS(dep117), dep117, NELS(dep116), dep116, },
  { NELS(dep119), dep119, NELS(dep118), dep118, },
  { NELS(dep120), dep120, NELS(dep62), dep62, },
  { NELS(dep121), dep121, NELS(dep31), dep31, },
  { NELS(dep123), dep123, NELS(dep122), dep122, },
  { NELS(dep124), dep124, NELS(dep0), dep0, },
  { NELS(dep126), dep126, NELS(dep125), dep125, },
  { NELS(dep128), dep128, NELS(dep127), dep127, },
  { NELS(dep129), dep129, NELS(dep0), dep0, },
  { NELS(dep130), dep130, NELS(dep0), dep0, },
  { NELS(dep132), dep132, NELS(dep131), dep131, },
  { NELS(dep133), dep133, NELS(dep0), dep0, },
  { NELS(dep134), dep134, NELS(dep31), dep31, },
  { NELS(dep136), dep136, NELS(dep135), dep135, },
  { NELS(dep137), dep137, NELS(dep135), dep135, },
  { NELS(dep139), dep139, NELS(dep138), dep138, },
  { NELS(dep140), dep140, NELS(dep138), dep138, },
  { NELS(dep141), dep141, NELS(dep135), dep135, },
  { NELS(dep143), dep143, NELS(dep142), dep142, },
  { NELS(dep145), dep145, NELS(dep144), dep144, },
  { NELS(dep147), dep147, NELS(dep146), dep146, },
  { NELS(dep149), dep149, NELS(dep148), dep148, },
  { NELS(dep150), dep150, NELS(dep0), dep0, },
  { NELS(dep152), dep152, NELS(dep151), dep151, },
  { NELS(dep154), dep154, NELS(dep153), dep153, },
  { NELS(dep156), dep156, NELS(dep155), dep155, },
  { NELS(dep158), dep158, NELS(dep157), dep157, },
  { NELS(dep160), dep160, NELS(dep159), dep159, },
  { NELS(dep161), dep161, NELS(dep0), dep0, },
  { NELS(dep162), dep162, NELS(dep0), dep0, },
  { NELS(dep163), dep163, NELS(dep0), dep0, },
  { NELS(dep164), dep164, NELS(dep31), dep31, },
  { NELS(dep166), dep166, NELS(dep165), dep165, },
  { NELS(dep167), dep167, NELS(dep165), dep165, },
  { NELS(dep169), dep169, NELS(dep168), dep168, },
  { NELS(dep171), dep171, NELS(dep170), dep170, },
  { NELS(dep173), dep173, NELS(dep172), dep172, },
  { NELS(dep175), dep175, NELS(dep174), dep174, },
  { NELS(dep177), dep177, NELS(dep176), dep176, },
  { NELS(dep179), dep179, NELS(dep178), dep178, },
  { NELS(dep181), dep181, NELS(dep180), dep180, },
  { NELS(dep183), dep183, NELS(dep182), dep182, },
  { NELS(dep185), dep185, NELS(dep184), dep184, },
  { NELS(dep186), dep186, NELS(dep0), dep0, },
  { NELS(dep187), dep187, NELS(dep0), dep0, },
  { NELS(dep188), dep188, NELS(dep0), dep0, },
  { NELS(dep189), dep189, NELS(dep0), dep0, },
  { NELS(dep190), dep190, NELS(dep0), dep0, },
  { NELS(dep191), dep191, NELS(dep0), dep0, },
  { NELS(dep192), dep192, NELS(dep0), dep0, },
  { NELS(dep193), dep193, NELS(dep0), dep0, },
  { NELS(dep195), dep195, NELS(dep194), dep194, },
  { NELS(dep197), dep197, NELS(dep196), dep196, },
  { NELS(dep199), dep199, NELS(dep198), dep198, },
  { NELS(dep201), dep201, NELS(dep200), dep200, },
  { NELS(dep202), dep202, NELS(dep0), dep0, },
  { NELS(dep203), dep203, NELS(dep0), dep0, },
  { NELS(dep204), dep204, NELS(dep0), dep0, },
  { NELS(dep205), dep205, NELS(dep31), dep31, },
  { NELS(dep206), dep206, NELS(dep31), dep31, },
  { NELS(dep207), dep207, NELS(dep194), dep194, },
  { NELS(dep208), dep208, NELS(dep0), dep0, },
  { NELS(dep210), dep210, NELS(dep209), dep209, },
  { NELS(dep211), dep211, NELS(dep0), dep0, },
  { NELS(dep213), dep213, NELS(dep212), dep212, },
  { NELS(dep214), dep214, NELS(dep212), dep212, },
  { NELS(dep215), dep215, NELS(dep0), dep0, },
  { NELS(dep213), dep213, NELS(dep216), dep216, },
  { NELS(dep218), dep218, NELS(dep217), dep217, },
  { NELS(dep219), dep219, NELS(dep217), dep217, },
  { NELS(dep221), dep221, NELS(dep220), dep220, },
  { NELS(dep223), dep223, NELS(dep222), dep222, },
  { NELS(dep224), dep224, NELS(dep222), dep222, },
  { NELS(dep225), dep225, NELS(dep222), dep222, },
  { NELS(dep226), dep226, NELS(dep0), dep0, },
  { NELS(dep227), dep227, NELS(dep222), dep222, },
  { NELS(dep229), dep229, NELS(dep228), dep228, },
  { NELS(dep230), dep230, NELS(dep62), dep62, },
  { NELS(dep231), dep231, NELS(dep62), dep62, },
  { NELS(dep233), dep233, NELS(dep232), dep232, },
  { NELS(dep234), dep234, NELS(dep232), dep232, },
  { NELS(dep233), dep233, NELS(dep235), dep235, },
  { NELS(dep237), dep237, NELS(dep236), dep236, },
  { NELS(dep238), dep238, NELS(dep236), dep236, },
  { NELS(dep240), dep240, NELS(dep239), dep239, },
  { NELS(dep241), dep241, NELS(dep239), dep239, },
  { NELS(dep240), dep240, NELS(dep242), dep242, },
  { NELS(dep243), dep243, NELS(dep217), dep217, },
  { NELS(dep244), dep244, NELS(dep31), dep31, },
  { NELS(dep245), dep245, NELS(dep31), dep31, },
  { NELS(dep246), dep246, NELS(dep0), dep0, },
  { NELS(dep247), dep247, NELS(dep0), dep0, },
  { NELS(dep248), dep248, NELS(dep62), dep62, },
  { NELS(dep249), dep249, NELS(dep222), dep222, },
  { 0, NULL, 0, NULL, },
  { NELS(dep251), dep251, NELS(dep250), dep250, },
};

static const struct ia64_completer_table
completer_table[] = {
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 88 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 88 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 576, -1, 0, 1, 6 },
  { 0x0, 0x0, 0, 639, -1, 0, 1, 17 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 157 },
  { 0x0, 0x0, 0, 738, -1, 0, 1, 17 },
  { 0x0, 0x0, 0, 2164, -1, 0, 1, 10 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 9 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 13 },
  { 0x1, 0x1, 0, -1, -1, 13, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, 2372, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, 1122, -1, 0, 1, 122 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 44 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 78 },
  { 0x0, 0x0, 0, 2212, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 2439, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 2216, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, 2218, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 2448, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 2451, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 2473, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 2476, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 24 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 24 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 24 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 24 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 35 },
  { 0x0, 0x0, 0, 2484, -1, 0, 1, 29 },
  { 0x0, 0x0, 0, 1391, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 157 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 77 },
  { 0x0, 0x0, 0, 1439, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1448, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1457, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1459, -1, 0, 1, 125 },
  { 0x0, 0x0, 0, 1461, -1, 0, 1, 125 },
  { 0x0, 0x0, 0, 1470, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1479, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1488, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1497, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1506, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1515, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1525, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1535, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1545, -1, 0, 1, 124 },
  { 0x0, 0x0, 0, 1554, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1560, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1566, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1572, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1578, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1584, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1590, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1596, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1602, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1608, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1614, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1620, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1626, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1632, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1638, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1644, -1, 0, 1, 140 },
  { 0x0, 0x0, 0, 1650, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1656, -1, 0, 1, 145 },
  { 0x0, 0x0, 0, 1660, -1, 0, 1, 151 },
  { 0x0, 0x0, 0, 1664, -1, 0, 1, 153 },
  { 0x0, 0x0, 0, 1668, -1, 0, 1, 153 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 79 },
  { 0x0, 0x0, 0, 256, -1, 0, 1, 40 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 67 },
  { 0x1, 0x1, 0, 1148, -1, 20, 1, 67 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 68 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 69 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 69 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 70 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 71 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 72 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 86 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 87 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 89 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 90 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 91 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 92 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 97 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 98 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 99 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 100 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 101 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 102 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 103 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 106 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 107 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 108 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 109 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 110 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 111 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 112 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 113 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 158 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 158 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 158 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 71 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 157 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2824, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2825, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2176, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2177, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2839, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2840, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2841, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2842, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2843, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2826, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, 2827, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 11 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 84 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 83 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x1, 0x1, 0, -1, -1, 13, 1, 0 },
  { 0x0, 0x0, 0, 2845, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 84 },
  { 0x0, 0x0, 0, 1948, -1, 0, 1, 131 },
  { 0x0, 0x0, 0, 1950, -1, 0, 1, 138 },
  { 0x0, 0x0, 0, 1952, -1, 0, 1, 132 },
  { 0x0, 0x0, 0, 1954, -1, 0, 1, 132 },
  { 0x0, 0x0, 0, 1956, -1, 0, 1, 131 },
  { 0x0, 0x0, 0, 1958, -1, 0, 1, 138 },
  { 0x0, 0x0, 0, 1960, -1, 0, 1, 131 },
  { 0x0, 0x0, 0, 1962, -1, 0, 1, 138 },
  { 0x0, 0x0, 0, 1965, -1, 0, 1, 131 },
  { 0x0, 0x0, 0, 1968, -1, 0, 1, 138 },
  { 0x0, 0x0, 0, 1971, -1, 0, 1, 150 },
  { 0x0, 0x0, 0, 1972, -1, 0, 1, 156 },
  { 0x0, 0x0, 0, 1973, -1, 0, 1, 150 },
  { 0x0, 0x0, 0, 1974, -1, 0, 1, 156 },
  { 0x0, 0x0, 0, 1975, -1, 0, 1, 150 },
  { 0x0, 0x0, 0, 1976, -1, 0, 1, 156 },
  { 0x0, 0x0, 0, 1977, -1, 0, 1, 150 },
  { 0x0, 0x0, 0, 1978, -1, 0, 1, 156 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 82 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 120 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 118 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 120 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 119 },
  { 0x0, 0x0, 0, 1669, -1, 0, 1, 136 },
  { 0x0, 0x0, 0, 1670, -1, 0, 1, 136 },
  { 0x0, 0x0, 0, 1671, -1, 0, 1, 136 },
  { 0x0, 0x0, 0, 1672, -1, 0, 1, 136 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 0, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 1, 223, -1, 0, 1, 12 },
  { 0x1, 0x1, 2, -1, -1, 27, 1, 12 },
  { 0x0, 0x0, 3, -1, 1322, 0, 0, -1 },
  { 0x0, 0x0, 3, -1, 1323, 0, 0, -1 },
  { 0x1, 0x1, 3, 2715, 1432, 33, 1, 127 },
  { 0x1, 0x1, 3, 2716, 1441, 33, 1, 127 },
  { 0x1, 0x1, 3, 2717, 1450, 33, 1, 127 },
  { 0x1, 0x1, 3, 2718, 1463, 33, 1, 127 },
  { 0x1, 0x1, 3, 2719, 1472, 33, 1, 127 },
  { 0x1, 0x1, 3, 2720, 1481, 33, 1, 127 },
  { 0x1, 0x1, 3, 2721, 1490, 33, 1, 127 },
  { 0x1, 0x1, 3, 2722, 1499, 33, 1, 127 },
  { 0x1, 0x1, 3, 2723, 1508, 33, 1, 127 },
  { 0x1, 0x1, 3, 2724, 1517, 33, 1, 127 },
  { 0x1, 0x1, 3, 2725, 1527, 33, 1, 127 },
  { 0x1, 0x1, 3, 2726, 1537, 33, 1, 127 },
  { 0x1, 0x1, 3, 2727, 1550, 33, 1, 142 },
  { 0x1, 0x1, 3, 2728, 1556, 33, 1, 147 },
  { 0x1, 0x1, 3, 2729, 1562, 33, 1, 147 },
  { 0x1, 0x1, 3, 2730, 1568, 33, 1, 142 },
  { 0x1, 0x1, 3, 2731, 1574, 33, 1, 147 },
  { 0x1, 0x1, 3, 2732, 1580, 33, 1, 147 },
  { 0x1, 0x1, 3, 2733, 1586, 33, 1, 142 },
  { 0x1, 0x1, 3, 2734, 1592, 33, 1, 147 },
  { 0x1, 0x1, 3, 2735, 1598, 33, 1, 147 },
  { 0x1, 0x1, 3, 2736, 1604, 33, 1, 142 },
  { 0x1, 0x1, 3, 2737, 1610, 33, 1, 147 },
  { 0x1, 0x1, 3, 2738, 1616, 33, 1, 142 },
  { 0x1, 0x1, 3, 2739, 1622, 33, 1, 147 },
  { 0x1, 0x1, 3, 2740, 1628, 33, 1, 142 },
  { 0x1, 0x1, 3, 2741, 1634, 33, 1, 147 },
  { 0x1, 0x1, 3, 2742, 1640, 33, 1, 142 },
  { 0x1, 0x1, 3, 2743, 1646, 33, 1, 147 },
  { 0x1, 0x1, 3, 2744, 1652, 33, 1, 147 },
  { 0x1, 0x1, 3, -1, -1, 27, 1, 40 },
  { 0x0, 0x0, 4, 2178, 1407, 0, 1, 135 },
  { 0x0, 0x0, 4, 2179, 1409, 0, 1, 135 },
  { 0x0, 0x0, 4, 2180, 1411, 0, 1, 134 },
  { 0x0, 0x0, 4, 2181, 1413, 0, 1, 134 },
  { 0x0, 0x0, 4, 2182, 1415, 0, 1, 134 },
  { 0x0, 0x0, 4, 2183, 1417, 0, 1, 134 },
  { 0x0, 0x0, 4, 2184, 1419, 0, 1, 134 },
  { 0x0, 0x0, 4, 2185, 1421, 0, 1, 134 },
  { 0x0, 0x0, 4, 2186, 1423, 0, 1, 134 },
  { 0x0, 0x0, 4, 2187, 1425, 0, 1, 134 },
  { 0x0, 0x0, 4, 2188, 1427, 0, 1, 136 },
  { 0x0, 0x0, 4, 2189, 1429, 0, 1, 136 },
  { 0x1, 0x1, 4, -1, 1436, 33, 1, 130 },
  { 0x5, 0x5, 4, 534, 1435, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1445, 33, 1, 130 },
  { 0x5, 0x5, 4, 535, 1444, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1454, 33, 1, 130 },
  { 0x5, 0x5, 4, 536, 1453, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1458, 32, 1, 125 },
  { 0x1, 0x1, 4, -1, 1460, 32, 1, 125 },
  { 0x1, 0x1, 4, -1, 1467, 33, 1, 130 },
  { 0x5, 0x5, 4, 537, 1466, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1476, 33, 1, 130 },
  { 0x5, 0x5, 4, 538, 1475, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1485, 33, 1, 130 },
  { 0x5, 0x5, 4, 539, 1484, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1494, 33, 1, 130 },
  { 0x5, 0x5, 4, 540, 1493, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1503, 33, 1, 130 },
  { 0x5, 0x5, 4, 541, 1502, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1512, 33, 1, 130 },
  { 0x5, 0x5, 4, 542, 1511, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1522, 33, 1, 130 },
  { 0x5, 0x5, 4, 1018, 1520, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1532, 33, 1, 130 },
  { 0x5, 0x5, 4, 1019, 1530, 32, 1, 124 },
  { 0x1, 0x1, 4, -1, 1542, 33, 1, 130 },
  { 0x5, 0x5, 4, 1020, 1540, 32, 1, 124 },
  { 0x1, 0x21, 10, 1991, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 1992, -1, 12, 1, 3 },
  { 0x1, 0x21, 10, 410, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2048, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, -1, 2049, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2050, 0, 0, -1 },
  { 0x0, 0x0, 10, 1995, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 1996, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 1997, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 1998, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, 420, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2054, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 424, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2056, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, 428, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2058, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 432, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2060, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, 436, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2062, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 440, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2064, -1, 12, 1, 3 },
  { 0x1, 0x21, 10, 2011, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2012, -1, 12, 1, 3 },
  { 0x1, 0x21, 10, 450, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2070, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, -1, 2071, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2072, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2075, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2076, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2077, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2078, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2079, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2080, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2081, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2082, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2083, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2084, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2085, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2086, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2087, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2088, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2089, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2090, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2091, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2092, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2093, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2094, 0, 0, -1 },
  { 0x1, 0x21, 10, 2015, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2016, -1, 12, 1, 3 },
  { 0x1, 0x21, 10, 458, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2096, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, -1, 2097, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2098, 0, 0, -1 },
  { 0x0, 0x0, 10, 2019, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2020, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 2021, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2022, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, 468, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2102, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 472, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2104, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, 476, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2106, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 480, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2108, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, 484, -1, 0, 1, 3 },
  { 0x1, 0x1, 10, 2110, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 488, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2112, -1, 12, 1, 3 },
  { 0x1, 0x21, 10, 2035, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2036, -1, 12, 1, 3 },
  { 0x1, 0x21, 10, 498, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 10, 2118, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, -1, 2119, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2120, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2123, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2124, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2125, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2126, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2127, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2128, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2129, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2130, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2131, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2132, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2133, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2134, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2135, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2136, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2137, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2138, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2139, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2140, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2141, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2142, 0, 0, -1 },
  { 0x1, 0x1, 10, 2039, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 10, 2040, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 2041, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 10, 2042, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, -1, 2143, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2145, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2147, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2149, 0, 0, -1 },
  { 0x1, 0x1, 10, 2043, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 10, 2044, -1, 12, 1, 3 },
  { 0x1, 0x1, 10, 2045, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 10, 2046, -1, 12, 1, 3 },
  { 0x0, 0x0, 10, -1, 2151, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2153, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2155, 0, 0, -1 },
  { 0x0, 0x0, 10, -1, 2157, 0, 0, -1 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x4200001, 11, 1993, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 298, -1, 33, 1, 3 },
  { 0x0, 0x0, 11, 2051, -1, 0, 1, 3 },
  { 0x1, 0x1, 11, 2052, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 1999, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x0, 0x0, 11, 306, -1, 0, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x200001, 11, 2001, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 308, -1, 33, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 2003, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x0, 0x0, 11, 310, -1, 0, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x200001, 11, 2005, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 312, -1, 33, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 2007, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x0, 0x0, 11, 314, -1, 0, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x200001, 11, 2009, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 316, -1, 33, 1, 3 },
  { 0x0, 0x0, 11, 2065, -1, 0, 1, 3 },
  { 0x1, 0x1, 11, 2066, -1, 12, 1, 3 },
  { 0x1, 0x1, 11, 2067, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 11, 2068, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x4200001, 11, 2013, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 320, -1, 33, 1, 3 },
  { 0x0, 0x0, 11, 2073, -1, 0, 1, 3 },
  { 0x1, 0x1, 11, 2074, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x4200001, 11, 2017, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 346, -1, 33, 1, 3 },
  { 0x0, 0x0, 11, 2099, -1, 0, 1, 3 },
  { 0x1, 0x1, 11, 2100, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 2023, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x0, 0x0, 11, 354, -1, 0, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x200001, 11, 2025, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 356, -1, 33, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 2027, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x0, 0x0, 11, 358, -1, 0, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x200001, 11, 2029, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 360, -1, 33, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 2031, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x0, 0x0, 11, 362, -1, 0, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x200001, 11, 2033, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 364, -1, 33, 1, 3 },
  { 0x0, 0x0, 11, 2113, -1, 0, 1, 3 },
  { 0x1, 0x1, 11, 2114, -1, 12, 1, 3 },
  { 0x1, 0x1, 11, 2115, -1, 33, 1, 3 },
  { 0x200001, 0x200001, 11, 2116, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x200001, 0x4200001, 11, 2037, -1, 12, 1, 3 },
  { 0x2, 0x3, 11, -1, -1, 37, 1, 5 },
  { 0x1, 0x1, 11, 368, -1, 33, 1, 3 },
  { 0x0, 0x0, 11, 2121, -1, 0, 1, 3 },
  { 0x1, 0x1, 11, 2122, -1, 12, 1, 3 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, 2144, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 11, 2146, -1, 12, 1, 3 },
  { 0x1, 0x1, 11, 2148, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 11, 2150, -1, 12, 1, 3 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, -1, -1, 36, 1, 5 },
  { 0x1, 0x1, 11, 2152, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 11, 2154, -1, 12, 1, 3 },
  { 0x1, 0x1, 11, 2156, -1, 36, 1, 3 },
  { 0x1000001, 0x1000001, 11, 2158, -1, 12, 1, 3 },
  { 0x0, 0x0, 12, -1, -1, 0, 1, 14 },
  { 0x0, 0x0, 12, -1, -1, 0, 1, 14 },
  { 0x0, 0x0, 12, -1, -1, 0, 1, 14 },
  { 0x1, 0x1, 13, 270, 1434, 34, 1, 124 },
  { 0x1, 0x1, 13, 272, 1443, 34, 1, 124 },
  { 0x1, 0x1, 13, 274, 1452, 34, 1, 124 },
  { 0x1, 0x1, 13, 278, 1465, 34, 1, 124 },
  { 0x1, 0x1, 13, 280, 1474, 34, 1, 124 },
  { 0x1, 0x1, 13, 282, 1483, 34, 1, 124 },
  { 0x1, 0x1, 13, 284, 1492, 34, 1, 124 },
  { 0x1, 0x1, 13, 286, 1501, 34, 1, 124 },
  { 0x1, 0x1, 13, 288, 1510, 34, 1, 124 },
  { 0x1, 0x1, 13, 290, 1519, 34, 1, 124 },
  { 0x1, 0x1, 13, 292, 1529, 34, 1, 124 },
  { 0x1, 0x1, 13, 294, 1539, 34, 1, 124 },
  { 0x0, 0x0, 19, -1, 777, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 778, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 779, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 780, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 781, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 782, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 783, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 784, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 785, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 786, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 787, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 788, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 789, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 790, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 791, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 792, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 793, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 794, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 795, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 796, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 797, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 798, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 799, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 800, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 801, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 802, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 803, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 804, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 805, 0, 0, -1 },
  { 0x0, 0x0, 19, -1, 806, 0, 0, -1 },
  { 0x0, 0x0, 20, -1, 2793, 0, 0, -1 },
  { 0x0, 0x0, 20, -1, 2794, 0, 0, -1 },
  { 0x0, 0x0, 20, -1, 2809, 0, 0, -1 },
  { 0x0, 0x0, 20, -1, 2810, 0, 0, -1 },
  { 0x0, 0x0, 20, -1, 2815, 0, 0, -1 },
  { 0x0, 0x0, 20, -1, 2816, 0, 0, -1 },
  { 0x0, 0x0, 21, 813, 2805, 0, 0, -1 },
  { 0x0, 0x0, 21, 814, 2807, 0, 0, -1 },
  { 0x0, 0x0, 23, -1, 2803, 0, 0, -1 },
  { 0x0, 0x0, 23, -1, 2804, 0, 0, -1 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, 1254, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 6 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 7 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 8 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 15 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, 1275, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 18 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 19 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 20 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, 1308, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 17 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 35, 1, 21 },
  { 0x1, 0x1, 24, -1, -1, 33, 1, 76 },
  { 0x1, 0x1, 24, -1, -1, 33, 1, 76 },
  { 0x1, 0x1, 24, 1324, 1437, 35, 1, 130 },
  { 0x1, 0x1, 24, 1325, 1446, 35, 1, 130 },
  { 0x1, 0x1, 24, 1326, 1455, 35, 1, 130 },
  { 0x1, 0x1, 24, 1327, 1468, 35, 1, 130 },
  { 0x1, 0x1, 24, 1328, 1477, 35, 1, 130 },
  { 0x1, 0x1, 24, 1329, 1486, 35, 1, 130 },
  { 0x1, 0x1, 24, 1330, 1495, 35, 1, 130 },
  { 0x1, 0x1, 24, 1331, 1504, 35, 1, 130 },
  { 0x1, 0x1, 24, 1332, 1513, 35, 1, 130 },
  { 0x1, 0x1, 24, 1333, 1523, 35, 1, 130 },
  { 0x1, 0x1, 24, 1334, 1533, 35, 1, 130 },
  { 0x1, 0x1, 24, 1335, 1543, 35, 1, 130 },
  { 0x1, 0x1, 24, 1336, 1552, 35, 1, 144 },
  { 0x1, 0x1, 24, 1337, 1558, 35, 1, 149 },
  { 0x1, 0x1, 24, 1338, 1564, 35, 1, 149 },
  { 0x1, 0x1, 24, 1339, 1570, 35, 1, 144 },
  { 0x1, 0x1, 24, 1340, 1576, 35, 1, 149 },
  { 0x1, 0x1, 24, 1341, 1582, 35, 1, 149 },
  { 0x1, 0x1, 24, 1342, 1588, 35, 1, 144 },
  { 0x1, 0x1, 24, 1343, 1594, 35, 1, 149 },
  { 0x1, 0x1, 24, 1344, 1600, 35, 1, 149 },
  { 0x1, 0x1, 24, 1345, 1606, 35, 1, 144 },
  { 0x1, 0x1, 24, 1346, 1612, 35, 1, 149 },
  { 0x1, 0x1, 24, 1347, 1618, 35, 1, 144 },
  { 0x1, 0x1, 24, 1348, 1624, 35, 1, 149 },
  { 0x1, 0x1, 24, 1349, 1630, 35, 1, 144 },
  { 0x1, 0x1, 24, 1350, 1636, 35, 1, 149 },
  { 0x1, 0x1, 24, 1351, 1642, 35, 1, 144 },
  { 0x1, 0x1, 24, 1352, 1648, 35, 1, 149 },
  { 0x1, 0x1, 24, 1353, 1654, 35, 1, 149 },
  { 0x0, 0x0, 33, 2787, 2785, 0, 0, -1 },
  { 0x0, 0x0, 33, 2790, 2788, 0, 0, -1 },
  { 0x0, 0x0, 33, 2796, 2795, 0, 0, -1 },
  { 0x0, 0x0, 33, 2798, 2797, 0, 0, -1 },
  { 0x0, 0x0, 33, 2812, 2811, 0, 0, -1 },
  { 0x0, 0x0, 33, 2814, 2813, 0, 0, -1 },
  { 0x0, 0x0, 35, -1, 2806, 0, 0, -1 },
  { 0x0, 0x0, 35, -1, 2808, 0, 0, -1 },
  { 0x1, 0x1, 38, -1, 2256, 37, 1, 29 },
  { 0x1, 0x1, 38, -1, 2315, 37, 1, 29 },
  { 0x0, 0x0, 38, -1, 2318, 0, 0, -1 },
  { 0x1, 0x1, 38, -1, -1, 37, 1, 29 },
  { 0x1, 0x1, 38, -1, 2323, 37, 1, 29 },
  { 0x0, 0x0, 38, -1, 2326, 0, 0, -1 },
  { 0x1, 0x1, 38, -1, -1, 37, 1, 29 },
  { 0x0, 0x0, 38, -1, 2329, 0, 0, -1 },
  { 0x1, 0x1, 38, -1, -1, 37, 1, 29 },
  { 0x1, 0x1, 38, -1, 2332, 37, 1, 29 },
  { 0x1, 0x1, 38, -1, 2335, 37, 1, 29 },
  { 0x1, 0x1, 38, -1, 2368, 37, 1, 29 },
  { 0x3, 0x3, 38, -1, -1, 30, 1, 137 },
  { 0x0, 0x0, 38, 1124, -1, 0, 1, 95 },
  { 0x0, 0x0, 38, -1, -1, 0, 1, 104 },
  { 0x0, 0x0, 38, 1130, -1, 0, 1, 116 },
  { 0x3, 0x3, 38, -1, -1, 30, 1, 155 },
  { 0x0, 0x0, 38, 1131, -1, 0, 1, 40 },
  { 0x0, 0x0, 40, -1, 955, 0, 0, -1 },
  { 0x0, 0x0, 40, -1, 963, 0, 0, -1 },
  { 0x0, 0x0, 40, 1133, 959, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 604, 33, 1, 6 },
  { 0x18000001, 0x18000001, 40, -1, 612, 6, 1, 7 },
  { 0x3, 0x3, 40, 1134, 608, 33, 1, 6 },
  { 0x0, 0x0, 40, -1, 967, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 624, 33, 1, 8 },
  { 0x0, 0x0, 40, -1, 971, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 636, 33, 1, 15 },
  { 0x0, 0x0, 40, -1, 976, 0, 0, -1 },
  { 0x0, 0x0, 40, -1, 980, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 659, 33, 1, 17 },
  { 0x3, 0x3, 40, -1, 663, 33, 1, 17 },
  { 0x0, 0x0, 40, -1, 984, 0, 0, -1 },
  { 0x0, 0x0, 40, -1, 988, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 683, 33, 1, 18 },
  { 0x18000001, 0x18000001, 40, -1, 687, 6, 1, 18 },
  { 0x0, 0x0, 40, -1, 992, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 699, 33, 1, 19 },
  { 0x0, 0x0, 40, -1, 996, 0, 0, -1 },
  { 0x0, 0x0, 40, -1, 1000, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 719, 33, 1, 20 },
  { 0x18000001, 0x18000001, 40, -1, 723, 6, 1, 20 },
  { 0x0, 0x0, 40, -1, 1004, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 735, 33, 1, 21 },
  { 0x0, 0x0, 40, -1, 1009, 0, 0, -1 },
  { 0x0, 0x0, 40, -1, 1013, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 758, 33, 1, 17 },
  { 0x3, 0x3, 40, -1, 762, 33, 1, 17 },
  { 0x0, 0x0, 40, -1, 1017, 0, 0, -1 },
  { 0x3, 0x3, 40, -1, 774, 33, 1, 21 },
  { 0x0, 0x0, 41, 833, 954, 0, 0, -1 },
  { 0x0, 0x0, 41, 834, 962, 0, 0, -1 },
  { 0x0, 0x0, 41, 835, 958, 0, 0, -1 },
  { 0x1, 0x1, 41, 836, 603, 34, 1, 6 },
  { 0x10000001, 0x10000001, 41, 837, 611, 6, 1, 7 },
  { 0x1, 0x1, 41, 838, 607, 34, 1, 6 },
  { 0x0, 0x0, 41, 839, 966, 0, 0, -1 },
  { 0x1, 0x1, 41, 840, 623, 34, 1, 8 },
  { 0x0, 0x0, 41, 841, 970, 0, 0, -1 },
  { 0x1, 0x1, 41, 842, 635, 34, 1, 15 },
  { 0x0, 0x0, 41, 843, 975, 0, 0, -1 },
  { 0x0, 0x0, 41, 844, 979, 0, 0, -1 },
  { 0x1, 0x1, 41, 845, 658, 34, 1, 17 },
  { 0x1, 0x1, 41, 846, 662, 34, 1, 17 },
  { 0x0, 0x0, 41, 847, 983, 0, 0, -1 },
  { 0x0, 0x0, 41, 848, 987, 0, 0, -1 },
  { 0x1, 0x1, 41, 849, 682, 34, 1, 18 },
  { 0x10000001, 0x10000001, 41, 850, 686, 6, 1, 18 },
  { 0x0, 0x0, 41, 851, 991, 0, 0, -1 },
  { 0x1, 0x1, 41, 852, 698, 34, 1, 19 },
  { 0x0, 0x0, 41, 853, 995, 0, 0, -1 },
  { 0x0, 0x0, 41, 854, 999, 0, 0, -1 },
  { 0x1, 0x1, 41, 855, 718, 34, 1, 20 },
  { 0x10000001, 0x10000001, 41, 856, 722, 6, 1, 20 },
  { 0x0, 0x0, 41, 857, 1003, 0, 0, -1 },
  { 0x1, 0x1, 41, 858, 734, 34, 1, 21 },
  { 0x0, 0x0, 41, 859, 1008, 0, 0, -1 },
  { 0x0, 0x0, 41, 860, 1012, 0, 0, -1 },
  { 0x1, 0x1, 41, 861, 757, 34, 1, 17 },
  { 0x1, 0x1, 41, 862, 761, 34, 1, 17 },
  { 0x0, 0x0, 41, 863, 1016, 0, 0, -1 },
  { 0x1, 0x1, 41, 864, 773, 34, 1, 21 },
  { 0x800001, 0x800001, 41, -1, 1138, 4, 1, 16 },
  { 0x1, 0x1, 41, 2202, 1136, 4, 1, 16 },
  { 0x1, 0x1, 41, 939, 1141, 4, 1, 22 },
  { 0x2, 0x3, 41, -1, 1146, 20, 1, 67 },
  { 0x1, 0x1, 41, 2203, 1144, 21, 1, 67 },
  { 0x0, 0x0, 42, -1, -1, 0, 1, 80 },
  { 0x0, 0x0, 42, -1, -1, 0, 1, 80 },
  { 0x0, 0x0, 42, -1, -1, 0, 1, 123 },
  { 0x1, 0x1, 44, 1354, 295, 38, 1, 1 },
  { 0x1, 0x1, 44, 1355, 297, 38, 1, 1 },
  { 0x0, 0x0, 44, -1, 300, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 414, 0, 0, -1 },
  { 0x1, 0x1, 44, 1359, 317, 38, 1, 1 },
  { 0x1, 0x1, 44, 1360, 319, 38, 1, 1 },
  { 0x0, 0x0, 44, -1, 322, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 454, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 324, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 342, 0, 0, -1 },
  { 0x1, 0x1, 44, 1366, 343, 38, 1, 1 },
  { 0x1, 0x1, 44, 1367, 345, 38, 1, 1 },
  { 0x0, 0x0, 44, -1, 348, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 462, 0, 0, -1 },
  { 0x1, 0x1, 44, 1371, 365, 38, 1, 1 },
  { 0x1, 0x1, 44, 1372, 367, 38, 1, 1 },
  { 0x0, 0x0, 44, -1, 370, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 502, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 372, 0, 0, -1 },
  { 0x0, 0x0, 44, -1, 390, 0, 0, -1 },
  { 0x0, 0x0, 44, 1230, 2263, 0, 0, -1 },
  { 0x0, 0x0, 44, 1231, 2271, 0, 1, 54 },
  { 0x0, 0x0, 44, 1232, 2938, 0, 1, 54 },
  { 0x0, 0x0, 44, 1233, 2339, 0, 0, -1 },
  { 0x0, 0x0, 44, 1234, -1, 0, 1, 49 },
  { 0x0, 0x0, 44, 1102, -1, 0, 1, 0 },
  { 0x0, 0x0, 44, 1103, -1, 0, 1, 0 },
  { 0x0, 0x0, 44, 1104, -1, 0, 1, 0 },
  { 0x1, 0x1, 45, -1, 1658, 30, 1, 152 },
  { 0x1, 0x1, 45, 945, 1657, 30, 1, 151 },
  { 0x1, 0x1, 45, -1, 1662, 30, 1, 154 },
  { 0x1, 0x1, 45, 946, 1661, 30, 1, 153 },
  { 0x1, 0x1, 45, -1, 1666, 30, 1, 154 },
  { 0x1, 0x1, 45, 947, 1665, 30, 1, 153 },
  { 0x3, 0x3, 46, -1, 1142, 3, 1, 22 },
  { 0x1, 0x1, 47, 2223, -1, 30, 1, 137 },
  { 0x1, 0x1, 47, 2254, -1, 30, 1, 155 },
  { 0x0, 0x0, 49, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 49, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 49, -1, -1, 0, 1, 40 },
  { 0x1, 0x1, 56, -1, 1659, 31, 1, 152 },
  { 0x1, 0x1, 56, -1, 1663, 31, 1, 154 },
  { 0x1, 0x1, 56, -1, 1667, 31, 1, 154 },
  { 0x0, 0x0, 56, -1, -1, 0, 1, 94 },
  { 0x2, 0x3, 56, -1, -1, 27, 1, 94 },
  { 0x1, 0x1, 56, -1, -1, 28, 1, 94 },
  { 0x0, 0x0, 65, 14, 574, 0, 1, 6 },
  { 0x0, 0x0, 65, 1255, 577, 0, 1, 6 },
  { 0x1, 0x1, 65, 1256, 579, 33, 1, 6 },
  { 0x1, 0x1, 65, 1257, 581, 34, 1, 6 },
  { 0x3, 0x3, 65, 1258, 583, 33, 1, 6 },
  { 0x0, 0x0, 65, 1259, 585, 0, 1, 6 },
  { 0x1, 0x1, 65, 1260, 587, 33, 1, 6 },
  { 0x1, 0x1, 65, 1261, 589, 34, 1, 6 },
  { 0x3, 0x3, 65, 1262, 591, 33, 1, 6 },
  { 0x1, 0x1, 65, 1263, 593, 6, 1, 7 },
  { 0x8000001, 0x8000001, 65, 1264, 595, 6, 1, 7 },
  { 0x10000001, 0x10000001, 65, 1265, 597, 6, 1, 7 },
  { 0x18000001, 0x18000001, 65, 1266, 599, 6, 1, 7 },
  { 0x0, 0x0, 65, 1267, 613, 0, 1, 8 },
  { 0x1, 0x1, 65, 1268, 615, 33, 1, 8 },
  { 0x1, 0x1, 65, 1269, 617, 34, 1, 8 },
  { 0x3, 0x3, 65, 1270, 619, 33, 1, 8 },
  { 0x0, 0x0, 65, 1271, 625, 0, 1, 15 },
  { 0x1, 0x1, 65, 1272, 627, 33, 1, 15 },
  { 0x1, 0x1, 65, 1273, 629, 34, 1, 15 },
  { 0x3, 0x3, 65, 1274, 631, 33, 1, 15 },
  { 0x0, 0x0, 65, 15, 637, 0, 1, 17 },
  { 0x0, 0x0, 65, 1276, 640, 0, 1, 17 },
  { 0x1, 0x1, 65, 1277, 642, 33, 1, 17 },
  { 0x1, 0x1, 65, 1278, 644, 34, 1, 17 },
  { 0x3, 0x3, 65, 1279, 646, 33, 1, 17 },
  { 0x0, 0x0, 65, 1280, 648, 0, 1, 17 },
  { 0x1, 0x1, 65, 1281, 650, 33, 1, 17 },
  { 0x1, 0x1, 65, 1282, 652, 34, 1, 17 },
  { 0x3, 0x3, 65, 1283, 654, 33, 1, 17 },
  { 0x0, 0x0, 65, 1284, 664, 0, 1, 18 },
  { 0x1, 0x1, 65, 1285, 666, 33, 1, 18 },
  { 0x1, 0x1, 65, 1286, 668, 34, 1, 18 },
  { 0x3, 0x3, 65, 1287, 670, 33, 1, 18 },
  { 0x1, 0x1, 65, 1288, 672, 6, 1, 18 },
  { 0x8000001, 0x8000001, 65, 1289, 674, 6, 1, 18 },
  { 0x10000001, 0x10000001, 65, 1290, 676, 6, 1, 18 },
  { 0x18000001, 0x18000001, 65, 1291, 678, 6, 1, 18 },
  { 0x0, 0x0, 65, 1292, 688, 0, 1, 19 },
  { 0x1, 0x1, 65, 1293, 690, 33, 1, 19 },
  { 0x1, 0x1, 65, 1294, 692, 34, 1, 19 },
  { 0x3, 0x3, 65, 1295, 694, 33, 1, 19 },
  { 0x0, 0x0, 65, 1296, 700, 0, 1, 20 },
  { 0x1, 0x1, 65, 1297, 702, 33, 1, 20 },
  { 0x1, 0x1, 65, 1298, 704, 34, 1, 20 },
  { 0x3, 0x3, 65, 1299, 706, 33, 1, 20 },
  { 0x1, 0x1, 65, 1300, 708, 6, 1, 20 },
  { 0x8000001, 0x8000001, 65, 1301, 710, 6, 1, 20 },
  { 0x10000001, 0x10000001, 65, 1302, 712, 6, 1, 20 },
  { 0x18000001, 0x18000001, 65, 1303, 714, 6, 1, 20 },
  { 0x0, 0x0, 65, 1304, 724, 0, 1, 21 },
  { 0x1, 0x1, 65, 1305, 726, 33, 1, 21 },
  { 0x1, 0x1, 65, 1306, 728, 34, 1, 21 },
  { 0x3, 0x3, 65, 1307, 730, 33, 1, 21 },
  { 0x0, 0x0, 65, 17, 736, 0, 1, 17 },
  { 0x0, 0x0, 65, 1309, 739, 0, 1, 17 },
  { 0x1, 0x1, 65, 1310, 741, 33, 1, 17 },
  { 0x1, 0x1, 65, 1311, 743, 34, 1, 17 },
  { 0x3, 0x3, 65, 1312, 745, 33, 1, 17 },
  { 0x0, 0x0, 65, 1313, 747, 0, 1, 17 },
  { 0x1, 0x1, 65, 1314, 749, 33, 1, 17 },
  { 0x1, 0x1, 65, 1315, 751, 34, 1, 17 },
  { 0x3, 0x3, 65, 1316, 753, 33, 1, 17 },
  { 0x0, 0x0, 65, 1317, 763, 0, 1, 21 },
  { 0x1, 0x1, 65, 1318, 765, 33, 1, 21 },
  { 0x1, 0x1, 65, 1319, 767, 34, 1, 21 },
  { 0x3, 0x3, 65, 1320, 769, 33, 1, 21 },
  { 0x3, 0x3, 66, 543, 1521, 33, 1, 129 },
  { 0x3, 0x3, 66, 544, 1531, 33, 1, 129 },
  { 0x3, 0x3, 66, 545, 1541, 33, 1, 129 },
  { 0x0, 0x0, 66, -1, 1546, 0, 1, 140 },
  { 0x0, 0x0, 66, -1, 1547, 0, 1, 145 },
  { 0x0, 0x0, 66, -1, 1548, 0, 1, 145 },
  { 0x0, 0x0, 107, 1028, 2311, 0, 0, -1 },
  { 0x0, 0x0, 107, 1029, 2830, 0, 1, 29 },
  { 0x0, 0x0, 107, 1030, 2352, 0, 0, -1 },
  { 0x0, 0x0, 107, 1031, 2834, 0, 1, 29 },
  { 0x0, 0x0, 109, -1, 2313, 0, 0, -1 },
  { 0x1, 0x1, 109, -1, 2831, 27, 1, 29 },
  { 0x0, 0x0, 109, -1, 2354, 0, 0, -1 },
  { 0x1, 0x1, 109, -1, 2835, 27, 1, 29 },
  { 0x0, 0x0, 110, 1033, -1, 0, 1, 115 },
  { 0x1, 0x1, 111, -1, -1, 27, 1, 115 },
  { 0x0, 0x0, 112, 1064, 2860, 0, 1, 1 },
  { 0x0, 0x0, 112, 1065, 2863, 0, 1, 1 },
  { 0x0, 0x0, 112, 1206, 303, 0, 0, -1 },
  { 0x0, 0x0, 112, 1207, 307, 0, 0, -1 },
  { 0x0, 0x0, 112, 1167, 430, 0, 0, -1 },
  { 0x0, 0x0, 112, 1168, 438, 0, 0, -1 },
  { 0x0, 0x0, 112, -1, 446, 0, 0, -1 },
  { 0x0, 0x0, 112, 1066, 2876, 0, 1, 1 },
  { 0x0, 0x0, 112, 1067, 2879, 0, 1, 1 },
  { 0x0, 0x0, 112, -1, 328, 0, 0, -1 },
  { 0x0, 0x0, 112, -1, 332, 0, 0, -1 },
  { 0x0, 0x0, 112, 1215, 333, 0, 0, -1 },
  { 0x0, 0x0, 112, 1216, 337, 0, 0, -1 },
  { 0x0, 0x0, 112, 1068, 2900, 0, 1, 1 },
  { 0x0, 0x0, 112, 1069, 2903, 0, 1, 1 },
  { 0x0, 0x0, 112, 1219, 351, 0, 0, -1 },
  { 0x0, 0x0, 112, 1220, 355, 0, 0, -1 },
  { 0x0, 0x0, 112, 1180, 478, 0, 0, -1 },
  { 0x0, 0x0, 112, 1181, 486, 0, 0, -1 },
  { 0x0, 0x0, 112, -1, 494, 0, 0, -1 },
  { 0x0, 0x0, 112, 1373, 2914, 0, 1, 1 },
  { 0x0, 0x0, 112, 1374, 2916, 0, 1, 1 },
  { 0x0, 0x0, 112, -1, 376, 0, 0, -1 },
  { 0x0, 0x0, 112, -1, 380, 0, 0, -1 },
  { 0x0, 0x0, 112, 1228, 381, 0, 0, -1 },
  { 0x0, 0x0, 112, 1229, 385, 0, 0, -1 },
  { 0x0, 0x0, 112, -1, 2281, 0, 0, -1 },
  { 0x1, 0x9, 112, -1, 2285, 33, 1, 54 },
  { 0x1, 0x9, 112, -1, 2947, 33, 1, 54 },
  { 0x2, 0x3, 112, 1390, 2348, 27, 1, 49 },
  { 0x1, 0x1, 114, 1356, 2861, 37, 1, 1 },
  { 0x1, 0x1, 114, 1357, 2864, 37, 1, 1 },
  { 0x1, 0x1, 114, 1361, 2877, 37, 1, 1 },
  { 0x1, 0x1, 114, 1362, 2880, 37, 1, 1 },
  { 0x1, 0x1, 114, 1368, 2901, 37, 1, 1 },
  { 0x1, 0x1, 114, 1369, 2904, 37, 1, 1 },
  { 0x0, 0x0, 114, -1, 2924, 0, 1, 1 },
  { 0x0, 0x0, 114, -1, 2925, 0, 1, 1 },
  { 0x0, 0x0, 115, 1105, 2856, 0, 1, 1 },
  { 0x0, 0x0, 115, 1106, 2858, 0, 1, 1 },
  { 0x0, 0x0, 115, 1165, 301, 0, 0, -1 },
  { 0x0, 0x0, 115, 1166, 305, 0, 0, -1 },
  { 0x0, 0x0, 115, -1, 434, 0, 0, -1 },
  { 0x0, 0x0, 115, -1, 442, 0, 0, -1 },
  { 0x0, 0x0, 115, 1210, 444, 0, 0, -1 },
  { 0x0, 0x0, 115, -1, 2874, 0, 1, 1 },
  { 0x0, 0x0, 115, -1, 2875, 0, 1, 1 },
  { 0x0, 0x0, 115, 1213, 326, 0, 0, -1 },
  { 0x0, 0x0, 115, 1214, 330, 0, 0, -1 },
  { 0x0, 0x0, 115, 1174, 335, 0, 0, -1 },
  { 0x0, 0x0, 115, 1175, 339, 0, 0, -1 },
  { 0x0, 0x0, 115, 1109, 2896, 0, 1, 1 },
  { 0x0, 0x0, 115, 1110, 2898, 0, 1, 1 },
  { 0x0, 0x0, 115, 1178, 349, 0, 0, -1 },
  { 0x0, 0x0, 115, 1179, 353, 0, 0, -1 },
  { 0x0, 0x0, 115, -1, 482, 0, 0, -1 },
  { 0x0, 0x0, 115, -1, 490, 0, 0, -1 },
  { 0x0, 0x0, 115, 1223, 492, 0, 0, -1 },
  { 0x0, 0x0, 115, -1, 2912, 0, 1, 1 },
  { 0x0, 0x0, 115, -1, 2913, 0, 1, 1 },
  { 0x0, 0x0, 115, 1226, 374, 0, 0, -1 },
  { 0x0, 0x0, 115, 1227, 378, 0, 0, -1 },
  { 0x0, 0x0, 115, 1187, 383, 0, 0, -1 },
  { 0x0, 0x0, 115, 1188, 387, 0, 0, -1 },
  { 0x0, 0x0, 115, 1060, 2279, 0, 0, -1 },
  { 0x0, 0x0, 115, 1061, 2283, 0, 1, 54 },
  { 0x0, 0x0, 115, 1062, 2946, 0, 1, 54 },
  { 0x0, 0x0, 115, 1063, 2347, 0, 1, 49 },
  { 0x1, 0x1, 115, -1, -1, 27, 1, 0 },
  { 0x1, 0x1, 115, -1, -1, 27, 1, 0 },
  { 0x1, 0x1, 115, -1, -1, 27, 1, 0 },
  { 0x1, 0x1, 116, -1, 2857, 37, 1, 1 },
  { 0x1, 0x1, 116, -1, 2859, 37, 1, 1 },
  { 0x0, 0x0, 116, -1, 2884, 0, 1, 1 },
  { 0x0, 0x0, 116, -1, 2885, 0, 1, 1 },
  { 0x1, 0x1, 116, -1, 2897, 37, 1, 1 },
  { 0x1, 0x1, 116, -1, 2899, 37, 1, 1 },
  { 0x0, 0x0, 116, -1, 2922, 0, 1, 1 },
  { 0x0, 0x0, 116, -1, 2923, 0, 1, 1 },
  { 0x0, 0x0, 117, 1158, -1, 0, 1, 0 },
  { 0x0, 0x0, 117, 1159, -1, 0, 1, 0 },
  { 0x0, 0x0, 117, 1160, -1, 0, 1, 0 },
  { 0x3, 0x3, 117, 1118, -1, 34, 1, 33 },
  { 0x3, 0x3, 117, 1119, -1, 34, 1, 40 },
  { 0x1, 0x1, 119, -1, -1, 35, 1, 33 },
  { 0x1, 0x1, 119, -1, -1, 35, 1, 40 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 66 },
  { 0x1, 0x1, 120, -1, -1, 36, 1, 122 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 40 },
  { 0x1, 0x1, 120, -1, -1, 27, 1, 96 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 105 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 73 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 73 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 74 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 40 },
  { 0x1, 0x1, 120, -1, -1, 27, 1, 117 },
  { 0x1, 0x1, 120, -1, -1, 27, 1, 40 },
  { 0x0, 0x0, 120, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 121, -1, 2786, 0, 0, -1 },
  { 0x0, 0x0, 121, -1, 2789, 0, 0, -1 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 16 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 16 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 16 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 16 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 22 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 22 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 22 },
  { 0x1, 0x1, 122, -1, -1, 35, 1, 22 },
  { 0x1, 0x1, 122, -1, -1, 23, 1, 67 },
  { 0x1, 0x1, 122, -1, -1, 23, 1, 67 },
  { 0x1, 0x1, 122, -1, -1, 23, 1, 67 },
  { 0x1, 0x1, 122, -1, -1, 23, 1, 67 },
  { 0x1, 0x1, 122, 900, -1, 23, 1, 67 },
  { 0x9, 0x9, 122, 901, -1, 20, 1, 67 },
  { 0x0, 0x0, 126, 2165, -1, 0, 1, 0 },
  { 0x0, 0x0, 126, 2166, -1, 0, 1, 0 },
  { 0x1, 0x1, 126, -1, -1, 28, 1, 33 },
  { 0x1, 0x1, 126, -1, -1, 27, 1, 33 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x0, 0x0, 126, -1, -1, 0, 1, 114 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 126, -1, -1, 29, 1, 0 },
  { 0x0, 0x0, 126, 1116, -1, 0, 1, 33 },
  { 0x0, 0x0, 126, 1244, -1, 0, 1, 40 },
  { 0x0, 0x0, 140, 1194, 2852, 0, 1, 1 },
  { 0x0, 0x0, 140, 1195, 2854, 0, 1, 1 },
  { 0x0, 0x0, 140, 1036, 302, 0, 0, -1 },
  { 0x0, 0x0, 140, 1037, 422, 0, 0, -1 },
  { 0x0, 0x0, 140, 1076, 311, 0, 0, -1 },
  { 0x0, 0x0, 140, 1077, 315, 0, 0, -1 },
  { 0x0, 0x0, 140, 1078, 443, 0, 0, -1 },
  { 0x0, 0x0, 140, -1, 2872, 0, 1, 1 },
  { 0x0, 0x0, 140, -1, 2873, 0, 1, 1 },
  { 0x0, 0x0, 140, 1081, 325, 0, 0, -1 },
  { 0x0, 0x0, 140, 1082, 329, 0, 0, -1 },
  { 0x0, 0x0, 140, -1, 336, 0, 0, -1 },
  { 0x0, 0x0, 140, -1, 340, 0, 0, -1 },
  { 0x0, 0x0, 140, 1198, 2892, 0, 1, 1 },
  { 0x0, 0x0, 140, 1199, 2894, 0, 1, 1 },
  { 0x0, 0x0, 140, 1049, 350, 0, 0, -1 },
  { 0x0, 0x0, 140, 1050, 470, 0, 0, -1 },
  { 0x0, 0x0, 140, 1089, 359, 0, 0, -1 },
  { 0x0, 0x0, 140, 1090, 363, 0, 0, -1 },
  { 0x0, 0x0, 140, 1091, 491, 0, 0, -1 },
  { 0x0, 0x0, 140, -1, 2910, 0, 1, 1 },
  { 0x0, 0x0, 140, -1, 2911, 0, 1, 1 },
  { 0x0, 0x0, 140, 1094, 373, 0, 0, -1 },
  { 0x0, 0x0, 140, 1095, 377, 0, 0, -1 },
  { 0x0, 0x0, 140, -1, 384, 0, 0, -1 },
  { 0x0, 0x0, 140, -1, 388, 0, 0, -1 },
  { 0x0, 0x0, 140, 2974, 2267, 0, 0, -1 },
  { 0x1, 0x1, 140, 2975, 2275, 33, 1, 54 },
  { 0x1, 0x1, 140, 2976, 2940, 33, 1, 54 },
  { 0x0, 0x0, 140, 2977, 2341, 0, 0, -1 },
  { 0x1, 0x1, 140, 2978, -1, 28, 1, 49 },
  { 0x1, 0x1, 141, -1, 2853, 37, 1, 1 },
  { 0x1, 0x1, 141, -1, 2855, 37, 1, 1 },
  { 0x0, 0x0, 141, -1, 2882, 0, 1, 1 },
  { 0x0, 0x0, 141, -1, 2883, 0, 1, 1 },
  { 0x1, 0x1, 141, -1, 2893, 37, 1, 1 },
  { 0x1, 0x1, 141, -1, 2895, 37, 1, 1 },
  { 0x0, 0x0, 141, -1, 2920, 0, 1, 1 },
  { 0x0, 0x0, 141, -1, 2921, 0, 1, 1 },
  { 0x1, 0x1, 144, 899, 1140, 3, 1, 22 },
  { 0x0, 0x0, 145, 2167, -1, 0, 1, 33 },
  { 0x0, 0x0, 146, 905, 2846, 0, 1, 1 },
  { 0x0, 0x0, 146, 906, 2849, 0, 1, 1 },
  { 0x0, 0x0, 146, -1, 304, 0, 0, -1 },
  { 0x0, 0x0, 146, -1, 426, 0, 0, -1 },
  { 0x0, 0x0, 146, 1038, 309, 0, 0, -1 },
  { 0x0, 0x0, 146, 1039, 313, 0, 0, -1 },
  { 0x0, 0x0, 146, 1040, 445, 0, 0, -1 },
  { 0x0, 0x0, 146, 909, 2866, 0, 1, 1 },
  { 0x0, 0x0, 146, 910, 2869, 0, 1, 1 },
  { 0x0, 0x0, 146, 1043, 327, 0, 0, -1 },
  { 0x0, 0x0, 146, 1044, 331, 0, 0, -1 },
  { 0x0, 0x0, 146, 1083, 334, 0, 0, -1 },
  { 0x0, 0x0, 146, 1084, 338, 0, 0, -1 },
  { 0x0, 0x0, 146, 915, 2886, 0, 1, 1 },
  { 0x0, 0x0, 146, 916, 2889, 0, 1, 1 },
  { 0x0, 0x0, 146, -1, 352, 0, 0, -1 },
  { 0x0, 0x0, 146, -1, 474, 0, 0, -1 },
  { 0x0, 0x0, 146, 1051, 357, 0, 0, -1 },
  { 0x0, 0x0, 146, 1052, 361, 0, 0, -1 },
  { 0x0, 0x0, 146, 1053, 493, 0, 0, -1 },
  { 0x0, 0x0, 146, 919, 2906, 0, 1, 1 },
  { 0x0, 0x0, 146, 920, 2908, 0, 1, 1 },
  { 0x0, 0x0, 146, 1056, 375, 0, 0, -1 },
  { 0x0, 0x0, 146, 1057, 379, 0, 0, -1 },
  { 0x0, 0x0, 146, 1096, 382, 0, 0, -1 },
  { 0x0, 0x0, 146, 1097, 386, 0, 0, -1 },
  { 0x0, 0x0, 146, 1189, 2265, 0, 0, -1 },
  { 0x1, 0x1, 146, 1190, 2273, 36, 1, 54 },
  { 0x1, 0x1, 146, 1191, 2939, 36, 1, 54 },
  { 0x0, 0x0, 146, 1192, 2340, 0, 0, -1 },
  { 0x1, 0x1, 146, 1193, -1, 27, 1, 49 },
  { 0x1, 0x1, 147, -1, 2848, 37, 1, 1 },
  { 0x1, 0x1, 147, -1, 2851, 37, 1, 1 },
  { 0x1, 0x1, 147, -1, 2868, 37, 1, 1 },
  { 0x1, 0x1, 147, -1, 2871, 37, 1, 1 },
  { 0x1, 0x1, 147, -1, 2888, 37, 1, 1 },
  { 0x1, 0x1, 147, -1, 2891, 37, 1, 1 },
  { 0x0, 0x0, 147, -1, 2918, 0, 1, 1 },
  { 0x0, 0x0, 147, -1, 2919, 0, 1, 1 },
  { 0x0, 0x0, 148, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 148, 1117, -1, 0, 1, 40 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 66 },
  { 0x0, 0x0, 149, -1, 2926, 0, 1, 63 },
  { 0x0, 0x0, 149, -1, 2927, 0, 1, 63 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 81 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 81 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 85 },
  { 0x0, 0x0, 149, -1, -1, 0, 1, 40 },
  { 0x1, 0x1, 150, -1, 575, 12, 1, 6 },
  { 0x1, 0x1, 150, -1, 578, 12, 1, 6 },
  { 0x200001, 0x200001, 150, -1, 580, 12, 1, 6 },
  { 0x400001, 0x400001, 150, -1, 582, 12, 1, 6 },
  { 0x600001, 0x600001, 150, -1, 584, 12, 1, 6 },
  { 0x1, 0x1, 150, -1, 586, 12, 1, 6 },
  { 0x200001, 0x200001, 150, -1, 588, 12, 1, 6 },
  { 0x400001, 0x400001, 150, -1, 590, 12, 1, 6 },
  { 0x600001, 0x600001, 150, -1, 592, 12, 1, 6 },
  { 0x41, 0x41, 150, -1, 594, 6, 1, 7 },
  { 0x8000041, 0x8000041, 150, -1, 596, 6, 1, 7 },
  { 0x10000041, 0x10000041, 150, -1, 598, 6, 1, 7 },
  { 0x18000041, 0x18000041, 150, -1, 600, 6, 1, 7 },
  { 0x1, 0x1, 150, -1, 614, 12, 1, 8 },
  { 0x200001, 0x200001, 150, -1, 616, 12, 1, 8 },
  { 0x400001, 0x400001, 150, -1, 618, 12, 1, 8 },
  { 0x600001, 0x600001, 150, -1, 620, 12, 1, 8 },
  { 0x1, 0x1, 150, -1, 626, 12, 1, 15 },
  { 0x200001, 0x200001, 150, -1, 628, 12, 1, 15 },
  { 0x400001, 0x400001, 150, -1, 630, 12, 1, 15 },
  { 0x600001, 0x600001, 150, -1, 632, 12, 1, 15 },
  { 0x1, 0x1, 150, -1, 638, 12, 1, 17 },
  { 0x1, 0x1, 150, -1, 641, 12, 1, 17 },
  { 0x200001, 0x200001, 150, -1, 643, 12, 1, 17 },
  { 0x400001, 0x400001, 150, -1, 645, 12, 1, 17 },
  { 0x600001, 0x600001, 150, -1, 647, 12, 1, 17 },
  { 0x1, 0x1, 150, -1, 649, 12, 1, 17 },
  { 0x200001, 0x200001, 150, -1, 651, 12, 1, 17 },
  { 0x400001, 0x400001, 150, -1, 653, 12, 1, 17 },
  { 0x600001, 0x600001, 150, -1, 655, 12, 1, 17 },
  { 0x1, 0x1, 150, -1, 665, 12, 1, 18 },
  { 0x200001, 0x200001, 150, -1, 667, 12, 1, 18 },
  { 0x400001, 0x400001, 150, -1, 669, 12, 1, 18 },
  { 0x600001, 0x600001, 150, -1, 671, 12, 1, 18 },
  { 0x41, 0x41, 150, -1, 673, 6, 1, 18 },
  { 0x8000041, 0x8000041, 150, -1, 675, 6, 1, 18 },
  { 0x10000041, 0x10000041, 150, -1, 677, 6, 1, 18 },
  { 0x18000041, 0x18000041, 150, -1, 679, 6, 1, 18 },
  { 0x1, 0x1, 150, -1, 689, 12, 1, 19 },
  { 0x200001, 0x200001, 150, -1, 691, 12, 1, 19 },
  { 0x400001, 0x400001, 150, -1, 693, 12, 1, 19 },
  { 0x600001, 0x600001, 150, -1, 695, 12, 1, 19 },
  { 0x1, 0x1, 150, -1, 701, 12, 1, 20 },
  { 0x200001, 0x200001, 150, -1, 703, 12, 1, 20 },
  { 0x400001, 0x400001, 150, -1, 705, 12, 1, 20 },
  { 0x600001, 0x600001, 150, -1, 707, 12, 1, 20 },
  { 0x41, 0x41, 150, -1, 709, 6, 1, 20 },
  { 0x8000041, 0x8000041, 150, -1, 711, 6, 1, 20 },
  { 0x10000041, 0x10000041, 150, -1, 713, 6, 1, 20 },
  { 0x18000041, 0x18000041, 150, -1, 715, 6, 1, 20 },
  { 0x1, 0x1, 150, -1, 725, 12, 1, 21 },
  { 0x200001, 0x200001, 150, -1, 727, 12, 1, 21 },
  { 0x400001, 0x400001, 150, -1, 729, 12, 1, 21 },
  { 0x600001, 0x600001, 150, -1, 731, 12, 1, 21 },
  { 0x1, 0x1, 150, -1, 737, 12, 1, 17 },
  { 0x1, 0x1, 150, -1, 740, 12, 1, 17 },
  { 0x200001, 0x200001, 150, -1, 742, 12, 1, 17 },
  { 0x400001, 0x400001, 150, -1, 744, 12, 1, 17 },
  { 0x600001, 0x600001, 150, -1, 746, 12, 1, 17 },
  { 0x1, 0x1, 150, -1, 748, 12, 1, 17 },
  { 0x200001, 0x200001, 150, -1, 750, 12, 1, 17 },
  { 0x400001, 0x400001, 150, -1, 752, 12, 1, 17 },
  { 0x600001, 0x600001, 150, -1, 754, 12, 1, 17 },
  { 0x1, 0x1, 150, -1, 764, 12, 1, 21 },
  { 0x200001, 0x200001, 150, -1, 766, 12, 1, 21 },
  { 0x400001, 0x400001, 150, -1, 768, 12, 1, 21 },
  { 0x600001, 0x600001, 150, -1, 770, 12, 1, 21 },
  { 0x0, 0x0, 155, -1, -1, 0, 1, 124 },
  { 0x0, 0x0, 159, 775, -1, 0, 1, 75 },
  { 0x0, 0x0, 159, 776, -1, 0, 1, 75 },
  { 0x9, 0x9, 159, -1, 1438, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1447, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1456, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1469, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1478, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1487, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1496, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1505, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1514, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1524, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1534, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1544, 32, 1, 130 },
  { 0x9, 0x9, 159, -1, 1553, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1559, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1565, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1571, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1577, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1583, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1589, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1595, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1601, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1607, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1613, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1619, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1625, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1631, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1637, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1643, 32, 1, 144 },
  { 0x9, 0x9, 159, -1, 1649, 32, 1, 149 },
  { 0x9, 0x9, 159, -1, 1655, 32, 1, 149 },
  { 0x0, 0x0, 160, 1235, 296, 0, 0, -1 },
  { 0x0, 0x0, 160, 1236, 412, 0, 0, -1 },
  { 0x1, 0x1, 160, -1, 2862, 38, 1, 1 },
  { 0x1, 0x1, 160, 907, 2865, 38, 1, 1 },
  { 0x0, 0x0, 160, 908, 413, 0, 0, -1 },
  { 0x0, 0x0, 160, 1237, 318, 0, 0, -1 },
  { 0x0, 0x0, 160, 1238, 452, 0, 0, -1 },
  { 0x1, 0x1, 160, -1, 2878, 38, 1, 1 },
  { 0x1, 0x1, 160, 911, 2881, 38, 1, 1 },
  { 0x0, 0x0, 160, 912, 453, 0, 0, -1 },
  { 0x0, 0x0, 160, 913, 323, 0, 0, -1 },
  { 0x0, 0x0, 160, 914, 341, 0, 0, -1 },
  { 0x0, 0x0, 160, 1239, 344, 0, 0, -1 },
  { 0x0, 0x0, 160, 1240, 460, 0, 0, -1 },
  { 0x1, 0x1, 160, -1, 2902, 38, 1, 1 },
  { 0x1, 0x1, 160, 917, 2905, 38, 1, 1 },
  { 0x0, 0x0, 160, 918, 461, 0, 0, -1 },
  { 0x0, 0x0, 160, -1, 366, 0, 0, -1 },
  { 0x0, 0x0, 160, -1, 500, 0, 0, -1 },
  { 0x1, 0x1, 160, -1, 2915, 38, 1, 1 },
  { 0x1, 0x1, 160, 921, 2917, 38, 1, 1 },
  { 0x0, 0x0, 160, 922, 501, 0, 0, -1 },
  { 0x0, 0x0, 160, 923, 371, 0, 0, -1 },
  { 0x0, 0x0, 160, 924, 389, 0, 0, -1 },
  { 0x0, 0x0, 161, 1397, 2287, 0, 0, -1 },
  { 0x0, 0x0, 161, 1398, 2295, 0, 1, 54 },
  { 0x0, 0x0, 161, 1399, 2956, 0, 1, 54 },
  { 0x0, 0x0, 161, 1400, 2343, 0, 0, -1 },
  { 0x1, 0x1, 161, 1401, -1, 29, 1, 49 },
  { 0x0, 0x0, 162, -1, 2305, 0, 0, -1 },
  { 0x1, 0x9, 162, -1, 2309, 33, 1, 54 },
  { 0x1, 0x9, 162, -1, 2965, 33, 1, 54 },
  { 0x6, 0x7, 162, -1, 2350, 27, 1, 49 },
  { 0x0, 0x0, 163, 1383, 2303, 0, 0, -1 },
  { 0x0, 0x0, 163, 1384, 2307, 0, 1, 54 },
  { 0x0, 0x0, 163, 1385, 2964, 0, 1, 54 },
  { 0x1, 0x1, 163, 1386, 2349, 29, 1, 49 },
  { 0x1, 0x1, 164, 1404, -1, 27, 1, 33 },
  { 0x0, 0x0, 165, 2159, 2291, 0, 0, -1 },
  { 0x1, 0x1, 165, 2160, 2299, 33, 1, 54 },
  { 0x1, 0x1, 165, 2161, 2958, 33, 1, 54 },
  { 0x0, 0x0, 165, 2162, 2345, 0, 0, -1 },
  { 0x3, 0x3, 165, 2163, -1, 28, 1, 49 },
  { 0x0, 0x0, 166, 1392, 2289, 0, 0, -1 },
  { 0x1, 0x1, 166, 1393, 2297, 36, 1, 54 },
  { 0x1, 0x1, 166, 1394, 2957, 36, 1, 54 },
  { 0x0, 0x0, 166, 1395, 2344, 0, 0, -1 },
  { 0x5, 0x5, 166, 1396, -1, 27, 1, 49 },
  { 0x0, 0x0, 167, -1, 2928, 0, 1, 63 },
  { 0x0, 0x0, 167, -1, 2929, 0, 1, 63 },
  { 0x1, 0x1, 169, -1, -1, 28, 1, 33 },
  { 0x1, 0x1, 170, 2745, -1, 27, 1, 33 },
  { 0x1, 0x1, 170, 2746, -1, 27, 1, 33 },
  { 0x1, 0x1, 171, 1685, -1, 28, 1, 135 },
  { 0x1, 0x1, 171, 1686, -1, 28, 1, 135 },
  { 0x1, 0x1, 171, 1687, -1, 28, 1, 135 },
  { 0x1, 0x1, 171, 1688, -1, 28, 1, 135 },
  { 0x1, 0x1, 171, 1689, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1690, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1691, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1692, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1693, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1694, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1695, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1696, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1697, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1698, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1699, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1700, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1701, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1702, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1703, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1704, -1, 28, 1, 134 },
  { 0x1, 0x1, 171, 1705, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1706, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1707, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1708, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1709, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1710, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1711, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1712, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1713, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1714, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1715, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1716, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1717, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1718, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1719, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1720, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1721, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1722, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1723, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1724, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1725, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1726, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1727, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1728, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1729, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1730, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1731, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1732, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1733, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1734, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1735, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1736, -1, 28, 1, 125 },
  { 0x1, 0x1, 171, 1737, -1, 28, 1, 125 },
  { 0x1, 0x1, 171, 1738, -1, 28, 1, 125 },
  { 0x1, 0x1, 171, 1739, -1, 28, 1, 125 },
  { 0x1, 0x1, 171, 1740, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1741, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1742, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1743, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1744, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1745, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1746, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1747, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1748, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1749, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1750, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1751, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1752, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1753, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1754, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1755, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1756, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1757, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1758, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1759, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1760, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1761, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1762, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1763, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1764, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1765, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1766, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1767, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1768, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1769, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1770, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1771, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1772, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1773, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1774, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1775, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1776, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1777, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1778, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1779, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1780, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1781, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1782, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1783, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1784, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1785, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1786, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1787, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1788, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1789, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1790, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1791, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1792, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1793, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1794, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1795, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1796, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1797, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1798, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1799, -1, 28, 1, 129 },
  { 0x1, 0x1, 171, 1800, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1801, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1802, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1803, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1804, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1805, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1806, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1807, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1808, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1809, -1, 28, 1, 129 },
  { 0x1, 0x1, 171, 1810, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1811, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1812, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1813, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1814, -1, 28, 1, 126 },
  { 0x1, 0x1, 171, 1815, -1, 28, 1, 127 },
  { 0x1, 0x1, 171, 1816, -1, 28, 1, 128 },
  { 0x1, 0x1, 171, 1817, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1818, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1819, -1, 28, 1, 129 },
  { 0x1, 0x1, 171, 1820, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1821, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1822, -1, 28, 1, 130 },
  { 0x1, 0x1, 171, 1823, -1, 28, 1, 124 },
  { 0x1, 0x1, 171, 1824, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1825, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1826, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1827, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1828, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1829, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1830, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1831, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1832, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1833, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1834, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1835, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1836, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1837, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1838, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1839, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1840, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1841, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1842, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1843, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1844, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1845, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1846, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1847, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1848, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1849, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1850, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1851, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1852, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1853, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1854, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1855, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1856, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1857, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1858, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1859, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1860, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1861, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1862, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1863, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1864, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1865, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1866, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1867, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1868, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1869, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1870, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1871, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1872, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1873, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1874, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1875, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1876, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1877, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1878, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1879, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1880, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1881, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1882, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1883, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1884, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1885, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1886, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1887, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1888, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1889, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1890, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1891, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1892, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1893, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1894, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1895, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1896, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1897, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1898, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1899, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1900, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1901, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1902, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1903, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1904, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1905, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1906, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1907, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1908, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1909, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1910, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1911, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1912, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1913, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1914, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1915, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1916, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1917, -1, 28, 1, 141 },
  { 0x1, 0x1, 171, 1918, -1, 28, 1, 142 },
  { 0x1, 0x1, 171, 1919, -1, 28, 1, 143 },
  { 0x1, 0x1, 171, 1920, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1921, -1, 28, 1, 144 },
  { 0x1, 0x1, 171, 1922, -1, 28, 1, 140 },
  { 0x1, 0x1, 171, 1923, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1924, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1925, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1926, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1927, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1928, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1929, -1, 28, 1, 146 },
  { 0x1, 0x1, 171, 1930, -1, 28, 1, 147 },
  { 0x1, 0x1, 171, 1931, -1, 28, 1, 148 },
  { 0x1, 0x1, 171, 1932, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1933, -1, 28, 1, 149 },
  { 0x1, 0x1, 171, 1934, -1, 28, 1, 145 },
  { 0x1, 0x1, 171, 1673, -1, 28, 1, 151 },
  { 0x1, 0x1, 171, 1674, -1, 28, 1, 152 },
  { 0x1, 0x1, 171, 1675, -1, 28, 1, 152 },
  { 0x1, 0x1, 171, 1676, -1, 28, 1, 151 },
  { 0x1, 0x1, 171, 1677, -1, 28, 1, 153 },
  { 0x1, 0x1, 171, 1678, -1, 28, 1, 154 },
  { 0x1, 0x1, 171, 1679, -1, 28, 1, 154 },
  { 0x1, 0x1, 171, 1680, -1, 28, 1, 153 },
  { 0x1, 0x1, 171, 1681, -1, 28, 1, 153 },
  { 0x1, 0x1, 171, 1682, -1, 28, 1, 154 },
  { 0x1, 0x1, 171, 1683, -1, 28, 1, 154 },
  { 0x1, 0x1, 171, 1684, -1, 28, 1, 153 },
  { 0x1, 0x1, 171, 1979, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1980, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1981, -1, 28, 1, 136 },
  { 0x1, 0x1, 171, 1982, -1, 28, 1, 136 },
  { 0x1, 0x1, 172, 1935, -1, 29, 1, 151 },
  { 0x1, 0x1, 172, 1936, -1, 29, 1, 152 },
  { 0x1, 0x1, 172, 1937, -1, 29, 1, 152 },
  { 0x1, 0x1, 172, 1938, -1, 29, 1, 151 },
  { 0x1, 0x1, 172, 1939, -1, 29, 1, 153 },
  { 0x1, 0x1, 172, 1940, -1, 29, 1, 154 },
  { 0x1, 0x1, 172, 1941, -1, 29, 1, 154 },
  { 0x1, 0x1, 172, 1942, -1, 29, 1, 153 },
  { 0x1, 0x1, 172, 1943, -1, 29, 1, 153 },
  { 0x1, 0x1, 172, 1944, -1, 29, 1, 154 },
  { 0x1, 0x1, 172, 1945, -1, 29, 1, 154 },
  { 0x1, 0x1, 172, 1946, -1, 29, 1, 153 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 135 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 135 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 135 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 135 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 134 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 269, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2224, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 271, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2225, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 273, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2226, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 125 },
  { 0x3, 0x3, 173, 275, -1, 28, 1, 125 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 125 },
  { 0x3, 0x3, 173, 276, -1, 28, 1, 125 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 277, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2227, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 279, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2228, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 281, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2229, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 283, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2230, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 285, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2231, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 287, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2232, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 129 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 289, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2233, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 129 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 291, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2234, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 126 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 127 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 128 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 129 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 293, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 130 },
  { 0x3, 0x3, 173, 2235, -1, 28, 1, 124 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2236, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2237, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2238, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2239, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2240, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2241, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2242, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2243, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2244, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2245, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2246, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2247, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2248, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2249, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2250, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 141 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 142 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 143 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 144 },
  { 0x3, 0x3, 173, 2251, -1, 28, 1, 140 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2252, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 146 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 147 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 148 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 149 },
  { 0x3, 0x3, 173, 2253, -1, 28, 1, 145 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 151 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 152 },
  { 0x3, 0x3, 173, 933, -1, 28, 1, 152 },
  { 0x3, 0x3, 173, 934, -1, 28, 1, 151 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 153 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 154 },
  { 0x3, 0x3, 173, 935, -1, 28, 1, 154 },
  { 0x3, 0x3, 173, 936, -1, 28, 1, 153 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 153 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 154 },
  { 0x3, 0x3, 173, 937, -1, 28, 1, 154 },
  { 0x3, 0x3, 173, 938, -1, 28, 1, 153 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, 2190, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, 2191, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 132 },
  { 0x3, 0x3, 173, 2192, -1, 28, 1, 132 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 132 },
  { 0x3, 0x3, 173, 2193, -1, 28, 1, 132 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, 2194, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, 2195, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, 2196, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, 2197, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 133 },
  { 0x3, 0x3, 173, 2198, -1, 28, 1, 131 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 139 },
  { 0x3, 0x3, 173, 2199, -1, 28, 1, 138 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 150 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 156 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 150 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 156 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 150 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 156 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 150 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 156 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 150 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 156 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x3, 0x3, 173, -1, -1, 28, 1, 136 },
  { 0x0, 0x0, 174, -1, 392, 0, 0, -1 },
  { 0x0, 0x0, 174, -1, 394, 0, 0, -1 },
  { 0x0, 0x0, 174, 3004, 2968, 0, 1, 1 },
  { 0x0, 0x0, 174, 3005, 2969, 0, 1, 1 },
  { 0x0, 0x0, 174, -1, 400, 0, 0, -1 },
  { 0x0, 0x0, 174, -1, 402, 0, 0, -1 },
  { 0x0, 0x0, 174, 3008, 2972, 0, 1, 1 },
  { 0x0, 0x0, 174, 3009, 2973, 0, 1, 1 },
  { 0x11, 0x31, 175, 2847, 407, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 408, 12, 1, 4 },
  { 0x11, 0x31, 175, 2047, 409, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 411, 12, 1, 4 },
  { 0x1, 0x1, 175, -1, 415, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 416, 12, 1, 4 },
  { 0x11, 0x11, 175, -1, 417, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 418, 12, 1, 4 },
  { 0x1, 0x1, 175, 2053, 419, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 421, 12, 1, 4 },
  { 0x11, 0x11, 175, 2055, 423, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 425, 12, 1, 4 },
  { 0x1, 0x1, 175, 2057, 427, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 429, 12, 1, 4 },
  { 0x11, 0x11, 175, 2059, 431, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 433, 12, 1, 4 },
  { 0x1, 0x1, 175, 2061, 435, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 437, 12, 1, 4 },
  { 0x11, 0x11, 175, 2063, 439, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 441, 12, 1, 4 },
  { 0x11, 0x31, 175, 2867, 447, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 448, 12, 1, 4 },
  { 0x11, 0x31, 175, 2069, 449, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 451, 12, 1, 4 },
  { 0x11, 0x31, 175, 2887, 455, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 456, 12, 1, 4 },
  { 0x11, 0x31, 175, 2095, 457, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 459, 12, 1, 4 },
  { 0x1, 0x1, 175, -1, 463, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 464, 12, 1, 4 },
  { 0x11, 0x11, 175, -1, 465, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 466, 12, 1, 4 },
  { 0x1, 0x1, 175, 2101, 467, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 469, 12, 1, 4 },
  { 0x11, 0x11, 175, 2103, 471, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 473, 12, 1, 4 },
  { 0x1, 0x1, 175, 2105, 475, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 477, 12, 1, 4 },
  { 0x11, 0x11, 175, 2107, 479, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 481, 12, 1, 4 },
  { 0x1, 0x1, 175, 2109, 483, 37, 1, 4 },
  { 0x2000001, 0x2000001, 175, -1, 485, 12, 1, 4 },
  { 0x11, 0x11, 175, 2111, 487, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 489, 12, 1, 4 },
  { 0x11, 0x31, 175, 2907, 495, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 496, 12, 1, 4 },
  { 0x11, 0x31, 175, 2117, 497, 33, 1, 4 },
  { 0x2200001, 0x2200001, 175, -1, 499, 12, 1, 4 },
  { 0x1, 0x1, 175, -1, 503, 33, 1, 4 },
  { 0x200001, 0x200001, 175, -1, 504, 12, 1, 4 },
  { 0x1, 0x1, 175, -1, 505, 33, 1, 4 },
  { 0x200001, 0x200001, 175, -1, 506, 12, 1, 4 },
  { 0x1, 0x1, 175, -1, 511, 33, 1, 4 },
  { 0x200001, 0x200001, 175, -1, 512, 12, 1, 4 },
  { 0x1, 0x1, 175, -1, 513, 33, 1, 4 },
  { 0x200001, 0x200001, 175, -1, 514, 12, 1, 4 },
  { 0x2200001, 0x6200001, 176, 2850, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 1994, -1, 33, 1, 4 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x4200001, 0x4200001, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 37, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x1, 0x1, 176, 2000, -1, 37, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2002, -1, 33, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x1, 0x1, 176, 2004, -1, 37, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2006, -1, 33, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x1, 0x1, 176, 2008, -1, 37, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2010, -1, 33, 1, 4 },
  { 0x1, 0x1, 176, -1, -1, 37, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, -1, -1, 33, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x2200001, 0x6200001, 176, 2870, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2014, -1, 33, 1, 4 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x4200001, 0x4200001, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 37, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x2200001, 0x6200001, 176, 2890, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2018, -1, 33, 1, 4 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x4200001, 0x4200001, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 37, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x1, 0x1, 176, 2024, -1, 37, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2026, -1, 33, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x1, 0x1, 176, 2028, -1, 37, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2030, -1, 33, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x1, 0x1, 176, 2032, -1, 37, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2034, -1, 33, 1, 4 },
  { 0x1, 0x1, 176, -1, -1, 37, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, -1, -1, 33, 1, 4 },
  { 0x2200001, 0x2200001, 176, -1, -1, 12, 1, 4 },
  { 0x2200001, 0x6200001, 176, 2909, -1, 12, 1, 4 },
  { 0x11, 0x11, 176, 2038, -1, 33, 1, 4 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x4200001, 0x4200001, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 37, 1, 4 },
  { 0x2000001, 0x2000001, 176, -1, -1, 12, 1, 4 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 33, 1, 5 },
  { 0x200001, 0x200001, 176, -1, -1, 12, 1, 5 },
  { 0x0, 0x0, 176, -1, -1, 0, 1, 5 },
  { 0x1, 0x1, 176, -1, -1, 12, 1, 5 },
  { 0x9, 0x9, 176, -1, -1, 33, 1, 5 },
  { 0x1, 0x1, 176, 395, -1, 33, 1, 4 },
  { 0x1200001, 0x1200001, 176, -1, -1, 12, 1, 5 },
  { 0x200001, 0x200001, 176, 396, -1, 12, 1, 4 },
  { 0x9, 0x9, 176, -1, -1, 33, 1, 5 },
  { 0x1, 0x1, 176, 397, -1, 33, 1, 4 },
  { 0x1200001, 0x1200001, 176, -1, -1, 12, 1, 5 },
  { 0x200001, 0x200001, 176, 398, -1, 12, 1, 4 },
  { 0x9, 0x9, 176, -1, -1, 33, 1, 5 },
  { 0x1, 0x1, 176, 403, -1, 33, 1, 4 },
  { 0x1200001, 0x1200001, 176, -1, -1, 12, 1, 5 },
  { 0x200001, 0x200001, 176, 404, -1, 12, 1, 4 },
  { 0x9, 0x9, 176, -1, -1, 33, 1, 5 },
  { 0x1, 0x1, 176, 405, -1, 33, 1, 4 },
  { 0x1200001, 0x1200001, 176, -1, -1, 12, 1, 5 },
  { 0x200001, 0x200001, 176, 406, -1, 12, 1, 4 },
  { 0x0, 0x0, 177, -1, 2293, 0, 0, -1 },
  { 0x9, 0x9, 177, -1, 2301, 33, 1, 49 },
  { 0x9, 0x9, 177, -1, 2959, 33, 1, 49 },
  { 0x0, 0x0, 177, -1, 2346, 0, 0, -1 },
  { 0x7, 0x7, 177, -1, -1, 27, 1, 49 },
  { 0x1, 0x1, 197, -1, -1, 27, 1, 10 },
  { 0x1, 0x1, 211, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 211, -1, -1, 29, 1, 0 },
  { 0x2, 0x3, 211, 1151, -1, 27, 1, 33 },
  { 0x0, 0x0, 211, 1152, -1, 0, 1, 33 },
  { 0x0, 0x0, 211, 1153, -1, 0, 1, 0 },
  { 0x0, 0x0, 211, 1154, -1, 0, 1, 0 },
  { 0x0, 0x0, 211, 1155, -1, 0, 1, 0 },
  { 0x0, 0x0, 211, 1156, -1, 0, 1, 0 },
  { 0x0, 0x0, 211, 2988, -1, 0, 1, 93 },
  { 0x0, 0x0, 211, 2989, -1, 0, 1, 93 },
  { 0x0, 0x0, 211, 2990, 949, 0, 0, -1 },
  { 0x1, 0x1, 212, -1, -1, 27, 1, 0 },
  { 0x1, 0x1, 212, -1, -1, 27, 1, 0 },
  { 0x1, 0x1, 213, -1, 1408, 32, 1, 135 },
  { 0x1, 0x1, 213, -1, 1410, 32, 1, 135 },
  { 0x1, 0x1, 213, -1, 1412, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1414, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1416, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1418, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1420, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1422, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1424, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1426, 32, 1, 134 },
  { 0x1, 0x1, 213, -1, 1428, 32, 1, 136 },
  { 0x1, 0x1, 213, -1, 1430, 32, 1, 136 },
  { 0x1, 0x1, 213, -1, 1947, 32, 1, 131 },
  { 0x1, 0x1, 213, -1, 1949, 32, 1, 138 },
  { 0x1, 0x1, 213, -1, 1951, 32, 1, 132 },
  { 0x1, 0x1, 213, -1, 1953, 32, 1, 132 },
  { 0x1, 0x1, 213, -1, 1955, 32, 1, 131 },
  { 0x1, 0x1, 213, -1, 1957, 32, 1, 138 },
  { 0x1, 0x1, 213, -1, 1959, 32, 1, 131 },
  { 0x1, 0x1, 213, -1, 1961, 32, 1, 138 },
  { 0x1, 0x1, 213, 2749, 1963, 32, 1, 131 },
  { 0x1, 0x1, 213, 2750, 1966, 32, 1, 138 },
  { 0x0, 0x0, 214, -1, 2791, 0, 0, -1 },
  { 0x0, 0x0, 214, -1, 2792, 0, 0, -1 },
  { 0x0, 0x0, 214, -1, 2817, 0, 0, -1 },
  { 0x5, 0x5, 214, -1, 2820, 20, 1, 67 },
  { 0x0, 0x0, 218, 2175, 948, 0, 0, -1 },
  { 0x0, 0x0, 219, -1, 1121, 0, 0, -1 },
  { 0x0, 0x0, 219, -1, 1246, 0, 0, -1 },
  { 0x0, 0x0, 219, -1, -1, 0, 1, 121 },
  { 0x0, 0x0, 219, -1, -1, 0, 1, 66 },
  { 0x1, 0x1, 219, 815, 2255, 36, 1, 65 },
  { 0x1, 0x1, 219, 816, 2314, 36, 1, 65 },
  { 0x0, 0x0, 219, 817, 2317, 0, 0, -1 },
  { 0x1, 0x1, 219, 818, -1, 36, 1, 65 },
  { 0x0, 0x0, 219, 1405, -1, 0, 1, 33 },
  { 0x1, 0x1, 219, 819, 2322, 36, 1, 65 },
  { 0x0, 0x0, 219, 820, 2325, 0, 0, -1 },
  { 0x1, 0x1, 219, 821, -1, 36, 1, 65 },
  { 0x0, 0x0, 219, 822, 2328, 0, 0, -1 },
  { 0x1, 0x1, 219, 823, -1, 36, 1, 65 },
  { 0x1, 0x1, 219, 824, 2331, 36, 1, 65 },
  { 0x1, 0x1, 219, 825, 2334, 36, 1, 65 },
  { 0x0, 0x0, 219, 1406, -1, 0, 1, 33 },
  { 0x1, 0x1, 219, 826, 2367, 36, 1, 65 },
  { 0x1, 0x1, 219, 827, -1, 31, 1, 137 },
  { 0x1, 0x1, 219, 226, 1431, 32, 1, 126 },
  { 0x1, 0x1, 219, 227, 1440, 32, 1, 126 },
  { 0x1, 0x1, 219, 228, 1449, 32, 1, 126 },
  { 0x1, 0x1, 219, 229, 1462, 32, 1, 126 },
  { 0x1, 0x1, 219, 230, 1471, 32, 1, 126 },
  { 0x1, 0x1, 219, 231, 1480, 32, 1, 126 },
  { 0x1, 0x1, 219, 232, 1489, 32, 1, 126 },
  { 0x1, 0x1, 219, 233, 1498, 32, 1, 126 },
  { 0x1, 0x1, 219, 234, 1507, 32, 1, 126 },
  { 0x1, 0x1, 219, 235, 1516, 32, 1, 126 },
  { 0x1, 0x1, 219, 236, 1526, 32, 1, 126 },
  { 0x1, 0x1, 219, 237, 1536, 32, 1, 126 },
  { 0x1, 0x1, 219, 238, 1549, 32, 1, 141 },
  { 0x1, 0x1, 219, 239, 1555, 32, 1, 146 },
  { 0x1, 0x1, 219, 240, 1561, 32, 1, 146 },
  { 0x1, 0x1, 219, 241, 1567, 32, 1, 141 },
  { 0x1, 0x1, 219, 242, 1573, 32, 1, 146 },
  { 0x1, 0x1, 219, 243, 1579, 32, 1, 146 },
  { 0x1, 0x1, 219, 244, 1585, 32, 1, 141 },
  { 0x1, 0x1, 219, 245, 1591, 32, 1, 146 },
  { 0x1, 0x1, 219, 246, 1597, 32, 1, 146 },
  { 0x1, 0x1, 219, 247, 1603, 32, 1, 141 },
  { 0x1, 0x1, 219, 248, 1609, 32, 1, 146 },
  { 0x1, 0x1, 219, 249, 1615, 32, 1, 141 },
  { 0x1, 0x1, 219, 250, 1621, 32, 1, 146 },
  { 0x1, 0x1, 219, 251, 1627, 32, 1, 141 },
  { 0x1, 0x1, 219, 252, 1633, 32, 1, 146 },
  { 0x1, 0x1, 219, 253, 1639, 32, 1, 141 },
  { 0x1, 0x1, 219, 254, 1645, 32, 1, 146 },
  { 0x1, 0x1, 219, 255, 1651, 32, 1, 146 },
  { 0x1, 0x1, 219, 831, -1, 31, 1, 155 },
  { 0x0, 0x0, 220, 2370, -1, 0, 1, 65 },
  { 0x0, 0x0, 220, 2371, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 25, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2373, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2374, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2375, -1, 0, 1, 44 },
  { 0x0, 0x0, 220, 2376, -1, 0, 1, 39 },
  { 0x1, 0x1, 220, 2377, -1, 12, 1, 58 },
  { 0x0, 0x0, 220, 2378, -1, 0, 1, 53 },
  { 0x1000001, 0x1000001, 220, 2379, -1, 12, 1, 58 },
  { 0x1, 0x1, 220, 2380, -1, 36, 1, 53 },
  { 0x200001, 0x200001, 220, 2381, -1, 12, 1, 58 },
  { 0x1, 0x1, 220, 2382, -1, 33, 1, 53 },
  { 0x1200001, 0x1200001, 220, 2383, -1, 12, 1, 48 },
  { 0x9, 0x9, 220, 2384, -1, 33, 1, 48 },
  { 0x0, 0x0, 220, 2385, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2386, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2387, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2388, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2389, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2390, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2391, -1, 0, 1, 48 },
  { 0x0, 0x0, 220, 2392, -1, 0, 1, 48 },
  { 0x1, 0x1, 220, 2393, -1, 12, 1, 58 },
  { 0x0, 0x0, 220, 2394, -1, 0, 1, 53 },
  { 0x200001, 0x1200001, 220, 2395, -1, 12, 1, 58 },
  { 0x1, 0x9, 220, 2396, -1, 33, 1, 53 },
  { 0x0, 0x0, 220, 2397, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2398, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2399, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2400, -1, 0, 1, 53 },
  { 0x1, 0x1, 220, 2401, -1, 12, 1, 58 },
  { 0x0, 0x0, 220, 2402, -1, 0, 1, 53 },
  { 0x1000001, 0x1000001, 220, 2403, -1, 12, 1, 58 },
  { 0x1, 0x1, 220, 2404, -1, 36, 1, 53 },
  { 0x200001, 0x200001, 220, 2405, -1, 12, 1, 58 },
  { 0x1, 0x1, 220, 2406, -1, 33, 1, 53 },
  { 0x1200001, 0x1200001, 220, 2407, -1, 12, 1, 48 },
  { 0x9, 0x9, 220, 2408, -1, 33, 1, 48 },
  { 0x0, 0x0, 220, 2409, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2410, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2411, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2412, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2413, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2414, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2415, -1, 0, 1, 48 },
  { 0x0, 0x0, 220, 2416, -1, 0, 1, 48 },
  { 0x1, 0x1, 220, 2417, -1, 12, 1, 58 },
  { 0x0, 0x0, 220, 2418, -1, 0, 1, 53 },
  { 0x200001, 0x1200001, 220, 2419, -1, 12, 1, 58 },
  { 0x1, 0x9, 220, 2420, -1, 33, 1, 53 },
  { 0x0, 0x0, 220, 2421, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2422, -1, 0, 1, 53 },
  { 0x0, 0x0, 220, 2423, -1, 0, 1, 58 },
  { 0x0, 0x0, 220, 2424, -1, 0, 1, 53 },
  { 0x1, 0x1, 220, 2425, -1, 28, 1, 28 },
  { 0x0, 0x0, 220, 2426, -1, 0, 1, 28 },
  { 0x3, 0x3, 220, 2427, -1, 27, 1, 28 },
  { 0x1, 0x1, 220, 2428, -1, 27, 1, 28 },
  { 0x0, 0x0, 220, 2429, -1, 0, 1, 65 },
  { 0x0, 0x0, 220, 2430, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2431, -1, 0, 1, 28 },
  { 0x1, 0x1, 220, 2432, -1, 36, 1, 65 },
  { 0x1, 0x1, 220, 2433, -1, 37, 1, 28 },
  { 0x0, 0x0, 220, 2434, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2435, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2436, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2437, -1, 0, 1, 65 },
  { 0x0, 0x0, 220, 2438, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 37, -1, 0, 1, 28 },
  { 0x1, 0x1, 220, 2440, -1, 36, 1, 65 },
  { 0x1, 0x1, 220, 2441, -1, 37, 1, 28 },
  { 0x0, 0x0, 220, 2442, -1, 0, 1, 28 },
  { 0x1, 0x1, 220, 2443, -1, 36, 1, 65 },
  { 0x1, 0x1, 220, 2444, -1, 37, 1, 28 },
  { 0x0, 0x0, 220, 2445, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2446, -1, 0, 1, 65 },
  { 0x0, 0x0, 220, 2447, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 42, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2449, -1, 0, 1, 65 },
  { 0x0, 0x0, 220, 2450, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 43, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2452, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2453, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2454, -1, 0, 1, 48 },
  { 0x1, 0x1, 220, 2455, -1, 27, 1, 48 },
  { 0x1, 0x1, 220, 2456, -1, 28, 1, 48 },
  { 0x3, 0x3, 220, 2457, -1, 27, 1, 48 },
  { 0x1, 0x1, 220, 2458, -1, 29, 1, 48 },
  { 0x5, 0x5, 220, 2459, -1, 27, 1, 48 },
  { 0x3, 0x3, 220, 2460, -1, 28, 1, 48 },
  { 0x7, 0x7, 220, 2461, -1, 27, 1, 48 },
  { 0x0, 0x0, 220, 2462, -1, 0, 1, 48 },
  { 0x0, 0x0, 220, 2463, -1, 0, 1, 48 },
  { 0x0, 0x0, 220, 2464, -1, 0, 1, 48 },
  { 0x0, 0x0, 220, 2465, -1, 0, 1, 48 },
  { 0x1, 0x1, 220, 2466, -1, 28, 1, 28 },
  { 0x0, 0x0, 220, 2467, -1, 0, 1, 28 },
  { 0x3, 0x3, 220, 2468, -1, 27, 1, 28 },
  { 0x1, 0x1, 220, 2469, -1, 27, 1, 28 },
  { 0x0, 0x0, 220, 2470, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2471, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2472, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 52, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2474, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2475, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 57, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 2477, -1, 0, 1, 23 },
  { 0x0, 0x0, 220, 2478, -1, 0, 1, 23 },
  { 0x0, 0x0, 220, 2479, -1, 0, 1, 23 },
  { 0x0, 0x0, 220, 2480, -1, 0, 1, 23 },
  { 0x0, 0x0, 220, 2481, -1, 0, 1, 34 },
  { 0x0, 0x0, 220, 2482, -1, 0, 1, 65 },
  { 0x0, 0x0, 220, 2483, -1, 0, 1, 28 },
  { 0x0, 0x0, 220, 64, -1, 0, 1, 28 },
  { 0x1, 0x1, 221, 2485, -1, 34, 1, 65 },
  { 0x1, 0x1, 221, 2486, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2487, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2488, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2489, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2490, -1, 34, 1, 45 },
  { 0x1, 0x1, 221, 2491, -1, 34, 1, 41 },
  { 0x400001, 0x400001, 221, 2492, -1, 12, 1, 60 },
  { 0x1, 0x1, 221, 2493, -1, 34, 1, 55 },
  { 0x1400001, 0x1400001, 221, 2494, -1, 12, 1, 60 },
  { 0x5, 0x5, 221, 2495, -1, 34, 1, 55 },
  { 0x600001, 0x600001, 221, 2496, -1, 12, 1, 60 },
  { 0x3, 0x3, 221, 2497, -1, 33, 1, 55 },
  { 0x1600001, 0x1600001, 221, 2498, -1, 12, 1, 50 },
  { 0xb, 0xb, 221, 2499, -1, 33, 1, 50 },
  { 0x1, 0x1, 221, 2500, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2501, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2502, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2503, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2504, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2505, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2506, -1, 34, 1, 50 },
  { 0x1, 0x1, 221, 2507, -1, 34, 1, 50 },
  { 0x400001, 0x400001, 221, 2508, -1, 12, 1, 60 },
  { 0x1, 0x1, 221, 2509, -1, 34, 1, 55 },
  { 0x600001, 0x1600001, 221, 2510, -1, 12, 1, 60 },
  { 0x3, 0xb, 221, 2511, -1, 33, 1, 55 },
  { 0x1, 0x1, 221, 2512, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2513, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2514, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2515, -1, 34, 1, 55 },
  { 0x400001, 0x400001, 221, 2516, -1, 12, 1, 60 },
  { 0x1, 0x1, 221, 2517, -1, 34, 1, 55 },
  { 0x1400001, 0x1400001, 221, 2518, -1, 12, 1, 60 },
  { 0x5, 0x5, 221, 2519, -1, 34, 1, 55 },
  { 0x600001, 0x600001, 221, 2520, -1, 12, 1, 60 },
  { 0x3, 0x3, 221, 2521, -1, 33, 1, 55 },
  { 0x1600001, 0x1600001, 221, 2522, -1, 12, 1, 50 },
  { 0xb, 0xb, 221, 2523, -1, 33, 1, 50 },
  { 0x1, 0x1, 221, 2524, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2525, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2526, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2527, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2528, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2529, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2530, -1, 34, 1, 50 },
  { 0x1, 0x1, 221, 2531, -1, 34, 1, 50 },
  { 0x400001, 0x400001, 221, 2532, -1, 12, 1, 60 },
  { 0x1, 0x1, 221, 2533, -1, 34, 1, 55 },
  { 0x600001, 0x1600001, 221, 2534, -1, 12, 1, 60 },
  { 0x3, 0xb, 221, 2535, -1, 33, 1, 55 },
  { 0x1, 0x1, 221, 2536, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2537, -1, 34, 1, 55 },
  { 0x1, 0x1, 221, 2538, -1, 34, 1, 60 },
  { 0x1, 0x1, 221, 2539, -1, 34, 1, 55 },
  { 0x41, 0x41, 221, 2540, -1, 28, 1, 30 },
  { 0x1, 0x1, 221, 2541, -1, 34, 1, 30 },
  { 0x83, 0x83, 221, 2542, -1, 27, 1, 30 },
  { 0x81, 0x81, 221, 2543, -1, 27, 1, 30 },
  { 0x1, 0x1, 221, 2544, -1, 34, 1, 65 },
  { 0x1, 0x1, 221, 2545, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2546, -1, 34, 1, 30 },
  { 0x5, 0x5, 221, 2547, -1, 34, 1, 65 },
  { 0x9, 0x9, 221, 2548, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2549, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2550, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2551, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2552, -1, 34, 1, 65 },
  { 0x1, 0x1, 221, 2553, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2554, -1, 34, 1, 30 },
  { 0x5, 0x5, 221, 2555, -1, 34, 1, 65 },
  { 0x9, 0x9, 221, 2556, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2557, -1, 34, 1, 30 },
  { 0x5, 0x5, 221, 2558, -1, 34, 1, 65 },
  { 0x9, 0x9, 221, 2559, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2560, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2561, -1, 34, 1, 65 },
  { 0x1, 0x1, 221, 2562, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2563, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2564, -1, 34, 1, 65 },
  { 0x1, 0x1, 221, 2565, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2566, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2567, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2568, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2569, -1, 34, 1, 50 },
  { 0x81, 0x81, 221, 2570, -1, 27, 1, 50 },
  { 0x41, 0x41, 221, 2571, -1, 28, 1, 50 },
  { 0x83, 0x83, 221, 2572, -1, 27, 1, 50 },
  { 0x21, 0x21, 221, 2573, -1, 29, 1, 50 },
  { 0x85, 0x85, 221, 2574, -1, 27, 1, 50 },
  { 0x43, 0x43, 221, 2575, -1, 28, 1, 50 },
  { 0x87, 0x87, 221, 2576, -1, 27, 1, 50 },
  { 0x1, 0x1, 221, 2577, -1, 34, 1, 50 },
  { 0x1, 0x1, 221, 2578, -1, 34, 1, 50 },
  { 0x1, 0x1, 221, 2579, -1, 34, 1, 50 },
  { 0x1, 0x1, 221, 2580, -1, 34, 1, 50 },
  { 0x41, 0x41, 221, 2581, -1, 28, 1, 30 },
  { 0x1, 0x1, 221, 2582, -1, 34, 1, 30 },
  { 0x83, 0x83, 221, 2583, -1, 27, 1, 30 },
  { 0x81, 0x81, 221, 2584, -1, 27, 1, 30 },
  { 0x1, 0x1, 221, 2585, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2586, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2587, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2588, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2589, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2590, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2591, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2592, -1, 34, 1, 25 },
  { 0x1, 0x1, 221, 2593, -1, 34, 1, 25 },
  { 0x1, 0x1, 221, 2594, -1, 34, 1, 25 },
  { 0x1, 0x1, 221, 2595, -1, 34, 1, 25 },
  { 0x1, 0x1, 221, 2596, -1, 34, 1, 36 },
  { 0x1, 0x1, 221, 2597, -1, 34, 1, 65 },
  { 0x1, 0x1, 221, 2598, -1, 34, 1, 30 },
  { 0x1, 0x1, 221, 2599, -1, 34, 1, 30 },
  { 0x1, 0x1, 222, 2600, -1, 35, 1, 65 },
  { 0x1, 0x1, 222, 2601, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2602, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2603, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2604, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2605, -1, 35, 1, 46 },
  { 0x1, 0x1, 222, 2606, -1, 35, 1, 42 },
  { 0x800001, 0x800001, 222, 2607, -1, 12, 1, 61 },
  { 0x1, 0x1, 222, 2608, -1, 35, 1, 56 },
  { 0x1800001, 0x1800001, 222, 2609, -1, 12, 1, 61 },
  { 0x3, 0x3, 222, 2610, -1, 35, 1, 56 },
  { 0xa00001, 0xa00001, 222, 2611, -1, 12, 1, 61 },
  { 0x5, 0x5, 222, 2612, -1, 33, 1, 56 },
  { 0x1a00001, 0x1a00001, 222, 2613, -1, 12, 1, 51 },
  { 0xd, 0xd, 222, 2614, -1, 33, 1, 51 },
  { 0x1, 0x1, 222, 2615, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2616, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2617, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2618, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2619, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2620, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2621, -1, 35, 1, 51 },
  { 0x1, 0x1, 222, 2622, -1, 35, 1, 51 },
  { 0x800001, 0x800001, 222, 2623, -1, 12, 1, 61 },
  { 0x1, 0x1, 222, 2624, -1, 35, 1, 56 },
  { 0xa00001, 0x1a00001, 222, 2625, -1, 12, 1, 61 },
  { 0x5, 0xd, 222, 2626, -1, 33, 1, 56 },
  { 0x1, 0x1, 222, 2627, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2628, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2629, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2630, -1, 35, 1, 56 },
  { 0x800001, 0x800001, 222, 2631, -1, 12, 1, 61 },
  { 0x1, 0x1, 222, 2632, -1, 35, 1, 56 },
  { 0x1800001, 0x1800001, 222, 2633, -1, 12, 1, 61 },
  { 0x3, 0x3, 222, 2634, -1, 35, 1, 56 },
  { 0xa00001, 0xa00001, 222, 2635, -1, 12, 1, 61 },
  { 0x5, 0x5, 222, 2636, -1, 33, 1, 56 },
  { 0x1a00001, 0x1a00001, 222, 2637, -1, 12, 1, 51 },
  { 0xd, 0xd, 222, 2638, -1, 33, 1, 51 },
  { 0x1, 0x1, 222, 2639, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2640, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2641, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2642, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2643, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2644, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2645, -1, 35, 1, 51 },
  { 0x1, 0x1, 222, 2646, -1, 35, 1, 51 },
  { 0x800001, 0x800001, 222, 2647, -1, 12, 1, 61 },
  { 0x1, 0x1, 222, 2648, -1, 35, 1, 56 },
  { 0xa00001, 0x1a00001, 222, 2649, -1, 12, 1, 61 },
  { 0x5, 0xd, 222, 2650, -1, 33, 1, 56 },
  { 0x1, 0x1, 222, 2651, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2652, -1, 35, 1, 56 },
  { 0x1, 0x1, 222, 2653, -1, 35, 1, 61 },
  { 0x1, 0x1, 222, 2654, -1, 35, 1, 56 },
  { 0x81, 0x81, 222, 2655, -1, 28, 1, 31 },
  { 0x1, 0x1, 222, 2656, -1, 35, 1, 31 },
  { 0x103, 0x103, 222, 2657, -1, 27, 1, 31 },
  { 0x101, 0x101, 222, 2658, -1, 27, 1, 31 },
  { 0x1, 0x1, 222, 2659, -1, 35, 1, 65 },
  { 0x1, 0x1, 222, 2660, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2661, -1, 35, 1, 31 },
  { 0x3, 0x3, 222, 2662, -1, 35, 1, 65 },
  { 0x5, 0x5, 222, 2663, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2664, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2665, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2666, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2667, -1, 35, 1, 65 },
  { 0x1, 0x1, 222, 2668, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2669, -1, 35, 1, 31 },
  { 0x3, 0x3, 222, 2670, -1, 35, 1, 65 },
  { 0x5, 0x5, 222, 2671, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2672, -1, 35, 1, 31 },
  { 0x3, 0x3, 222, 2673, -1, 35, 1, 65 },
  { 0x5, 0x5, 222, 2674, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2675, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2676, -1, 35, 1, 65 },
  { 0x1, 0x1, 222, 2677, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2678, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2679, -1, 35, 1, 65 },
  { 0x1, 0x1, 222, 2680, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2681, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2682, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2683, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2684, -1, 35, 1, 51 },
  { 0x101, 0x101, 222, 2685, -1, 27, 1, 51 },
  { 0x81, 0x81, 222, 2686, -1, 28, 1, 51 },
  { 0x103, 0x103, 222, 2687, -1, 27, 1, 51 },
  { 0x41, 0x41, 222, 2688, -1, 29, 1, 51 },
  { 0x105, 0x105, 222, 2689, -1, 27, 1, 51 },
  { 0x83, 0x83, 222, 2690, -1, 28, 1, 51 },
  { 0x107, 0x107, 222, 2691, -1, 27, 1, 51 },
  { 0x1, 0x1, 222, 2692, -1, 35, 1, 51 },
  { 0x1, 0x1, 222, 2693, -1, 35, 1, 51 },
  { 0x1, 0x1, 222, 2694, -1, 35, 1, 51 },
  { 0x1, 0x1, 222, 2695, -1, 35, 1, 51 },
  { 0x81, 0x81, 222, 2696, -1, 28, 1, 31 },
  { 0x1, 0x1, 222, 2697, -1, 35, 1, 31 },
  { 0x103, 0x103, 222, 2698, -1, 27, 1, 31 },
  { 0x101, 0x101, 222, 2699, -1, 27, 1, 31 },
  { 0x1, 0x1, 222, 2700, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2701, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2702, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2703, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2704, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2705, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2706, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2707, -1, 35, 1, 26 },
  { 0x1, 0x1, 222, 2708, -1, 35, 1, 26 },
  { 0x1, 0x1, 222, 2709, -1, 35, 1, 26 },
  { 0x1, 0x1, 222, 2710, -1, 35, 1, 26 },
  { 0x1, 0x1, 222, 2711, -1, 35, 1, 37 },
  { 0x1, 0x1, 222, 2712, -1, 35, 1, 65 },
  { 0x1, 0x1, 222, 2713, -1, 35, 1, 31 },
  { 0x1, 0x1, 222, 2714, -1, 35, 1, 31 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 65 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2209, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 47 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 43 },
  { 0xc00001, 0xc00001, 223, -1, -1, 12, 1, 62 },
  { 0x3, 0x3, 223, 2930, -1, 34, 1, 57 },
  { 0x1c00001, 0x1c00001, 223, -1, -1, 12, 1, 62 },
  { 0x7, 0x7, 223, 2931, -1, 34, 1, 57 },
  { 0xe00001, 0xe00001, 223, -1, -1, 12, 1, 62 },
  { 0x7, 0x7, 223, 2932, -1, 33, 1, 57 },
  { 0x1e00001, 0x1e00001, 223, -1, -1, 12, 1, 52 },
  { 0xf, 0xf, 223, 2933, -1, 33, 1, 52 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2934, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2935, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2936, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0x3, 0x3, 223, 2937, -1, 34, 1, 52 },
  { 0xc00001, 0xc00001, 223, -1, -1, 12, 1, 62 },
  { 0x3, 0x3, 223, 2942, -1, 34, 1, 57 },
  { 0xe00001, 0x1e00001, 223, -1, -1, 12, 1, 62 },
  { 0x7, 0xf, 223, 2943, -1, 33, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2944, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2945, -1, 34, 1, 57 },
  { 0xc00001, 0xc00001, 223, -1, -1, 12, 1, 62 },
  { 0x3, 0x3, 223, 2948, -1, 34, 1, 57 },
  { 0x1c00001, 0x1c00001, 223, -1, -1, 12, 1, 62 },
  { 0x7, 0x7, 223, 2949, -1, 34, 1, 57 },
  { 0xe00001, 0xe00001, 223, -1, -1, 12, 1, 62 },
  { 0x7, 0x7, 223, 2950, -1, 33, 1, 57 },
  { 0x1e00001, 0x1e00001, 223, -1, -1, 12, 1, 52 },
  { 0xf, 0xf, 223, 2951, -1, 33, 1, 52 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2952, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2953, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2954, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0x3, 0x3, 223, 2955, -1, 34, 1, 52 },
  { 0xc00001, 0xc00001, 223, -1, -1, 12, 1, 62 },
  { 0x3, 0x3, 223, 2960, -1, 34, 1, 57 },
  { 0xe00001, 0x1e00001, 223, -1, -1, 12, 1, 62 },
  { 0x7, 0xf, 223, 2961, -1, 33, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2962, -1, 34, 1, 57 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 62 },
  { 0x3, 0x3, 223, 2963, -1, 34, 1, 57 },
  { 0xc1, 0xc1, 223, -1, -1, 28, 1, 32 },
  { 0x3, 0x3, 223, 2828, -1, 34, 1, 32 },
  { 0x183, 0x183, 223, -1, -1, 27, 1, 32 },
  { 0x181, 0x181, 223, 2829, -1, 27, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 65 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2210, -1, 34, 1, 32 },
  { 0x7, 0x7, 223, -1, -1, 34, 1, 65 },
  { 0xb, 0xb, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2211, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 65 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2214, -1, 34, 1, 32 },
  { 0x7, 0x7, 223, -1, -1, 34, 1, 65 },
  { 0xb, 0xb, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2215, -1, 34, 1, 32 },
  { 0x7, 0x7, 223, -1, -1, 34, 1, 65 },
  { 0xb, 0xb, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2217, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 65 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2219, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 65 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2220, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0x181, 0x181, 223, -1, -1, 27, 1, 52 },
  { 0xc1, 0xc1, 223, -1, -1, 28, 1, 52 },
  { 0x183, 0x183, 223, -1, -1, 27, 1, 52 },
  { 0x61, 0x61, 223, -1, -1, 29, 1, 52 },
  { 0x185, 0x185, 223, -1, -1, 27, 1, 52 },
  { 0xc3, 0xc3, 223, -1, -1, 28, 1, 52 },
  { 0x187, 0x187, 223, -1, -1, 27, 1, 52 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 52 },
  { 0xc1, 0xc1, 223, -1, -1, 28, 1, 32 },
  { 0x3, 0x3, 223, 2832, -1, 34, 1, 32 },
  { 0x183, 0x183, 223, -1, -1, 27, 1, 32 },
  { 0x181, 0x181, 223, 2833, -1, 27, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 27 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 27 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 27 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 27 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 38 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 65 },
  { 0x3, 0x3, 223, -1, -1, 34, 1, 32 },
  { 0x3, 0x3, 223, 2222, -1, 34, 1, 32 },
  { 0x3, 0x3, 224, 522, 1433, 32, 1, 128 },
  { 0x3, 0x3, 224, 523, 1442, 32, 1, 128 },
  { 0x3, 0x3, 224, 524, 1451, 32, 1, 128 },
  { 0x3, 0x3, 224, 525, 1464, 32, 1, 128 },
  { 0x3, 0x3, 224, 526, 1473, 32, 1, 128 },
  { 0x3, 0x3, 224, 527, 1482, 32, 1, 128 },
  { 0x3, 0x3, 224, 528, 1491, 32, 1, 128 },
  { 0x3, 0x3, 224, 529, 1500, 32, 1, 128 },
  { 0x3, 0x3, 224, 530, 1509, 32, 1, 128 },
  { 0x3, 0x3, 224, 531, 1518, 32, 1, 128 },
  { 0x3, 0x3, 224, 532, 1528, 32, 1, 128 },
  { 0x3, 0x3, 224, 533, 1538, 32, 1, 128 },
  { 0x3, 0x3, 224, 546, 1551, 32, 1, 143 },
  { 0x3, 0x3, 224, 547, 1557, 32, 1, 148 },
  { 0x3, 0x3, 224, 548, 1563, 32, 1, 148 },
  { 0x3, 0x3, 224, 549, 1569, 32, 1, 143 },
  { 0x3, 0x3, 224, 550, 1575, 32, 1, 148 },
  { 0x3, 0x3, 224, 551, 1581, 32, 1, 148 },
  { 0x3, 0x3, 224, 552, 1587, 32, 1, 143 },
  { 0x3, 0x3, 224, 553, 1593, 32, 1, 148 },
  { 0x3, 0x3, 224, 554, 1599, 32, 1, 148 },
  { 0x3, 0x3, 224, 555, 1605, 32, 1, 143 },
  { 0x3, 0x3, 224, 556, 1611, 32, 1, 148 },
  { 0x3, 0x3, 224, 557, 1617, 32, 1, 143 },
  { 0x3, 0x3, 224, 558, 1623, 32, 1, 148 },
  { 0x3, 0x3, 224, 559, 1629, 32, 1, 143 },
  { 0x3, 0x3, 224, 560, 1635, 32, 1, 148 },
  { 0x3, 0x3, 224, 561, 1641, 32, 1, 143 },
  { 0x3, 0x3, 224, 562, 1647, 32, 1, 148 },
  { 0x3, 0x3, 224, 563, 1653, 32, 1, 148 },
  { 0x1, 0x1, 225, -1, -1, 28, 1, 33 },
  { 0x1, 0x1, 225, -1, -1, 28, 1, 33 },
  { 0x0, 0x0, 232, 940, -1, 0, 1, 137 },
  { 0x0, 0x0, 232, 941, -1, 0, 1, 155 },
  { 0x1, 0x1, 233, -1, 1964, 33, 1, 133 },
  { 0x1, 0x1, 233, -1, 1967, 33, 1, 139 },
  { 0x0, 0x0, 233, -1, 1969, 0, 1, 150 },
  { 0x0, 0x0, 233, -1, 1970, 0, 1, 156 },
  { 0x0, 0x0, 234, 865, 953, 0, 0, -1 },
  { 0x0, 0x0, 234, 866, 961, 0, 0, -1 },
  { 0x0, 0x0, 234, 867, 957, 0, 0, -1 },
  { 0x1, 0x1, 234, 868, 602, 33, 1, 6 },
  { 0x8000001, 0x8000001, 234, 869, 610, 6, 1, 7 },
  { 0x1, 0x1, 234, 870, 606, 33, 1, 6 },
  { 0x0, 0x0, 234, 871, 965, 0, 0, -1 },
  { 0x1, 0x1, 234, 872, 622, 33, 1, 8 },
  { 0x0, 0x0, 234, 873, 969, 0, 0, -1 },
  { 0x1, 0x1, 234, 874, 634, 33, 1, 15 },
  { 0x0, 0x0, 234, 875, 974, 0, 0, -1 },
  { 0x0, 0x0, 234, 876, 978, 0, 0, -1 },
  { 0x1, 0x1, 234, 877, 657, 33, 1, 17 },
  { 0x1, 0x1, 234, 878, 661, 33, 1, 17 },
  { 0x0, 0x0, 234, 879, 982, 0, 0, -1 },
  { 0x0, 0x0, 234, 880, 986, 0, 0, -1 },
  { 0x1, 0x1, 234, 881, 681, 33, 1, 18 },
  { 0x8000001, 0x8000001, 234, 882, 685, 6, 1, 18 },
  { 0x0, 0x0, 234, 883, 990, 0, 0, -1 },
  { 0x1, 0x1, 234, 884, 697, 33, 1, 19 },
  { 0x0, 0x0, 234, 885, 994, 0, 0, -1 },
  { 0x0, 0x0, 234, 886, 998, 0, 0, -1 },
  { 0x1, 0x1, 234, 887, 717, 33, 1, 20 },
  { 0x8000001, 0x8000001, 234, 888, 721, 6, 1, 20 },
  { 0x0, 0x0, 234, 889, 1002, 0, 0, -1 },
  { 0x1, 0x1, 234, 890, 733, 33, 1, 21 },
  { 0x0, 0x0, 234, 891, 1007, 0, 0, -1 },
  { 0x0, 0x0, 234, 892, 1011, 0, 0, -1 },
  { 0x1, 0x1, 234, 893, 756, 33, 1, 17 },
  { 0x1, 0x1, 234, 894, 760, 33, 1, 17 },
  { 0x0, 0x0, 234, 895, 1015, 0, 0, -1 },
  { 0x1, 0x1, 234, 896, 772, 33, 1, 21 },
  { 0x0, 0x0, 235, 2753, 952, 0, 0, -1 },
  { 0x0, 0x0, 235, 2754, 960, 0, 0, -1 },
  { 0x0, 0x0, 235, 2755, 956, 0, 0, -1 },
  { 0x0, 0x0, 235, 2756, 601, 0, 1, 6 },
  { 0x1, 0x1, 235, 2757, 609, 6, 1, 7 },
  { 0x0, 0x0, 235, 2758, 605, 0, 1, 6 },
  { 0x0, 0x0, 235, 2759, 964, 0, 0, -1 },
  { 0x0, 0x0, 235, 2760, 621, 0, 1, 8 },
  { 0x0, 0x0, 235, 2761, 968, 0, 0, -1 },
  { 0x0, 0x0, 235, 2762, 633, 0, 1, 15 },
  { 0x0, 0x0, 235, 2763, 973, 0, 0, -1 },
  { 0x0, 0x0, 235, 2764, 977, 0, 0, -1 },
  { 0x0, 0x0, 235, 2765, 656, 0, 1, 17 },
  { 0x0, 0x0, 235, 2766, 660, 0, 1, 17 },
  { 0x0, 0x0, 235, 2767, 981, 0, 0, -1 },
  { 0x0, 0x0, 235, 2768, 985, 0, 0, -1 },
  { 0x0, 0x0, 235, 2769, 680, 0, 1, 18 },
  { 0x1, 0x1, 235, 2770, 684, 6, 1, 18 },
  { 0x0, 0x0, 235, 2771, 989, 0, 0, -1 },
  { 0x0, 0x0, 235, 2772, 696, 0, 1, 19 },
  { 0x0, 0x0, 235, 2773, 993, 0, 0, -1 },
  { 0x0, 0x0, 235, 2774, 997, 0, 0, -1 },
  { 0x0, 0x0, 235, 2775, 716, 0, 1, 20 },
  { 0x1, 0x1, 235, 2776, 720, 6, 1, 20 },
  { 0x0, 0x0, 235, 2777, 1001, 0, 0, -1 },
  { 0x0, 0x0, 235, 2778, 732, 0, 1, 21 },
  { 0x0, 0x0, 235, 2779, 1006, 0, 0, -1 },
  { 0x0, 0x0, 235, 2780, 1010, 0, 0, -1 },
  { 0x0, 0x0, 235, 2781, 755, 0, 1, 17 },
  { 0x0, 0x0, 235, 2782, 759, 0, 1, 17 },
  { 0x0, 0x0, 235, 2783, 1014, 0, 0, -1 },
  { 0x0, 0x0, 235, 2784, 771, 0, 1, 21 },
  { 0x1, 0x1, 235, 897, 1137, 27, 1, 16 },
  { 0x0, 0x0, 235, 898, 1135, 0, 1, 16 },
  { 0x0, 0x0, 235, 1202, 1139, 0, 1, 22 },
  { 0x0, 0x1, 235, 1147, 1145, 20, 1, 67 },
  { 0x0, 0x0, 235, 111, 1143, 0, 1, 67 },
  { 0x1, 0x1, 238, -1, -1, 29, 1, 0 },
  { 0x0, 0x0, 238, -1, -1, 0, 1, 0 },
  { 0x1, 0x1, 238, 2984, -1, 27, 1, 0 },
  { 0x1, 0x1, 238, 2985, -1, 27, 1, 0 },
  { 0x1, 0x1, 238, 2986, -1, 27, 1, 0 },
  { 0x1, 0x1, 238, 2987, -1, 27, 1, 0 },
  { 0x0, 0x0, 260, -1, 2310, 0, 0, -1 },
  { 0x0, 0x0, 260, -1, 2312, 0, 0, -1 },
  { 0x1, 0x1, 260, -1, -1, 28, 1, 29 },
  { 0x1, 0x1, 260, -1, -1, 28, 1, 29 },
  { 0x0, 0x0, 260, -1, 2351, 0, 0, -1 },
  { 0x0, 0x0, 260, -1, 2353, 0, 0, -1 },
  { 0x1, 0x1, 260, -1, -1, 28, 1, 29 },
  { 0x1, 0x1, 260, -1, -1, 28, 1, 29 },
  { 0x0, 0x0, 262, 23, -1, 0, 1, 0 },
  { 0x0, 0x0, 262, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 262, -1, -1, 0, 1, 0 },
  { 0x0, 0x1, 262, -1, -1, 29, 1, 0 },
  { 0x0, 0x1, 262, -1, -1, 29, 1, 0 },
  { 0x0, 0x1, 262, -1, -1, 29, 1, 0 },
  { 0x0, 0x1, 262, -1, -1, 29, 1, 0 },
  { 0x0, 0x1, 262, -1, -1, 29, 1, 0 },
  { 0x0, 0x0, 262, 180, -1, 0, 1, 0 },
  { 0x0, 0x1, 262, -1, -1, 29, 1, 0 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 299, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 321, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 347, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 369, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 64 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 64 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 64 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 64 },
  { 0x0, 0x0, 263, -1, 2262, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2264, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2266, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2268, 0, 0, -1 },
  { 0x1, 0x1, 263, -1, 2270, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2272, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2274, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2276, 12, 1, 49 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 49 },
  { 0x0, 0x0, 263, -1, 2278, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2280, 0, 0, -1 },
  { 0x1, 0x1, 263, -1, 2282, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2284, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x0, 0x0, 263, -1, 2286, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2288, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2290, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2292, 0, 0, -1 },
  { 0x1, 0x1, 263, -1, 2294, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2296, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2298, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2300, 12, 1, 49 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 49 },
  { 0x0, 0x0, 263, -1, 2302, 0, 0, -1 },
  { 0x0, 0x0, 263, -1, 2304, 0, 0, -1 },
  { 0x1, 0x1, 263, -1, 2306, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, 2308, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, -1, -1, 12, 1, 59 },
  { 0x1, 0x1, 263, 391, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 393, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 507, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 509, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 399, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 401, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 515, -1, 12, 1, 2 },
  { 0x1, 0x1, 263, 517, -1, 12, 1, 2 },
  { 0x0, 0x0, 264, -1, 2269, 0, 0, -1 },
  { 0x9, 0x9, 264, -1, 2277, 33, 1, 49 },
  { 0x9, 0x9, 264, -1, 2941, 33, 1, 49 },
  { 0x0, 0x0, 264, 1381, 2342, 0, 0, -1 },
  { 0x3, 0x3, 264, 1382, -1, 27, 1, 49 },
  { 0x0, 0x0, 268, 2822, -1, 0, 1, 0 },
  { 0x3, 0x3, 269, -1, -1, 27, 1, 0 },
  { 0x3, 0x3, 269, -1, -1, 27, 1, 0 },
  { 0x3, 0x3, 269, -1, -1, 27, 1, 0 },
  { 0x3, 0x3, 269, -1, -1, 27, 1, 0 },
  { 0x1, 0x1, 270, 2980, -1, 28, 1, 0 },
  { 0x1, 0x1, 270, 2981, -1, 28, 1, 0 },
  { 0x1, 0x1, 270, 2982, -1, 28, 1, 0 },
  { 0x1, 0x1, 270, 2983, -1, 28, 1, 0 },
  { 0x1, 0x1, 271, -1, -1, 27, 1, 93 },
  { 0x1, 0x1, 271, -1, -1, 27, 1, 93 },
  { 0x0, 0x0, 271, -1, 950, 0, 0, -1 },
  { 0x0, 0x0, 272, 2993, 2799, 0, 0, -1 },
  { 0x0, 0x0, 272, 2994, 2801, 0, 0, -1 },
  { 0x0, 0x0, 273, -1, 2800, 0, 0, -1 },
  { 0x0, 0x0, 273, -1, 2802, 0, 0, -1 },
  { 0x0, 0x0, 274, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 274, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 274, -1, -1, 0, 1, 40 },
  { 0x0, 0x0, 279, -1, -1, 0, 1, 33 },
  { 0x0, 0x0, 283, -1, 2316, 0, 1, 29 },
  { 0x0, 0x0, 284, -1, -1, 0, 1, 0 },
  { 0x0, 0x0, 284, -1, -1, 0, 1, 71 },
  { 0x0, 0x0, 284, 1983, 2966, 0, 1, 1 },
  { 0x0, 0x0, 284, 1984, 2967, 0, 1, 1 },
  { 0x0, 0x0, 284, -1, 508, 0, 0, -1 },
  { 0x0, 0x0, 284, -1, 510, 0, 0, -1 },
  { 0x0, 0x0, 284, 1987, 2970, 0, 1, 1 },
  { 0x0, 0x0, 284, 1988, 2971, 0, 1, 1 },
  { 0x0, 0x0, 284, -1, 516, 0, 0, -1 },
  { 0x0, 0x0, 284, -1, 518, 0, 0, -1 },
};

static const struct ia64_main_table
main_table[] = {
  { 5, 1, 1, 0x0000010000000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 0, },
  { 5, 1, 1, 0x0000010008000000ull, 0x000001eff8000000ull, { 24, 25, 26, 4, 0 }, 0x0, 1, },
  { 5, 7, 1, 0x0000000000000000ull, 0x0000000000000000ull, { 24, 66, 27, 0, 0 }, 0x0, 2, },
  { 5, 7, 1, 0x0000000000000000ull, 0x0000000000000000ull, { 24, 63, 26, 0, 0 }, 0x0, 3, },
  { 6, 1, 1, 0x0000012000000000ull, 0x000001e000000000ull, { 24, 66, 27, 0, 0 }, 0x0, 4, },
  { 7, 1, 1, 0x0000010040000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 5, },
  { 7, 1, 1, 0x0000010c00000000ull, 0x000001ee00000000ull, { 24, 63, 26, 0, 0 }, 0x0, 6, },
  { 8, 1, 1, 0x0000010800000000ull, 0x000001ee00000000ull, { 24, 63, 26, 0, 0 }, 0x0, 7, },
  { 9, 3, 1, 0x0000002c00000000ull, 0x000001ee00000000ull, { 24, 3, 52, 53, 54 }, 0x221, 8, },
  { 9, 3, 1, 0x0000002c00000000ull, 0x000001ee00000000ull, { 24, 52, 53, 54, 0 }, 0x261, 9, },
  { 10, 1, 1, 0x0000010060000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 10, },
  { 10, 1, 1, 0x0000010160000000ull, 0x000001eff8000000ull, { 24, 55, 26, 0, 0 }, 0x0, 11, },
  { 11, 1, 1, 0x0000010068000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 12, },
  { 11, 1, 1, 0x0000010168000000ull, 0x000001eff8000000ull, { 24, 55, 26, 0, 0 }, 0x0, 13, },
  { 14, 4, 0, 0x0000000100000000ull, 0x000001eff80011ffull, { 16, 0, 0, 0, 0 }, 0x40, 951, },
  { 14, 4, 0, 0x0000000100000000ull, 0x000001eff80011c0ull, { 16, 0, 0, 0, 0 }, 0x0, 807, },
  { 14, 4, 0, 0x0000000100000000ull, 0x000001eff80011c0ull, { 16, 0, 0, 0, 0 }, 0x40, 808, },
  { 14, 4, 0, 0x0000000108000100ull, 0x000001eff80011c0ull, { 16, 0, 0, 0, 0 }, 0x200, 2200, },
  { 14, 4, 0, 0x0000000108000100ull, 0x000001eff80011c0ull, { 16, 0, 0, 0, 0 }, 0x240, 2201, },
  { 14, 4, 1, 0x0000002100000000ull, 0x000001ef00001000ull, { 15, 16, 0, 0, 0 }, 0x0, 564, },
  { 14, 4, 1, 0x0000002100000000ull, 0x000001ef00001000ull, { 15, 16, 0, 0, 0 }, 0x40, 565, },
  { 14, 4, 0, 0x0000008000000000ull, 0x000001ee000011ffull, { 81, 0, 0, 0, 0 }, 0x40, 972, },
  { 14, 4, 0, 0x0000008000000000ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x0, 809, },
  { 14, 4, 0, 0x0000008000000000ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x40, 810, },
  { 14, 4, 0, 0x0000008000000080ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x210, 2991, },
  { 14, 4, 0, 0x0000008000000080ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x250, 2992, },
  { 14, 4, 0, 0x0000008000000140ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x30, 572, },
  { 14, 4, 0, 0x0000008000000140ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x70, 573, },
  { 14, 4, 0, 0x0000008000000180ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x230, 570, },
  { 14, 4, 0, 0x0000008000000180ull, 0x000001ee000011c0ull, { 81, 0, 0, 0, 0 }, 0x270, 571, },
  { 14, 4, 1, 0x000000a000000000ull, 0x000001ee00001000ull, { 15, 81, 0, 0, 0 }, 0x0, 566, },
  { 14, 4, 1, 0x000000a000000000ull, 0x000001ee00001000ull, { 15, 81, 0, 0, 0 }, 0x40, 567, },
  { 15, 4, 0, 0x0000000000000000ull, 0x000001e1f8000000ull, { 65, 0, 0, 0, 0 }, 0x0, 519, },
  { 15, 5, 0, 0x0000000000000000ull, 0x000001e3f8000000ull, { 65, 0, 0, 0, 0 }, 0x0, 942, },
  { 15, 2, 0, 0x0000000000000000ull, 0x000001eff8000000ull, { 65, 0, 0, 0, 0 }, 0x2, 1120, },
  { 15, 3, 0, 0x0000000000000000ull, 0x000001eff8000000ull, { 65, 0, 0, 0, 0 }, 0x0, 1245, },
  { 15, 6, 0, 0x0000000000000000ull, 0x000001eff8000000ull, { 69, 0, 0, 0, 0 }, 0x0, 2995, },
  { 15, 7, 0, 0x0000000000000000ull, 0x0000000000000000ull, { 65, 0, 0, 0, 0 }, 0x0, 16, },
  { 16, 6, 0, 0x0000018000000000ull, 0x000001ee000011ffull, { 82, 0, 0, 0, 0 }, 0x40, 1005, },
  { 16, 6, 0, 0x0000018000000000ull, 0x000001ee000011c0ull, { 82, 0, 0, 0, 0 }, 0x0, 811, },
  { 16, 6, 0, 0x0000018000000000ull, 0x000001ee000011c0ull, { 82, 0, 0, 0, 0 }, 0x40, 812, },
  { 16, 6, 1, 0x000001a000000000ull, 0x000001ee00001000ull, { 15, 82, 0, 0, 0 }, 0x0, 568, },
  { 16, 6, 1, 0x000001a000000000ull, 0x000001ee00001000ull, { 15, 82, 0, 0, 0 }, 0x40, 569, },
  { 17, 4, 0, 0x0000004080000000ull, 0x000001e9f8000018ull, { 16, 77, 0, 0, 0 }, 0x20, 2818, },
  { 17, 4, 0, 0x000000e000000000ull, 0x000001e800000018ull, { 81, 77, 0, 0, 0 }, 0x20, 2819, },
  { 18, 4, 0, 0x0000000060000000ull, 0x000001e1f8000000ull, { 0, 0, 0, 0, 0 }, 0x2c, 222, },
  { 22, 2, 0, 0x0000000200000000ull, 0x000001ee00000000ull, { 25, 80, 0, 0, 0 }, 0x0, 2205, },
  { 22, 3, 0, 0x0000000800000000ull, 0x000001ee00000000ull, { 24, 81, 0, 0, 0 }, 0x0, 224, },
  { 22, 3, 0, 0x0000000c00000000ull, 0x000001ee00000000ull, { 18, 81, 0, 0, 0 }, 0x0, 225, },
  { 22, 3, 0, 0x0000002200000000ull, 0x000001ee00000000ull, { 25, 80, 0, 0, 0 }, 0x0, 2206, },
  { 22, 3, 0, 0x0000002600000000ull, 0x000001ee00000000ull, { 19, 80, 0, 0, 0 }, 0x0, 2207, },
  { 22, 7, 0, 0x0000000000000000ull, 0x0000000000000000ull, { 25, 80, 0, 0, 0 }, 0x0, 2208, },
  { 25, 4, 0, 0x0000000020000000ull, 0x000001e1f8000000ull, { 0, 0, 0, 0, 0 }, 0x224, 18, },
  { 26, 1, 2, 0x0000018000000000ull, 0x000001fe00001000ull, { 22, 23, 25, 26, 0 }, 0x0, 1204, },
  { 26, 1, 1, 0x0000018000000000ull, 0x000001fe00001000ull, { 22, 25, 26, 0, 0 }, 0x40, 1205, },
  { 26, 1, 2, 0x0000018000000000ull, 0x000001fe00001000ull, { 23, 22, 26, 25, 0 }, 0x0, 1163, },
  { 26, 1, 1, 0x0000018000000000ull, 0x000001fe00001000ull, { 23, 26, 25, 0, 0 }, 0x40, 1164, },
  { 26, 1, 2, 0x0000018000000000ull, 0x000001fe00001000ull, { 22, 23, 26, 25, 0 }, 0x0, 1072, },
  { 26, 1, 1, 0x0000018000000000ull, 0x000001fe00001000ull, { 22, 26, 25, 0, 0 }, 0x40, 1073, },
  { 26, 1, 2, 0x0000018000000000ull, 0x000001fe00001000ull, { 23, 22, 25, 26, 0 }, 0x0, 1034, },
  { 26, 1, 1, 0x0000018000000000ull, 0x000001fe00001000ull, { 23, 25, 26, 0, 0 }, 0x40, 1035, },
  { 26, 1, 2, 0x0000018200000000ull, 0x000001fe00001000ull, { 22, 23, 25, 26, 0 }, 0x40, 1358, },
  { 26, 1, 2, 0x0000019000000000ull, 0x000001fe00001000ull, { 22, 23, 7, 26, 0 }, 0x0, 1074, },
  { 26, 1, 1, 0x0000019000000000ull, 0x000001fe00001000ull, { 22, 7, 26, 0, 0 }, 0x40, 1075, },
  { 26, 1, 2, 0x0000019000000000ull, 0x000001fe00001000ull, { 22, 23, 26, 7, 0 }, 0x40, 1208, },
  { 26, 1, 1, 0x0000019000000000ull, 0x000001fe00001000ull, { 22, 26, 7, 0, 0 }, 0x40, 1209, },
  { 26, 1, 2, 0x0000019000000000ull, 0x000001fe00001000ull, { 22, 23, 7, 26, 0 }, 0x40, 1169, },
  { 26, 1, 2, 0x0000018800000000ull, 0x000001ee00001000ull, { 22, 23, 55, 26, 0 }, 0x0, 1211, },
  { 26, 1, 1, 0x0000018800000000ull, 0x000001ee00001000ull, { 22, 55, 26, 0, 0 }, 0x40, 1212, },
  { 26, 1, 2, 0x0000018800000000ull, 0x000001ee00001000ull, { 22, 23, 57, 26, 0 }, 0x0, 1170, },
  { 26, 1, 1, 0x0000018800000000ull, 0x000001ee00001000ull, { 22, 57, 26, 0, 0 }, 0x40, 1171, },
  { 26, 1, 2, 0x0000018800000000ull, 0x000001ee00001000ull, { 23, 22, 57, 26, 0 }, 0x0, 1079, },
  { 26, 1, 1, 0x0000018800000000ull, 0x000001ee00001000ull, { 23, 57, 26, 0, 0 }, 0x40, 1080, },
  { 26, 1, 2, 0x0000018800000000ull, 0x000001ee00001000ull, { 23, 22, 55, 26, 0 }, 0x0, 1041, },
  { 26, 1, 1, 0x0000018800000000ull, 0x000001ee00001000ull, { 23, 55, 26, 0, 0 }, 0x40, 1042, },
  { 26, 1, 2, 0x0000018a00000000ull, 0x000001ee00001000ull, { 22, 23, 55, 26, 0 }, 0x40, 1363, },
  { 26, 1, 2, 0x000001a800000000ull, 0x000001ee00001000ull, { 22, 23, 59, 26, 0 }, 0x0, 1196, },
  { 26, 1, 1, 0x000001a800000000ull, 0x000001ee00001000ull, { 22, 59, 26, 0, 0 }, 0x40, 1197, },
  { 26, 1, 2, 0x000001a800000000ull, 0x000001ee00001000ull, { 23, 22, 59, 26, 0 }, 0x0, 1107, },
  { 26, 1, 1, 0x000001a800000000ull, 0x000001ee00001000ull, { 23, 59, 26, 0, 0 }, 0x40, 1108, },
  { 26, 1, 2, 0x000001c200000000ull, 0x000001fe00001000ull, { 23, 22, 25, 26, 0 }, 0x40, 1364, },
  { 26, 1, 2, 0x000001d000000000ull, 0x000001fe00001000ull, { 23, 22, 7, 26, 0 }, 0x40, 1172, },
  { 26, 1, 1, 0x000001d000000000ull, 0x000001fe00001000ull, { 23, 7, 26, 0, 0 }, 0x40, 1173, },
  { 26, 1, 2, 0x000001d000000000ull, 0x000001fe00001000ull, { 23, 22, 26, 7, 0 }, 0x40, 1045, },
  { 26, 1, 1, 0x000001d000000000ull, 0x000001fe00001000ull, { 23, 26, 7, 0, 0 }, 0x40, 1046, },
  { 26, 1, 2, 0x000001ca00000000ull, 0x000001ee00001000ull, { 23, 22, 55, 26, 0 }, 0x40, 1365, },
  { 27, 1, 2, 0x0000018400000000ull, 0x000001fe00001000ull, { 22, 23, 25, 26, 0 }, 0x0, 1217, },
  { 27, 1, 1, 0x0000018400000000ull, 0x000001fe00001000ull, { 22, 25, 26, 0, 0 }, 0x40, 1218, },
  { 27, 1, 2, 0x0000018400000000ull, 0x000001fe00001000ull, { 23, 22, 26, 25, 0 }, 0x0, 1176, },
  { 27, 1, 1, 0x0000018400000000ull, 0x000001fe00001000ull, { 23, 26, 25, 0, 0 }, 0x40, 1177, },
  { 27, 1, 2, 0x0000018400000000ull, 0x000001fe00001000ull, { 22, 23, 26, 25, 0 }, 0x0, 1085, },
  { 27, 1, 1, 0x0000018400000000ull, 0x000001fe00001000ull, { 22, 26, 25, 0, 0 }, 0x40, 1086, },
  { 27, 1, 2, 0x0000018400000000ull, 0x000001fe00001000ull, { 23, 22, 25, 26, 0 }, 0x0, 1047, },
  { 27, 1, 1, 0x0000018400000000ull, 0x000001fe00001000ull, { 23, 25, 26, 0, 0 }, 0x40, 1048, },
  { 27, 1, 2, 0x0000018600000000ull, 0x000001fe00001000ull, { 22, 23, 25, 26, 0 }, 0x40, 1370, },
  { 27, 1, 2, 0x0000019400000000ull, 0x000001fe00001000ull, { 22, 23, 7, 26, 0 }, 0x0, 1087, },
  { 27, 1, 1, 0x0000019400000000ull, 0x000001fe00001000ull, { 22, 7, 26, 0, 0 }, 0x40, 1088, },
  { 27, 1, 2, 0x0000019400000000ull, 0x000001fe00001000ull, { 22, 23, 26, 7, 0 }, 0x40, 1221, },
  { 27, 1, 1, 0x0000019400000000ull, 0x000001fe00001000ull, { 22, 26, 7, 0, 0 }, 0x40, 1222, },
  { 27, 1, 2, 0x0000019400000000ull, 0x000001fe00001000ull, { 22, 23, 7, 26, 0 }, 0x40, 1182, },
  { 27, 1, 2, 0x0000018c00000000ull, 0x000001ee00001000ull, { 22, 23, 55, 26, 0 }, 0x0, 1224, },
  { 27, 1, 1, 0x0000018c00000000ull, 0x000001ee00001000ull, { 22, 55, 26, 0, 0 }, 0x40, 1225, },
  { 27, 1, 2, 0x0000018c00000000ull, 0x000001ee00001000ull, { 22, 23, 57, 26, 0 }, 0x0, 1183, },
  { 27, 1, 1, 0x0000018c00000000ull, 0x000001ee00001000ull, { 22, 57, 26, 0, 0 }, 0x40, 1184, },
  { 27, 1, 2, 0x0000018c00000000ull, 0x000001ee00001000ull, { 23, 22, 57, 26, 0 }, 0x0, 1092, },
  { 27, 1, 1, 0x0000018c00000000ull, 0x000001ee00001000ull, { 23, 57, 26, 0, 0 }, 0x40, 1093, },
  { 27, 1, 2, 0x0000018c00000000ull, 0x000001ee00001000ull, { 23, 22, 55, 26, 0 }, 0x0, 1054, },
  { 27, 1, 1, 0x0000018c00000000ull, 0x000001ee00001000ull, { 23, 55, 26, 0, 0 }, 0x40, 1055, },
  { 27, 1, 2, 0x0000018e00000000ull, 0x000001ee00001000ull, { 22, 23, 55, 26, 0 }, 0x40, 1375, },
  { 27, 1, 2, 0x000001ac00000000ull, 0x000001ee00001000ull, { 22, 23, 56, 26, 0 }, 0x0, 1241, },
  { 27, 1, 1, 0x000001ac00000000ull, 0x000001ee00001000ull, { 22, 56, 26, 0, 0 }, 0x40, 1242, },
  { 27, 1, 2, 0x000001ac00000000ull, 0x000001ee00001000ull, { 22, 23, 58, 26, 0 }, 0x0, 1200, },
  { 27, 1, 1, 0x000001ac00000000ull, 0x000001ee00001000ull, { 22, 58, 26, 0, 0 }, 0x40, 1201, },
  { 27, 1, 2, 0x000001ac00000000ull, 0x000001ee00001000ull, { 23, 22, 58, 26, 0 }, 0x0, 1111, },
  { 27, 1, 1, 0x000001ac00000000ull, 0x000001ee00001000ull, { 23, 58, 26, 0, 0 }, 0x40, 1112, },
  { 27, 1, 2, 0x000001ac00000000ull, 0x000001ee00001000ull, { 23, 22, 56, 26, 0 }, 0x0, 1070, },
  { 27, 1, 1, 0x000001ac00000000ull, 0x000001ee00001000ull, { 23, 56, 26, 0, 0 }, 0x40, 1071, },
  { 27, 1, 2, 0x000001c600000000ull, 0x000001fe00001000ull, { 23, 22, 25, 26, 0 }, 0x40, 1376, },
  { 27, 1, 2, 0x000001d400000000ull, 0x000001fe00001000ull, { 23, 22, 7, 26, 0 }, 0x40, 1185, },
  { 27, 1, 1, 0x000001d400000000ull, 0x000001fe00001000ull, { 23, 7, 26, 0, 0 }, 0x40, 1186, },
  { 27, 1, 2, 0x000001d400000000ull, 0x000001fe00001000ull, { 23, 22, 26, 7, 0 }, 0x40, 1058, },
  { 27, 1, 1, 0x000001d400000000ull, 0x000001fe00001000ull, { 23, 26, 7, 0, 0 }, 0x40, 1059, },
  { 27, 1, 2, 0x000001ce00000000ull, 0x000001ee00001000ull, { 23, 22, 55, 26, 0 }, 0x40, 1377, },
  { 28, 3, 1, 0x0000008808000000ull, 0x000001fff8000000ull, { 24, 28, 25, 1, 2 }, 0x0, 257, },
  { 28, 3, 1, 0x0000008808000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x40, 258, },
  { 29, 3, 1, 0x0000008008000000ull, 0x000001fff8000000ull, { 24, 28, 25, 2, 0 }, 0x0, 259, },
  { 29, 3, 1, 0x0000008008000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x40, 260, },
  { 30, 3, 1, 0x0000008048000000ull, 0x000001fff8000000ull, { 24, 28, 25, 2, 0 }, 0x0, 261, },
  { 30, 3, 1, 0x0000008048000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x40, 262, },
  { 31, 3, 1, 0x0000008088000000ull, 0x000001fff8000000ull, { 24, 28, 25, 2, 0 }, 0x0, 263, },
  { 31, 3, 1, 0x0000008088000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x40, 264, },
  { 32, 3, 1, 0x00000080c8000000ull, 0x000001fff8000000ull, { 24, 28, 25, 2, 0 }, 0x0, 265, },
  { 32, 3, 1, 0x00000080c8000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x40, 266, },
  { 34, 4, 0, 0x0000000010000000ull, 0x000001e1f8000000ull, { 0, 0, 0, 0, 0 }, 0x224, 19, },
  { 36, 2, 1, 0x00000000c0000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 1149, },
  { 37, 2, 1, 0x00000000c8000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 1150, },
  { 39, 2, 1, 0x0000008000000000ull, 0x000001e000000000ull, { 24, 25, 26, 47, 72 }, 0x0, 20, },
  { 39, 2, 1, 0x000000a600000000ull, 0x000001ee04000000ull, { 24, 25, 45, 73, 0 }, 0x0, 3000, },
  { 39, 2, 1, 0x000000a604000000ull, 0x000001ee04000000ull, { 24, 55, 45, 73, 0 }, 0x0, 3001, },
  { 39, 2, 1, 0x000000ae00000000ull, 0x000001ee00000000ull, { 24, 48, 26, 46, 73 }, 0x0, 21, },
  { 43, 4, 0, 0x0000000080000000ull, 0x000001e1f8000000ull, { 0, 0, 0, 0, 0 }, 0x20, 22, },
  { 48, 2, 1, 0x000000a400000000ull, 0x000001ee00002000ull, { 24, 26, 76, 73, 0 }, 0x0, 2836, },
  { 50, 5, 1, 0x0000000080000000ull, 0x000001e3f80fe000ull, { 18, 20, 0, 0, 0 }, 0x40, 24, },
  { 51, 5, 1, 0x0000010008000000ull, 0x000001fff8000000ull, { 18, 20, 19, 0, 0 }, 0x40, 2257, },
  { 52, 5, 1, 0x00000000b8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2258, },
  { 52, 5, 1, 0x00000000b8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 26, },
  { 53, 5, 1, 0x00000000b0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2259, },
  { 53, 5, 1, 0x00000000b0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 27, },
  { 54, 5, 1, 0x0000000160000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 28, },
  { 55, 5, 1, 0x0000000168000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 29, },
  { 57, 3, 0, 0x0000002180000000ull, 0x000001fff8000000ull, { 26, 0, 0, 0, 0 }, 0x0, 30, },
  { 58, 5, 0, 0x0000000040000000ull, 0x000001eff8000000ull, { 79, 0, 0, 0, 0 }, 0x0, 2260, },
  { 58, 5, 0, 0x0000000040000000ull, 0x000001eff8000000ull, { 79, 0, 0, 0, 0 }, 0x40, 31, },
  { 59, 5, 2, 0x000000a000000000ull, 0x000001e000001000ull, { 22, 23, 19, 60, 0 }, 0x0, 1247, },
  { 59, 5, 1, 0x000000a000000000ull, 0x000001e000001000ull, { 22, 19, 60, 0, 0 }, 0x40, 1248, },
  { 59, 5, 2, 0x000000a000000000ull, 0x000001e000001000ull, { 23, 22, 19, 60, 0 }, 0x40, 1402, },
  { 59, 5, 1, 0x000000a000000000ull, 0x000001e000001000ull, { 23, 19, 60, 0, 0 }, 0x40, 1403, },
  { 60, 5, 0, 0x0000000028000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x0, 2261, },
  { 60, 5, 0, 0x0000000028000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x40, 32, },
  { 61, 5, 2, 0x0000008000000000ull, 0x000001fe00001000ull, { 22, 23, 19, 20, 0 }, 0x0, 925, },
  { 61, 5, 1, 0x0000008000000000ull, 0x000001fe00001000ull, { 22, 19, 20, 0, 0 }, 0x40, 926, },
  { 61, 5, 2, 0x0000008000000000ull, 0x000001fe00001000ull, { 22, 23, 19, 20, 0 }, 0x40, 927, },
  { 61, 5, 2, 0x0000009000000000ull, 0x000001fe00001000ull, { 22, 23, 20, 19, 0 }, 0x0, 1098, },
  { 61, 5, 1, 0x0000009000000000ull, 0x000001fe00001000ull, { 22, 20, 19, 0, 0 }, 0x40, 1099, },
  { 61, 5, 2, 0x0000009000000000ull, 0x000001fe00001000ull, { 22, 23, 20, 19, 0 }, 0x40, 1100, },
  { 61, 5, 2, 0x0000008000000000ull, 0x000001fe00001000ull, { 23, 22, 19, 20, 0 }, 0x0, 1378, },
  { 61, 5, 1, 0x0000008000000000ull, 0x000001fe00001000ull, { 23, 19, 20, 0, 0 }, 0x40, 1379, },
  { 61, 5, 2, 0x0000008000000000ull, 0x000001fe00001000ull, { 23, 22, 19, 20, 0 }, 0x40, 1380, },
  { 61, 5, 2, 0x0000009000000000ull, 0x000001fe00001000ull, { 23, 22, 20, 19, 0 }, 0x0, 1387, },
  { 61, 5, 1, 0x0000009000000000ull, 0x000001fe00001000ull, { 23, 20, 19, 0, 0 }, 0x40, 1388, },
  { 61, 5, 2, 0x0000009000000000ull, 0x000001fe00001000ull, { 23, 22, 20, 19, 0 }, 0x40, 1389, },
  { 62, 5, 1, 0x00000000c0000000ull, 0x000001eff8000000ull, { 18, 19, 0, 0, 0 }, 0x0, 1024, },
  { 62, 5, 1, 0x00000000c0000000ull, 0x000001eff8000000ull, { 18, 19, 0, 0, 0 }, 0x40, 1025, },
  { 62, 5, 1, 0x00000000e0000000ull, 0x000001e3f8000000ull, { 18, 19, 0, 0, 0 }, 0x0, 2998, },
  { 62, 5, 1, 0x0000010008000000ull, 0x000001fff80fe000ull, { 18, 20, 0, 0, 0 }, 0x40, 2999, },
  { 63, 3, 1, 0x0000008488000000ull, 0x000001fff8000000ull, { 24, 28, 71, 0, 0 }, 0x0, 267, },
  { 64, 3, 1, 0x00000084c8000000ull, 0x000001fff8000000ull, { 24, 28, 71, 0, 0 }, 0x0, 268, },
  { 67, 3, 0, 0x0000000060000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x21, 33, },
  { 68, 5, 1, 0x0000010000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 2319, },
  { 68, 5, 1, 0x0000010000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 34, },
  { 69, 5, 1, 0x00000000a8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2320, },
  { 69, 5, 1, 0x00000000a8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 35, },
  { 70, 5, 1, 0x0000000080000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2213, },
  { 71, 5, 1, 0x00000000a0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2321, },
  { 71, 5, 1, 0x00000000a0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 36, },
  { 72, 5, 1, 0x00000001c8000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 1203, },
  { 73, 5, 1, 0x0000010000000000ull, 0x000001fc000fe000ull, { 18, 20, 21, 0, 0 }, 0x40, 2324, },
  { 74, 5, 1, 0x0000014000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 2327, },
  { 74, 5, 1, 0x0000014000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 38, },
  { 75, 5, 1, 0x0000000088000000ull, 0x000001e3f8000000ull, { 18, 20, 0, 0, 0 }, 0xc0, 39, },
  { 76, 5, 1, 0x0000000088000000ull, 0x000001e3f80fe000ull, { 18, 20, 0, 0, 0 }, 0x40, 40, },
  { 77, 5, 1, 0x0000018000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 2330, },
  { 77, 5, 1, 0x0000018000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 41, },
  { 78, 5, 1, 0x0000018000000000ull, 0x000001fc000fe000ull, { 18, 20, 21, 0, 0 }, 0x40, 2333, },
  { 79, 5, 1, 0x0000010008000000ull, 0x000001fff80fe000ull, { 18, 20, 0, 0, 0 }, 0x40, 2336, },
  { 80, 5, 1, 0x0000000170000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 44, },
  { 81, 5, 1, 0x0000002080000000ull, 0x000001e3f80fe000ull, { 18, 20, 0, 0, 0 }, 0x40, 45, },
  { 82, 5, 1, 0x0000000140000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 46, },
  { 83, 5, 1, 0x00000020b8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2337, },
  { 83, 5, 1, 0x00000020b8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 47, },
  { 84, 5, 1, 0x00000020b0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2338, },
  { 84, 5, 1, 0x00000020b0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 48, },
  { 85, 5, 1, 0x0000002180000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 928, },
  { 85, 5, 1, 0x0000002180000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 929, },
  { 85, 5, 1, 0x0000002188000000ull, 0x000001eff8000000ull, { 18, 20, 19, 0, 0 }, 0x40, 1101, },
  { 86, 5, 1, 0x00000020c0000000ull, 0x000001eff8000000ull, { 18, 19, 0, 0, 0 }, 0x0, 1026, },
  { 86, 5, 1, 0x00000020c0000000ull, 0x000001eff8000000ull, { 18, 19, 0, 0, 0 }, 0x40, 1027, },
  { 87, 5, 1, 0x0000013000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 2355, },
  { 87, 5, 1, 0x0000013000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 49, },
  { 88, 5, 1, 0x00000020a8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2356, },
  { 88, 5, 1, 0x00000020a8000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 50, },
  { 89, 5, 1, 0x0000002080000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2221, },
  { 90, 5, 1, 0x00000020a0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2357, },
  { 90, 5, 1, 0x00000020a0000000ull, 0x000001eff8000000ull, { 18, 19, 20, 0, 0 }, 0x40, 51, },
  { 91, 5, 1, 0x0000013000000000ull, 0x000001fc000fe000ull, { 18, 20, 21, 0, 0 }, 0x40, 2358, },
  { 92, 5, 1, 0x0000017000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 2359, },
  { 92, 5, 1, 0x0000017000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 53, },
  { 93, 5, 1, 0x0000002088000000ull, 0x000001e3f8000000ull, { 18, 20, 0, 0, 0 }, 0xc0, 54, },
  { 94, 5, 1, 0x0000002088000000ull, 0x000001e3f80fe000ull, { 18, 20, 0, 0, 0 }, 0x40, 55, },
  { 95, 5, 1, 0x000001b000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 2360, },
  { 95, 5, 1, 0x000001b000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 56, },
  { 96, 5, 1, 0x000001b000000000ull, 0x000001fc000fe000ull, { 18, 20, 21, 0, 0 }, 0x40, 2361, },
  { 97, 5, 2, 0x0000002200000000ull, 0x000001fe00000000ull, { 18, 23, 19, 20, 0 }, 0x0, 2362, },
  { 97, 5, 2, 0x0000002200000000ull, 0x000001fe00000000ull, { 18, 23, 19, 20, 0 }, 0x40, 58, },
  { 98, 5, 2, 0x0000003200000000ull, 0x000001fe00000000ull, { 18, 23, 20, 0, 0 }, 0x0, 2363, },
  { 98, 5, 2, 0x0000003200000000ull, 0x000001fe00000000ull, { 18, 23, 20, 0, 0 }, 0x40, 59, },
  { 99, 5, 2, 0x0000000200000000ull, 0x000001fe00000000ull, { 18, 23, 19, 20, 0 }, 0x0, 2364, },
  { 99, 5, 2, 0x0000000200000000ull, 0x000001fe00000000ull, { 18, 23, 19, 20, 0 }, 0x40, 60, },
  { 100, 5, 2, 0x0000001200000000ull, 0x000001fe00000000ull, { 18, 23, 20, 0, 0 }, 0x0, 2365, },
  { 100, 5, 2, 0x0000001200000000ull, 0x000001fe00000000ull, { 18, 23, 20, 0, 0 }, 0x40, 61, },
  { 101, 5, 1, 0x000001c000000000ull, 0x000001f000000000ull, { 18, 20, 21, 19, 0 }, 0x0, 62, },
  { 102, 5, 0, 0x0000000020000000ull, 0x000001eff8000000ull, { 50, 51, 0, 0, 0 }, 0x0, 2366, },
  { 102, 5, 0, 0x0000000020000000ull, 0x000001eff8000000ull, { 50, 51, 0, 0, 0 }, 0x40, 63, },
  { 103, 5, 1, 0x0000014008000000ull, 0x000001fff8000000ull, { 18, 20, 19, 0, 0 }, 0x40, 2369, },
  { 104, 5, 1, 0x00000001a0000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 65, },
  { 105, 5, 1, 0x00000001e0000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 2168, },
  { 106, 3, 0, 0x0000000100000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x0, 66, },
  { 108, 5, 1, 0x0000000178000000ull, 0x000001e3f8000000ull, { 18, 19, 20, 0, 0 }, 0x0, 67, },
  { 113, 3, 1, 0x0000008708000000ull, 0x000001ffc8000000ull, { 24, 19, 0, 0, 0 }, 0x0, 2747, },
  { 118, 4, 0, 0x0000004008000000ull, 0x000001e1f8000000ull, { 65, 0, 0, 0, 0 }, 0x0, 520, },
  { 118, 5, 0, 0x000000000c000000ull, 0x000001e3fc000000ull, { 65, 0, 0, 0, 0 }, 0x0, 943, },
  { 118, 2, 0, 0x000000000c000000ull, 0x000001effc000000ull, { 65, 0, 0, 0, 0 }, 0x2, 1123, },
  { 118, 3, 0, 0x000000000c000000ull, 0x000001effc000000ull, { 65, 0, 0, 0, 0 }, 0x0, 1249, },
  { 118, 6, 0, 0x000000000c000000ull, 0x000001effc000000ull, { 69, 0, 0, 0, 0 }, 0x0, 2996, },
  { 118, 7, 0, 0x0000000000000000ull, 0x0000000000000000ull, { 65, 0, 0, 0, 0 }, 0x0, 68, },
  { 123, 3, 0, 0x0000000080000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x0, 69, },
  { 123, 3, 0, 0x0000000090000000ull, 0x000001eff8000000ull, { 24, 0, 0, 0, 0 }, 0x0, 902, },
  { 123, 3, 0, 0x0000000098000000ull, 0x000001eff8000000ull, { 18, 0, 0, 0, 0 }, 0x0, 903, },
  { 124, 3, 0, 0x0000002170000000ull, 0x000001eff8000000ull, { 25, 0, 0, 0, 0 }, 0xc, 828, },
  { 125, 3, 1, 0x0000002070000000ull, 0x000001eff8000000ull, { 31, 25, 0, 0, 0 }, 0x8, 829, },
  { 125, 3, 1, 0x0000002078000000ull, 0x000001eff8000000ull, { 32, 25, 0, 0, 0 }, 0x8, 1125, },
  { 127, 3, 1, 0x0000008000000000ull, 0x000001fff8000000ull, { 24, 28, 0, 0, 0 }, 0x0, 70, },
  { 127, 3, 1, 0x0000009000000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x400, 71, },
  { 127, 3, 1, 0x000000a000000000ull, 0x000001eff0000000ull, { 24, 28, 62, 0, 0 }, 0x400, 72, },
  { 128, 3, 2, 0x0000008a08000000ull, 0x000001fff8000000ull, { 24, 1, 28, 0, 0 }, 0x0, 73, },
  { 128, 3, 1, 0x0000008a08000000ull, 0x000001fff8000000ull, { 24, 28, 0, 0, 0 }, 0x40, 74, },
  { 129, 3, 1, 0x0000008040000000ull, 0x000001fff8000000ull, { 24, 28, 0, 0, 0 }, 0x0, 75, },
  { 129, 3, 1, 0x0000009040000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x400, 76, },
  { 129, 3, 1, 0x000000a040000000ull, 0x000001eff0000000ull, { 24, 28, 62, 0, 0 }, 0x400, 77, },
  { 130, 3, 1, 0x0000008080000000ull, 0x000001fff8000000ull, { 24, 28, 0, 0, 0 }, 0x0, 78, },
  { 130, 3, 1, 0x0000009080000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x400, 79, },
  { 130, 3, 1, 0x000000a080000000ull, 0x000001eff0000000ull, { 24, 28, 62, 0, 0 }, 0x400, 80, },
  { 131, 3, 1, 0x00000080c0000000ull, 0x000001fff8000000ull, { 24, 28, 0, 0, 0 }, 0x0, 81, },
  { 131, 3, 1, 0x00000080c0000000ull, 0x000001fff8000000ull, { 24, 28, 83, 0, 0 }, 0x0, 1321, },
  { 131, 3, 1, 0x00000090c0000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x400, 82, },
  { 131, 3, 1, 0x000000a0c0000000ull, 0x000001eff0000000ull, { 24, 28, 62, 0, 0 }, 0x400, 83, },
  { 132, 3, 1, 0x000000c6c0000000ull, 0x000001fff8000000ull, { 18, 28, 0, 0, 0 }, 0x0, 1021, },
  { 132, 3, 1, 0x000000d6c0000000ull, 0x000001fff8000000ull, { 18, 28, 25, 0, 0 }, 0x400, 1022, },
  { 132, 3, 1, 0x000000e6c0000000ull, 0x000001eff0000000ull, { 18, 28, 62, 0, 0 }, 0x400, 1023, },
  { 133, 3, 1, 0x000000c040000000ull, 0x000001fff8000000ull, { 18, 28, 0, 0, 0 }, 0x0, 84, },
  { 133, 3, 1, 0x000000d040000000ull, 0x000001fff8000000ull, { 18, 28, 25, 0, 0 }, 0x400, 85, },
  { 133, 3, 1, 0x000000e040000000ull, 0x000001eff0000000ull, { 18, 28, 62, 0, 0 }, 0x400, 86, },
  { 134, 3, 1, 0x000000c0c0000000ull, 0x000001fff8000000ull, { 18, 28, 0, 0, 0 }, 0x0, 87, },
  { 134, 3, 1, 0x000000d0c0000000ull, 0x000001fff8000000ull, { 18, 28, 25, 0, 0 }, 0x400, 88, },
  { 134, 3, 1, 0x000000e0c0000000ull, 0x000001eff0000000ull, { 18, 28, 62, 0, 0 }, 0x400, 89, },
  { 135, 3, 1, 0x000000c000000000ull, 0x000001fff8000000ull, { 18, 28, 0, 0, 0 }, 0x0, 90, },
  { 135, 3, 1, 0x000000d000000000ull, 0x000001fff8000000ull, { 18, 28, 25, 0, 0 }, 0x400, 91, },
  { 135, 3, 1, 0x000000e000000000ull, 0x000001eff0000000ull, { 18, 28, 62, 0, 0 }, 0x400, 92, },
  { 136, 3, 2, 0x000000c048000000ull, 0x000001fff8000000ull, { 18, 19, 28, 0, 0 }, 0x0, 93, },
  { 136, 3, 2, 0x000000d048000000ull, 0x000001fff8000000ull, { 18, 19, 28, 6, 0 }, 0x400, 94, },
  { 137, 3, 2, 0x000000c0c8000000ull, 0x000001fff8000000ull, { 18, 19, 28, 0, 0 }, 0x0, 95, },
  { 137, 3, 2, 0x000000d0c8000000ull, 0x000001fff8000000ull, { 18, 19, 28, 6, 0 }, 0x400, 96, },
  { 138, 3, 2, 0x000000c088000000ull, 0x000001fff8000000ull, { 18, 19, 28, 0, 0 }, 0x0, 97, },
  { 138, 3, 2, 0x000000d088000000ull, 0x000001fff8000000ull, { 18, 19, 28, 5, 0 }, 0x400, 98, },
  { 139, 3, 1, 0x000000c080000000ull, 0x000001fff8000000ull, { 18, 28, 0, 0, 0 }, 0x0, 99, },
  { 139, 3, 1, 0x000000d080000000ull, 0x000001fff8000000ull, { 18, 28, 25, 0, 0 }, 0x400, 100, },
  { 139, 3, 1, 0x000000e080000000ull, 0x000001eff0000000ull, { 18, 28, 62, 0, 0 }, 0x400, 101, },
  { 142, 3, 0, 0x000000cb00000000ull, 0x000001fff8000000ull, { 28, 0, 0, 0, 0 }, 0x0, 102, },
  { 142, 3, 0, 0x000000db00000000ull, 0x000001fff8000000ull, { 28, 25, 0, 0, 0 }, 0x400, 103, },
  { 142, 3, 0, 0x000000eb00000000ull, 0x000001eff0000000ull, { 28, 62, 0, 0, 0 }, 0x400, 104, },
  { 143, 3, 0, 0x0000000050000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x21, 105, },
  { 151, 3, 0, 0x0000000110000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x0, 106, },
  { 152, 2, 1, 0x000000e880000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2169, },
  { 153, 2, 1, 0x000000ea80000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2170, },
  { 154, 2, 1, 0x000000f880000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2171, },
  { 155, 1, 1, 0x0000010800000000ull, 0x000001fff80fe000ull, { 24, 26, 0, 0, 0 }, 0x0, 107, },
  { 155, 1, 1, 0x0000012000000000ull, 0x000001e000300000ull, { 24, 66, 0, 0, 0 }, 0x40, 108, },
  { 155, 5, 1, 0x0000000080000000ull, 0x000001e3f8000000ull, { 18, 20, 0, 0, 0 }, 0xc0, 109, },
  { 155, 2, 1, 0x0000000e00100000ull, 0x000001ee00f00000ull, { 15, 25, 0, 0, 0 }, 0x40, 110, },
  { 155, 2, 1, 0x0000000e00000000ull, 0x000001ee00f00000ull, { 15, 25, 78, 0, 0 }, 0x0, 2821, },
  { 155, 2, 1, 0x0000000188000000ull, 0x000001eff8000000ull, { 24, 16, 0, 0, 0 }, 0x0, 112, },
  { 155, 2, 1, 0x0000000600000000ull, 0x000001ee00000000ull, { 9, 25, 64, 0, 0 }, 0x0, 113, },
  { 155, 2, 1, 0x00000016ff001fc0ull, 0x000001feff001fc0ull, { 9, 25, 0, 0, 0 }, 0x40, 114, },
  { 155, 2, 1, 0x0000000400000000ull, 0x000001ee00000000ull, { 10, 68, 0, 0, 0 }, 0x0, 115, },
  { 155, 2, 1, 0x0000000180000000ull, 0x000001eff8000000ull, { 24, 8, 0, 0, 0 }, 0x0, 116, },
  { 155, 2, 1, 0x0000000198000000ull, 0x000001eff8000000ull, { 24, 9, 0, 0, 0 }, 0x0, 117, },
  { 155, 2, 1, 0x0000000150000000ull, 0x000001eff8000000ull, { 14, 25, 0, 0, 0 }, 0x0, 1126, },
  { 155, 2, 1, 0x0000000050000000ull, 0x000001eff8000000ull, { 14, 55, 0, 0, 0 }, 0x0, 1127, },
  { 155, 2, 1, 0x0000000190000000ull, 0x000001eff8000000ull, { 24, 14, 0, 0, 0 }, 0x0, 1128, },
  { 155, 3, 1, 0x0000000140000000ull, 0x000001eff8000000ull, { 14, 55, 0, 0, 0 }, 0x0, 1250, },
  { 155, 3, 1, 0x0000002150000000ull, 0x000001eff8000000ull, { 14, 25, 0, 0, 0 }, 0x0, 1251, },
  { 155, 3, 1, 0x0000002110000000ull, 0x000001eff8000000ull, { 24, 14, 0, 0, 0 }, 0x0, 1252, },
  { 155, 3, 1, 0x0000002160000000ull, 0x000001eff8000000ull, { 17, 25, 0, 0, 0 }, 0x8, 118, },
  { 155, 3, 1, 0x0000002120000000ull, 0x000001eff8000000ull, { 24, 17, 0, 0, 0 }, 0x8, 119, },
  { 155, 3, 1, 0x0000002168000000ull, 0x000001eff8000000ull, { 12, 25, 0, 0, 0 }, 0x8, 120, },
  { 155, 3, 1, 0x0000002148000000ull, 0x000001eff8000000ull, { 13, 25, 0, 0, 0 }, 0x0, 121, },
  { 155, 3, 1, 0x0000002128000000ull, 0x000001eff8000000ull, { 24, 11, 0, 0, 0 }, 0x8, 122, },
  { 155, 3, 1, 0x0000002108000000ull, 0x000001eff8000000ull, { 24, 13, 0, 0, 0 }, 0x0, 123, },
  { 155, 3, 1, 0x0000002000000000ull, 0x000001eff8000000ull, { 38, 25, 0, 0, 0 }, 0x8, 124, },
  { 155, 3, 1, 0x0000002008000000ull, 0x000001eff8000000ull, { 30, 25, 0, 0, 0 }, 0x8, 125, },
  { 155, 3, 1, 0x0000002010000000ull, 0x000001eff8000000ull, { 33, 25, 0, 0, 0 }, 0x8, 126, },
  { 155, 3, 1, 0x0000002018000000ull, 0x000001eff8000000ull, { 35, 25, 0, 0, 0 }, 0x8, 127, },
  { 155, 3, 1, 0x0000002020000000ull, 0x000001eff8000000ull, { 36, 25, 0, 0, 0 }, 0x8, 128, },
  { 155, 3, 1, 0x0000002028000000ull, 0x000001eff8000000ull, { 37, 25, 0, 0, 0 }, 0x8, 129, },
  { 155, 3, 1, 0x0000002030000000ull, 0x000001eff8000000ull, { 34, 25, 0, 0, 0 }, 0x8, 130, },
  { 155, 3, 1, 0x0000002080000000ull, 0x000001eff8000000ull, { 24, 38, 0, 0, 0 }, 0x8, 131, },
  { 155, 3, 1, 0x0000002088000000ull, 0x000001eff8000000ull, { 24, 30, 0, 0, 0 }, 0x8, 132, },
  { 155, 3, 1, 0x0000002090000000ull, 0x000001eff8000000ull, { 24, 33, 0, 0, 0 }, 0x8, 133, },
  { 155, 3, 1, 0x0000002098000000ull, 0x000001eff8000000ull, { 24, 35, 0, 0, 0 }, 0x8, 134, },
  { 155, 3, 1, 0x00000020a0000000ull, 0x000001eff8000000ull, { 24, 36, 0, 0, 0 }, 0x8, 135, },
  { 155, 3, 1, 0x00000020a8000000ull, 0x000001eff8000000ull, { 24, 37, 0, 0, 0 }, 0x0, 136, },
  { 155, 3, 1, 0x00000020b0000000ull, 0x000001eff8000000ull, { 24, 34, 0, 0, 0 }, 0x8, 137, },
  { 155, 3, 1, 0x00000020b8000000ull, 0x000001eff8000000ull, { 24, 29, 0, 0, 0 }, 0x0, 138, },
  { 155, 7, 1, 0x0000000000000000ull, 0x0000000000000000ull, { 24, 14, 0, 0, 0 }, 0x0, 139, },
  { 155, 7, 1, 0x0000000000000000ull, 0x0000000000000000ull, { 14, 55, 0, 0, 0 }, 0x0, 140, },
  { 155, 7, 1, 0x0000000000000000ull, 0x0000000000000000ull, { 14, 25, 0, 0, 0 }, 0x0, 141, },
  { 156, 6, 1, 0x000000c000000000ull, 0x000001e000100000ull, { 24, 70, 0, 0, 0 }, 0x0, 142, },
  { 157, 2, 1, 0x000000eca0000000ull, 0x000001fff0000000ull, { 24, 25, 74, 0, 0 }, 0x0, 143, },
  { 158, 2, 1, 0x000000eea0000000ull, 0x000001fff0000000ull, { 24, 25, 75, 0, 0 }, 0x0, 144, },
  { 168, 4, 0, 0x0000004000000000ull, 0x000001e1f8000000ull, { 65, 0, 0, 0, 0 }, 0x0, 521, },
  { 168, 5, 0, 0x0000000008000000ull, 0x000001e3fc000000ull, { 65, 0, 0, 0, 0 }, 0x0, 944, },
  { 168, 2, 0, 0x0000000008000000ull, 0x000001effc000000ull, { 65, 0, 0, 0, 0 }, 0x2, 1129, },
  { 168, 3, 0, 0x0000000008000000ull, 0x000001effc000000ull, { 65, 0, 0, 0, 0 }, 0x0, 1253, },
  { 168, 6, 0, 0x0000000008000000ull, 0x000001effc000000ull, { 69, 0, 0, 0, 0 }, 0x0, 2997, },
  { 168, 7, 0, 0x0000000000000000ull, 0x0000000000000000ull, { 65, 0, 0, 0, 0 }, 0x0, 145, },
  { 175, 1, 1, 0x0000010070000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 146, },
  { 175, 1, 1, 0x0000010170000000ull, 0x000001eff8000000ull, { 24, 55, 26, 0, 0 }, 0x0, 147, },
  { 178, 2, 1, 0x000000ea00000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2979, },
  { 179, 2, 1, 0x000000f820000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2823, },
  { 180, 1, 1, 0x0000010400000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 148, },
  { 181, 1, 1, 0x0000010600000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 149, },
  { 182, 1, 1, 0x0000011400000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 150, },
  { 183, 1, 1, 0x0000010450000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 151, },
  { 184, 1, 1, 0x0000010650000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 152, },
  { 185, 1, 1, 0x0000010470000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 153, },
  { 186, 1, 1, 0x0000010670000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 154, },
  { 187, 1, 1, 0x0000010520000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 930, },
  { 188, 1, 1, 0x0000010720000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 931, },
  { 189, 1, 1, 0x0000011520000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 932, },
  { 190, 2, 1, 0x000000e850000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2837, },
  { 191, 2, 1, 0x000000ea70000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 155, },
  { 192, 2, 1, 0x000000e810000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2838, },
  { 193, 2, 1, 0x000000ea30000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 156, },
  { 194, 2, 1, 0x000000ead0000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 2172, },
  { 195, 2, 1, 0x000000e230000000ull, 0x000001ff30000000ull, { 24, 25, 26, 42, 0 }, 0x0, 157, },
  { 196, 2, 1, 0x000000e690000000ull, 0x000001fff0000000ull, { 24, 26, 0, 0, 0 }, 0x0, 158, },
  { 198, 3, 1, 0x00000021c0000000ull, 0x000001eff8000000ull, { 24, 26, 25, 0, 0 }, 0x0, 2173, },
  { 198, 3, 1, 0x00000020c0000000ull, 0x000001eff8000000ull, { 24, 26, 49, 0, 0 }, 0x0, 2174, },
  { 198, 3, 0, 0x0000002188000000ull, 0x000001eff8000000ull, { 26, 49, 0, 0, 0 }, 0x0, 2204, },
  { 199, 2, 1, 0x000000e8b0000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 159, },
  { 200, 2, 1, 0x000000e240000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 160, },
  { 200, 2, 1, 0x000000ee50000000ull, 0x000001fff0000000ull, { 24, 25, 39, 0, 0 }, 0x0, 161, },
  { 201, 2, 1, 0x000000f040000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 162, },
  { 201, 2, 1, 0x000000fc50000000ull, 0x000001fff0000000ull, { 24, 25, 39, 0, 0 }, 0x0, 163, },
  { 202, 1, 1, 0x0000010680000000ull, 0x000001ffe0000000ull, { 24, 25, 41, 26, 0 }, 0x0, 164, },
  { 203, 2, 1, 0x000000e220000000ull, 0x000001fff0000000ull, { 24, 26, 25, 0, 0 }, 0x0, 165, },
  { 203, 2, 1, 0x000000e630000000ull, 0x000001fff0000000ull, { 24, 26, 43, 0, 0 }, 0x0, 166, },
  { 204, 2, 1, 0x000000f020000000ull, 0x000001fff0000000ull, { 24, 26, 25, 0, 0 }, 0x0, 167, },
  { 204, 2, 1, 0x000000f430000000ull, 0x000001fff0000000ull, { 24, 26, 43, 0, 0 }, 0x0, 168, },
  { 205, 1, 1, 0x00000106c0000000ull, 0x000001ffe0000000ull, { 24, 25, 41, 26, 0 }, 0x0, 169, },
  { 206, 1, 1, 0x0000010420000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 170, },
  { 207, 1, 1, 0x0000010620000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 171, },
  { 208, 1, 1, 0x0000011420000000ull, 0x000001fff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 172, },
  { 209, 3, 0, 0x0000002048000000ull, 0x000001eff8000000ull, { 26, 25, 0, 0, 0 }, 0x8, 1157, },
  { 209, 3, 0, 0x0000002050000000ull, 0x000001eff8000000ull, { 26, 25, 0, 0, 0 }, 0xc, 1032, },
  { 209, 3, 0, 0x00000021a0000000ull, 0x000001eff8000000ull, { 26, 0, 0, 0, 0 }, 0x8, 904, },
  { 210, 3, 0, 0x0000002060000000ull, 0x000001eff8000000ull, { 26, 25, 0, 0, 0 }, 0x8, 830, },
  { 215, 4, 0, 0x0000000040000000ull, 0x000001e1f8000000ull, { 0, 0, 0, 0, 0 }, 0x22c, 173, },
  { 216, 3, 0, 0x0000000038000000ull, 0x000001ee78000000ull, { 67, 0, 0, 0, 0 }, 0x8, 174, },
  { 217, 3, 0, 0x0000000028000000ull, 0x000001ee78000000ull, { 67, 0, 0, 0, 0 }, 0x0, 175, },
  { 226, 3, 1, 0x000000c708000000ull, 0x000001ffc8000000ull, { 18, 25, 0, 0, 0 }, 0x0, 2748, },
  { 227, 2, 1, 0x000000a600000000ull, 0x000001ee04000000ull, { 24, 25, 45, 0, 0 }, 0x140, 176, },
  { 227, 2, 1, 0x000000f240000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 177, },
  { 228, 1, 1, 0x0000010080000000ull, 0x000001efe0000000ull, { 24, 25, 40, 26, 0 }, 0x0, 178, },
  { 229, 1, 1, 0x00000100c0000000ull, 0x000001efe0000000ull, { 24, 25, 40, 26, 0 }, 0x0, 179, },
  { 230, 2, 1, 0x000000a400000000ull, 0x000001ee00002000ull, { 24, 26, 76, 0, 0 }, 0x140, 2844, },
  { 230, 2, 1, 0x000000f220000000ull, 0x000001fff0000000ull, { 24, 26, 25, 0, 0 }, 0x0, 181, },
  { 231, 2, 1, 0x000000ac00000000ull, 0x000001ee00000000ull, { 24, 25, 26, 44, 0 }, 0x0, 182, },
  { 236, 3, 0, 0x0000000180000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x0, 832, },
  { 237, 3, 0, 0x0000000030000000ull, 0x000001ee78000000ull, { 67, 0, 0, 0, 0 }, 0x8, 183, },
  { 239, 3, 1, 0x0000008c00000000ull, 0x000001fff8000000ull, { 28, 25, 0, 0, 0 }, 0x0, 184, },
  { 239, 3, 1, 0x000000ac00000000ull, 0x000001eff0000000ull, { 28, 25, 61, 0, 0 }, 0x400, 185, },
  { 240, 3, 1, 0x0000008c08000000ull, 0x000001fff8000000ull, { 28, 25, 1, 0, 0 }, 0x0, 186, },
  { 240, 3, 1, 0x0000008c08000000ull, 0x000001fff8000000ull, { 28, 25, 0, 0, 0 }, 0x40, 187, },
  { 241, 3, 1, 0x0000008c40000000ull, 0x000001fff8000000ull, { 28, 25, 0, 0, 0 }, 0x0, 188, },
  { 241, 3, 1, 0x000000ac40000000ull, 0x000001eff0000000ull, { 28, 25, 61, 0, 0 }, 0x400, 189, },
  { 242, 3, 1, 0x0000008c80000000ull, 0x000001fff8000000ull, { 28, 25, 0, 0, 0 }, 0x0, 190, },
  { 242, 3, 1, 0x000000ac80000000ull, 0x000001eff0000000ull, { 28, 25, 61, 0, 0 }, 0x400, 191, },
  { 243, 3, 1, 0x0000008cc0000000ull, 0x000001fff8000000ull, { 28, 25, 0, 0, 0 }, 0x0, 192, },
  { 243, 3, 1, 0x000000acc0000000ull, 0x000001eff0000000ull, { 28, 25, 61, 0, 0 }, 0x400, 193, },
  { 244, 3, 1, 0x000000cec0000000ull, 0x000001fff8000000ull, { 28, 19, 0, 0, 0 }, 0x0, 2751, },
  { 244, 3, 1, 0x000000eec0000000ull, 0x000001eff0000000ull, { 28, 19, 61, 0, 0 }, 0x400, 2752, },
  { 245, 3, 1, 0x000000cc40000000ull, 0x000001fff8000000ull, { 28, 19, 0, 0, 0 }, 0x0, 194, },
  { 245, 3, 1, 0x000000ec40000000ull, 0x000001eff0000000ull, { 28, 19, 61, 0, 0 }, 0x400, 195, },
  { 246, 3, 1, 0x000000ccc0000000ull, 0x000001fff8000000ull, { 28, 19, 0, 0, 0 }, 0x0, 196, },
  { 246, 3, 1, 0x000000ecc0000000ull, 0x000001eff0000000ull, { 28, 19, 61, 0, 0 }, 0x400, 197, },
  { 247, 3, 1, 0x000000cc00000000ull, 0x000001fff8000000ull, { 28, 19, 0, 0, 0 }, 0x0, 198, },
  { 247, 3, 1, 0x000000ec00000000ull, 0x000001eff0000000ull, { 28, 19, 61, 0, 0 }, 0x400, 199, },
  { 248, 3, 1, 0x000000cc80000000ull, 0x000001fff8000000ull, { 28, 19, 0, 0, 0 }, 0x0, 200, },
  { 248, 3, 1, 0x000000ec80000000ull, 0x000001eff0000000ull, { 28, 19, 61, 0, 0 }, 0x400, 201, },
  { 249, 1, 1, 0x0000010028000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 202, },
  { 249, 1, 1, 0x0000010020000000ull, 0x000001eff8000000ull, { 24, 25, 26, 4, 0 }, 0x0, 203, },
  { 249, 1, 1, 0x0000010128000000ull, 0x000001eff8000000ull, { 24, 55, 26, 0, 0 }, 0x0, 204, },
  { 250, 3, 0, 0x0000000020000000ull, 0x000001ee78000000ull, { 67, 0, 0, 0, 0 }, 0x0, 205, },
  { 251, 2, 1, 0x00000000a0000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 206, },
  { 252, 2, 1, 0x00000000a8000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 207, },
  { 253, 2, 1, 0x00000000b0000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 208, },
  { 254, 3, 0, 0x0000000198000000ull, 0x000001eff8000000ull, { 0, 0, 0, 0, 0 }, 0x0, 1132, },
  { 255, 3, 1, 0x00000020f8000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x8, 209, },
  { 256, 2, 2, 0x000000a000000000ull, 0x000001fe00003000ull, { 22, 23, 26, 76, 0 }, 0x0, 3002, },
  { 256, 2, 1, 0x000000a000000000ull, 0x000001fe00003000ull, { 22, 26, 76, 0, 0 }, 0x40, 3003, },
  { 256, 2, 2, 0x000000a000000000ull, 0x000001fe00003000ull, { 23, 22, 26, 76, 0 }, 0x40, 1985, },
  { 256, 2, 1, 0x000000a000000000ull, 0x000001fe00003000ull, { 23, 26, 76, 0, 0 }, 0x40, 1986, },
  { 257, 3, 1, 0x00000020d0000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 210, },
  { 258, 2, 2, 0x000000a000002000ull, 0x000001fe00003000ull, { 22, 23, 26, 0, 0 }, 0x0, 3006, },
  { 258, 2, 1, 0x000000a000002000ull, 0x000001fe00003000ull, { 22, 26, 0, 0, 0 }, 0x40, 3007, },
  { 258, 2, 2, 0x000000a000002000ull, 0x000001fe00003000ull, { 23, 22, 26, 0, 0 }, 0x40, 1989, },
  { 258, 2, 1, 0x000000a000002000ull, 0x000001fe00003000ull, { 23, 26, 0, 0, 0 }, 0x40, 1990, },
  { 259, 3, 1, 0x00000020f0000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x8, 211, },
  { 261, 3, 1, 0x00000020d8000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 212, },
  { 265, 2, 1, 0x000000e840000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 1113, },
  { 266, 2, 1, 0x000000ea40000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 1114, },
  { 267, 2, 1, 0x000000f840000000ull, 0x000001fff0000000ull, { 24, 25, 26, 0, 0 }, 0x0, 1115, },
  { 275, 3, 1, 0x0000008208000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x0, 213, },
  { 276, 3, 1, 0x0000008248000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x0, 214, },
  { 277, 3, 1, 0x0000008288000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x0, 215, },
  { 278, 3, 1, 0x00000082c8000000ull, 0x000001fff8000000ull, { 24, 28, 25, 0, 0 }, 0x0, 216, },
  { 280, 5, 1, 0x000001d000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x0, 1161, },
  { 280, 5, 1, 0x000001d000000000ull, 0x000001fc00000000ull, { 18, 20, 21, 19, 0 }, 0x40, 1243, },
  { 281, 5, 1, 0x000001d000000000ull, 0x000001fc000fe000ull, { 18, 20, 21, 0, 0 }, 0x40, 1162, },
  { 282, 1, 1, 0x0000010078000000ull, 0x000001eff8000000ull, { 24, 25, 26, 0, 0 }, 0x0, 217, },
  { 282, 1, 1, 0x0000010178000000ull, 0x000001eff8000000ull, { 24, 55, 26, 0, 0 }, 0x0, 218, },
  { 285, 2, 1, 0x0000000080000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 219, },
  { 286, 2, 1, 0x0000000088000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 220, },
  { 287, 2, 1, 0x0000000090000000ull, 0x000001eff8000000ull, { 24, 26, 0, 0, 0 }, 0x0, 221, },
};

static const char dis_table[] = {
0xa0, 0xc5, 0xe8, 0xa0, 0x2e, 0x98, 0xa0, 0x2c, 0x80, 0xa0, 0x1b, 0xc0, 
0x98, 0xb0, 0x02, 0x50, 0x90, 0x50, 0x90, 0x28, 0x24, 0x38, 0x28, 0x24, 
0x38, 0x20, 0x90, 0x28, 0x24, 0x38, 0x18, 0x24, 0x38, 0x10, 0x91, 0x60, 
0x90, 0x28, 0x24, 0x38, 0x00, 0x10, 0x10, 0x58, 0x41, 0x61, 0xbf, 0xc0, 
0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 
0x10, 0x10, 0x52, 0xc0, 0xc0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 
0x10, 0x10, 0x10, 0x24, 0x23, 0x70, 0x90, 0x28, 0x24, 0x37, 0xf0, 0x24, 
0x37, 0xe8, 0xa8, 0x0b, 0x48, 0x15, 0x20, 0x97, 0x20, 0x95, 0xc8, 0x9a, 
0xb8, 0x05, 0x38, 0x91, 0x18, 0x90, 0xa0, 0x90, 0x60, 0x80, 0x90, 0x20, 
0x34, 0x86, 0xa4, 0x24, 0x00, 0x34, 0x83, 0x80, 0xa4, 0x35, 0xa0, 0x36, 
0xb9, 0x90, 0x50, 0x90, 0x28, 0x80, 0x36, 0xaf, 0x80, 0x34, 0x66, 0x81, 
0x33, 0xe2, 0x90, 0xe0, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x23, 0x10, 0x34, 
0x63, 0xa4, 0x1f, 0x08, 0x34, 0x60, 0x90, 0x38, 0xa4, 0x37, 0xa0, 0x36, 
0xfa, 0xa4, 0x37, 0x48, 0x36, 0xee, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x36, 
0x20, 0x36, 0xcf, 0xa4, 0x35, 0xf8, 0x36, 0xca, 0x80, 0xa4, 0x22, 0xf0, 
0x34, 0x5f, 0x92, 0x18, 0x91, 0xc0, 0x80, 0x91, 0x80, 0x90, 0xf8, 0xdb, 
0x84, 0x60, 0xf9, 0x40, 0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x58, 0x8c, 0x42, 
0xb8, 0x84, 0x38, 0x61, 0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x48, 0x8c, 0x42, 
0x98, 0x84, 0x38, 0x5f, 0xd3, 0x82, 0x40, 0x50, 0xc0, 0xc0, 0x81, 0x38, 
0x13, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x11, 0xa4, 0x1f, 0x18, 0x33, 0xe4, 
0x80, 0x90, 0x28, 0x80, 0x33, 0xe0, 0x80, 0x34, 0x68, 0x81, 0x90, 0x38, 
0xa4, 0x23, 0x80, 0x34, 0x6b, 0xa4, 0x23, 0x48, 0x34, 0x65, 0xc0, 0x40, 
0x10, 0x10, 0x90, 0x38, 0xa4, 0x1e, 0xf0, 0x33, 0xdf, 0xa4, 0x1e, 0xe0, 
0x33, 0xdd, 0x18, 0x24, 0x23, 0xf8, 0x83, 0x90, 0xa8, 0xd3, 0x82, 0xc0, 
0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x28, 0x38, 0x4b, 0xc0, 0xc0, 0x80, 0xa4, 
0x41, 0x18, 0x38, 0x47, 0xd3, 0x82, 0x40, 0x50, 0xc0, 0xc0, 0x81, 0x38, 
0x0d, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x0b, 0x92, 0xb8, 0x99, 0x84, 0x23, 
0x68, 0x90, 0x78, 0x90, 0x50, 0x10, 0x10, 0x80, 0xa4, 0x35, 0x98, 0x36, 
0xb8, 0x82, 0x36, 0xae, 0x90, 0x80, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x37, 
0x98, 0x36, 0xf9, 0xa4, 0x37, 0x40, 0x36, 0xed, 0x80, 0x90, 0x38, 0xa4, 
0x36, 0x18, 0x36, 0xce, 0xa4, 0x35, 0xf0, 0x36, 0xc9, 0x83, 0x90, 0xa8, 
0xd3, 0x82, 0xc0, 0xc0, 0xc0, 0x80, 0xa4, 0x40, 0xf8, 0x38, 0x3f, 0xc0, 
0xc0, 0x80, 0xa4, 0x40, 0xe8, 0x38, 0x3b, 0xd3, 0x82, 0x40, 0x50, 0xc0, 
0xc0, 0x81, 0x38, 0x07, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x05, 0x18, 0x24, 
0x23, 0x78, 0x83, 0x90, 0xa8, 0xd3, 0x82, 0xc0, 0xc0, 0xc0, 0x80, 0xa4, 
0x40, 0xc8, 0x38, 0x33, 0xc0, 0xc0, 0x80, 0xa4, 0x40, 0xb8, 0x38, 0x2f, 
0xd3, 0x82, 0x40, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x01, 0x50, 0xc0, 0xc0, 
0x81, 0x37, 0xff, 0x94, 0x50, 0x92, 0xf8, 0x99, 0x84, 0x1f, 0x48, 0x90, 
0x78, 0x90, 0x50, 0x10, 0x10, 0x80, 0xa4, 0x35, 0x90, 0x36, 0xb7, 0x82, 
0x36, 0xad, 0x90, 0x80, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x37, 0x90, 0x36, 
0xf8, 0xa4, 0x37, 0x38, 0x36, 0xec, 0x80, 0x90, 0x38, 0xa4, 0x36, 0x10, 
0x36, 0xcd, 0xa4, 0x35, 0xe8, 0x36, 0xc8, 0x83, 0x90, 0xe8, 0xd3, 0x83, 
0xc0, 0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x68, 0x8c, 0x42, 0xd8, 0x84, 0x38, 
0x63, 0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x50, 0x8c, 0x42, 0xa8, 0x84, 0x38, 
0x60, 0xd3, 0x82, 0x40, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x15, 0x50, 0xc0, 
0xc0, 0x81, 0x38, 0x12, 0x18, 0x24, 0x1f, 0x40, 0x83, 0x90, 0xa8, 0xd3, 
0x82, 0xc0, 0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x38, 0x38, 0x4f, 0xc0, 0xc0, 
0x80, 0xa4, 0x41, 0x20, 0x38, 0x49, 0xd3, 0x82, 0x40, 0x50, 0xc0, 0xc0, 
0x81, 0x38, 0x0f, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x0c, 0x92, 0xb8, 0x99, 
0x84, 0x1f, 0x38, 0x90, 0x78, 0x90, 0x50, 0x10, 0x10, 0x80, 0xa4, 0x35, 
0x88, 0x36, 0xb6, 0x82, 0x36, 0xac, 0x90, 0x80, 0x10, 0x10, 0x90, 0x38, 
0xa4, 0x37, 0x88, 0x36, 0xf7, 0xa4, 0x37, 0x30, 0x36, 0xeb, 0x80, 0x90, 
0x38, 0xa4, 0x36, 0x08, 0x36, 0xcc, 0xa4, 0x35, 0xe0, 0x36, 0xc7, 0x83, 
0x90, 0xa8, 0xd3, 0x82, 0xc0, 0xc0, 0xc0, 0x80, 0xa4, 0x41, 0x08, 0x38, 
0x43, 0xc0, 0xc0, 0x80, 0xa4, 0x40, 0xf0, 0x38, 0x3d, 0xd3, 0x82, 0x40, 
0x50, 0xc0, 0xc0, 0x81, 0x38, 0x09, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x06, 
0x18, 0x20, 0x01, 0x48, 0x83, 0x90, 0xa8, 0xd3, 0x82, 0xc0, 0xc0, 0xc0, 
0x80, 0xa4, 0x40, 0xd8, 0x38, 0x37, 0xc0, 0xc0, 0x80, 0xa4, 0x40, 0xc0, 
0x38, 0x31, 0xd3, 0x82, 0x40, 0x50, 0xc0, 0xc0, 0x81, 0x38, 0x03, 0x50, 
0xc0, 0xc0, 0x81, 0x38, 0x00, 0xda, 0x06, 0xe0, 0xf9, 0x80, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x23, 0xe8, 0x34, 0x7b, 0x80, 0x34, 0x78, 0x90, 0x38, 
0xa4, 0x23, 0x90, 0x34, 0x76, 0x80, 0x34, 0x73, 0x90, 0x60, 0x90, 0x38, 
0xa4, 0x23, 0xd0, 0x34, 0x7c, 0x80, 0x34, 0x79, 0x90, 0x38, 0xa4, 0x23, 
0xa8, 0x34, 0x77, 0x80, 0x34, 0x74, 0xc8, 0x40, 0x19, 0x00, 0x91, 0x58, 
0x90, 0x60, 0x82, 0x90, 0x20, 0x36, 0xab, 0xa4, 0x35, 0x48, 0x36, 0xaa, 
0x90, 0xc0, 0x80, 0x90, 0x90, 0x90, 0x48, 0xc9, 0xe1, 0xb9, 0x00, 0x85, 
0x36, 0xe3, 0xc9, 0xe1, 0xb8, 0x40, 0x85, 0x36, 0xe0, 0x80, 0x36, 0xdf, 
0x10, 0x10, 0x81, 0x36, 0xbb, 0x90, 0xa8, 0x10, 0x10, 0x90, 0x28, 0x81, 
0x36, 0xd9, 0x90, 0x38, 0xa4, 0x36, 0xa0, 0x36, 0xd5, 0xa4, 0x36, 0x90, 
0x36, 0xd3, 0x90, 0x70, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x36, 0xb8, 0x36, 
0xd8, 0x80, 0x36, 0xd6, 0x90, 0x60, 0x90, 0x28, 0x24, 0x36, 0xf0, 0xa4, 
0x36, 0xe0, 0x36, 0xdd, 0x80, 0xa4, 0x36, 0xd0, 0x36, 0xdb, 0x80, 0x90, 
0xf8, 0x90, 0x90, 0x90, 0x50, 0x90, 0x28, 0x80, 0x37, 0xf7, 0x80, 0x37, 
0xfe, 0x80, 0xa4, 0x3f, 0xe0, 0x37, 0xfd, 0x90, 0x28, 0x81, 0x37, 0xfb, 
0x80, 0xa4, 0x3f, 0xc8, 0x37, 0xfa, 0x83, 0x37, 0xf8, 0x98, 0xe8, 0x01, 
0xb0, 0x90, 0x88, 0x90, 0x60, 0xa4, 0x35, 0x38, 0x10, 0x10, 0x10, 0x10, 
0x83, 0x33, 0xb7, 0x24, 0x35, 0x30, 0x90, 0x28, 0x24, 0x35, 0x28, 0x24, 
0x35, 0x20, 0x90, 0x88, 0x90, 0x60, 0xa4, 0x35, 0x10, 0x10, 0x10, 0x10, 
0x10, 0x83, 0x33, 0xb6, 0x24, 0x35, 0x08, 0x90, 0x28, 0x24, 0x35, 0x00, 
0x24, 0x34, 0xf8, 0xa8, 0x09, 0x00, 0x0e, 0x20, 0x96, 0x48, 0x95, 0xe8, 
0x93, 0x38, 0x91, 0xa0, 0x90, 0xd0, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x1e, 
0x60, 0x33, 0xcd, 0xa4, 0x1e, 0x50, 0x33, 0xcb, 0x90, 0x38, 0xa4, 0x1e, 
0x40, 0x33, 0xc9, 0x80, 0x33, 0xc7, 0x90, 0x60, 0x90, 0x28, 0x24, 0x1e, 
0x00, 0xa4, 0x1d, 0xf0, 0x33, 0xbf, 0x90, 0x38, 0xa4, 0x1d, 0xe0, 0x33, 
0xbd, 0xa4, 0x1e, 0x28, 0x33, 0xc6, 0x90, 0xe0, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x1e, 0x18, 0x33, 0xc4, 0xa4, 0x1e, 0x08, 0x33, 0xc2, 0x90, 0x38, 
0xa4, 0x34, 0xb0, 0x36, 0x9c, 0xa4, 0x34, 0x50, 0x36, 0x90, 0x90, 0x70, 
0x90, 0x38, 0xa4, 0x31, 0x90, 0x36, 0x3e, 0xa4, 0x31, 0x60, 0x36, 0x38, 
0x10, 0x10, 0xa4, 0x1d, 0xd0, 0x33, 0xbb, 0x99, 0x60, 0x02, 0x70, 0x90, 
0x90, 0x90, 0x50, 0x90, 0x28, 0x24, 0x1e, 0x90, 0x80, 0x33, 0xda, 0x80, 
0xa4, 0x1e, 0x98, 0x33, 0xd8, 0x90, 0x50, 0x90, 0x28, 0x24, 0x1e, 0xa0, 
0x80, 0x33, 0xdb, 0x90, 0x38, 0xa4, 0x1e, 0xa8, 0x33, 0xd9, 0xa4, 0x1e, 
0x70, 0x33, 0xcf, 0x90, 0xe0, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x33, 0xe8, 
0x36, 0x85, 0xa4, 0x33, 0x48, 0x36, 0x72, 0x90, 0x38, 0xa4, 0x32, 0xe0, 
0x36, 0x63, 0xa4, 0x32, 0x50, 0x36, 0x52, 0x81, 0xa4, 0x1e, 0x80, 0x33, 
0xd1, 0xe4, 0xa1, 0xfc, 0x40, 0x37, 0xf3, 0x18, 0x24, 0x1d, 0xc8, 0xe4, 
0xe1, 0xfa, 0xc0, 0x37, 0xed, 0x92, 0x40, 0x91, 0x08, 0x10, 0x10, 0x90, 
0x80, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x34, 0xa8, 0x36, 0x9b, 0xa4, 0x34, 
0x48, 0x36, 0x8f, 0x80, 0x90, 0x38, 0xa4, 0x31, 0x88, 0x36, 0x3d, 0xa4, 
0x31, 0x58, 0x36, 0x37, 0x18, 0x20, 0x00, 0xf8, 0x80, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x33, 0xd8, 0x36, 0x84, 0xa4, 0x33, 0x40, 0x36, 0x70, 0x90, 
0x38, 0xa4, 0x32, 0xd0, 0x36, 0x62, 0xa4, 0x32, 0x48, 0x36, 0x50, 0xe4, 
0xa1, 0xf9, 0x40, 0x37, 0xe7, 0x18, 0x24, 0x1d, 0xc0, 0xe4, 0xe1, 0xf7, 
0xc0, 0x37, 0xe1, 0x92, 0x90, 0x92, 0x40, 0x91, 0x08, 0x10, 0x10, 0x90, 
0x80, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x34, 0xa0, 0x36, 0x9a, 0xa4, 0x34, 
0x40, 0x36, 0x8e, 0x80, 0x90, 0x38, 0xa4, 0x31, 0x80, 0x36, 0x3c, 0xa4, 
0x31, 0x50, 0x36, 0x36, 0x18, 0x20, 0x00, 0xf8, 0x80, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x33, 0xc8, 0x36, 0x83, 0xa4, 0x33, 0x38, 0x36, 0x6e, 0x90, 
0x38, 0xa4, 0x32, 0xc0, 0x36, 0x61, 0xa4, 0x32, 0x40, 0x36, 0x4e, 0xe4, 
0xa1, 0xfc, 0x80, 0x37, 0xf5, 0x10, 0x10, 0xe4, 0xe1, 0xfb, 0x00, 0x37, 
0xef, 0x92, 0x50, 0x99, 0x1c, 0x1e, 0xb0, 0x10, 0x10, 0x90, 0x80, 0x10, 
0x10, 0x90, 0x38, 0xa4, 0x34, 0x98, 0x36, 0x99, 0xa4, 0x34, 0x38, 0x36, 
0x8d, 0x80, 0x90, 0x38, 0xa4, 0x31, 0x78, 0x36, 0x3b, 0xa4, 0x31, 0x48, 
0x36, 0x35, 0x18, 0x20, 0x00, 0xf8, 0x80, 0x90, 0x70, 0x90, 0x38, 0xa4, 
0x33, 0xb8, 0x36, 0x82, 0xa4, 0x33, 0x30, 0x36, 0x6c, 0x90, 0x38, 0xa4, 
0x32, 0xb0, 0x36, 0x60, 0xa4, 0x32, 0x38, 0x36, 0x4c, 0xe4, 0xa1, 0xf9, 
0x80, 0x37, 0xe9, 0x10, 0x10, 0xe4, 0xe1, 0xf8, 0x00, 0x37, 0xe3, 0xc0, 
0x40, 0x80, 0x10, 0x10, 0x81, 0x90, 0x90, 0x90, 0x48, 0xc9, 0xe1, 0x90, 
0x80, 0x85, 0x36, 0x46, 0xc9, 0xe1, 0x91, 0x00, 0x85, 0x36, 0x43, 0x80, 
0x36, 0x41, 0x80, 0xd8, 0x47, 0x80, 0x0d, 0xc0, 0xc0, 0x80, 0x10, 0x10, 
0x82, 0x90, 0x58, 0xd5, 0x81, 0x80, 0x80, 0x37, 0xdd, 0x80, 0x37, 0xdb, 
0xd5, 0x81, 0x80, 0x80, 0x37, 0xd9, 0x80, 0x37, 0xd7, 0xc0, 0x80, 0x10, 
0x10, 0x82, 0x90, 0x58, 0xd5, 0x81, 0x80, 0x80, 0x37, 0xde, 0x80, 0x37, 
0xdc, 0xd5, 0x81, 0x80, 0x80, 0x37, 0xda, 0x80, 0x37, 0xd8, 0xc0, 0x80, 
0x83, 0xa4, 0x3e, 0xa8, 0x37, 0xd6, 0xa0, 0x57, 0xc0, 0xa0, 0x41, 0xe0, 
0xa8, 0x1e, 0xb0, 0x34, 0x88, 0xa0, 0x12, 0x38, 0xa0, 0x0b, 0x48, 0x96, 
0x00, 0x9a, 0xf0, 0x05, 0xc0, 0x91, 0x70, 0x90, 0xb8, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x15, 0x58, 0x33, 0xb5, 0xa4, 0x15, 0x78, 0x33, 0xb4, 0x10, 
0x10, 0xa4, 0x15, 0x68, 0x33, 0xb3, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x14, 
0xf8, 0x33, 0x9a, 0xa4, 0x15, 0x18, 0x33, 0x99, 0x10, 0x10, 0xa4, 0x15, 
0x08, 0x33, 0x98, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x14, 0x98, 
0x33, 0x7f, 0xa4, 0x14, 0xb8, 0x33, 0x7e, 0x10, 0x10, 0xa4, 0x14, 0xa8, 
0x33, 0x7d, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x14, 0x38, 0x33, 0x63, 0xa4, 
0x14, 0x58, 0x33, 0x62, 0x10, 0x10, 0xa4, 0x14, 0x48, 0x33, 0x61, 0x91, 
0x70, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x15, 0x28, 0x33, 0xb0, 
0xa4, 0x15, 0x48, 0x33, 0xb2, 0x10, 0x10, 0xa4, 0x15, 0x38, 0x33, 0xb1, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x14, 0xc8, 0x33, 0x95, 0xa4, 0x14, 0xe8, 
0x33, 0x97, 0x10, 0x10, 0xa4, 0x14, 0xd8, 0x33, 0x96, 0x90, 0xb8, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x14, 0x68, 0x33, 0x7a, 0xa4, 0x14, 0x88, 0x33, 
0x7c, 0x10, 0x10, 0xa4, 0x14, 0x78, 0x33, 0x7b, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x14, 0x08, 0x33, 0x5e, 0xa4, 0x14, 0x28, 0x33, 0x60, 0x10, 0x10, 
0xa4, 0x14, 0x18, 0x33, 0x5f, 0xe4, 0xe1, 0x83, 0x40, 0x36, 0x21, 0x9a, 
0xf0, 0x05, 0x00, 0x91, 0x70, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 
0x13, 0xa0, 0x33, 0xad, 0xa4, 0x13, 0x98, 0x33, 0xaf, 0x10, 0x10, 0xa4, 
0x13, 0x90, 0x33, 0xae, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0x88, 0x33, 
0x92, 0xa4, 0x13, 0x80, 0x33, 0x94, 0x10, 0x10, 0xa4, 0x13, 0x78, 0x33, 
0x93, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0x70, 0x33, 0x77, 
0xa4, 0x13, 0x68, 0x33, 0x79, 0x10, 0x10, 0xa4, 0x13, 0x60, 0x33, 0x78, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0x58, 0x33, 0x5b, 0xa4, 0x13, 0x50, 
0x33, 0x5d, 0x10, 0x10, 0xa4, 0x13, 0x48, 0x33, 0x5c, 0x91, 0x10, 0x90, 
0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0xaa, 0x80, 0x33, 0xac, 0x10, 
0x10, 0x80, 0x33, 0xab, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x8f, 0x80, 
0x33, 0x91, 0x10, 0x10, 0x80, 0x33, 0x90, 0x90, 0x88, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x33, 0x74, 0x80, 0x33, 0x76, 0x10, 0x10, 0x80, 0x33, 0x75, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x58, 0x80, 0x33, 0x5a, 0x10, 0x10, 
0x80, 0x33, 0x59, 0xe4, 0xe1, 0x5e, 0x40, 0x35, 0xa1, 0x95, 0x40, 0x9a, 
0x90, 0x05, 0x00, 0x91, 0x10, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 
0x33, 0xa7, 0x80, 0x33, 0xa9, 0x10, 0x10, 0x80, 0x33, 0xa8, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x33, 0x8c, 0x80, 0x33, 0x8e, 0x10, 0x10, 0x80, 0x33, 
0x8d, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0x30, 0x33, 0x71, 
0xa4, 0x13, 0x40, 0x33, 0x73, 0x10, 0x10, 0xa4, 0x13, 0x38, 0x33, 0x72, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0x00, 0x33, 0x55, 0xa4, 0x13, 0x10, 
0x33, 0x57, 0x10, 0x10, 0xa4, 0x13, 0x08, 0x33, 0x56, 0x91, 0x10, 0x90, 
0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0xa4, 0x80, 0x33, 0xa6, 0x10, 
0x10, 0x80, 0x33, 0xa5, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x89, 0x80, 
0x33, 0x8b, 0x10, 0x10, 0x80, 0x33, 0x8a, 0x90, 0xb8, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x13, 0x18, 0x33, 0x6e, 0xa4, 0x13, 0x28, 0x33, 0x70, 0x10, 
0x10, 0xa4, 0x13, 0x20, 0x33, 0x6f, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x12, 
0xe8, 0x33, 0x52, 0xa4, 0x12, 0xf8, 0x33, 0x54, 0x10, 0x10, 0xa4, 0x12, 
0xf0, 0x33, 0x53, 0xe4, 0xe1, 0x82, 0x40, 0x36, 0x1d, 0x98, 0xb8, 0x01, 
0x68, 0x10, 0x10, 0x10, 0x10, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x4f, 
0x80, 0x33, 0x51, 0x10, 0x10, 0x80, 0x33, 0x50, 0x90, 0x60, 0x90, 0x30, 
0x60, 0xa0, 0x97, 0x00, 0x60, 0xa0, 0x96, 0xc0, 0x90, 0x30, 0x60, 0xa0, 
0x96, 0x80, 0x60, 0xa0, 0x96, 0x40, 0xe4, 0xe1, 0x5c, 0x40, 0x35, 0x99, 
0xa0, 0x08, 0x08, 0x94, 0xe0, 0x9a, 0x60, 0x04, 0xa0, 0x91, 0x40, 0x90, 
0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0xd8, 0x33, 0x9e, 0xa4, 0x13, 
0xf8, 0x33, 0xa3, 0x10, 0x10, 0xa4, 0x13, 0xe8, 0x33, 0xa2, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x33, 0x83, 0x80, 0x33, 0x88, 0x10, 0x10, 0x80, 0x33, 
0x87, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x68, 0x80, 0x33, 
0x6d, 0x10, 0x10, 0x80, 0x33, 0x6c, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0x49, 0x80, 0x33, 0x4e, 0x10, 0x10, 0x80, 0x33, 0x4d, 0x91, 0x40, 0x90, 
0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x13, 0xa8, 0x33, 0x9b, 0xa4, 0x13, 
0xc8, 0x33, 0x9d, 0x10, 0x10, 0xa4, 0x13, 0xb8, 0x33, 0x9c, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x33, 0x80, 0x80, 0x33, 0x82, 0x10, 0x10, 0x80, 0x33, 
0x81, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x65, 0x80, 0x33, 
0x67, 0x10, 0x10, 0x80, 0x33, 0x66, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0x46, 0x80, 0x33, 0x48, 0x10, 0x10, 0x80, 0x33, 0x47, 0xe4, 0xe1, 0x81, 
0x40, 0x36, 0x19, 0x9a, 0x60, 0x02, 0xe0, 0x91, 0x40, 0x90, 0xb8, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x1a, 0x20, 0x33, 0x9f, 0xa4, 0x1a, 0x10, 0x33, 
0xa1, 0x10, 0x10, 0xa4, 0x1a, 0x00, 0x33, 0xa0, 0x90, 0x50, 0x90, 0x28, 
0x80, 0x33, 0x84, 0x80, 0x33, 0x86, 0x10, 0x10, 0x80, 0x33, 0x85, 0x90, 
0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x69, 0x80, 0x33, 0x6b, 0x10, 
0x10, 0x80, 0x33, 0x6a, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x4a, 0x80, 
0x33, 0x4c, 0x10, 0x10, 0x80, 0x33, 0x4b, 0x81, 0x90, 0x50, 0x90, 0x28, 
0x24, 0x19, 0xd0, 0x24, 0x19, 0xf0, 0x10, 0x10, 0x24, 0x19, 0xe0, 0xe4, 
0xe1, 0x5a, 0x40, 0x35, 0x91, 0x93, 0x90, 0x99, 0xb8, 0x03, 0x50, 0x90, 
0xe8, 0x90, 0x88, 0x90, 0x40, 0x80, 0xa4, 0x15, 0xb8, 0x32, 0xca, 0x10, 
0x10, 0xa4, 0x15, 0xa8, 0x32, 0xc9, 0x90, 0x28, 0x81, 0x32, 0xc6, 0x10, 
0x10, 0x80, 0x32, 0xc5, 0x90, 0x60, 0x90, 0x28, 0x81, 0x32, 0xc2, 0x10, 
0x10, 0x80, 0x32, 0xc1, 0x90, 0x28, 0x81, 0x32, 0xbe, 0x10, 0x10, 0x80, 
0x32, 0xbd, 0x90, 0xe8, 0x90, 0x88, 0x90, 0x40, 0x80, 0xa4, 0x15, 0x88, 
0x32, 0xc7, 0x10, 0x10, 0xa4, 0x15, 0x98, 0x32, 0xc8, 0x90, 0x28, 0x81, 
0x32, 0xc3, 0x10, 0x10, 0x80, 0x32, 0xc4, 0x90, 0x60, 0x90, 0x28, 0x81, 
0x32, 0xbf, 0x10, 0x10, 0x80, 0x32, 0xc0, 0x90, 0x28, 0x81, 0x32, 0xbb, 
0x10, 0x10, 0x80, 0x32, 0xbc, 0xe4, 0xe1, 0x80, 0x40, 0x36, 0x15, 0x88, 
0x00, 0x88, 0x10, 0x10, 0x10, 0x10, 0x90, 0x28, 0x81, 0x32, 0xb9, 0x10, 
0x10, 0x80, 0x32, 0xba, 0xe4, 0xe1, 0x58, 0x40, 0x35, 0x89, 0xa0, 0x0e, 
0x80, 0xa0, 0x09, 0x08, 0x94, 0x80, 0x9a, 0x30, 0x04, 0x40, 0x91, 0x10, 
0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x39, 0x80, 0x33, 0x38, 
0x10, 0x10, 0x80, 0x33, 0x37, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x1e, 
0x80, 0x33, 0x1d, 0x10, 0x10, 0x80, 0x33, 0x1c, 0x90, 0x88, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x33, 0x03, 0x80, 0x33, 0x02, 0x10, 0x10, 0x80, 0x33, 
0x01, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xe8, 0x80, 0x32, 0xe7, 0x10, 
0x10, 0x80, 0x32, 0xe6, 0x91, 0x10, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 
0x80, 0x33, 0x34, 0x80, 0x33, 0x36, 0x10, 0x10, 0x80, 0x33, 0x35, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x33, 0x19, 0x80, 0x33, 0x1b, 0x10, 0x10, 0x80, 
0x33, 0x1a, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xfe, 0x80, 
0x33, 0x00, 0x10, 0x10, 0x80, 0x32, 0xff, 0x90, 0x50, 0x90, 0x28, 0x80, 
0x32, 0xe3, 0x80, 0x32, 0xe5, 0x10, 0x10, 0x80, 0x32, 0xe4, 0xe4, 0xe1, 
0x72, 0x40, 0x35, 0xf1, 0x9a, 0x30, 0x04, 0x40, 0x91, 0x10, 0x90, 0x88, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x31, 0x80, 0x33, 0x33, 0x10, 0x10, 
0x80, 0x33, 0x32, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x16, 0x80, 0x33, 
0x18, 0x10, 0x10, 0x80, 0x33, 0x17, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 
0x80, 0x32, 0xfb, 0x80, 0x32, 0xfd, 0x10, 0x10, 0x80, 0x32, 0xfc, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x32, 0xe0, 0x80, 0x32, 0xe2, 0x10, 0x10, 0x80, 
0x32, 0xe1, 0x91, 0x10, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0x2e, 0x80, 0x33, 0x30, 0x10, 0x10, 0x80, 0x33, 0x2f, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x33, 0x13, 0x80, 0x33, 0x15, 0x10, 0x10, 0x80, 0x33, 0x14, 
0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xf8, 0x80, 0x32, 0xfa, 
0x10, 0x10, 0x80, 0x32, 0xf9, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xdd, 
0x80, 0x32, 0xdf, 0x10, 0x10, 0x80, 0x32, 0xde, 0xe4, 0xe1, 0x51, 0x40, 
0x35, 0x59, 0x94, 0x80, 0x9a, 0x30, 0x04, 0x40, 0x91, 0x10, 0x90, 0x88, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x2b, 0x80, 0x33, 0x2d, 0x10, 0x10, 
0x80, 0x33, 0x2c, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x10, 0x80, 0x33, 
0x12, 0x10, 0x10, 0x80, 0x33, 0x11, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 
0x80, 0x32, 0xf5, 0x80, 0x32, 0xf7, 0x10, 0x10, 0x80, 0x32, 0xf6, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x32, 0xda, 0x80, 0x32, 0xdc, 0x10, 0x10, 0x80, 
0x32, 0xdb, 0x91, 0x10, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0x28, 0x80, 0x33, 0x2a, 0x10, 0x10, 0x80, 0x33, 0x29, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x33, 0x0d, 0x80, 0x33, 0x0f, 0x10, 0x10, 0x80, 0x33, 0x0e, 
0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xf2, 0x80, 0x32, 0xf4, 
0x10, 0x10, 0x80, 0x32, 0xf3, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xd7, 
0x80, 0x32, 0xd9, 0x10, 0x10, 0x80, 0x32, 0xd8, 0xe4, 0xe1, 0x70, 0x40, 
0x35, 0xe9, 0x88, 0x00, 0xb0, 0x10, 0x10, 0x10, 0x10, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x32, 0xd4, 0x80, 0x32, 0xd6, 0x10, 0x10, 0x80, 0x32, 0xd5, 
0xe4, 0xe1, 0x50, 0x40, 0x35, 0x55, 0x96, 0xe8, 0x94, 0x80, 0x9a, 0x30, 
0x04, 0x40, 0x91, 0x10, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0x22, 0x80, 0x33, 0x27, 0x10, 0x10, 0x80, 0x33, 0x26, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x33, 0x07, 0x80, 0x33, 0x0c, 0x10, 0x10, 0x80, 0x33, 0x0b, 
0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xec, 0x80, 0x32, 0xf1, 
0x10, 0x10, 0x80, 0x32, 0xf0, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xce, 
0x80, 0x32, 0xd3, 0x10, 0x10, 0x80, 0x32, 0xd2, 0x91, 0x10, 0x90, 0x88, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x1f, 0x80, 0x33, 0x21, 0x10, 0x10, 
0x80, 0x33, 0x20, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x04, 0x80, 0x33, 
0x06, 0x10, 0x10, 0x80, 0x33, 0x05, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 
0x80, 0x32, 0xe9, 0x80, 0x32, 0xeb, 0x10, 0x10, 0x80, 0x32, 0xea, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x32, 0xcb, 0x80, 0x32, 0xcd, 0x10, 0x10, 0x80, 
0x32, 0xcc, 0xe4, 0xe1, 0x6e, 0x40, 0x35, 0xe1, 0x88, 0x02, 0x28, 0x91, 
0x10, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0x23, 0x80, 0x33, 
0x25, 0x10, 0x10, 0x80, 0x33, 0x24, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0x08, 0x80, 0x33, 0x0a, 0x10, 0x10, 0x80, 0x33, 0x09, 0x90, 0x88, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x32, 0xed, 0x80, 0x32, 0xef, 0x10, 0x10, 0x80, 
0x32, 0xee, 0x90, 0x50, 0x90, 0x28, 0x80, 0x32, 0xcf, 0x80, 0x32, 0xd1, 
0x10, 0x10, 0x80, 0x32, 0xd0, 0xe4, 0xe1, 0x4f, 0x40, 0x35, 0x51, 0x90, 
0x40, 0xe5, 0x21, 0x6c, 0x40, 0x35, 0xd9, 0xe5, 0x21, 0x4e, 0x40, 0x35, 
0x4d, 0x9e, 0xb4, 0x22, 0xe8, 0x93, 0x70, 0x91, 0xd8, 0xd5, 0x07, 0x80, 
0xd0, 0xc4, 0x40, 0x90, 0x48, 0x80, 0x8c, 0x3e, 0x38, 0x84, 0x37, 0xd1, 
0xa4, 0x3c, 0x18, 0x37, 0x9b, 0x90, 0x28, 0x24, 0x3b, 0x58, 0xa4, 0x39, 
0xd8, 0x37, 0x53, 0xd0, 0xc4, 0x40, 0x90, 0x48, 0x80, 0x8c, 0x3e, 0x18, 
0x84, 0x37, 0xcf, 0xa4, 0x3c, 0x08, 0x37, 0x99, 0x90, 0x28, 0x24, 0x3b, 
0x48, 0xa4, 0x39, 0xc8, 0x37, 0x51, 0xd5, 0x06, 0x80, 0xd0, 0xc3, 0x40, 
0x90, 0x28, 0x80, 0x37, 0xbb, 0xa4, 0x3b, 0xe8, 0x37, 0x95, 0x90, 0x28, 
0x24, 0x3b, 0x28, 0xa4, 0x39, 0xa8, 0x37, 0x4d, 0xd0, 0xc3, 0x40, 0x90, 
0x28, 0x80, 0x37, 0xb7, 0xa4, 0x3b, 0xd8, 0x37, 0x93, 0x90, 0x28, 0x24, 
0x3b, 0x18, 0xa4, 0x39, 0x98, 0x37, 0x4b, 0x91, 0x98, 0xd5, 0x06, 0x80, 
0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 0xaf, 0xa4, 0x3b, 0xb8, 0x37, 
0x8f, 0x90, 0x28, 0x24, 0x3a, 0xf8, 0xa4, 0x39, 0x78, 0x37, 0x47, 0xd0, 
0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 0xab, 0xa4, 0x3b, 0xa8, 0x37, 0x8d, 
0x90, 0x28, 0x24, 0x3a, 0xe8, 0xa4, 0x39, 0x68, 0x37, 0x45, 0xd5, 0x06, 
0x80, 0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 0xa3, 0xa4, 0x3b, 0x88, 
0x37, 0x89, 0x90, 0x28, 0x24, 0x3a, 0xc8, 0xa4, 0x39, 0x48, 0x37, 0x41, 
0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 0x9f, 0xa4, 0x3b, 0x78, 0x37, 
0x87, 0x90, 0x28, 0x24, 0x3a, 0xb8, 0xa4, 0x39, 0x38, 0x37, 0x3f, 0x93, 
0x70, 0x91, 0xd8, 0xd5, 0x07, 0x80, 0xd0, 0xc4, 0x40, 0x90, 0x48, 0x80, 
0x8c, 0x3e, 0x58, 0x84, 0x37, 0xd3, 0xa4, 0x3c, 0x28, 0x37, 0x9d, 0x90, 
0x28, 0x24, 0x3b, 0x68, 0xa4, 0x39, 0xe8, 0x37, 0x55, 0xd0, 0xc4, 0x40, 
0x90, 0x48, 0x80, 0x8c, 0x3e, 0x28, 0x84, 0x37, 0xd0, 0xa4, 0x3c, 0x10, 
0x37, 0x9a, 0x90, 0x28, 0x24, 0x3b, 0x50, 0xa4, 0x39, 0xd0, 0x37, 0x52, 
0xd5, 0x06, 0x80, 0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 0xbf, 0xa4, 
0x3b, 0xf8, 0x37, 0x97, 0x90, 0x28, 0x24, 0x3b, 0x38, 0xa4, 0x39, 0xb8, 
0x37, 0x4f, 0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 0xb9, 0xa4, 0x3b, 
0xe0, 0x37, 0x94, 0x90, 0x28, 0x24, 0x3b, 0x20, 0xa4, 0x39, 0xa0, 0x37, 
0x4c, 0x91, 0x98, 0xd5, 0x06, 0x80, 0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 
0x37, 0xb3, 0xa4, 0x3b, 0xc8, 0x37, 0x91, 0x90, 0x28, 0x24, 0x3b, 0x08, 
0xa4, 0x39, 0x88, 0x37, 0x49, 0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 0x37, 
0xad, 0xa4, 0x3b, 0xb0, 0x37, 0x8e, 0x90, 0x28, 0x24, 0x3a, 0xf0, 0xa4, 
0x39, 0x70, 0x37, 0x46, 0xd5, 0x06, 0x80, 0xd0, 0xc3, 0x40, 0x90, 0x28, 
0x80, 0x37, 0xa7, 0xa4, 0x3b, 0x98, 0x37, 0x8b, 0x90, 0x28, 0x24, 0x3a, 
0xd8, 0xa4, 0x39, 0x58, 0x37, 0x43, 0xd0, 0xc3, 0x40, 0x90, 0x28, 0x80, 
0x37, 0xa1, 0xa4, 0x3b, 0x80, 0x37, 0x88, 0x90, 0x28, 0x24, 0x3a, 0xc0, 
0xa4, 0x39, 0x40, 0x37, 0x40, 0x99, 0x08, 0x01, 0xf0, 0x81, 0x90, 0x78, 
0xd4, 0xc2, 0x00, 0xa4, 0x22, 0x80, 0x34, 0x40, 0xa4, 0x21, 0x80, 0x34, 
0x20, 0xd4, 0xc2, 0x00, 0xa4, 0x21, 0xa0, 0x34, 0x44, 0xa4, 0x20, 0xa0, 
0x34, 0x24, 0x81, 0x90, 0x78, 0xd4, 0xc2, 0x00, 0xa4, 0x21, 0xe0, 0x34, 
0x4c, 0xa4, 0x20, 0xe0, 0x34, 0x2c, 0xd4, 0xc2, 0x00, 0xa4, 0x21, 0xc0, 
0x34, 0x48, 0xa4, 0x20, 0xc0, 0x34, 0x28, 0xa8, 0x0b, 0x18, 0x13, 0xa8, 
0x96, 0x80, 0x93, 0x40, 0x99, 0x90, 0x03, 0x00, 0x90, 0xc0, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x12, 0xb8, 0x32, 0x58, 0x24, 0x12, 0xb0, 0x90, 0x38, 
0xa4, 0x11, 0xe0, 0x32, 0x3d, 0x24, 0x11, 0xd8, 0x90, 0x60, 0x90, 0x38, 
0xa4, 0x11, 0x08, 0x32, 0x22, 0x24, 0x11, 0x00, 0x90, 0x38, 0xa4, 0x10, 
0x30, 0x32, 0x07, 0x24, 0x10, 0x28, 0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 
0xa4, 0x12, 0xa8, 0x32, 0x53, 0x24, 0x12, 0xa0, 0x90, 0x38, 0xa4, 0x11, 
0xd0, 0x32, 0x38, 0x24, 0x11, 0xc8, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x10, 
0xf8, 0x32, 0x1d, 0x24, 0x10, 0xf0, 0x90, 0x38, 0xa4, 0x10, 0x20, 0x32, 
0x02, 0x24, 0x10, 0x18, 0xe4, 0xe1, 0xc8, 0x40, 0x37, 0x23, 0x99, 0x90, 
0x03, 0x00, 0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x12, 0x90, 0x32, 
0x50, 0x24, 0x12, 0x88, 0x90, 0x38, 0xa4, 0x11, 0xb8, 0x32, 0x35, 0x24, 
0x11, 0xb0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x10, 0xe0, 0x32, 0x1a, 0x24, 
0x10, 0xd8, 0x90, 0x38, 0xa4, 0x10, 0x08, 0x31, 0xff, 0x24, 0x10, 0x00, 
0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x12, 0x78, 0x32, 0x4d, 0x24, 
0x12, 0x70, 0x90, 0x38, 0xa4, 0x11, 0xa0, 0x32, 0x32, 0x24, 0x11, 0x98, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x10, 0xc8, 0x32, 0x17, 0x24, 0x10, 0xc0, 
0x90, 0x38, 0xa4, 0x0f, 0xf0, 0x31, 0xfc, 0x24, 0x0f, 0xe8, 0xe4, 0xe1, 
0xc6, 0xc0, 0x37, 0x1d, 0x93, 0x78, 0x99, 0x90, 0x03, 0x00, 0x90, 0xc0, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x12, 0x60, 0x32, 0x4a, 0x24, 0x12, 0x58, 
0x90, 0x38, 0xa4, 0x11, 0x88, 0x32, 0x2f, 0x24, 0x11, 0x80, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x10, 0xb0, 0x32, 0x14, 0x24, 0x10, 0xa8, 0x90, 0x38, 
0xa4, 0x0f, 0xd8, 0x31, 0xf9, 0x24, 0x0f, 0xd0, 0x90, 0xc0, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x12, 0x48, 0x32, 0x47, 0x24, 0x12, 0x40, 0x90, 0x38, 
0xa4, 0x11, 0x70, 0x32, 0x2c, 0x24, 0x11, 0x68, 0x90, 0x60, 0x90, 0x38, 
0xa4, 0x10, 0x98, 0x32, 0x11, 0x24, 0x10, 0x90, 0x90, 0x38, 0xa4, 0x0f, 
0xc0, 0x31, 0xf6, 0x24, 0x0f, 0xb8, 0xec, 0xa1, 0x16, 0x00, 0x02, 0x00, 
0x34, 0x5a, 0xa4, 0x38, 0xa8, 0x37, 0x17, 0x88, 0x00, 0x88, 0x10, 0x10, 
0x10, 0x10, 0x90, 0x38, 0xa4, 0x0f, 0xa8, 0x31, 0xf3, 0x24, 0x0f, 0xa0, 
0xe9, 0x61, 0x15, 0x40, 0x02, 0x00, 0x34, 0x56, 0xe3, 0x61, 0xc3, 0xc0, 
0x37, 0x11, 0x95, 0x08, 0x93, 0x40, 0x99, 0x90, 0x03, 0x00, 0x90, 0xc0, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x12, 0x30, 0x32, 0x41, 0x24, 0x12, 0x28, 
0x90, 0x38, 0xa4, 0x11, 0x58, 0x32, 0x26, 0x24, 0x11, 0x50, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x10, 0x80, 0x32, 0x0b, 0x24, 0x10, 0x78, 0x90, 0x38, 
0xa4, 0x0f, 0x90, 0x31, 0xed, 0x24, 0x0f, 0x88, 0x90, 0xc0, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x12, 0x00, 0x32, 0x3e, 0x24, 0x11, 0xf8, 0x90, 0x38, 
0xa4, 0x11, 0x28, 0x32, 0x23, 0x24, 0x11, 0x20, 0x90, 0x60, 0x90, 0x38, 
0xa4, 0x10, 0x50, 0x32, 0x08, 0x24, 0x10, 0x48, 0x90, 0x38, 0xa4, 0x0f, 
0x60, 0x31, 0xea, 0x24, 0x0f, 0x58, 0xe4, 0xe1, 0xc8, 0x80, 0x37, 0x25, 
0x88, 0x01, 0x88, 0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x12, 0x20, 
0x32, 0x42, 0x24, 0x12, 0x18, 0x90, 0x38, 0xa4, 0x11, 0x48, 0x32, 0x27, 
0x24, 0x11, 0x40, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x10, 0x70, 0x32, 0x0c, 
0x24, 0x10, 0x68, 0x90, 0x38, 0xa4, 0x0f, 0x80, 0x31, 0xee, 0x24, 0x0f, 
0x78, 0xe4, 0xe1, 0xc7, 0x00, 0x37, 0x1f, 0x92, 0xd0, 0x99, 0x50, 0x02, 
0x80, 0x90, 0xa0, 0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0xe9, 0x24, 0x0f, 
0x40, 0x90, 0x28, 0x80, 0x31, 0xe5, 0x24, 0x0f, 0x20, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x31, 0xe1, 0x24, 0x0f, 0x00, 0x90, 0x28, 0x80, 0x31, 0xdd, 
0x24, 0x0e, 0xe0, 0x90, 0xa0, 0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0xe6, 
0x24, 0x0f, 0x38, 0x90, 0x28, 0x80, 0x31, 0xe2, 0x24, 0x0f, 0x18, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x31, 0xde, 0x24, 0x0e, 0xf8, 0x90, 0x28, 0x80, 
0x31, 0xda, 0x24, 0x0e, 0xd8, 0xec, 0xe1, 0xc5, 0xa1, 0x17, 0x00, 0x37, 
0x19, 0x88, 0x00, 0x78, 0x10, 0x10, 0x10, 0x10, 0x90, 0x28, 0x80, 0x31, 
0xd8, 0x24, 0x0e, 0xc8, 0xec, 0xe1, 0xc4, 0x21, 0x15, 0x00, 0x37, 0x13, 
0xe5, 0xa1, 0x4d, 0x40, 0x35, 0x31, 0xa0, 0x2a, 0x10, 0xa8, 0x16, 0x60, 
0x29, 0xd8, 0xa0, 0x0c, 0x48, 0xa0, 0x0a, 0xc8, 0x95, 0x60, 0x92, 0xb0, 
0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0xa1, 0x80, 
0x31, 0xa0, 0x10, 0x10, 0x80, 0x31, 0x9f, 0x90, 0x70, 0x90, 0x38, 0xa4, 
0x08, 0x98, 0x31, 0xb3, 0xa4, 0x08, 0x90, 0x31, 0xb2, 0x10, 0x10, 0xa4, 
0x08, 0x88, 0x31, 0xb1, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x09, 
0xb8, 0x31, 0xd7, 0xa4, 0x09, 0xb0, 0x31, 0xd6, 0x10, 0x10, 0xa4, 0x09, 
0xa8, 0x31, 0xd5, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x09, 0x28, 0x31, 0xc5, 
0xa4, 0x09, 0x20, 0x31, 0xc4, 0x10, 0x10, 0xa4, 0x09, 0x18, 0x31, 0xc3, 
0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0x9c, 0x80, 
0x31, 0x9e, 0x10, 0x10, 0x80, 0x31, 0x9d, 0x90, 0x70, 0x90, 0x38, 0xa4, 
0x08, 0x70, 0x31, 0xae, 0xa4, 0x08, 0x80, 0x31, 0xb0, 0x10, 0x10, 0xa4, 
0x08, 0x78, 0x31, 0xaf, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x09, 
0x90, 0x31, 0xd2, 0xa4, 0x09, 0xa0, 0x31, 0xd4, 0x10, 0x10, 0xa4, 0x09, 
0x98, 0x31, 0xd3, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x09, 0x00, 0x31, 0xc0, 
0xa4, 0x09, 0x10, 0x31, 0xc2, 0x10, 0x10, 0xa4, 0x09, 0x08, 0x31, 0xc1, 
0x92, 0xb0, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 
0x99, 0x80, 0x31, 0x9b, 0x10, 0x10, 0x80, 0x31, 0x9a, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x08, 0x58, 0x31, 0xab, 0xa4, 0x08, 0x68, 0x31, 0xad, 0x10, 
0x10, 0xa4, 0x08, 0x60, 0x31, 0xac, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x09, 0x78, 0x31, 0xcf, 0xa4, 0x09, 0x88, 0x31, 0xd1, 0x10, 0x10, 
0xa4, 0x09, 0x80, 0x31, 0xd0, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x08, 0xe8, 
0x31, 0xbd, 0xa4, 0x08, 0xf8, 0x31, 0xbf, 0x10, 0x10, 0xa4, 0x08, 0xf0, 
0x31, 0xbe, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 
0x96, 0x80, 0x31, 0x98, 0x10, 0x10, 0x80, 0x31, 0x97, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x08, 0x40, 0x31, 0xa8, 0xa4, 0x08, 0x50, 0x31, 0xaa, 0x10, 
0x10, 0xa4, 0x08, 0x48, 0x31, 0xa9, 0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x09, 0x60, 0x31, 0xcc, 0xa4, 0x09, 0x70, 0x31, 0xce, 0x10, 0x10, 
0xa4, 0x09, 0x68, 0x31, 0xcd, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x08, 0xd0, 
0x31, 0xba, 0xa4, 0x08, 0xe0, 0x31, 0xbc, 0x10, 0x10, 0xa4, 0x08, 0xd8, 
0x31, 0xbb, 0x10, 0x10, 0x90, 0xa8, 0x10, 0x10, 0x10, 0x10, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x31, 0x8d, 0x80, 0x31, 0x8f, 0x10, 0x10, 0x80, 0x31, 
0x8e, 0x90, 0x60, 0x90, 0x30, 0x60, 0xa0, 0x2a, 0xc0, 0x60, 0xa0, 0x2a, 
0x80, 0x90, 0x30, 0x60, 0xa0, 0x2a, 0x40, 0x60, 0xa0, 0x2a, 0x00, 0x97, 
0xf0, 0x95, 0x60, 0x92, 0xb0, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x31, 0x93, 0x80, 0x31, 0x95, 0x10, 0x10, 0x80, 0x31, 0x94, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x08, 0x28, 0x31, 0xa5, 0xa4, 0x08, 0x38, 
0x31, 0xa7, 0x10, 0x10, 0xa4, 0x08, 0x30, 0x31, 0xa6, 0x90, 0xb8, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x09, 0x48, 0x31, 0xc9, 0xa4, 0x09, 0x58, 0x31, 
0xcb, 0x10, 0x10, 0xa4, 0x09, 0x50, 0x31, 0xca, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x08, 0xb8, 0x31, 0xb7, 0xa4, 0x08, 0xc8, 0x31, 0xb9, 0x10, 0x10, 
0xa4, 0x08, 0xc0, 0x31, 0xb8, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x31, 0x90, 0x80, 0x31, 0x92, 0x10, 0x10, 0x80, 0x31, 0x91, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x08, 0x10, 0x31, 0xa2, 0xa4, 0x08, 0x20, 
0x31, 0xa4, 0x10, 0x10, 0xa4, 0x08, 0x18, 0x31, 0xa3, 0x90, 0xb8, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x09, 0x30, 0x31, 0xc6, 0xa4, 0x09, 0x40, 0x31, 
0xc8, 0x10, 0x10, 0xa4, 0x09, 0x38, 0x31, 0xc7, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x08, 0xa0, 0x31, 0xb4, 0xa4, 0x08, 0xb0, 0x31, 0xb6, 0x10, 0x10, 
0xa4, 0x08, 0xa8, 0x31, 0xb5, 0x10, 0x10, 0x91, 0x40, 0x90, 0xa0, 0x90, 
0x50, 0x90, 0x28, 0x80, 0x30, 0xcb, 0x80, 0x30, 0xca, 0x90, 0x28, 0x80, 
0x30, 0xc9, 0x80, 0x30, 0xc8, 0x90, 0x50, 0x90, 0x28, 0x80, 0x30, 0xc4, 
0x80, 0x30, 0xc7, 0x90, 0x28, 0x80, 0x30, 0xc6, 0x80, 0x30, 0xc5, 0x90, 
0xa0, 0x90, 0x50, 0x90, 0x28, 0x80, 0x30, 0xbc, 0x80, 0x30, 0xc3, 0x90, 
0x28, 0x80, 0x30, 0xc2, 0x80, 0x30, 0xc1, 0x90, 0x50, 0x90, 0x28, 0x80, 
0x30, 0xbd, 0x80, 0x30, 0xc0, 0x90, 0x28, 0x80, 0x30, 0xbf, 0x80, 0x30, 
0xbe, 0x91, 0x88, 0x80, 0x90, 0xc0, 0x90, 0x60, 0x90, 0x28, 0x81, 0x31, 
0x3b, 0x10, 0x10, 0x80, 0x31, 0x3a, 0x90, 0x28, 0x81, 0x31, 0x3d, 0x10, 
0x10, 0x80, 0x31, 0x3c, 0x90, 0x60, 0x90, 0x28, 0x81, 0x31, 0x41, 0x10, 
0x10, 0x80, 0x31, 0x40, 0x90, 0x28, 0x81, 0x31, 0x3f, 0x10, 0x10, 0x80, 
0x31, 0x3e, 0x80, 0x10, 0x10, 0x10, 0x10, 0x90, 0x28, 0x81, 0x31, 0x38, 
0x10, 0x10, 0x80, 0x31, 0x39, 0xa0, 0x0b, 0x90, 0xa0, 0x0a, 0xc8, 0x95, 
0x60, 0x92, 0xb0, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 
0x31, 0x56, 0x80, 0x31, 0x55, 0x10, 0x10, 0x80, 0x31, 0x54, 0x90, 0x70, 
0x90, 0x38, 0xa4, 0x06, 0xe8, 0x31, 0x68, 0xa4, 0x06, 0xe0, 0x31, 0x67, 
0x10, 0x10, 0xa4, 0x06, 0xd8, 0x31, 0x66, 0x90, 0xb8, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x08, 0x08, 0x31, 0x8c, 0xa4, 0x08, 0x00, 0x31, 0x8b, 0x10, 
0x10, 0xa4, 0x07, 0xf8, 0x31, 0x8a, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x07, 
0x78, 0x31, 0x7a, 0xa4, 0x07, 0x70, 0x31, 0x79, 0x10, 0x10, 0xa4, 0x07, 
0x68, 0x31, 0x78, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 0x28, 0x80, 
0x31, 0x51, 0x80, 0x31, 0x53, 0x10, 0x10, 0x80, 0x31, 0x52, 0x90, 0x70, 
0x90, 0x38, 0xa4, 0x06, 0xc0, 0x31, 0x63, 0xa4, 0x06, 0xd0, 0x31, 0x65, 
0x10, 0x10, 0xa4, 0x06, 0xc8, 0x31, 0x64, 0x90, 0xb8, 0x90, 0x70, 0x90, 
0x38, 0xa4, 0x07, 0xe0, 0x31, 0x87, 0xa4, 0x07, 0xf0, 0x31, 0x89, 0x10, 
0x10, 0xa4, 0x07, 0xe8, 0x31, 0x88, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x07, 
0x50, 0x31, 0x75, 0xa4, 0x07, 0x60, 0x31, 0x77, 0x10, 0x10, 0xa4, 0x07, 
0x58, 0x31, 0x76, 0x92, 0xb0, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x31, 0x4e, 0x80, 0x31, 0x50, 0x10, 0x10, 0x80, 0x31, 0x4f, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x06, 0xa8, 0x31, 0x60, 0xa4, 0x06, 0xb8, 
0x31, 0x62, 0x10, 0x10, 0xa4, 0x06, 0xb0, 0x31, 0x61, 0x90, 0xb8, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x07, 0xc8, 0x31, 0x84, 0xa4, 0x07, 0xd8, 0x31, 
0x86, 0x10, 0x10, 0xa4, 0x07, 0xd0, 0x31, 0x85, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x07, 0x38, 0x31, 0x72, 0xa4, 0x07, 0x48, 0x31, 0x74, 0x10, 0x10, 
0xa4, 0x07, 0x40, 0x31, 0x73, 0x91, 0x40, 0x90, 0x88, 0x90, 0x50, 0x90, 
0x28, 0x80, 0x31, 0x4b, 0x80, 0x31, 0x4d, 0x10, 0x10, 0x80, 0x31, 0x4c, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x06, 0x90, 0x31, 0x5d, 0xa4, 0x06, 0xa0, 
0x31, 0x5f, 0x10, 0x10, 0xa4, 0x06, 0x98, 0x31, 0x5e, 0x90, 0xb8, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x07, 0xb0, 0x31, 0x81, 0xa4, 0x07, 0xc0, 0x31, 
0x83, 0x10, 0x10, 0xa4, 0x07, 0xb8, 0x31, 0x82, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x07, 0x20, 0x31, 0x6f, 0xa4, 0x07, 0x30, 0x31, 0x71, 0x10, 0x10, 
0xa4, 0x07, 0x28, 0x31, 0x70, 0x10, 0x10, 0x80, 0x10, 0x10, 0x10, 0x10, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0x42, 0x80, 0x31, 0x44, 0x10, 0x10, 
0x80, 0x31, 0x43, 0x80, 0x95, 0x60, 0x92, 0xb0, 0x91, 0x40, 0x90, 0x88, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0x48, 0x80, 0x31, 0x4a, 0x10, 0x10, 
0x80, 0x31, 0x49, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x06, 0x78, 0x31, 0x5a, 
0xa4, 0x06, 0x88, 0x31, 0x5c, 0x10, 0x10, 0xa4, 0x06, 0x80, 0x31, 0x5b, 
0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x07, 0x98, 0x31, 0x7e, 0xa4, 
0x07, 0xa8, 0x31, 0x80, 0x10, 0x10, 0xa4, 0x07, 0xa0, 0x31, 0x7f, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x07, 0x08, 0x31, 0x6c, 0xa4, 0x07, 0x18, 0x31, 
0x6e, 0x10, 0x10, 0xa4, 0x07, 0x10, 0x31, 0x6d, 0x91, 0x40, 0x90, 0x88, 
0x90, 0x50, 0x90, 0x28, 0x80, 0x31, 0x45, 0x80, 0x31, 0x47, 0x10, 0x10, 
0x80, 0x31, 0x46, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x06, 0x60, 0x31, 0x57, 
0xa4, 0x06, 0x70, 0x31, 0x59, 0x10, 0x10, 0xa4, 0x06, 0x68, 0x31, 0x58, 
0x90, 0xb8, 0x90, 0x70, 0x90, 0x38, 0xa4, 0x07, 0x80, 0x31, 0x7b, 0xa4, 
0x07, 0x90, 0x31, 0x7d, 0x10, 0x10, 0xa4, 0x07, 0x88, 0x31, 0x7c, 0x90, 
0x70, 0x90, 0x38, 0xa4, 0x06, 0xf0, 0x31, 0x69, 0xa4, 0x07, 0x00, 0x31, 
0x6b, 0x10, 0x10, 0xa4, 0x06, 0xf8, 0x31, 0x6a, 0x10, 0x10, 0x91, 0x40, 
0x90, 0xa0, 0x90, 0x50, 0x90, 0x28, 0x80, 0x30, 0xbb, 0x80, 0x30, 0xba, 
0x90, 0x28, 0x80, 0x30, 0xb9, 0x80, 0x30, 0xb8, 0x90, 0x50, 0x90, 0x28, 
0x80, 0x30, 0xb4, 0x80, 0x30, 0xb7, 0x90, 0x28, 0x80, 0x30, 0xb6, 0x80, 
0x30, 0xb5, 0x90, 0xa0, 0x90, 0x50, 0x90, 0x28, 0x80, 0x30, 0xac, 0x80, 
0x30, 0xb3, 0x90, 0x28, 0x80, 0x30, 0xb2, 0x80, 0x30, 0xb1, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x30, 0xad, 0x80, 0x30, 0xb0, 0x90, 0x28, 0x80, 0x30, 
0xaf, 0x80, 0x30, 0xae, 0xc3, 0xc0, 0x30, 0x42, 0x9c, 0xe8, 0x07, 0x60, 
0x91, 0x90, 0x90, 0xf0, 0x10, 0x10, 0x80, 0x88, 0x00, 0x80, 0x90, 0x50, 
0x90, 0x28, 0x80, 0x33, 0xf8, 0x80, 0x33, 0xf9, 0x81, 0x33, 0xef, 0xd0, 
0x41, 0x80, 0x24, 0x20, 0x90, 0x24, 0x20, 0x98, 0x10, 0x10, 0x80, 0x90, 
0x58, 0x80, 0x90, 0x28, 0x24, 0x1f, 0x90, 0x24, 0x1f, 0x98, 0x81, 0x24, 
0x1f, 0x50, 0x92, 0x68, 0x91, 0x00, 0x80, 0x90, 0x90, 0x90, 0x30, 0x80, 
0x24, 0x20, 0x00, 0x90, 0x38, 0xa4, 0x1f, 0xf8, 0x34, 0x06, 0x80, 0x34, 
0x05, 0x80, 0x90, 0x28, 0x80, 0x34, 0x0f, 0xa4, 0x1f, 0xe0, 0x34, 0x0e, 
0x80, 0x90, 0xc0, 0x90, 0x60, 0x90, 0x28, 0x80, 0x34, 0x09, 0xa4, 0x1f, 
0xf0, 0x34, 0x08, 0x90, 0x28, 0x80, 0x34, 0x04, 0xa4, 0x1f, 0xe8, 0x34, 
0x03, 0x90, 0x50, 0x90, 0x28, 0x80, 0x34, 0x0d, 0x80, 0x34, 0x0c, 0x90, 
0x28, 0x24, 0x20, 0x88, 0x24, 0x20, 0x80, 0x90, 0x58, 0x80, 0x10, 0x10, 
0x80, 0x10, 0x10, 0x80, 0x33, 0xfb, 0x80, 0x90, 0x40, 0x10, 0x10, 0x80, 
0x24, 0x1f, 0x60, 0x80, 0x10, 0x10, 0x80, 0x33, 0xfa, 0x91, 0x58, 0x91, 
0x00, 0x90, 0x80, 0x81, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 0xf6, 0x80, 
0x33, 0xf7, 0x81, 0x33, 0xee, 0x81, 0x90, 0x50, 0x90, 0x28, 0x80, 0x33, 
0xf4, 0x80, 0x33, 0xf5, 0x81, 0x33, 0xed, 0x83, 0x90, 0x28, 0x24, 0x1f, 
0x80, 0x24, 0x1f, 0x88, 0x90, 0xe8, 0x81, 0x90, 0x88, 0x90, 0x38, 0x10, 
0x10, 0x80, 0x34, 0x07, 0x90, 0x28, 0x80, 0x34, 0x02, 0x80, 0x34, 0x01, 
0x80, 0x90, 0x28, 0x80, 0x34, 0x0b, 0x80, 0x34, 0x0a, 0x82, 0x10, 0x10, 
0x80, 0x24, 0x1f, 0x58, 0x97, 0x10, 0x9e, 0x10, 0x06, 0x98, 0x93, 0x00, 
0x91, 0x80, 0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x03, 0x80, 0x30, 
0x71, 0x24, 0x03, 0x78, 0x90, 0x38, 0xa4, 0x04, 0x10, 0x30, 0x83, 0x24, 
0x04, 0x08, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x05, 0x30, 0x30, 0xa7, 0x24, 
0x05, 0x28, 0x90, 0x38, 0xa4, 0x04, 0xa0, 0x30, 0x95, 0x24, 0x04, 0x98, 
0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x03, 0x70, 0x30, 0x6c, 0x24, 
0x03, 0x68, 0x90, 0x38, 0xa4, 0x04, 0x00, 0x30, 0x7e, 0x24, 0x03, 0xf8, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x05, 0x20, 0x30, 0xa2, 0x24, 0x05, 0x18, 
0x90, 0x38, 0xa4, 0x04, 0x90, 0x30, 0x90, 0x24, 0x04, 0x88, 0x91, 0x80, 
0x90, 0xc0, 0x90, 0x60, 0x90, 0x38, 0xa4, 0x03, 0x58, 0x30, 0x69, 0x24, 
0x03, 0x50, 0x90, 0x38, 0xa4, 0x03, 0xe8, 0x30, 0x7b, 0x24, 0x03, 0xe0, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x05, 0x08, 0x30, 0x9f, 0x24, 0x05, 0x00, 
0x90, 0x38, 0xa4, 0x04, 0x78, 0x30, 0x8d, 0x24, 0x04, 0x70, 0x90, 0xc0, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x03, 0x40, 0x30, 0x66, 0x24, 0x03, 0x38, 
0x90, 0x38, 0xa4, 0x03, 0xd0, 0x30, 0x78, 0x24, 0x03, 0xc8, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x04, 0xf0, 0x30, 0x9c, 0x24, 0x04, 0xe8, 0x90, 0x38, 
0xa4, 0x04, 0x60, 0x30, 0x8a, 0x24, 0x04, 0x58, 0x10, 0x10, 0x80, 0x10, 
0x10, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x02, 0xf8, 0x30, 0x5d, 0x24, 0x02, 
0xf0, 0xd7, 0x42, 0x00, 0xa4, 0x38, 0x58, 0x37, 0x0d, 0xa4, 0x38, 0x38, 
0x37, 0x09, 0x9c, 0xe0, 0x06, 0x90, 0x93, 0x00, 0x91, 0x80, 0x90, 0xc0, 
0x90, 0x60, 0x90, 0x38, 0xa4, 0x03, 0x28, 0x30, 0x63, 0x24, 0x03, 0x20, 
0x90, 0x38, 0xa4, 0x03, 0xb8, 0x30, 0x75, 0x24, 0x03, 0xb0, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x04, 0xd8, 0x30, 0x99, 0x24, 0x04, 0xd0, 0x90, 0x38, 
0xa4, 0x04, 0x48, 0x30, 0x87, 0x24, 0x04, 0x40, 0x90, 0xc0, 0x90, 0x60, 
0x90, 0x38, 0xa4, 0x03, 0x10, 0x30, 0x60, 0x24, 0x03, 0x08, 0x90, 0x38, 
0xa4, 0x03, 0xa0, 0x30, 0x72, 0x24, 0x03, 0x98, 0x90, 0x60, 0x90, 0x38, 
0xa4, 0x04, 0xc0, 0x30, 0x96, 0x24, 0x04, 0xb8, 0x90, 0x38, 0xa4, 0x04, 
0x30, 0x30, 0x84, 0x24, 0x04, 0x28, 0x10, 0x10, 0x90, 0xe0, 0x90, 0x70, 
0x90, 0x38, 0xa4, 0x02, 0x88, 0x30, 0x52, 0xa4, 0x02, 0x78, 0x30, 0x50, 
0x90, 0x38, 0xa4, 0x02, 0x70, 0x30, 0x4b, 0xa4, 0x02, 0x60, 0x30, 0x4d, 
0x90, 0x70, 0x90, 0x38, 0xa4, 0x02, 0x50, 0x30, 0x43, 0xa4, 0x02, 0x40, 
0x30, 0x49, 0x90, 0x38, 0xa4, 0x02, 0x38, 0x30, 0x44, 0xa4, 0x02, 0x28, 
0x30, 0x46, 0x91, 0x48, 0x80, 0x90, 0xa0, 0x90, 0x50, 0x90, 0x28, 0x80, 
0x30, 0x56, 0x24, 0x02, 0xa8, 0x90, 0x28, 0x80, 0x30, 0x58, 0x24, 0x02, 
0xb8, 0x90, 0x50, 0x90, 0x28, 0x80, 0x30, 0x5c, 0x24, 0x02, 0xd8, 0x90, 
0x28, 0x80, 0x30, 0x5a, 0x24, 0x02, 0xc8, 0x80, 0x10, 0x10, 0x10, 0x10, 
0x90, 0x28, 0x80, 0x30, 0x53, 0x24, 0x02, 0xa0, 0xd7, 0x42, 0x00, 0xa4, 
0x38, 0x60, 0x37, 0x0e, 0xa4, 0x38, 0x40, 0x37, 0x0a, 0xa0, 0x14, 0x68, 
0xa0, 0x10, 0x90, 0xa0, 0x0c, 0x60, 0x9e, 0x88, 0x09, 0xd0, 0x94, 0xf0, 
0x90, 0xb0, 0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 0x44, 0x40, 
0x85, 0x35, 0x2d, 0xcb, 0x61, 0x3d, 0x00, 0x85, 0x35, 0x03, 0x9a, 0x00, 
0x03, 0xf8, 0x91, 0x98, 0x80, 0x91, 0x10, 0x90, 0xa0, 0x90, 0x68, 0x90, 
0x20, 0x3a, 0x53, 0xc9, 0xe2, 0x94, 0x40, 0x85, 0x35, 0x2b, 0xa4, 0x52, 
0x78, 0x3a, 0x50, 0x90, 0x38, 0xa4, 0x52, 0x40, 0x3a, 0x49, 0xa4, 0x52, 
0x30, 0x3a, 0x47, 0x90, 0x48, 0x10, 0x10, 0xa4, 0x51, 0xf8, 0x3a, 0x40, 
0x10, 0x10, 0x80, 0x3a, 0x3c, 0x81, 0x10, 0x10, 0x80, 0xa4, 0x51, 0xc8, 
0x3a, 0x3a, 0x91, 0xb0, 0x91, 0x60, 0x90, 0xe0, 0x90, 0x70, 0x90, 0x38, 
0xa4, 0x52, 0x68, 0x3a, 0x4e, 0xa4, 0x52, 0x58, 0x3a, 0x4c, 0x90, 0x38, 
0xa4, 0x52, 0x20, 0x3a, 0x45, 0xa4, 0x52, 0x10, 0x3a, 0x43, 0x90, 0x48, 
0x10, 0x10, 0xa4, 0x51, 0xe8, 0x3a, 0x3e, 0x10, 0x10, 0x80, 0x3a, 0x3b, 
0x90, 0x28, 0x80, 0x3a, 0x34, 0x80, 0x3a, 0x33, 0x81, 0x10, 0x10, 0x80, 
0xa4, 0x51, 0xb8, 0x3a, 0x38, 0xcb, 0x61, 0x3c, 0xc0, 0x85, 0x35, 0x02, 
0x90, 0xd8, 0x88, 0x00, 0x90, 0x84, 0x90, 0x38, 0xc1, 0xc0, 0x85, 0x3a, 
0x56, 0xc9, 0xe1, 0x44, 0x00, 0x85, 0x35, 0x29, 0xcb, 0x61, 0x3c, 0x80, 
0x85, 0x35, 0x01, 0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 0x43, 
0xc0, 0x85, 0x35, 0x27, 0xcb, 0x61, 0x3c, 0x40, 0x85, 0x35, 0x00, 0x91, 
0xf8, 0x90, 0xb0, 0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 0x43, 
0x40, 0x85, 0x35, 0x23, 0xcb, 0x61, 0x3b, 0xc0, 0x85, 0x34, 0xfe, 0x88, 
0x01, 0x00, 0x90, 0xa0, 0x81, 0x90, 0x70, 0x80, 0x90, 0x20, 0x3a, 0x4a, 
0xc9, 0xe1, 0x43, 0x00, 0x85, 0x35, 0x21, 0x81, 0x3a, 0x41, 0x81, 0x10, 
0x10, 0x80, 0xa4, 0x51, 0xa8, 0x3a, 0x36, 0xcb, 0x61, 0x3b, 0x80, 0x85, 
0x34, 0xfd, 0x90, 0xb0, 0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 
0x42, 0xc0, 0x85, 0x35, 0x1f, 0xcb, 0x61, 0x3b, 0x40, 0x85, 0x34, 0xfc, 
0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 0x42, 0x80, 0x85, 0x35, 
0x1d, 0xcb, 0x61, 0x3b, 0x00, 0x85, 0x34, 0xfb, 0x92, 0x38, 0x81, 0x91, 
0x68, 0x91, 0x18, 0x90, 0x80, 0x90, 0x40, 0x80, 0xa4, 0x53, 0x28, 0x3a, 
0x66, 0x80, 0xa4, 0x53, 0x20, 0x3a, 0x63, 0x90, 0x28, 0x81, 0x3a, 0x62, 
0x90, 0x38, 0xa4, 0x53, 0x00, 0x3a, 0x61, 0xa4, 0x52, 0xf0, 0x3a, 0x5f, 
0x90, 0x28, 0x80, 0x3a, 0x5d, 0x80, 0x3a, 0x5c, 0x80, 0x90, 0x40, 0x10, 
0x10, 0x80, 0x24, 0x52, 0xd8, 0x10, 0x10, 0x90, 0x38, 0xa4, 0x52, 0xc8, 
0x3a, 0x5a, 0xa4, 0x52, 0xb8, 0x3a, 0x58, 0x90, 0x28, 0x80, 0x3a, 0x55, 
0x80, 0x3a, 0x54, 0x9a, 0xd0, 0x03, 0xe0, 0x91, 0x60, 0x90, 0xb0, 0x88, 
0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 0x42, 0x00, 0x85, 0x35, 0x19, 
0xcb, 0x61, 0x3a, 0x80, 0x85, 0x34, 0xf9, 0x88, 0x00, 0x68, 0x84, 0x10, 
0x10, 0xc9, 0xe1, 0x41, 0xc0, 0x85, 0x35, 0x17, 0xcb, 0x61, 0x3a, 0x40, 
0x85, 0x34, 0xf8, 0x90, 0xb0, 0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 
0xe1, 0x41, 0x80, 0x85, 0x35, 0x15, 0xcb, 0x61, 0x3a, 0x00, 0x85, 0x34, 
0xf7, 0x88, 0x00, 0x68, 0x84, 0x10, 0x10, 0xc9, 0xe1, 0x41, 0x40, 0x85, 
0x35, 0x13, 0xcb, 0x61, 0x39, 0xc0, 0x85, 0x34, 0xf6, 0x90, 0x90, 0x90, 
0x48, 0xcb, 0xa1, 0x38, 0x00, 0x85, 0x34, 0xe5, 0xcb, 0xa1, 0x37, 0xc0, 
0x85, 0x34, 0xe4, 0x90, 0x48, 0xcb, 0xa1, 0x37, 0x80, 0x85, 0x34, 0xe3, 
0xcb, 0xa1, 0x37, 0x40, 0x85, 0x34, 0xe2, 0xcb, 0xa2, 0x8c, 0x40, 0x80, 
0x3a, 0x32, 0x92, 0x40, 0x91, 0x20, 0x90, 0x90, 0x90, 0x48, 0x8c, 0x26, 
0x60, 0x84, 0x24, 0x26, 0xd8, 0x8c, 0x26, 0x58, 0x84, 0x24, 0x26, 0xd0, 
0x90, 0x48, 0x8c, 0x26, 0x50, 0x84, 0x24, 0x26, 0xc8, 0x8c, 0x26, 0x48, 
0x84, 0x24, 0x26, 0xc0, 0x90, 0x90, 0x90, 0x48, 0x8c, 0x26, 0x38, 0x84, 
0x24, 0x26, 0xb0, 0x8c, 0x26, 0x30, 0x84, 0x24, 0x26, 0xa8, 0x90, 0x48, 
0x8c, 0x26, 0x28, 0x84, 0x24, 0x26, 0xa0, 0x8c, 0x26, 0x20, 0x84, 0x24, 
0x26, 0x98, 0x91, 0x20, 0x90, 0x90, 0x90, 0x48, 0x8c, 0x26, 0x10, 0x84, 
0x24, 0x26, 0x88, 0x8c, 0x26, 0x08, 0x84, 0x24, 0x26, 0x80, 0x90, 0x48, 
0x8c, 0x26, 0x00, 0x84, 0x24, 0x26, 0x78, 0x8c, 0x25, 0xf8, 0x84, 0x24, 
0x26, 0x70, 0x90, 0x38, 0xa4, 0x25, 0xe0, 0x34, 0xbd, 0xa4, 0x25, 0xd0, 
0x34, 0xbb, 0xa0, 0x0f, 0x50, 0xa0, 0x09, 0x08, 0x9a, 0x30, 0x04, 0x40, 
0x91, 0x90, 0x90, 0xc8, 0x98, 0x50, 0x00, 0x80, 0xe5, 0x22, 0x8a, 0x40, 
0x3a, 0x21, 0xe5, 0x22, 0x82, 0x40, 0x3a, 0x1d, 0xcb, 0x61, 0x2a, 0x40, 
0x85, 0x34, 0xb8, 0x98, 0x50, 0x00, 0x80, 0xe5, 0x22, 0x7a, 0x40, 0x39, 
0xe1, 0xe5, 0x22, 0x72, 0x40, 0x39, 0xdd, 0xcb, 0x61, 0x2a, 0x00, 0x85, 
0x34, 0xb7, 0x90, 0x48, 0xcb, 0xa1, 0x29, 0xc0, 0x85, 0x34, 0xb6, 0xcb, 
0xa1, 0x29, 0x80, 0x85, 0x34, 0xb5, 0x91, 0x90, 0x90, 0xc8, 0x98, 0x50, 
0x00, 0x80, 0xe5, 0x22, 0x64, 0x40, 0x39, 0xa9, 0xe5, 0x22, 0x58, 0x40, 
0x39, 0x79, 0xcb, 0x61, 0x29, 0x00, 0x85, 0x34, 0xb3, 0x98, 0x50, 0x00, 
0x80, 0xe5, 0x22, 0x4c, 0x40, 0x39, 0x49, 0xe5, 0x22, 0x40, 0x40, 0x39, 
0x19, 0xcb, 0x61, 0x28, 0xc0, 0x85, 0x34, 0xb2, 0x90, 0x48, 0xcb, 0xa1, 
0x28, 0x80, 0x85, 0x34, 0xb1, 0xcb, 0xa1, 0x28, 0x40, 0x85, 0x34, 0xb0, 
0x92, 0x20, 0x91, 0x30, 0x90, 0xb8, 0xd5, 0x03, 0x00, 0xc0, 0xc0, 0x81, 
0x8c, 0x01, 0xa0, 0x84, 0x30, 0x3e, 0xc0, 0xc0, 0x81, 0x8c, 0x01, 0x80, 
0x84, 0x30, 0x3c, 0xd5, 0x02, 0x00, 0xc0, 0xc0, 0x81, 0x30, 0x28, 0xc0, 
0xc0, 0x81, 0x30, 0x24, 0x90, 0x78, 0xd5, 0x02, 0x00, 0xc0, 0xc0, 0x81, 
0x30, 0x1c, 0xc0, 0xc0, 0x81, 0x30, 0x18, 0xd5, 0x02, 0x00, 0xc0, 0xc0, 
0x81, 0x30, 0x10, 0xc0, 0xc0, 0x81, 0x30, 0x0c, 0x91, 0x70, 0x90, 0xd8, 
0xd5, 0x03, 0x80, 0xc8, 0xe2, 0x38, 0x40, 0x81, 0x8c, 0x01, 0xc0, 0x84, 
0x30, 0x40, 0xc8, 0xe2, 0x3a, 0x40, 0x81, 0x8c, 0x01, 0x90, 0x84, 0x30, 
0x3d, 0xd5, 0x02, 0x80, 0xc8, 0xe2, 0x37, 0x40, 0x81, 0x30, 0x2c, 0xc8, 
0xe2, 0x31, 0xc0, 0x81, 0x30, 0x26, 0x90, 0x98, 0xd5, 0x02, 0x80, 0xc8, 
0xe2, 0x26, 0xc0, 0x81, 0x30, 0x20, 0xc8, 0xe2, 0x28, 0xc0, 0x81, 0x30, 
0x1a, 0xd5, 0x02, 0x80, 0xc8, 0xe2, 0x25, 0xc0, 0x81, 0x30, 0x14, 0xc8, 
0xe2, 0x20, 0x40, 0x81, 0x30, 0x0e, 0x9a, 0x30, 0x04, 0x40, 0x91, 0x90, 
0x90, 0xc8, 0x98, 0x50, 0x00, 0x80, 0xe5, 0x22, 0x7e, 0x40, 0x39, 0xf1, 
0xe5, 0x22, 0x80, 0x40, 0x3a, 0x15, 0xcb, 0x61, 0x27, 0xc0, 0x85, 0x34, 
0xae, 0x98, 0x50, 0x00, 0x80, 0xe5, 0x22, 0x6e, 0x40, 0x39, 0xb1, 0xe5, 
0x22, 0x70, 0x40, 0x39, 0xd5, 0xcb, 0x61, 0x27, 0x80, 0x85, 0x34, 0xad, 
0x90, 0x48, 0xcb, 0xa1, 0x27, 0x40, 0x85, 0x34, 0xac, 0xcb, 0xa1, 0x27, 
0x00, 0x85, 0x34, 0xab, 0x91, 0x90, 0x90, 0xc8, 0x98, 0x50, 0x00, 0x80, 
0xe5, 0x22, 0x60, 0x40, 0x39, 0x99, 0xe5, 0x22, 0x54, 0x40, 0x39, 0x69, 
0xcb, 0x61, 0x25, 0x40, 0x85, 0x34, 0x9a, 0x98, 0x50, 0x00, 0x80, 0xe5, 
0x22, 0x48, 0x40, 0x39, 0x39, 0xe5, 0x22, 0x3c, 0x40, 0x39, 0x09, 0xcb, 
0x61, 0x25, 0x00, 0x85, 0x34, 0x99, 0x90, 0x48, 0xcb, 0xa1, 0x24, 0xc0, 
0x85, 0x34, 0x98, 0xcb, 0xa1, 0x24, 0x80, 0x85, 0x34, 0x97, 0x91, 0x00, 
0x90, 0x80, 0x90, 0x40, 0xe5, 0x20, 0x02, 0x40, 0x30, 0x0a, 0xe5, 0x20, 
0x01, 0x80, 0x30, 0x07, 0x90, 0x40, 0xe5, 0x20, 0x00, 0xc0, 0x30, 0x04, 
0xe5, 0x20, 0x00, 0x00, 0x30, 0x01, 0x90, 0x80, 0x90, 0x40, 0xe5, 0x22, 
0x2d, 0x40, 0x38, 0xab, 0xe5, 0x22, 0x2f, 0x80, 0x38, 0xd3, 0x90, 0x40, 
0xe5, 0x22, 0x1b, 0xc0, 0x38, 0x65, 0xe5, 0x22, 0x1e, 0x00, 0x38, 0x8d, 
0x80, 0x99, 0x28, 0x02, 0xf0, 0x8c, 0x24, 0x48, 0x90, 0x80, 0x90, 0x40, 
0xe5, 0x22, 0x84, 0x40, 0x3a, 0x0d, 0xe5, 0x22, 0x81, 0x40, 0x3a, 0x19, 
0x90, 0x40, 0xe5, 0x22, 0x74, 0x40, 0x39, 0xcd, 0xe5, 0x22, 0x71, 0x40, 
0x39, 0xd9, 0x91, 0x48, 0x90, 0xc8, 0x98, 0x50, 0x00, 0x80, 0xe5, 0x22, 
0x62, 0x40, 0x39, 0xa1, 0xe5, 0x22, 0x56, 0x40, 0x39, 0x71, 0xcb, 0x61, 
0x23, 0x00, 0x85, 0x34, 0x90, 0x90, 0x40, 0xe5, 0x22, 0x4a, 0x40, 0x39, 
0x41, 0xe5, 0x22, 0x3e, 0x40, 0x39, 0x11, 0x90, 0x48, 0xcb, 0xa1, 0x22, 
0x80, 0x85, 0x34, 0x8e, 0xcb, 0xa1, 0x22, 0xc0, 0x85, 0x34, 0x8f, 0x10, 
0x10, 0x90, 0x80, 0x90, 0x40, 0xe5, 0x22, 0x33, 0xc0, 0x38, 0xcb, 0xe5, 
0x22, 0x30, 0xc0, 0x38, 0xd9, 0x90, 0x40, 0xe5, 0x22, 0x22, 0x40, 0x38, 
0x85, 0xe5, 0x22, 0x1f, 0x40, 0x38, 0x93, 
};

static const struct ia64_dis_names ia64_dis_names[] = {
{ 0x51, 41, 0, 10 },
{ 0x31, 41, 1, 20 },
{ 0x11, 42, 0, 19 },
{ 0x29, 41, 0, 12 },
{ 0x19, 41, 1, 24 },
{ 0x9, 42, 0, 23 },
{ 0x15, 41, 0, 14 },
{ 0xd, 41, 1, 28 },
{ 0x5, 42, 0, 27 },
{ 0xb, 41, 0, 16 },
{ 0x7, 41, 1, 32 },
{ 0x3, 42, 0, 31 },
{ 0x51, 39, 1, 58 },
{ 0x50, 39, 0, 34 },
{ 0xd1, 39, 1, 57 },
{ 0xd0, 39, 0, 33 },
{ 0x31, 39, 1, 68 },
{ 0x30, 39, 1, 44 },
{ 0x11, 40, 1, 67 },
{ 0x10, 40, 0, 43 },
{ 0x71, 39, 1, 66 },
{ 0x70, 39, 1, 42 },
{ 0x31, 40, 1, 65 },
{ 0x30, 40, 0, 41 },
{ 0x29, 39, 1, 60 },
{ 0x28, 39, 0, 36 },
{ 0x69, 39, 1, 59 },
{ 0x68, 39, 0, 35 },
{ 0x19, 39, 1, 72 },
{ 0x18, 39, 1, 48 },
{ 0x9, 40, 1, 71 },
{ 0x8, 40, 0, 47 },
{ 0x39, 39, 1, 70 },
{ 0x38, 39, 1, 46 },
{ 0x19, 40, 1, 69 },
{ 0x18, 40, 0, 45 },
{ 0x15, 39, 1, 62 },
{ 0x14, 39, 0, 38 },
{ 0x35, 39, 1, 61 },
{ 0x34, 39, 0, 37 },
{ 0xd, 39, 1, 76 },
{ 0xc, 39, 1, 52 },
{ 0x5, 40, 1, 75 },
{ 0x4, 40, 0, 51 },
{ 0x1d, 39, 1, 74 },
{ 0x1c, 39, 1, 50 },
{ 0xd, 40, 1, 73 },
{ 0xc, 40, 0, 49 },
{ 0xb, 39, 1, 64 },
{ 0xa, 39, 0, 40 },
{ 0x1b, 39, 1, 63 },
{ 0x1a, 39, 0, 39 },
{ 0x7, 39, 1, 80 },
{ 0x6, 39, 1, 56 },
{ 0x3, 40, 1, 79 },
{ 0x2, 40, 0, 55 },
{ 0xf, 39, 1, 78 },
{ 0xe, 39, 1, 54 },
{ 0x7, 40, 1, 77 },
{ 0x6, 40, 0, 53 },
{ 0x8, 38, 0, 82 },
{ 0x18, 38, 0, 81 },
{ 0x1, 38, 1, 86 },
{ 0x2, 38, 0, 85 },
{ 0x3, 38, 1, 84 },
{ 0x4, 38, 0, 83 },
{ 0x1, 336, 0, 87 },
{ 0x20, 289, 0, 98 },
{ 0x220, 289, 0, 94 },
{ 0x1220, 289, 0, 91 },
{ 0xa20, 289, 0, 92 },
{ 0x620, 289, 0, 93 },
{ 0x120, 289, 0, 95 },
{ 0xa0, 289, 0, 96 },
{ 0x60, 289, 0, 97 },
{ 0x10, 289, 0, 102 },
{ 0x90, 289, 0, 99 },
{ 0x50, 289, 0, 100 },
{ 0x30, 289, 0, 101 },
{ 0x8, 289, 0, 103 },
{ 0x4, 289, 0, 104 },
{ 0x2, 289, 0, 105 },
{ 0x1, 289, 0, 106 },
{ 0x1, 411, 0, 108 },
{ 0x3, 411, 0, 107 },
{ 0x2, 417, 0, 109 },
{ 0x1, 417, 0, 110 },
{ 0x2, 413, 0, 111 },
{ 0x1, 413, 0, 112 },
{ 0x2, 415, 0, 113 },
{ 0x1, 415, 0, 114 },
{ 0x2, 419, 0, 115 },
{ 0x1, 419, 0, 116 },
{ 0x1, 268, 0, 143 },
{ 0x5, 268, 0, 141 },
{ 0x3, 268, 0, 142 },
{ 0x140, 277, 0, 119 },
{ 0x540, 277, 0, 117 },
{ 0x340, 277, 0, 118 },
{ 0xc0, 277, 0, 131 },
{ 0x2c0, 277, 0, 129 },
{ 0x1c0, 277, 0, 130 },
{ 0x20, 277, 0, 146 },
{ 0xa0, 277, 0, 144 },
{ 0x60, 277, 0, 145 },
{ 0x10, 277, 0, 158 },
{ 0x50, 277, 0, 156 },
{ 0x30, 277, 0, 157 },
{ 0x8, 277, 0, 170 },
{ 0x28, 277, 0, 168 },
{ 0x18, 277, 0, 169 },
{ 0x4, 277, 0, 180 },
{ 0x2, 277, 0, 181 },
{ 0x1, 277, 0, 182 },
{ 0x140, 271, 0, 122 },
{ 0x540, 271, 0, 120 },
{ 0x340, 271, 0, 121 },
{ 0xc0, 271, 0, 134 },
{ 0x2c0, 271, 0, 132 },
{ 0x1c0, 271, 0, 133 },
{ 0x20, 271, 0, 149 },
{ 0xa0, 271, 0, 147 },
{ 0x60, 271, 0, 148 },
{ 0x10, 271, 0, 161 },
{ 0x50, 271, 0, 159 },
{ 0x30, 271, 0, 160 },
{ 0x8, 271, 0, 173 },
{ 0x28, 271, 0, 171 },
{ 0x18, 271, 0, 172 },
{ 0x4, 271, 0, 183 },
{ 0x2, 271, 0, 184 },
{ 0x1, 271, 0, 185 },
{ 0x140, 274, 0, 125 },
{ 0x540, 274, 0, 123 },
{ 0x340, 274, 0, 124 },
{ 0xc0, 274, 0, 137 },
{ 0x2c0, 274, 0, 135 },
{ 0x1c0, 274, 0, 136 },
{ 0x20, 274, 0, 152 },
{ 0xa0, 274, 0, 150 },
{ 0x60, 274, 0, 151 },
{ 0x10, 274, 0, 164 },
{ 0x50, 274, 0, 162 },
{ 0x30, 274, 0, 163 },
{ 0x8, 274, 0, 176 },
{ 0x28, 274, 0, 174 },
{ 0x18, 274, 0, 175 },
{ 0x4, 274, 0, 186 },
{ 0x2, 274, 0, 187 },
{ 0x1, 274, 0, 188 },
{ 0x140, 286, 0, 128 },
{ 0x540, 286, 0, 126 },
{ 0x340, 286, 0, 127 },
{ 0xc0, 286, 0, 140 },
{ 0x2c0, 286, 0, 138 },
{ 0x1c0, 286, 0, 139 },
{ 0x20, 286, 0, 155 },
{ 0xa0, 286, 0, 153 },
{ 0x60, 286, 0, 154 },
{ 0x10, 286, 0, 167 },
{ 0x50, 286, 0, 165 },
{ 0x30, 286, 0, 166 },
{ 0x8, 286, 0, 179 },
{ 0x28, 286, 0, 177 },
{ 0x18, 286, 0, 178 },
{ 0x4, 286, 0, 189 },
{ 0x2, 286, 0, 190 },
{ 0x1, 286, 0, 191 },
{ 0x8, 390, 0, 192 },
{ 0x4, 390, 0, 193 },
{ 0x2, 390, 0, 194 },
{ 0x1, 390, 0, 195 },
{ 0x20, 288, 0, 203 },
{ 0x220, 288, 0, 199 },
{ 0x1220, 288, 0, 196 },
{ 0xa20, 288, 0, 197 },
{ 0x620, 288, 0, 198 },
{ 0x120, 288, 0, 200 },
{ 0xa0, 288, 0, 201 },
{ 0x60, 288, 0, 202 },
{ 0x10, 288, 0, 207 },
{ 0x90, 288, 0, 204 },
{ 0x50, 288, 0, 205 },
{ 0x30, 288, 0, 206 },
{ 0x8, 288, 0, 208 },
{ 0x4, 288, 0, 209 },
{ 0x2, 288, 0, 210 },
{ 0x1, 288, 0, 211 },
{ 0x20, 287, 0, 219 },
{ 0x220, 287, 0, 215 },
{ 0x1220, 287, 0, 212 },
{ 0xa20, 287, 0, 213 },
{ 0x620, 287, 0, 214 },
{ 0x120, 287, 0, 216 },
{ 0xa0, 287, 0, 217 },
{ 0x60, 287, 0, 218 },
{ 0x10, 287, 0, 223 },
{ 0x90, 287, 0, 220 },
{ 0x50, 287, 0, 221 },
{ 0x30, 287, 0, 222 },
{ 0x8, 287, 0, 224 },
{ 0x4, 287, 0, 225 },
{ 0x2, 287, 0, 226 },
{ 0x1, 287, 0, 227 },
{ 0x140, 279, 0, 230 },
{ 0x540, 279, 0, 228 },
{ 0x340, 279, 0, 229 },
{ 0xc0, 279, 0, 239 },
{ 0x2c0, 279, 0, 237 },
{ 0x1c0, 279, 0, 238 },
{ 0x20, 279, 0, 248 },
{ 0xa0, 279, 0, 246 },
{ 0x60, 279, 0, 247 },
{ 0x10, 279, 0, 257 },
{ 0x50, 279, 0, 255 },
{ 0x30, 279, 0, 256 },
{ 0x8, 279, 0, 266 },
{ 0x28, 279, 0, 264 },
{ 0x18, 279, 0, 265 },
{ 0x4, 279, 0, 273 },
{ 0x2, 279, 0, 274 },
{ 0x1, 279, 0, 275 },
{ 0x140, 281, 0, 233 },
{ 0x540, 281, 0, 231 },
{ 0x340, 281, 0, 232 },
{ 0xc0, 281, 0, 242 },
{ 0x2c0, 281, 0, 240 },
{ 0x1c0, 281, 0, 241 },
{ 0x20, 281, 0, 251 },
{ 0xa0, 281, 0, 249 },
{ 0x60, 281, 0, 250 },
{ 0x10, 281, 0, 260 },
{ 0x50, 281, 0, 258 },
{ 0x30, 281, 0, 259 },
{ 0x8, 281, 0, 269 },
{ 0x28, 281, 0, 267 },
{ 0x18, 281, 0, 268 },
{ 0x4, 281, 0, 276 },
{ 0x2, 281, 0, 277 },
{ 0x1, 281, 0, 278 },
{ 0x140, 283, 0, 236 },
{ 0x540, 283, 0, 234 },
{ 0x340, 283, 0, 235 },
{ 0xc0, 283, 0, 245 },
{ 0x2c0, 283, 0, 243 },
{ 0x1c0, 283, 0, 244 },
{ 0x20, 283, 0, 254 },
{ 0xa0, 283, 0, 252 },
{ 0x60, 283, 0, 253 },
{ 0x10, 283, 0, 263 },
{ 0x50, 283, 0, 261 },
{ 0x30, 283, 0, 262 },
{ 0x8, 283, 0, 272 },
{ 0x28, 283, 0, 270 },
{ 0x18, 283, 0, 271 },
{ 0x4, 283, 0, 279 },
{ 0x2, 283, 0, 280 },
{ 0x1, 283, 0, 281 },
{ 0x140, 278, 0, 284 },
{ 0x540, 278, 0, 282 },
{ 0x340, 278, 0, 283 },
{ 0xc0, 278, 0, 293 },
{ 0x2c0, 278, 0, 291 },
{ 0x1c0, 278, 0, 292 },
{ 0x20, 278, 0, 302 },
{ 0xa0, 278, 0, 300 },
{ 0x60, 278, 0, 301 },
{ 0x10, 278, 0, 311 },
{ 0x50, 278, 0, 309 },
{ 0x30, 278, 0, 310 },
{ 0x8, 278, 0, 320 },
{ 0x28, 278, 0, 318 },
{ 0x18, 278, 0, 319 },
{ 0x4, 278, 0, 327 },
{ 0x2, 278, 0, 328 },
{ 0x1, 278, 0, 329 },
{ 0x140, 280, 0, 287 },
{ 0x540, 280, 0, 285 },
{ 0x340, 280, 0, 286 },
{ 0xc0, 280, 0, 296 },
{ 0x2c0, 280, 0, 294 },
{ 0x1c0, 280, 0, 295 },
{ 0x20, 280, 0, 305 },
{ 0xa0, 280, 0, 303 },
{ 0x60, 280, 0, 304 },
{ 0x10, 280, 0, 314 },
{ 0x50, 280, 0, 312 },
{ 0x30, 280, 0, 313 },
{ 0x8, 280, 0, 323 },
{ 0x28, 280, 0, 321 },
{ 0x18, 280, 0, 322 },
{ 0x4, 280, 0, 330 },
{ 0x2, 280, 0, 331 },
{ 0x1, 280, 0, 332 },
{ 0x140, 282, 0, 290 },
{ 0x540, 282, 0, 288 },
{ 0x340, 282, 0, 289 },
{ 0xc0, 282, 0, 299 },
{ 0x2c0, 282, 0, 297 },
{ 0x1c0, 282, 0, 298 },
{ 0x20, 282, 0, 308 },
{ 0xa0, 282, 0, 306 },
{ 0x60, 282, 0, 307 },
{ 0x10, 282, 0, 317 },
{ 0x50, 282, 0, 315 },
{ 0x30, 282, 0, 316 },
{ 0x8, 282, 0, 326 },
{ 0x28, 282, 0, 324 },
{ 0x18, 282, 0, 325 },
{ 0x4, 282, 0, 333 },
{ 0x2, 282, 0, 334 },
{ 0x1, 282, 0, 335 },
{ 0x1, 410, 0, 337 },
{ 0x3, 410, 0, 336 },
{ 0x2, 416, 0, 338 },
{ 0x1, 416, 0, 339 },
{ 0x2, 412, 0, 340 },
{ 0x1, 412, 0, 341 },
{ 0x2, 414, 0, 342 },
{ 0x1, 414, 0, 343 },
{ 0x2, 418, 0, 344 },
{ 0x1, 418, 0, 345 },
{ 0x1, 267, 0, 372 },
{ 0x5, 267, 0, 370 },
{ 0x3, 267, 0, 371 },
{ 0x140, 276, 0, 348 },
{ 0x540, 276, 0, 346 },
{ 0x340, 276, 0, 347 },
{ 0xc0, 276, 0, 360 },
{ 0x2c0, 276, 0, 358 },
{ 0x1c0, 276, 0, 359 },
{ 0x20, 276, 0, 375 },
{ 0xa0, 276, 0, 373 },
{ 0x60, 276, 0, 374 },
{ 0x10, 276, 0, 387 },
{ 0x50, 276, 0, 385 },
{ 0x30, 276, 0, 386 },
{ 0x8, 276, 0, 399 },
{ 0x28, 276, 0, 397 },
{ 0x18, 276, 0, 398 },
{ 0x4, 276, 0, 409 },
{ 0x2, 276, 0, 410 },
{ 0x1, 276, 0, 411 },
{ 0x140, 270, 0, 351 },
{ 0x540, 270, 0, 349 },
{ 0x340, 270, 0, 350 },
{ 0xc0, 270, 0, 363 },
{ 0x2c0, 270, 0, 361 },
{ 0x1c0, 270, 0, 362 },
{ 0x20, 270, 0, 378 },
{ 0xa0, 270, 0, 376 },
{ 0x60, 270, 0, 377 },
{ 0x10, 270, 0, 390 },
{ 0x50, 270, 0, 388 },
{ 0x30, 270, 0, 389 },
{ 0x8, 270, 0, 402 },
{ 0x28, 270, 0, 400 },
{ 0x18, 270, 0, 401 },
{ 0x4, 270, 0, 412 },
{ 0x2, 270, 0, 413 },
{ 0x1, 270, 0, 414 },
{ 0x140, 273, 0, 354 },
{ 0x540, 273, 0, 352 },
{ 0x340, 273, 0, 353 },
{ 0xc0, 273, 0, 366 },
{ 0x2c0, 273, 0, 364 },
{ 0x1c0, 273, 0, 365 },
{ 0x20, 273, 0, 381 },
{ 0xa0, 273, 0, 379 },
{ 0x60, 273, 0, 380 },
{ 0x10, 273, 0, 393 },
{ 0x50, 273, 0, 391 },
{ 0x30, 273, 0, 392 },
{ 0x8, 273, 0, 405 },
{ 0x28, 273, 0, 403 },
{ 0x18, 273, 0, 404 },
{ 0x4, 273, 0, 415 },
{ 0x2, 273, 0, 416 },
{ 0x1, 273, 0, 417 },
{ 0x140, 285, 0, 357 },
{ 0x540, 285, 0, 355 },
{ 0x340, 285, 0, 356 },
{ 0xc0, 285, 0, 369 },
{ 0x2c0, 285, 0, 367 },
{ 0x1c0, 285, 0, 368 },
{ 0x20, 285, 0, 384 },
{ 0xa0, 285, 0, 382 },
{ 0x60, 285, 0, 383 },
{ 0x10, 285, 0, 396 },
{ 0x50, 285, 0, 394 },
{ 0x30, 285, 0, 395 },
{ 0x8, 285, 0, 408 },
{ 0x28, 285, 0, 406 },
{ 0x18, 285, 0, 407 },
{ 0x4, 285, 0, 418 },
{ 0x2, 285, 0, 419 },
{ 0x1, 285, 0, 420 },
{ 0x1, 266, 0, 447 },
{ 0x5, 266, 0, 445 },
{ 0x3, 266, 0, 446 },
{ 0x140, 275, 0, 423 },
{ 0x540, 275, 0, 421 },
{ 0x340, 275, 0, 422 },
{ 0xc0, 275, 0, 435 },
{ 0x2c0, 275, 0, 433 },
{ 0x1c0, 275, 0, 434 },
{ 0x20, 275, 0, 450 },
{ 0xa0, 275, 0, 448 },
{ 0x60, 275, 0, 449 },
{ 0x10, 275, 0, 462 },
{ 0x50, 275, 0, 460 },
{ 0x30, 275, 0, 461 },
{ 0x8, 275, 0, 474 },
{ 0x28, 275, 0, 472 },
{ 0x18, 275, 0, 473 },
{ 0x4, 275, 0, 484 },
{ 0x2, 275, 0, 485 },
{ 0x1, 275, 0, 486 },
{ 0x140, 269, 0, 426 },
{ 0x540, 269, 0, 424 },
{ 0x340, 269, 0, 425 },
{ 0xc0, 269, 0, 438 },
{ 0x2c0, 269, 0, 436 },
{ 0x1c0, 269, 0, 437 },
{ 0x20, 269, 0, 453 },
{ 0xa0, 269, 0, 451 },
{ 0x60, 269, 0, 452 },
{ 0x10, 269, 0, 465 },
{ 0x50, 269, 0, 463 },
{ 0x30, 269, 0, 464 },
{ 0x8, 269, 0, 477 },
{ 0x28, 269, 0, 475 },
{ 0x18, 269, 0, 476 },
{ 0x4, 269, 0, 487 },
{ 0x2, 269, 0, 488 },
{ 0x1, 269, 0, 489 },
{ 0x140, 272, 0, 429 },
{ 0x540, 272, 0, 427 },
{ 0x340, 272, 0, 428 },
{ 0xc0, 272, 0, 441 },
{ 0x2c0, 272, 0, 439 },
{ 0x1c0, 272, 0, 440 },
{ 0x20, 272, 0, 456 },
{ 0xa0, 272, 0, 454 },
{ 0x60, 272, 0, 455 },
{ 0x10, 272, 0, 468 },
{ 0x50, 272, 0, 466 },
{ 0x30, 272, 0, 467 },
{ 0x8, 272, 0, 480 },
{ 0x28, 272, 0, 478 },
{ 0x18, 272, 0, 479 },
{ 0x4, 272, 0, 490 },
{ 0x2, 272, 0, 491 },
{ 0x1, 272, 0, 492 },
{ 0x140, 284, 0, 432 },
{ 0x540, 284, 0, 430 },
{ 0x340, 284, 0, 431 },
{ 0xc0, 284, 0, 444 },
{ 0x2c0, 284, 0, 442 },
{ 0x1c0, 284, 0, 443 },
{ 0x20, 284, 0, 459 },
{ 0xa0, 284, 0, 457 },
{ 0x60, 284, 0, 458 },
{ 0x10, 284, 0, 471 },
{ 0x50, 284, 0, 469 },
{ 0x30, 284, 0, 470 },
{ 0x8, 284, 0, 483 },
{ 0x28, 284, 0, 481 },
{ 0x18, 284, 0, 482 },
{ 0x4, 284, 0, 493 },
{ 0x2, 284, 0, 494 },
{ 0x1, 284, 0, 495 },
{ 0x8, 409, 0, 497 },
{ 0x18, 409, 0, 496 },
{ 0x4, 409, 0, 499 },
{ 0xc, 409, 0, 498 },
{ 0x2, 409, 0, 506 },
{ 0x1, 409, 0, 507 },
{ 0x4, 407, 0, 501 },
{ 0xc, 407, 0, 500 },
{ 0x2, 407, 0, 508 },
{ 0x1, 407, 0, 509 },
{ 0x4, 405, 0, 503 },
{ 0xc, 405, 0, 502 },
{ 0x2, 405, 0, 510 },
{ 0x1, 405, 0, 511 },
{ 0x4, 401, 0, 505 },
{ 0xc, 401, 0, 504 },
{ 0x2, 401, 0, 512 },
{ 0x1, 401, 0, 513 },
{ 0xa00, 265, 0, 528 },
{ 0x2a00, 265, 0, 526 },
{ 0x1a00, 265, 0, 527 },
{ 0x600, 265, 0, 540 },
{ 0x2600, 265, 0, 516 },
{ 0xa600, 265, 0, 514 },
{ 0x6600, 265, 0, 515 },
{ 0x1600, 265, 0, 538 },
{ 0xe00, 265, 0, 539 },
{ 0x100, 265, 0, 552 },
{ 0x500, 265, 0, 550 },
{ 0x300, 265, 0, 551 },
{ 0x80, 265, 0, 555 },
{ 0x280, 265, 0, 553 },
{ 0x180, 265, 0, 554 },
{ 0x40, 265, 0, 567 },
{ 0x140, 265, 0, 565 },
{ 0xc0, 265, 0, 566 },
{ 0x20, 265, 0, 579 },
{ 0xa0, 265, 0, 577 },
{ 0x60, 265, 0, 578 },
{ 0x10, 265, 0, 591 },
{ 0x50, 265, 0, 589 },
{ 0x30, 265, 0, 590 },
{ 0x8, 265, 0, 603 },
{ 0x28, 265, 0, 601 },
{ 0x18, 265, 0, 602 },
{ 0x4, 265, 0, 613 },
{ 0x2, 265, 0, 614 },
{ 0x1, 265, 0, 615 },
{ 0x500, 261, 0, 531 },
{ 0x1500, 261, 0, 529 },
{ 0xd00, 261, 0, 530 },
{ 0x300, 261, 0, 543 },
{ 0x1300, 261, 0, 519 },
{ 0x5300, 261, 0, 517 },
{ 0x3300, 261, 0, 518 },
{ 0xb00, 261, 0, 541 },
{ 0x700, 261, 0, 542 },
{ 0x80, 261, 0, 558 },
{ 0x280, 261, 0, 556 },
{ 0x180, 261, 0, 557 },
{ 0x40, 261, 0, 570 },
{ 0x140, 261, 0, 568 },
{ 0xc0, 261, 0, 569 },
{ 0x20, 261, 0, 582 },
{ 0xa0, 261, 0, 580 },
{ 0x60, 261, 0, 581 },
{ 0x10, 261, 0, 594 },
{ 0x50, 261, 0, 592 },
{ 0x30, 261, 0, 593 },
{ 0x8, 261, 0, 606 },
{ 0x28, 261, 0, 604 },
{ 0x18, 261, 0, 605 },
{ 0x4, 261, 0, 616 },
{ 0x2, 261, 0, 617 },
{ 0x1, 261, 0, 618 },
{ 0x500, 258, 0, 534 },
{ 0x1500, 258, 0, 532 },
{ 0xd00, 258, 0, 533 },
{ 0x300, 258, 0, 546 },
{ 0x1300, 258, 0, 522 },
{ 0x5300, 258, 0, 520 },
{ 0x3300, 258, 0, 521 },
{ 0xb00, 258, 0, 544 },
{ 0x700, 258, 0, 545 },
{ 0x80, 258, 0, 561 },
{ 0x280, 258, 0, 559 },
{ 0x180, 258, 0, 560 },
{ 0x40, 258, 0, 573 },
{ 0x140, 258, 0, 571 },
{ 0xc0, 258, 0, 572 },
{ 0x20, 258, 0, 585 },
{ 0xa0, 258, 0, 583 },
{ 0x60, 258, 0, 584 },
{ 0x10, 258, 0, 597 },
{ 0x50, 258, 0, 595 },
{ 0x30, 258, 0, 596 },
{ 0x8, 258, 0, 609 },
{ 0x28, 258, 0, 607 },
{ 0x18, 258, 0, 608 },
{ 0x4, 258, 0, 619 },
{ 0x2, 258, 0, 620 },
{ 0x1, 258, 0, 621 },
{ 0x500, 253, 0, 537 },
{ 0x1500, 253, 0, 535 },
{ 0xd00, 253, 0, 536 },
{ 0x300, 253, 0, 549 },
{ 0x1300, 253, 0, 525 },
{ 0x5300, 253, 0, 523 },
{ 0x3300, 253, 0, 524 },
{ 0xb00, 253, 0, 547 },
{ 0x700, 253, 0, 548 },
{ 0x80, 253, 0, 564 },
{ 0x280, 253, 0, 562 },
{ 0x180, 253, 0, 563 },
{ 0x40, 253, 0, 576 },
{ 0x140, 253, 0, 574 },
{ 0xc0, 253, 0, 575 },
{ 0x20, 253, 0, 588 },
{ 0xa0, 253, 0, 586 },
{ 0x60, 253, 0, 587 },
{ 0x10, 253, 0, 600 },
{ 0x50, 253, 0, 598 },
{ 0x30, 253, 0, 599 },
{ 0x8, 253, 0, 612 },
{ 0x28, 253, 0, 610 },
{ 0x18, 253, 0, 611 },
{ 0x4, 253, 0, 622 },
{ 0x2, 253, 0, 623 },
{ 0x1, 253, 0, 624 },
{ 0x8, 238, 0, 625 },
{ 0x4, 238, 0, 626 },
{ 0x2, 238, 0, 627 },
{ 0x1, 238, 0, 628 },
{ 0x2, 176, 0, 631 },
{ 0xa, 176, 0, 629 },
{ 0x6, 176, 0, 630 },
{ 0x1, 176, 0, 637 },
{ 0x5, 176, 0, 635 },
{ 0x3, 176, 0, 636 },
{ 0x2, 175, 0, 634 },
{ 0xa, 175, 0, 632 },
{ 0x6, 175, 0, 633 },
{ 0x1, 175, 0, 640 },
{ 0x5, 175, 0, 638 },
{ 0x3, 175, 0, 639 },
{ 0x4, 446, 0, 641 },
{ 0x2, 446, 0, 642 },
{ 0x1, 446, 0, 643 },
{ 0x4, 445, 0, 644 },
{ 0x2, 445, 0, 645 },
{ 0x1, 445, 0, 646 },
{ 0x4, 444, 0, 647 },
{ 0x2, 444, 0, 648 },
{ 0x1, 444, 0, 649 },
{ 0x4, 443, 0, 650 },
{ 0x2, 443, 0, 651 },
{ 0x1, 443, 0, 652 },
{ 0x2, 123, 1, 658 },
{ 0x2, 124, 0, 657 },
{ 0xa, 123, 1, 654 },
{ 0xa, 124, 0, 653 },
{ 0x6, 123, 1, 656 },
{ 0x6, 124, 0, 655 },
{ 0x1, 123, 1, 688 },
{ 0x1, 124, 0, 687 },
{ 0x5, 123, 1, 684 },
{ 0x5, 124, 0, 683 },
{ 0x3, 123, 1, 686 },
{ 0x3, 124, 0, 685 },
{ 0x2, 131, 1, 664 },
{ 0x2, 132, 0, 663 },
{ 0xa, 131, 1, 660 },
{ 0xa, 132, 0, 659 },
{ 0x6, 131, 1, 662 },
{ 0x6, 132, 0, 661 },
{ 0x1, 131, 1, 694 },
{ 0x1, 132, 0, 693 },
{ 0x5, 131, 1, 690 },
{ 0x5, 132, 0, 689 },
{ 0x3, 131, 1, 692 },
{ 0x3, 132, 0, 691 },
{ 0x2, 129, 1, 670 },
{ 0x2, 130, 0, 669 },
{ 0xa, 129, 1, 666 },
{ 0xa, 130, 0, 665 },
{ 0x6, 129, 1, 668 },
{ 0x6, 130, 0, 667 },
{ 0x1, 129, 1, 700 },
{ 0x1, 130, 0, 699 },
{ 0x5, 129, 1, 696 },
{ 0x5, 130, 0, 695 },
{ 0x3, 129, 1, 698 },
{ 0x3, 130, 0, 697 },
{ 0x2, 127, 1, 676 },
{ 0x2, 128, 0, 675 },
{ 0xa, 127, 1, 672 },
{ 0xa, 128, 0, 671 },
{ 0x6, 127, 1, 674 },
{ 0x6, 128, 0, 673 },
{ 0x1, 127, 1, 706 },
{ 0x1, 128, 0, 705 },
{ 0x5, 127, 1, 702 },
{ 0x5, 128, 0, 701 },
{ 0x3, 127, 1, 704 },
{ 0x3, 128, 0, 703 },
{ 0x2, 125, 1, 682 },
{ 0x2, 126, 0, 681 },
{ 0xa, 125, 1, 678 },
{ 0xa, 126, 0, 677 },
{ 0x6, 125, 1, 680 },
{ 0x6, 126, 0, 679 },
{ 0x1, 125, 1, 712 },
{ 0x1, 126, 0, 711 },
{ 0x5, 125, 1, 708 },
{ 0x5, 126, 0, 707 },
{ 0x3, 125, 1, 710 },
{ 0x3, 126, 0, 709 },
{ 0x4, 402, 1, 718 },
{ 0x4, 403, 0, 717 },
{ 0xc, 402, 1, 716 },
{ 0xc, 403, 0, 715 },
{ 0x2, 402, 1, 728 },
{ 0x2, 403, 0, 727 },
{ 0x1, 402, 1, 730 },
{ 0x1, 403, 0, 729 },
{ 0x8, 408, 0, 714 },
{ 0x18, 408, 0, 713 },
{ 0x4, 408, 0, 720 },
{ 0xc, 408, 0, 719 },
{ 0x2, 408, 0, 731 },
{ 0x1, 408, 0, 732 },
{ 0x4, 406, 0, 722 },
{ 0xc, 406, 0, 721 },
{ 0x2, 406, 0, 733 },
{ 0x1, 406, 0, 734 },
{ 0x4, 404, 0, 724 },
{ 0xc, 404, 0, 723 },
{ 0x2, 404, 0, 735 },
{ 0x1, 404, 0, 736 },
{ 0x4, 400, 0, 726 },
{ 0xc, 400, 0, 725 },
{ 0x2, 400, 0, 737 },
{ 0x1, 400, 0, 738 },
{ 0xa00, 264, 0, 753 },
{ 0x2a00, 264, 0, 751 },
{ 0x1a00, 264, 0, 752 },
{ 0x600, 264, 0, 765 },
{ 0x2600, 264, 0, 741 },
{ 0xa600, 264, 0, 739 },
{ 0x6600, 264, 0, 740 },
{ 0x1600, 264, 0, 763 },
{ 0xe00, 264, 0, 764 },
{ 0x100, 264, 0, 777 },
{ 0x500, 264, 0, 775 },
{ 0x300, 264, 0, 776 },
{ 0x80, 264, 0, 780 },
{ 0x280, 264, 0, 778 },
{ 0x180, 264, 0, 779 },
{ 0x40, 264, 0, 792 },
{ 0x140, 264, 0, 790 },
{ 0xc0, 264, 0, 791 },
{ 0x20, 264, 0, 804 },
{ 0xa0, 264, 0, 802 },
{ 0x60, 264, 0, 803 },
{ 0x10, 264, 0, 816 },
{ 0x50, 264, 0, 814 },
{ 0x30, 264, 0, 815 },
{ 0x8, 264, 0, 828 },
{ 0x28, 264, 0, 826 },
{ 0x18, 264, 0, 827 },
{ 0x4, 264, 0, 838 },
{ 0x2, 264, 0, 839 },
{ 0x1, 264, 0, 840 },
{ 0x500, 260, 0, 756 },
{ 0x1500, 260, 0, 754 },
{ 0xd00, 260, 0, 755 },
{ 0x300, 260, 0, 768 },
{ 0x1300, 260, 0, 744 },
{ 0x5300, 260, 0, 742 },
{ 0x3300, 260, 0, 743 },
{ 0xb00, 260, 0, 766 },
{ 0x700, 260, 0, 767 },
{ 0x80, 260, 0, 783 },
{ 0x280, 260, 0, 781 },
{ 0x180, 260, 0, 782 },
{ 0x40, 260, 0, 795 },
{ 0x140, 260, 0, 793 },
{ 0xc0, 260, 0, 794 },
{ 0x20, 260, 0, 807 },
{ 0xa0, 260, 0, 805 },
{ 0x60, 260, 0, 806 },
{ 0x10, 260, 0, 819 },
{ 0x50, 260, 0, 817 },
{ 0x30, 260, 0, 818 },
{ 0x8, 260, 0, 831 },
{ 0x28, 260, 0, 829 },
{ 0x18, 260, 0, 830 },
{ 0x4, 260, 0, 841 },
{ 0x2, 260, 0, 842 },
{ 0x1, 260, 0, 843 },
{ 0x500, 257, 0, 759 },
{ 0x1500, 257, 0, 757 },
{ 0xd00, 257, 0, 758 },
{ 0x300, 257, 0, 771 },
{ 0x1300, 257, 0, 747 },
{ 0x5300, 257, 0, 745 },
{ 0x3300, 257, 0, 746 },
{ 0xb00, 257, 0, 769 },
{ 0x700, 257, 0, 770 },
{ 0x80, 257, 0, 786 },
{ 0x280, 257, 0, 784 },
{ 0x180, 257, 0, 785 },
{ 0x40, 257, 0, 798 },
{ 0x140, 257, 0, 796 },
{ 0xc0, 257, 0, 797 },
{ 0x20, 257, 0, 810 },
{ 0xa0, 257, 0, 808 },
{ 0x60, 257, 0, 809 },
{ 0x10, 257, 0, 822 },
{ 0x50, 257, 0, 820 },
{ 0x30, 257, 0, 821 },
{ 0x8, 257, 0, 834 },
{ 0x28, 257, 0, 832 },
{ 0x18, 257, 0, 833 },
{ 0x4, 257, 0, 844 },
{ 0x2, 257, 0, 845 },
{ 0x1, 257, 0, 846 },
{ 0x500, 252, 0, 762 },
{ 0x1500, 252, 0, 760 },
{ 0xd00, 252, 0, 761 },
{ 0x300, 252, 0, 774 },
{ 0x1300, 252, 0, 750 },
{ 0x5300, 252, 0, 748 },
{ 0x3300, 252, 0, 749 },
{ 0xb00, 252, 0, 772 },
{ 0x700, 252, 0, 773 },
{ 0x80, 252, 0, 789 },
{ 0x280, 252, 0, 787 },
{ 0x180, 252, 0, 788 },
{ 0x40, 252, 0, 801 },
{ 0x140, 252, 0, 799 },
{ 0xc0, 252, 0, 800 },
{ 0x20, 252, 0, 813 },
{ 0xa0, 252, 0, 811 },
{ 0x60, 252, 0, 812 },
{ 0x10, 252, 0, 825 },
{ 0x50, 252, 0, 823 },
{ 0x30, 252, 0, 824 },
{ 0x8, 252, 0, 837 },
{ 0x28, 252, 0, 835 },
{ 0x18, 252, 0, 836 },
{ 0x4, 252, 0, 847 },
{ 0x2, 252, 0, 848 },
{ 0x1, 252, 0, 849 },
{ 0x8, 254, 1, 895 },
{ 0x8, 255, 0, 894 },
{ 0x28, 254, 1, 891 },
{ 0x28, 255, 0, 890 },
{ 0x18, 254, 1, 893 },
{ 0x18, 255, 0, 892 },
{ 0x4, 254, 1, 957 },
{ 0x4, 255, 0, 956 },
{ 0x2, 254, 1, 959 },
{ 0x2, 255, 0, 958 },
{ 0x1, 254, 1, 961 },
{ 0x1, 255, 0, 960 },
{ 0xa00, 262, 0, 865 },
{ 0x2a00, 262, 0, 863 },
{ 0x1a00, 262, 0, 864 },
{ 0x600, 262, 0, 877 },
{ 0x2600, 262, 0, 853 },
{ 0xa600, 262, 0, 851 },
{ 0x6600, 262, 0, 852 },
{ 0x1600, 262, 0, 875 },
{ 0xe00, 262, 0, 876 },
{ 0x100, 262, 0, 889 },
{ 0x500, 262, 0, 887 },
{ 0x300, 262, 0, 888 },
{ 0x80, 262, 0, 898 },
{ 0x280, 262, 0, 896 },
{ 0x180, 262, 0, 897 },
{ 0x40, 262, 0, 910 },
{ 0x140, 262, 0, 908 },
{ 0xc0, 262, 0, 909 },
{ 0x20, 262, 0, 922 },
{ 0xa0, 262, 0, 920 },
{ 0x60, 262, 0, 921 },
{ 0x10, 262, 0, 934 },
{ 0x50, 262, 0, 932 },
{ 0x30, 262, 0, 933 },
{ 0x8, 262, 0, 946 },
{ 0x28, 262, 0, 944 },
{ 0x18, 262, 0, 945 },
{ 0x4, 262, 0, 962 },
{ 0x2, 262, 0, 963 },
{ 0x1, 262, 1, 964 },
{ 0x1, 263, 0, 850 },
{ 0x500, 259, 0, 868 },
{ 0x1500, 259, 0, 866 },
{ 0xd00, 259, 0, 867 },
{ 0x300, 259, 0, 880 },
{ 0x1300, 259, 0, 856 },
{ 0x5300, 259, 0, 854 },
{ 0x3300, 259, 0, 855 },
{ 0xb00, 259, 0, 878 },
{ 0x700, 259, 0, 879 },
{ 0x80, 259, 0, 901 },
{ 0x280, 259, 0, 899 },
{ 0x180, 259, 0, 900 },
{ 0x40, 259, 0, 913 },
{ 0x140, 259, 0, 911 },
{ 0xc0, 259, 0, 912 },
{ 0x20, 259, 0, 925 },
{ 0xa0, 259, 0, 923 },
{ 0x60, 259, 0, 924 },
{ 0x10, 259, 0, 937 },
{ 0x50, 259, 0, 935 },
{ 0x30, 259, 0, 936 },
{ 0x8, 259, 0, 949 },
{ 0x28, 259, 0, 947 },
{ 0x18, 259, 0, 948 },
{ 0x4, 259, 0, 965 },
{ 0x2, 259, 0, 966 },
{ 0x1, 259, 0, 967 },
{ 0x500, 256, 0, 871 },
{ 0x1500, 256, 0, 869 },
{ 0xd00, 256, 0, 870 },
{ 0x300, 256, 0, 883 },
{ 0x1300, 256, 0, 859 },
{ 0x5300, 256, 0, 857 },
{ 0x3300, 256, 0, 858 },
{ 0xb00, 256, 0, 881 },
{ 0x700, 256, 0, 882 },
{ 0x80, 256, 0, 904 },
{ 0x280, 256, 0, 902 },
{ 0x180, 256, 0, 903 },
{ 0x40, 256, 0, 916 },
{ 0x140, 256, 0, 914 },
{ 0xc0, 256, 0, 915 },
{ 0x20, 256, 0, 928 },
{ 0xa0, 256, 0, 926 },
{ 0x60, 256, 0, 927 },
{ 0x10, 256, 0, 940 },
{ 0x50, 256, 0, 938 },
{ 0x30, 256, 0, 939 },
{ 0x8, 256, 0, 952 },
{ 0x28, 256, 0, 950 },
{ 0x18, 256, 0, 951 },
{ 0x4, 256, 0, 968 },
{ 0x2, 256, 0, 969 },
{ 0x1, 256, 0, 970 },
{ 0x500, 251, 0, 874 },
{ 0x1500, 251, 0, 872 },
{ 0xd00, 251, 0, 873 },
{ 0x300, 251, 0, 886 },
{ 0x1300, 251, 0, 862 },
{ 0x5300, 251, 0, 860 },
{ 0x3300, 251, 0, 861 },
{ 0xb00, 251, 0, 884 },
{ 0x700, 251, 0, 885 },
{ 0x80, 251, 0, 907 },
{ 0x280, 251, 0, 905 },
{ 0x180, 251, 0, 906 },
{ 0x40, 251, 0, 919 },
{ 0x140, 251, 0, 917 },
{ 0xc0, 251, 0, 918 },
{ 0x20, 251, 0, 931 },
{ 0xa0, 251, 0, 929 },
{ 0x60, 251, 0, 930 },
{ 0x10, 251, 0, 943 },
{ 0x50, 251, 0, 941 },
{ 0x30, 251, 0, 942 },
{ 0x8, 251, 0, 955 },
{ 0x28, 251, 0, 953 },
{ 0x18, 251, 0, 954 },
{ 0x4, 251, 0, 971 },
{ 0x2, 251, 0, 972 },
{ 0x1, 251, 0, 973 },
{ 0x2, 150, 0, 975 },
{ 0x1, 150, 0, 976 },
{ 0x1, 50, 0, 977 },
{ 0x3, 49, 0, 978 },
{ 0x1, 428, 0, 979 },
{ 0x1, 438, 0, 980 },
{ 0x2, 386, 0, 983 },
{ 0x1, 386, 0, 984 },
{ 0x2, 384, 0, 985 },
{ 0x1, 384, 0, 986 },
{ 0x1, 383, 0, 987 },
{ 0x1, 328, 0, 992 },
{ 0x1, 327, 0, 993 },
{ 0x1, 326, 0, 994 },
{ 0x1, 325, 0, 995 },
{ 0x1, 250, 0, 996 },
{ 0x1, 249, 0, 997 },
{ 0x1, 324, 0, 998 },
{ 0x1, 323, 0, 999 },
{ 0x1, 322, 0, 1000 },
{ 0x1, 321, 0, 1001 },
{ 0x1, 320, 0, 1002 },
{ 0x1, 319, 0, 1003 },
{ 0x1, 318, 0, 1004 },
{ 0x2, 248, 0, 1005 },
{ 0x1, 248, 0, 1006 },
{ 0x2, 366, 0, 1012 },
{ 0x1, 366, 0, 1013 },
{ 0x1, 317, 0, 1014 },
{ 0x1, 316, 0, 1015 },
{ 0x1, 315, 0, 1016 },
{ 0x1, 314, 0, 1017 },
{ 0x1, 8, 1, 1019 },
{ 0x1, 9, 0, 1018 },
{ 0x1, 313, 0, 1020 },
{ 0x1, 312, 0, 1021 },
{ 0x1, 311, 0, 1022 },
{ 0x1, 310, 0, 1023 },
{ 0x1, 388, 0, 1024 },
{ 0x1, 399, 0, 1025 },
{ 0x1, 389, 0, 1026 },
{ 0x1, 423, 0, 1027 },
{ 0x1, 309, 0, 1031 },
{ 0x1, 247, 0, 1032 },
{ 0x1, 177, 0, 1035 },
{ 0x2, 291, 0, 1039 },
{ 0x1, 291, 0, 1040 },
{ 0x1, 236, 0, 1041 },
{ 0x5, 48, 0, 1043 },
{ 0x3, 48, 0, 1044 },
{ 0x5, 47, 0, 1045 },
{ 0x3, 47, 0, 1046 },
{ 0x1, 365, 0, 1047 },
{ 0x1, 373, 0, 1048 },
{ 0x1, 371, 0, 1049 },
{ 0x1, 392, 0, 1050 },
{ 0x1, 372, 0, 1051 },
{ 0x1, 370, 0, 1052 },
{ 0x2, 378, 0, 1053 },
{ 0x1, 378, 0, 1055 },
{ 0x2, 376, 0, 1054 },
{ 0x1, 376, 0, 1056 },
{ 0x2, 396, 0, 1057 },
{ 0x1, 396, 0, 1060 },
{ 0x2, 377, 0, 1058 },
{ 0x1, 377, 0, 1061 },
{ 0x2, 375, 0, 1059 },
{ 0x1, 375, 0, 1062 },
{ 0x1, 338, 0, 1063 },
{ 0x1, 337, 0, 1064 },
{ 0x1, 369, 0, 1065 },
{ 0x1, 360, 0, 1066 },
{ 0x1, 362, 0, 1067 },
{ 0x1, 359, 0, 1068 },
{ 0x1, 361, 0, 1069 },
{ 0x2, 442, 0, 1070 },
{ 0x1, 442, 0, 1073 },
{ 0x2, 441, 0, 1071 },
{ 0x1, 441, 0, 1074 },
{ 0x2, 440, 0, 1072 },
{ 0x1, 440, 0, 1075 },
{ 0x1, 348, 0, 1076 },
{ 0x2, 347, 0, 1077 },
{ 0x1, 347, 0, 1078 },
{ 0x2, 294, 0, 1079 },
{ 0x1, 294, 0, 1082 },
{ 0x2, 293, 0, 1080 },
{ 0x1, 293, 0, 1083 },
{ 0x2, 292, 0, 1081 },
{ 0x1, 292, 0, 1084 },
{ 0x2, 363, 0, 1085 },
{ 0x1, 363, 0, 1086 },
{ 0x2, 364, 0, 1087 },
{ 0x1, 364, 0, 1088 },
{ 0xa, 434, 1, 1100 },
{ 0xa, 435, 1, 1099 },
{ 0xa, 436, 1, 1098 },
{ 0xa, 437, 0, 1097 },
{ 0x1a, 434, 1, 1092 },
{ 0x1a, 435, 1, 1091 },
{ 0x32, 436, 1, 1090 },
{ 0x32, 437, 0, 1089 },
{ 0x6, 434, 1, 1108 },
{ 0x6, 435, 1, 1107 },
{ 0x6, 436, 1, 1106 },
{ 0x6, 437, 0, 1105 },
{ 0x1, 434, 1, 1120 },
{ 0x1, 435, 1, 1119 },
{ 0x1, 436, 1, 1118 },
{ 0x1, 437, 0, 1117 },
{ 0x9, 434, 1, 1104 },
{ 0x9, 435, 1, 1103 },
{ 0x9, 436, 1, 1102 },
{ 0x9, 437, 0, 1101 },
{ 0x19, 434, 1, 1096 },
{ 0x19, 435, 1, 1095 },
{ 0x31, 436, 1, 1094 },
{ 0x31, 437, 0, 1093 },
{ 0x5, 434, 1, 1112 },
{ 0x5, 435, 1, 1111 },
{ 0x5, 436, 1, 1110 },
{ 0x5, 437, 0, 1109 },
{ 0x3, 434, 1, 1116 },
{ 0x3, 435, 1, 1115 },
{ 0x3, 436, 1, 1114 },
{ 0x3, 437, 0, 1113 },
{ 0xa, 429, 1, 1132 },
{ 0xa, 430, 1, 1131 },
{ 0xa, 431, 1, 1130 },
{ 0xa, 432, 0, 1129 },
{ 0x1a, 429, 1, 1124 },
{ 0x1a, 430, 1, 1123 },
{ 0x32, 431, 1, 1122 },
{ 0x32, 432, 0, 1121 },
{ 0x6, 429, 1, 1140 },
{ 0x6, 430, 1, 1139 },
{ 0x6, 431, 1, 1138 },
{ 0x6, 432, 0, 1137 },
{ 0x1, 429, 1, 1152 },
{ 0x1, 430, 1, 1151 },
{ 0x1, 431, 1, 1150 },
{ 0x1, 432, 0, 1149 },
{ 0x9, 429, 1, 1136 },
{ 0x9, 430, 1, 1135 },
{ 0x9, 431, 1, 1134 },
{ 0x9, 432, 0, 1133 },
{ 0x19, 429, 1, 1128 },
{ 0x19, 430, 1, 1127 },
{ 0x31, 431, 1, 1126 },
{ 0x31, 432, 0, 1125 },
{ 0x5, 429, 1, 1144 },
{ 0x5, 430, 1, 1143 },
{ 0x5, 431, 1, 1142 },
{ 0x5, 432, 0, 1141 },
{ 0x3, 429, 1, 1148 },
{ 0x3, 430, 1, 1147 },
{ 0x3, 431, 1, 1146 },
{ 0x3, 432, 0, 1145 },
{ 0x1, 139, 0, 1153 },
{ 0x1, 138, 0, 1154 },
{ 0x1, 391, 1, 1156 },
{ 0x1, 137, 0, 1155 },
{ 0x2, 395, 1, 1158 },
{ 0x2, 141, 0, 1157 },
{ 0x1, 395, 1, 1160 },
{ 0x1, 141, 0, 1159 },
{ 0x1, 397, 0, 1161 },
{ 0x1, 136, 0, 1162 },
{ 0x2, 135, 0, 1163 },
{ 0x2, 134, 0, 1164 },
{ 0x1, 454, 1, 1170 },
{ 0x1, 246, 0, 1033 },
{ 0x1, 453, 0, 1171 },
{ 0x1, 452, 1, 1172 },
{ 0x1, 245, 0, 1042 },
{ 0x1, 308, 0, 1173 },
{ 0x1, 307, 1, 1174 },
{ 0x1, 290, 0, 1034 },
{ 0x1, 306, 0, 1175 },
{ 0x1, 305, 1, 1176 },
{ 0x1, 427, 0, 1036 },
{ 0x1, 304, 1, 1177 },
{ 0x1, 398, 0, 1038 },
{ 0x1, 303, 0, 1178 },
{ 0x1, 302, 0, 1179 },
{ 0x1, 301, 0, 1180 },
{ 0x1, 300, 1, 1181 },
{ 0x2, 398, 0, 1037 },
{ 0x10, 299, 0, 1185 },
{ 0x90, 299, 0, 1183 },
{ 0x190, 299, 0, 1182 },
{ 0x50, 299, 0, 1184 },
{ 0x30, 299, 0, 1187 },
{ 0x70, 299, 0, 1186 },
{ 0x8, 299, 0, 1189 },
{ 0x18, 299, 0, 1188 },
{ 0x4, 299, 0, 1190 },
{ 0x1, 299, 0, 1193 },
{ 0x3, 299, 0, 1192 },
{ 0x1, 298, 1, 1194 },
{ 0x2, 299, 0, 1191 },
{ 0x3, 46, 0, 1195 },
{ 0x1, 241, 1, 1196 },
{ 0x1, 242, 1, 1028 },
{ 0x1, 243, 0, 88 },
{ 0x1, 341, 1, 1197 },
{ 0x1, 342, 1, 1029 },
{ 0x1, 343, 0, 89 },
{ 0x1, 34, 1, 1198 },
{ 0x1, 35, 1, 1030 },
{ 0x1, 36, 0, 90 },
{ 0x1, 230, 0, 1199 },
{ 0x4, 447, 0, 1200 },
{ 0x2, 447, 0, 1201 },
{ 0x1, 447, 1, 1203 },
{ 0x1, 448, 0, 1202 },
{ 0x8, 449, 0, 1204 },
{ 0x4, 449, 0, 1205 },
{ 0x1, 449, 1, 1207 },
{ 0x2, 449, 0, 1206 },
{ 0x8, 219, 0, 1208 },
{ 0x4, 219, 0, 1209 },
{ 0x2, 219, 0, 1210 },
{ 0x1, 219, 1, 1212 },
{ 0x1, 220, 0, 1211 },
{ 0x10, 221, 0, 1213 },
{ 0x8, 221, 0, 1214 },
{ 0x4, 221, 0, 1215 },
{ 0x1, 221, 1, 1217 },
{ 0x2, 221, 0, 1216 },
{ 0x220, 191, 0, 1218 },
{ 0x120, 191, 0, 1219 },
{ 0xa0, 191, 0, 1220 },
{ 0x60, 191, 1, 1222 },
{ 0x4, 192, 0, 1221 },
{ 0x110, 191, 0, 1228 },
{ 0x90, 191, 0, 1229 },
{ 0x50, 191, 0, 1230 },
{ 0x30, 191, 1, 1232 },
{ 0x2, 192, 0, 1231 },
{ 0x8, 191, 0, 1233 },
{ 0x4, 191, 0, 1234 },
{ 0x2, 191, 0, 1235 },
{ 0x1, 191, 1, 1237 },
{ 0x1, 192, 0, 1236 },
{ 0x440, 193, 0, 1223 },
{ 0x240, 193, 0, 1224 },
{ 0x140, 193, 0, 1225 },
{ 0xc0, 193, 1, 1227 },
{ 0x40, 193, 0, 1226 },
{ 0x220, 193, 0, 1238 },
{ 0x120, 193, 0, 1239 },
{ 0xa0, 193, 0, 1240 },
{ 0x60, 193, 1, 1242 },
{ 0x20, 193, 0, 1241 },
{ 0x10, 193, 0, 1243 },
{ 0x8, 193, 0, 1244 },
{ 0x4, 193, 0, 1245 },
{ 0x1, 193, 1, 1247 },
{ 0x2, 193, 0, 1246 },
{ 0x8, 215, 0, 1248 },
{ 0x4, 215, 0, 1249 },
{ 0x2, 215, 0, 1250 },
{ 0x1, 215, 1, 1252 },
{ 0x1, 216, 0, 1251 },
{ 0x220, 187, 0, 1253 },
{ 0x120, 187, 0, 1254 },
{ 0xa0, 187, 0, 1255 },
{ 0x60, 187, 1, 1257 },
{ 0x4, 188, 0, 1256 },
{ 0x110, 187, 0, 1263 },
{ 0x90, 187, 0, 1264 },
{ 0x50, 187, 0, 1265 },
{ 0x30, 187, 1, 1267 },
{ 0x2, 188, 0, 1266 },
{ 0x8, 187, 0, 1268 },
{ 0x4, 187, 0, 1269 },
{ 0x2, 187, 0, 1270 },
{ 0x1, 187, 1, 1272 },
{ 0x1, 188, 0, 1271 },
{ 0x440, 233, 0, 1258 },
{ 0x240, 233, 0, 1259 },
{ 0x140, 233, 0, 1260 },
{ 0xc0, 233, 1, 1262 },
{ 0x40, 233, 0, 1261 },
{ 0x220, 233, 0, 1273 },
{ 0x120, 233, 0, 1274 },
{ 0xa0, 233, 0, 1275 },
{ 0x60, 233, 1, 1277 },
{ 0x20, 233, 0, 1276 },
{ 0x10, 233, 0, 1278 },
{ 0x8, 233, 0, 1279 },
{ 0x4, 233, 0, 1280 },
{ 0x1, 233, 1, 1282 },
{ 0x2, 233, 0, 1281 },
{ 0x8, 207, 0, 1283 },
{ 0x4, 207, 0, 1284 },
{ 0x2, 207, 0, 1285 },
{ 0x1, 207, 1, 1287 },
{ 0x1, 208, 0, 1286 },
{ 0x10, 214, 0, 1288 },
{ 0x8, 214, 0, 1289 },
{ 0x4, 214, 0, 1290 },
{ 0x1, 214, 1, 1292 },
{ 0x2, 214, 0, 1291 },
{ 0x220, 178, 0, 1293 },
{ 0x120, 178, 0, 1294 },
{ 0xa0, 178, 0, 1295 },
{ 0x60, 178, 1, 1297 },
{ 0x4, 179, 0, 1296 },
{ 0x110, 178, 0, 1318 },
{ 0x90, 178, 0, 1319 },
{ 0x50, 178, 0, 1320 },
{ 0x30, 178, 1, 1322 },
{ 0x2, 179, 0, 1321 },
{ 0x8, 178, 0, 1323 },
{ 0x4, 178, 0, 1324 },
{ 0x2, 178, 0, 1325 },
{ 0x1, 178, 1, 1327 },
{ 0x1, 179, 0, 1326 },
{ 0x440, 186, 0, 1298 },
{ 0x240, 186, 0, 1299 },
{ 0x140, 186, 0, 1300 },
{ 0xc0, 186, 1, 1302 },
{ 0x40, 186, 0, 1301 },
{ 0x220, 186, 0, 1328 },
{ 0x120, 186, 0, 1329 },
{ 0xa0, 186, 0, 1330 },
{ 0x60, 186, 1, 1332 },
{ 0x20, 186, 0, 1331 },
{ 0x10, 186, 0, 1333 },
{ 0x8, 186, 0, 1334 },
{ 0x4, 186, 0, 1335 },
{ 0x1, 186, 1, 1337 },
{ 0x2, 186, 0, 1336 },
{ 0x440, 143, 0, 1303 },
{ 0x240, 143, 0, 1304 },
{ 0x140, 143, 0, 1305 },
{ 0xc0, 143, 1, 1307 },
{ 0x40, 143, 0, 1306 },
{ 0x220, 143, 0, 1338 },
{ 0x120, 143, 0, 1339 },
{ 0xa0, 143, 0, 1340 },
{ 0x60, 143, 1, 1342 },
{ 0x20, 143, 0, 1341 },
{ 0x10, 143, 0, 1343 },
{ 0x8, 143, 0, 1344 },
{ 0x1, 143, 1, 1347 },
{ 0x2, 143, 0, 1346 },
{ 0x440, 194, 1, 1313 },
{ 0x441, 174, 0, 1308 },
{ 0x240, 194, 1, 1314 },
{ 0x241, 174, 0, 1309 },
{ 0x140, 194, 1, 1315 },
{ 0x141, 174, 0, 1310 },
{ 0xc0, 194, 1, 1317 },
{ 0x40, 194, 1, 1316 },
{ 0xc1, 174, 1, 1312 },
{ 0x41, 174, 0, 1311 },
{ 0x220, 194, 1, 1358 },
{ 0x221, 174, 0, 1348 },
{ 0x120, 194, 1, 1359 },
{ 0x121, 174, 0, 1349 },
{ 0xa0, 194, 1, 1360 },
{ 0xa1, 174, 0, 1350 },
{ 0x60, 194, 1, 1362 },
{ 0x20, 194, 1, 1361 },
{ 0x61, 174, 1, 1352 },
{ 0x21, 174, 0, 1351 },
{ 0x10, 194, 1, 1363 },
{ 0x11, 174, 0, 1353 },
{ 0x8, 194, 1, 1364 },
{ 0x9, 174, 0, 1354 },
{ 0x4, 194, 1, 1365 },
{ 0x5, 174, 0, 1355 },
{ 0x1, 194, 1, 1367 },
{ 0x2, 194, 1, 1366 },
{ 0x3, 174, 1, 1357 },
{ 0x1, 174, 0, 1356 },
{ 0x1, 153, 1, 1375 },
{ 0x1, 154, 1, 1374 },
{ 0x1, 155, 1, 1373 },
{ 0x1, 156, 0, 1372 },
{ 0x3, 153, 1, 1371 },
{ 0x3, 154, 1, 1370 },
{ 0x3, 155, 1, 1369 },
{ 0x3, 156, 0, 1368 },
{ 0x1108, 159, 1, 1537 },
{ 0x1108, 160, 1, 1536 },
{ 0x1108, 165, 1, 1377 },
{ 0x1108, 166, 0, 1376 },
{ 0x908, 159, 1, 1539 },
{ 0x908, 160, 1, 1538 },
{ 0x908, 165, 1, 1379 },
{ 0x908, 166, 0, 1378 },
{ 0x508, 159, 1, 1541 },
{ 0x508, 160, 1, 1540 },
{ 0x508, 165, 1, 1381 },
{ 0x508, 166, 0, 1380 },
{ 0x308, 159, 1, 1545 },
{ 0x308, 160, 1, 1544 },
{ 0x108, 160, 1, 1542 },
{ 0x18, 161, 1, 1543 },
{ 0x308, 165, 1, 1385 },
{ 0x308, 166, 1, 1384 },
{ 0x108, 166, 1, 1382 },
{ 0x18, 167, 0, 1383 },
{ 0x88, 159, 1, 1577 },
{ 0x88, 160, 1, 1576 },
{ 0x88, 165, 1, 1457 },
{ 0x88, 166, 0, 1456 },
{ 0x48, 159, 1, 1579 },
{ 0x48, 160, 1, 1578 },
{ 0x48, 165, 1, 1459 },
{ 0x48, 166, 0, 1458 },
{ 0x28, 159, 1, 1581 },
{ 0x28, 160, 1, 1580 },
{ 0x28, 165, 1, 1461 },
{ 0x28, 166, 0, 1460 },
{ 0x18, 159, 1, 1585 },
{ 0x18, 160, 1, 1584 },
{ 0x8, 160, 1, 1582 },
{ 0x8, 161, 1, 1583 },
{ 0x18, 165, 1, 1465 },
{ 0x18, 166, 1, 1464 },
{ 0x8, 166, 1, 1462 },
{ 0x8, 167, 0, 1463 },
{ 0x884, 159, 1, 1547 },
{ 0x884, 160, 1, 1546 },
{ 0x442, 162, 1, 1437 },
{ 0x442, 163, 1, 1436 },
{ 0x884, 165, 1, 1407 },
{ 0x884, 166, 1, 1406 },
{ 0x442, 168, 1, 1387 },
{ 0x442, 169, 0, 1386 },
{ 0x484, 159, 1, 1549 },
{ 0x484, 160, 1, 1548 },
{ 0x242, 162, 1, 1439 },
{ 0x242, 163, 1, 1438 },
{ 0x484, 165, 1, 1409 },
{ 0x484, 166, 1, 1408 },
{ 0x242, 168, 1, 1389 },
{ 0x242, 169, 0, 1388 },
{ 0x284, 159, 1, 1551 },
{ 0x284, 160, 1, 1550 },
{ 0x142, 162, 1, 1441 },
{ 0x142, 163, 1, 1440 },
{ 0x284, 165, 1, 1411 },
{ 0x284, 166, 1, 1410 },
{ 0x142, 168, 1, 1391 },
{ 0x142, 169, 0, 1390 },
{ 0x184, 159, 1, 1555 },
{ 0x184, 160, 1, 1554 },
{ 0x84, 160, 1, 1552 },
{ 0xc, 161, 1, 1553 },
{ 0xc2, 162, 1, 1445 },
{ 0xc2, 163, 1, 1444 },
{ 0x42, 163, 1, 1442 },
{ 0x6, 164, 1, 1443 },
{ 0x184, 165, 1, 1415 },
{ 0x184, 166, 1, 1414 },
{ 0x84, 166, 1, 1412 },
{ 0xc, 167, 1, 1413 },
{ 0xc2, 168, 1, 1395 },
{ 0xc2, 169, 1, 1394 },
{ 0x42, 169, 1, 1392 },
{ 0x6, 170, 0, 1393 },
{ 0x44, 159, 1, 1587 },
{ 0x44, 160, 1, 1586 },
{ 0x22, 162, 1, 1517 },
{ 0x22, 163, 1, 1516 },
{ 0x44, 165, 1, 1487 },
{ 0x44, 166, 1, 1486 },
{ 0x22, 168, 1, 1467 },
{ 0x22, 169, 0, 1466 },
{ 0x24, 159, 1, 1589 },
{ 0x24, 160, 1, 1588 },
{ 0x12, 162, 1, 1519 },
{ 0x12, 163, 1, 1518 },
{ 0x24, 165, 1, 1489 },
{ 0x24, 166, 1, 1488 },
{ 0x12, 168, 1, 1469 },
{ 0x12, 169, 0, 1468 },
{ 0x14, 159, 1, 1591 },
{ 0x14, 160, 1, 1590 },
{ 0xa, 162, 1, 1521 },
{ 0xa, 163, 1, 1520 },
{ 0x14, 165, 1, 1491 },
{ 0x14, 166, 1, 1490 },
{ 0xa, 168, 1, 1471 },
{ 0xa, 169, 0, 1470 },
{ 0xc, 159, 1, 1595 },
{ 0xc, 160, 1, 1594 },
{ 0x4, 160, 1, 1592 },
{ 0x4, 161, 1, 1593 },
{ 0x6, 162, 1, 1525 },
{ 0x6, 163, 1, 1524 },
{ 0x2, 163, 1, 1522 },
{ 0x2, 164, 1, 1523 },
{ 0xc, 165, 1, 1495 },
{ 0xc, 166, 1, 1494 },
{ 0x4, 166, 1, 1492 },
{ 0x4, 167, 1, 1493 },
{ 0x6, 168, 1, 1475 },
{ 0x6, 169, 1, 1474 },
{ 0x2, 169, 1, 1472 },
{ 0x2, 170, 0, 1473 },
{ 0x442, 159, 1, 1557 },
{ 0x442, 160, 1, 1556 },
{ 0x221, 162, 1, 1447 },
{ 0x221, 163, 1, 1446 },
{ 0x442, 165, 1, 1417 },
{ 0x442, 166, 1, 1416 },
{ 0x221, 168, 1, 1397 },
{ 0x221, 169, 0, 1396 },
{ 0x242, 159, 1, 1559 },
{ 0x242, 160, 1, 1558 },
{ 0x121, 162, 1, 1449 },
{ 0x121, 163, 1, 1448 },
{ 0x242, 165, 1, 1419 },
{ 0x242, 166, 1, 1418 },
{ 0x121, 168, 1, 1399 },
{ 0x121, 169, 0, 1398 },
{ 0x142, 159, 1, 1561 },
{ 0x142, 160, 1, 1560 },
{ 0xa1, 162, 1, 1451 },
{ 0xa1, 163, 1, 1450 },
{ 0x142, 165, 1, 1421 },
{ 0x142, 166, 1, 1420 },
{ 0xa1, 168, 1, 1401 },
{ 0xa1, 169, 0, 1400 },
{ 0xc2, 159, 1, 1565 },
{ 0xc2, 160, 1, 1564 },
{ 0x42, 160, 1, 1562 },
{ 0x6, 161, 1, 1563 },
{ 0x61, 162, 1, 1455 },
{ 0x61, 163, 1, 1454 },
{ 0x21, 163, 1, 1452 },
{ 0x3, 164, 1, 1453 },
{ 0xc2, 165, 1, 1425 },
{ 0xc2, 166, 1, 1424 },
{ 0x42, 166, 1, 1422 },
{ 0x6, 167, 1, 1423 },
{ 0x61, 168, 1, 1405 },
{ 0x61, 169, 1, 1404 },
{ 0x21, 169, 1, 1402 },
{ 0x3, 170, 0, 1403 },
{ 0x22, 159, 1, 1597 },
{ 0x22, 160, 1, 1596 },
{ 0x11, 162, 1, 1527 },
{ 0x11, 163, 1, 1526 },
{ 0x22, 165, 1, 1497 },
{ 0x22, 166, 1, 1496 },
{ 0x11, 168, 1, 1477 },
{ 0x11, 169, 0, 1476 },
{ 0x12, 159, 1, 1599 },
{ 0x12, 160, 1, 1598 },
{ 0x9, 162, 1, 1529 },
{ 0x9, 163, 1, 1528 },
{ 0x12, 165, 1, 1499 },
{ 0x12, 166, 1, 1498 },
{ 0x9, 168, 1, 1479 },
{ 0x9, 169, 0, 1478 },
{ 0xa, 159, 1, 1601 },
{ 0xa, 160, 1, 1600 },
{ 0x5, 162, 1, 1531 },
{ 0x5, 163, 1, 1530 },
{ 0xa, 165, 1, 1501 },
{ 0xa, 166, 1, 1500 },
{ 0x5, 168, 1, 1481 },
{ 0x5, 169, 0, 1480 },
{ 0x6, 159, 1, 1605 },
{ 0x6, 160, 1, 1604 },
{ 0x2, 160, 1, 1602 },
{ 0x2, 161, 1, 1603 },
{ 0x3, 162, 1, 1535 },
{ 0x3, 163, 1, 1534 },
{ 0x1, 163, 1, 1532 },
{ 0x1, 164, 1, 1533 },
{ 0x6, 165, 1, 1505 },
{ 0x6, 166, 1, 1504 },
{ 0x2, 166, 1, 1502 },
{ 0x2, 167, 1, 1503 },
{ 0x3, 168, 1, 1485 },
{ 0x3, 169, 1, 1484 },
{ 0x1, 169, 1, 1482 },
{ 0x1, 170, 0, 1483 },
{ 0x221, 159, 1, 1567 },
{ 0x221, 160, 1, 1566 },
{ 0x221, 165, 1, 1427 },
{ 0x221, 166, 0, 1426 },
{ 0x121, 159, 1, 1569 },
{ 0x121, 160, 1, 1568 },
{ 0x121, 165, 1, 1429 },
{ 0x121, 166, 0, 1428 },
{ 0xa1, 159, 1, 1571 },
{ 0xa1, 160, 1, 1570 },
{ 0xa1, 165, 1, 1431 },
{ 0xa1, 166, 0, 1430 },
{ 0x61, 159, 1, 1575 },
{ 0x61, 160, 1, 1574 },
{ 0x21, 160, 1, 1572 },
{ 0x3, 161, 1, 1573 },
{ 0x61, 165, 1, 1435 },
{ 0x61, 166, 1, 1434 },
{ 0x21, 166, 1, 1432 },
{ 0x3, 167, 0, 1433 },
{ 0x11, 159, 1, 1607 },
{ 0x11, 160, 1, 1606 },
{ 0x11, 165, 1, 1507 },
{ 0x11, 166, 0, 1506 },
{ 0x9, 159, 1, 1609 },
{ 0x9, 160, 1, 1608 },
{ 0x9, 165, 1, 1509 },
{ 0x9, 166, 0, 1508 },
{ 0x5, 159, 1, 1611 },
{ 0x5, 160, 1, 1610 },
{ 0x5, 165, 1, 1511 },
{ 0x5, 166, 0, 1510 },
{ 0x3, 159, 1, 1615 },
{ 0x3, 160, 1, 1614 },
{ 0x1, 160, 1, 1612 },
{ 0x1, 161, 1, 1613 },
{ 0x3, 165, 1, 1515 },
{ 0x3, 166, 1, 1514 },
{ 0x1, 166, 1, 1512 },
{ 0x1, 167, 0, 1513 },
{ 0x442, 205, 0, 1616 },
{ 0x242, 205, 0, 1617 },
{ 0x142, 205, 0, 1618 },
{ 0xc2, 205, 1, 1620 },
{ 0x6, 206, 1, 1619 },
{ 0x1, 439, 0, 981 },
{ 0x22, 205, 0, 1626 },
{ 0x12, 205, 0, 1627 },
{ 0xa, 205, 0, 1628 },
{ 0x6, 205, 1, 1630 },
{ 0x2, 206, 1, 1629 },
{ 0x2, 367, 0, 1010 },
{ 0x221, 205, 0, 1621 },
{ 0x121, 205, 0, 1622 },
{ 0xa1, 205, 0, 1623 },
{ 0x61, 205, 1, 1625 },
{ 0x3, 206, 1, 1624 },
{ 0x1, 433, 0, 982 },
{ 0x11, 205, 0, 1631 },
{ 0x9, 205, 0, 1632 },
{ 0x5, 205, 0, 1633 },
{ 0x3, 205, 1, 1635 },
{ 0x1, 206, 1, 1634 },
{ 0x1, 367, 0, 1011 },
{ 0x4, 211, 0, 1636 },
{ 0x1, 211, 0, 1638 },
{ 0x1, 218, 0, 1639 },
{ 0x1, 217, 1, 1640 },
{ 0x2, 211, 0, 1637 },
{ 0x1, 196, 0, 1641 },
{ 0x880, 202, 0, 1642 },
{ 0x480, 202, 0, 1643 },
{ 0x280, 202, 0, 1644 },
{ 0x180, 202, 1, 1646 },
{ 0x80, 203, 0, 1645 },
{ 0x440, 202, 1, 1657 },
{ 0x88, 204, 0, 1647 },
{ 0x240, 202, 1, 1658 },
{ 0x48, 204, 0, 1648 },
{ 0x140, 202, 1, 1659 },
{ 0x28, 204, 0, 1649 },
{ 0xc0, 202, 1, 1661 },
{ 0x40, 203, 1, 1660 },
{ 0x18, 204, 1, 1651 },
{ 0x8, 204, 0, 1650 },
{ 0x220, 202, 1, 1662 },
{ 0x44, 204, 0, 1652 },
{ 0x120, 202, 1, 1663 },
{ 0x24, 204, 0, 1653 },
{ 0xa0, 202, 1, 1664 },
{ 0x14, 204, 0, 1654 },
{ 0x60, 202, 1, 1666 },
{ 0x20, 203, 1, 1665 },
{ 0xc, 204, 1, 1656 },
{ 0x4, 204, 0, 1655 },
{ 0x110, 202, 0, 1667 },
{ 0x90, 202, 0, 1668 },
{ 0x50, 202, 0, 1669 },
{ 0x30, 202, 1, 1671 },
{ 0x10, 203, 1, 1670 },
{ 0x1, 385, 0, 974 },
{ 0x88, 202, 0, 1672 },
{ 0x48, 202, 0, 1673 },
{ 0x28, 202, 0, 1674 },
{ 0x18, 202, 1, 1676 },
{ 0x8, 203, 1, 1675 },
{ 0xc, 368, 0, 1007 },
{ 0x44, 202, 1, 1687 },
{ 0x22, 204, 0, 1677 },
{ 0x24, 202, 1, 1688 },
{ 0x12, 204, 0, 1678 },
{ 0x14, 202, 1, 1689 },
{ 0xa, 204, 0, 1679 },
{ 0xc, 202, 1, 1691 },
{ 0x4, 203, 1, 1690 },
{ 0x6, 204, 1, 1681 },
{ 0x2, 204, 1, 1680 },
{ 0x6, 368, 0, 1008 },
{ 0x22, 202, 1, 1692 },
{ 0x11, 204, 0, 1682 },
{ 0x12, 202, 1, 1693 },
{ 0x9, 204, 0, 1683 },
{ 0xa, 202, 1, 1694 },
{ 0x5, 204, 0, 1684 },
{ 0x6, 202, 1, 1696 },
{ 0x2, 203, 1, 1695 },
{ 0x3, 204, 1, 1686 },
{ 0x1, 204, 1, 1685 },
{ 0x3, 368, 0, 1009 },
{ 0x11, 202, 0, 1697 },
{ 0x9, 202, 0, 1698 },
{ 0x5, 202, 0, 1699 },
{ 0x3, 202, 1, 1701 },
{ 0x1, 203, 0, 1700 },
{ 0x8, 198, 0, 1702 },
{ 0x4, 198, 0, 1703 },
{ 0x2, 198, 0, 1704 },
{ 0x1, 198, 1, 1706 },
{ 0x1, 199, 1, 1705 },
{ 0x1, 332, 0, 988 },
{ 0x8, 200, 0, 1707 },
{ 0x4, 200, 0, 1708 },
{ 0x2, 200, 0, 1709 },
{ 0x1, 200, 1, 1711 },
{ 0x1, 201, 1, 1710 },
{ 0x1, 331, 0, 989 },
{ 0x8, 209, 0, 1712 },
{ 0x4, 209, 0, 1713 },
{ 0x2, 209, 0, 1714 },
{ 0x1, 209, 1, 1716 },
{ 0x1, 210, 1, 1715 },
{ 0x1, 330, 0, 990 },
{ 0x8, 212, 0, 1717 },
{ 0x4, 212, 0, 1718 },
{ 0x2, 212, 0, 1719 },
{ 0x1, 212, 1, 1721 },
{ 0x1, 213, 1, 1720 },
{ 0x1, 329, 0, 991 },
{ 0x8, 224, 0, 1722 },
{ 0x4, 224, 0, 1723 },
{ 0x2, 224, 0, 1724 },
{ 0x1, 224, 1, 1726 },
{ 0x1, 225, 0, 1725 },
{ 0x8, 222, 0, 1727 },
{ 0x4, 222, 0, 1728 },
{ 0x2, 222, 0, 1729 },
{ 0x1, 222, 1, 1731 },
{ 0x1, 223, 0, 1730 },
{ 0x1, 240, 0, 1732 },
{ 0x1, 340, 0, 1733 },
{ 0x1, 33, 0, 1734 },
{ 0x8, 151, 0, 1735 },
{ 0x4, 151, 0, 1736 },
{ 0x2, 151, 0, 1737 },
{ 0x1, 151, 1, 1739 },
{ 0x1, 152, 0, 1738 },
{ 0x8, 157, 0, 1740 },
{ 0x4, 157, 0, 1741 },
{ 0x2, 157, 0, 1742 },
{ 0x1, 157, 1, 1744 },
{ 0x1, 158, 0, 1743 },
{ 0x8, 231, 0, 1745 },
{ 0x4, 231, 0, 1746 },
{ 0x2, 231, 0, 1747 },
{ 0x1, 231, 1, 1749 },
{ 0x1, 232, 0, 1748 },
{ 0x1, 173, 0, 1750 },
{ 0x442, 171, 0, 1751 },
{ 0x242, 171, 0, 1752 },
{ 0x142, 171, 0, 1753 },
{ 0xc2, 171, 1, 1755 },
{ 0x6, 172, 0, 1754 },
{ 0x22, 171, 0, 1761 },
{ 0x12, 171, 0, 1762 },
{ 0xa, 171, 0, 1763 },
{ 0x6, 171, 1, 1765 },
{ 0x2, 172, 1, 1764 },
{ 0x1, 135, 0, 1165 },
{ 0x221, 171, 0, 1756 },
{ 0x121, 171, 0, 1757 },
{ 0xa1, 171, 0, 1758 },
{ 0x61, 171, 1, 1760 },
{ 0x3, 172, 0, 1759 },
{ 0x11, 171, 0, 1766 },
{ 0x9, 171, 0, 1767 },
{ 0x5, 171, 0, 1768 },
{ 0x3, 171, 1, 1770 },
{ 0x1, 172, 1, 1769 },
{ 0x1, 134, 0, 1166 },
{ 0x1, 237, 0, 1771 },
{ 0x1, 195, 0, 1772 },
{ 0x1, 149, 0, 1773 },
{ 0x1, 148, 0, 1774 },
{ 0x4, 234, 0, 1775 },
{ 0x2, 234, 0, 1776 },
{ 0x1, 234, 0, 1777 },
{ 0x1, 197, 0, 1778 },
{ 0x2, 235, 0, 1779 },
{ 0x1, 235, 0, 1780 },
{ 0x4, 185, 0, 1781 },
{ 0x2, 185, 0, 1782 },
{ 0x1, 185, 0, 1783 },
{ 0x4, 182, 0, 1784 },
{ 0x1, 190, 0, 1787 },
{ 0x1, 189, 1, 1788 },
{ 0x2, 182, 0, 1785 },
{ 0x1, 142, 0, 1789 },
{ 0x1, 297, 1, 1790 },
{ 0x1, 182, 0, 1786 },
{ 0x8, 144, 0, 1791 },
{ 0x4, 144, 0, 1792 },
{ 0x2, 144, 0, 1793 },
{ 0x1, 144, 1, 1795 },
{ 0x1, 145, 0, 1794 },
{ 0x8, 146, 0, 1796 },
{ 0x4, 146, 0, 1797 },
{ 0x2, 146, 0, 1798 },
{ 0x1, 146, 1, 1800 },
{ 0x1, 147, 1, 1799 },
{ 0x1, 426, 0, 1167 },
{ 0x8, 180, 0, 1801 },
{ 0x4, 180, 0, 1802 },
{ 0x2, 180, 0, 1803 },
{ 0x1, 180, 1, 1805 },
{ 0x1, 181, 1, 1804 },
{ 0x1, 425, 0, 1168 },
{ 0x8, 183, 0, 1806 },
{ 0x4, 183, 0, 1807 },
{ 0x2, 183, 0, 1808 },
{ 0x1, 183, 1, 1810 },
{ 0x1, 184, 1, 1809 },
{ 0x1, 424, 0, 1169 },
{ 0x8, 228, 0, 1811 },
{ 0x4, 228, 0, 1812 },
{ 0x2, 228, 0, 1813 },
{ 0x1, 228, 1, 1815 },
{ 0x1, 229, 0, 1814 },
{ 0x8, 226, 0, 1816 },
{ 0x4, 226, 0, 1817 },
{ 0x2, 226, 0, 1818 },
{ 0x1, 226, 1, 1820 },
{ 0x1, 227, 0, 1819 },
{ 0x8, 44, 0, 1825 },
{ 0x18, 44, 0, 1821 },
{ 0x4, 44, 0, 1826 },
{ 0xc, 44, 0, 1822 },
{ 0x2, 44, 0, 1827 },
{ 0x6, 44, 0, 1823 },
{ 0x1, 44, 0, 1828 },
{ 0x3, 44, 0, 1824 },
{ 0x51, 30, 0, 1830 },
{ 0xd1, 30, 0, 1829 },
{ 0x31, 30, 1, 1840 },
{ 0x11, 31, 0, 1839 },
{ 0x71, 30, 1, 1838 },
{ 0x31, 31, 0, 1837 },
{ 0x29, 30, 0, 1832 },
{ 0x69, 30, 0, 1831 },
{ 0x19, 30, 1, 1844 },
{ 0x9, 31, 0, 1843 },
{ 0x39, 30, 1, 1842 },
{ 0x19, 31, 0, 1841 },
{ 0x15, 30, 0, 1834 },
{ 0x35, 30, 0, 1833 },
{ 0xd, 30, 1, 1848 },
{ 0x5, 31, 0, 1847 },
{ 0x1d, 30, 1, 1846 },
{ 0xd, 31, 0, 1845 },
{ 0xb, 30, 0, 1836 },
{ 0x1b, 30, 0, 1835 },
{ 0x7, 30, 1, 1852 },
{ 0x3, 31, 0, 1851 },
{ 0xf, 30, 1, 1850 },
{ 0x7, 31, 0, 1849 },
{ 0xa2, 28, 0, 1854 },
{ 0x1a2, 28, 0, 1853 },
{ 0x62, 28, 1, 1864 },
{ 0x22, 29, 0, 1863 },
{ 0xe2, 28, 1, 1862 },
{ 0x62, 29, 0, 1861 },
{ 0x52, 28, 0, 1856 },
{ 0xd2, 28, 0, 1855 },
{ 0x32, 28, 1, 1868 },
{ 0x12, 29, 0, 1867 },
{ 0x72, 28, 1, 1866 },
{ 0x32, 29, 0, 1865 },
{ 0x2a, 28, 0, 1858 },
{ 0x6a, 28, 0, 1857 },
{ 0x1a, 28, 1, 1872 },
{ 0xa, 29, 0, 1871 },
{ 0x3a, 28, 1, 1870 },
{ 0x1a, 29, 0, 1869 },
{ 0x16, 28, 0, 1860 },
{ 0x36, 28, 0, 1859 },
{ 0xe, 28, 1, 1876 },
{ 0x6, 29, 0, 1875 },
{ 0x1e, 28, 1, 1874 },
{ 0xe, 29, 0, 1873 },
{ 0x51, 28, 0, 1878 },
{ 0xd1, 28, 0, 1877 },
{ 0x31, 28, 1, 1888 },
{ 0x11, 29, 0, 1887 },
{ 0x71, 28, 1, 1886 },
{ 0x31, 29, 0, 1885 },
{ 0x29, 28, 0, 1880 },
{ 0x69, 28, 0, 1879 },
{ 0x19, 28, 1, 1892 },
{ 0x9, 29, 0, 1891 },
{ 0x39, 28, 1, 1890 },
{ 0x19, 29, 0, 1889 },
{ 0x15, 28, 0, 1882 },
{ 0x35, 28, 0, 1881 },
{ 0xd, 28, 1, 1896 },
{ 0x5, 29, 0, 1895 },
{ 0x1d, 28, 1, 1894 },
{ 0xd, 29, 0, 1893 },
{ 0xb, 28, 0, 1884 },
{ 0x1b, 28, 0, 1883 },
{ 0x7, 28, 1, 1900 },
{ 0x3, 29, 0, 1899 },
{ 0xf, 28, 1, 1898 },
{ 0x7, 29, 0, 1897 },
{ 0x51, 26, 0, 1902 },
{ 0xd1, 26, 0, 1901 },
{ 0x31, 26, 1, 1912 },
{ 0x11, 27, 0, 1911 },
{ 0x71, 26, 1, 1910 },
{ 0x31, 27, 0, 1909 },
{ 0x29, 26, 0, 1904 },
{ 0x69, 26, 0, 1903 },
{ 0x19, 26, 1, 1916 },
{ 0x9, 27, 0, 1915 },
{ 0x39, 26, 1, 1914 },
{ 0x19, 27, 0, 1913 },
{ 0x15, 26, 0, 1906 },
{ 0x35, 26, 0, 1905 },
{ 0xd, 26, 1, 1920 },
{ 0x5, 27, 0, 1919 },
{ 0x1d, 26, 1, 1918 },
{ 0xd, 27, 0, 1917 },
{ 0xb, 26, 0, 1908 },
{ 0x1b, 26, 0, 1907 },
{ 0x7, 26, 1, 1924 },
{ 0x3, 27, 0, 1923 },
{ 0xf, 26, 1, 1922 },
{ 0x7, 27, 0, 1921 },
{ 0xa2, 24, 0, 1926 },
{ 0x1a2, 24, 0, 1925 },
{ 0x62, 24, 1, 1936 },
{ 0x22, 25, 0, 1935 },
{ 0xe2, 24, 1, 1934 },
{ 0x62, 25, 0, 1933 },
{ 0x52, 24, 0, 1928 },
{ 0xd2, 24, 0, 1927 },
{ 0x32, 24, 1, 1940 },
{ 0x12, 25, 0, 1939 },
{ 0x72, 24, 1, 1938 },
{ 0x32, 25, 0, 1937 },
{ 0x2a, 24, 0, 1930 },
{ 0x6a, 24, 0, 1929 },
{ 0x1a, 24, 1, 1944 },
{ 0xa, 25, 0, 1943 },
{ 0x3a, 24, 1, 1942 },
{ 0x1a, 25, 0, 1941 },
{ 0x16, 24, 0, 1932 },
{ 0x36, 24, 0, 1931 },
{ 0xe, 24, 1, 1948 },
{ 0x6, 25, 0, 1947 },
{ 0x1e, 24, 1, 1946 },
{ 0xe, 25, 0, 1945 },
{ 0x51, 24, 0, 1950 },
{ 0xd1, 24, 0, 1949 },
{ 0x31, 24, 1, 1960 },
{ 0x11, 25, 0, 1959 },
{ 0x71, 24, 1, 1958 },
{ 0x31, 25, 0, 1957 },
{ 0x29, 24, 0, 1952 },
{ 0x69, 24, 0, 1951 },
{ 0x19, 24, 1, 1964 },
{ 0x9, 25, 0, 1963 },
{ 0x39, 24, 1, 1962 },
{ 0x19, 25, 0, 1961 },
{ 0x15, 24, 0, 1954 },
{ 0x35, 24, 0, 1953 },
{ 0xd, 24, 1, 1968 },
{ 0x5, 25, 0, 1967 },
{ 0x1d, 24, 1, 1966 },
{ 0xd, 25, 0, 1965 },
{ 0xb, 24, 0, 1956 },
{ 0x1b, 24, 0, 1955 },
{ 0x7, 24, 1, 1972 },
{ 0x3, 25, 0, 1971 },
{ 0xf, 24, 1, 1970 },
{ 0x7, 25, 0, 1969 },
{ 0x51, 22, 1, 1998 },
{ 0x50, 22, 0, 1974 },
{ 0xd1, 22, 1, 1997 },
{ 0xd0, 22, 0, 1973 },
{ 0x31, 22, 1, 2008 },
{ 0x30, 22, 1, 1984 },
{ 0x11, 23, 1, 2007 },
{ 0x10, 23, 0, 1983 },
{ 0x71, 22, 1, 2006 },
{ 0x70, 22, 1, 1982 },
{ 0x31, 23, 1, 2005 },
{ 0x30, 23, 0, 1981 },
{ 0x29, 22, 1, 2000 },
{ 0x28, 22, 0, 1976 },
{ 0x69, 22, 1, 1999 },
{ 0x68, 22, 0, 1975 },
{ 0x19, 22, 1, 2012 },
{ 0x18, 22, 1, 1988 },
{ 0x9, 23, 1, 2011 },
{ 0x8, 23, 0, 1987 },
{ 0x39, 22, 1, 2010 },
{ 0x38, 22, 1, 1986 },
{ 0x19, 23, 1, 2009 },
{ 0x18, 23, 0, 1985 },
{ 0x15, 22, 1, 2002 },
{ 0x14, 22, 0, 1978 },
{ 0x35, 22, 1, 2001 },
{ 0x34, 22, 0, 1977 },
{ 0xd, 22, 1, 2016 },
{ 0xc, 22, 1, 1992 },
{ 0x5, 23, 1, 2015 },
{ 0x4, 23, 0, 1991 },
{ 0x1d, 22, 1, 2014 },
{ 0x1c, 22, 1, 1990 },
{ 0xd, 23, 1, 2013 },
{ 0xc, 23, 0, 1989 },
{ 0xb, 22, 1, 2004 },
{ 0xa, 22, 0, 1980 },
{ 0x1b, 22, 1, 2003 },
{ 0x1a, 22, 0, 1979 },
{ 0x7, 22, 1, 2020 },
{ 0x6, 22, 1, 1996 },
{ 0x3, 23, 1, 2019 },
{ 0x2, 23, 0, 1995 },
{ 0xf, 22, 1, 2018 },
{ 0xe, 22, 1, 1994 },
{ 0x7, 23, 1, 2017 },
{ 0x6, 23, 0, 1993 },
{ 0x8, 21, 0, 2022 },
{ 0x18, 21, 0, 2021 },
{ 0x1, 21, 1, 2026 },
{ 0x2, 21, 0, 2025 },
{ 0x3, 21, 1, 2024 },
{ 0x4, 21, 0, 2023 },
{ 0x1, 239, 0, 2027 },
{ 0x1, 339, 0, 2028 },
{ 0x14, 43, 0, 2031 },
{ 0x34, 43, 0, 2029 },
{ 0xc, 43, 0, 2032 },
{ 0x1c, 43, 0, 2030 },
{ 0x2, 43, 0, 2035 },
{ 0x6, 43, 0, 2033 },
{ 0x1, 43, 0, 2036 },
{ 0x3, 43, 0, 2034 },
{ 0x51, 19, 0, 2038 },
{ 0xd1, 19, 0, 2037 },
{ 0x31, 19, 1, 2048 },
{ 0x11, 20, 0, 2047 },
{ 0x71, 19, 1, 2046 },
{ 0x31, 20, 0, 2045 },
{ 0x29, 19, 0, 2040 },
{ 0x69, 19, 0, 2039 },
{ 0x19, 19, 1, 2052 },
{ 0x9, 20, 0, 2051 },
{ 0x39, 19, 1, 2050 },
{ 0x19, 20, 0, 2049 },
{ 0x15, 19, 0, 2042 },
{ 0x35, 19, 0, 2041 },
{ 0xd, 19, 1, 2056 },
{ 0x5, 20, 0, 2055 },
{ 0x1d, 19, 1, 2054 },
{ 0xd, 20, 0, 2053 },
{ 0xb, 19, 0, 2044 },
{ 0x1b, 19, 0, 2043 },
{ 0x7, 19, 1, 2060 },
{ 0x3, 20, 0, 2059 },
{ 0xf, 19, 1, 2058 },
{ 0x7, 20, 0, 2057 },
{ 0x1, 32, 0, 2061 },
{ 0x1, 140, 0, 2062 },
{ 0x2, 45, 0, 2063 },
{ 0x1, 45, 0, 2064 },
{ 0x1, 387, 0, 2065 },
{ 0x2, 52, 0, 2066 },
{ 0x1, 52, 0, 2067 },
{ 0x1, 133, 0, 2068 },
{ 0x51, 17, 0, 2070 },
{ 0xd1, 17, 0, 2069 },
{ 0x31, 17, 1, 2080 },
{ 0x11, 18, 0, 2079 },
{ 0x71, 17, 1, 2078 },
{ 0x31, 18, 0, 2077 },
{ 0x29, 17, 0, 2072 },
{ 0x69, 17, 0, 2071 },
{ 0x19, 17, 1, 2084 },
{ 0x9, 18, 0, 2083 },
{ 0x39, 17, 1, 2082 },
{ 0x19, 18, 0, 2081 },
{ 0x15, 17, 0, 2074 },
{ 0x35, 17, 0, 2073 },
{ 0xd, 17, 1, 2088 },
{ 0x5, 18, 0, 2087 },
{ 0x1d, 17, 1, 2086 },
{ 0xd, 18, 0, 2085 },
{ 0xb, 17, 0, 2076 },
{ 0x1b, 17, 0, 2075 },
{ 0x7, 17, 1, 2092 },
{ 0x3, 18, 0, 2091 },
{ 0xf, 17, 1, 2090 },
{ 0x7, 18, 0, 2089 },
{ 0xa20, 15, 0, 2094 },
{ 0x1a20, 15, 0, 2093 },
{ 0x620, 15, 1, 2104 },
{ 0x220, 16, 0, 2103 },
{ 0xe20, 15, 1, 2102 },
{ 0x620, 16, 0, 2101 },
{ 0x520, 15, 0, 2096 },
{ 0xd20, 15, 0, 2095 },
{ 0x320, 15, 1, 2108 },
{ 0x120, 16, 0, 2107 },
{ 0x720, 15, 1, 2106 },
{ 0x320, 16, 0, 2105 },
{ 0x2a0, 15, 0, 2098 },
{ 0x6a0, 15, 0, 2097 },
{ 0x1a0, 15, 1, 2112 },
{ 0xa0, 16, 0, 2111 },
{ 0x3a0, 15, 1, 2110 },
{ 0x1a0, 16, 0, 2109 },
{ 0x160, 15, 0, 2100 },
{ 0x360, 15, 0, 2099 },
{ 0xe0, 15, 1, 2116 },
{ 0x60, 16, 0, 2115 },
{ 0x1e0, 15, 1, 2114 },
{ 0xe0, 16, 0, 2113 },
{ 0x51, 15, 1, 2142 },
{ 0x50, 15, 0, 2118 },
{ 0xd1, 15, 1, 2141 },
{ 0xd0, 15, 0, 2117 },
{ 0x31, 15, 1, 2152 },
{ 0x30, 15, 1, 2128 },
{ 0x11, 16, 1, 2151 },
{ 0x10, 16, 0, 2127 },
{ 0x71, 15, 1, 2150 },
{ 0x70, 15, 1, 2126 },
{ 0x31, 16, 1, 2149 },
{ 0x30, 16, 0, 2125 },
{ 0x29, 15, 1, 2144 },
{ 0x28, 15, 0, 2120 },
{ 0x69, 15, 1, 2143 },
{ 0x68, 15, 0, 2119 },
{ 0x19, 15, 1, 2156 },
{ 0x18, 15, 1, 2132 },
{ 0x9, 16, 1, 2155 },
{ 0x8, 16, 0, 2131 },
{ 0x39, 15, 1, 2154 },
{ 0x38, 15, 1, 2130 },
{ 0x19, 16, 1, 2153 },
{ 0x18, 16, 0, 2129 },
{ 0x15, 15, 1, 2146 },
{ 0x14, 15, 0, 2122 },
{ 0x35, 15, 1, 2145 },
{ 0x34, 15, 0, 2121 },
{ 0xd, 15, 1, 2160 },
{ 0xc, 15, 1, 2136 },
{ 0x5, 16, 1, 2159 },
{ 0x4, 16, 0, 2135 },
{ 0x1d, 15, 1, 2158 },
{ 0x1c, 15, 1, 2134 },
{ 0xd, 16, 1, 2157 },
{ 0xc, 16, 0, 2133 },
{ 0xb, 15, 1, 2148 },
{ 0xa, 15, 0, 2124 },
{ 0x1b, 15, 1, 2147 },
{ 0x1a, 15, 0, 2123 },
{ 0x7, 15, 1, 2164 },
{ 0x6, 15, 1, 2140 },
{ 0x3, 16, 1, 2163 },
{ 0x2, 16, 0, 2139 },
{ 0xf, 15, 1, 2162 },
{ 0xe, 15, 1, 2138 },
{ 0x7, 16, 1, 2161 },
{ 0x6, 16, 0, 2137 },
{ 0x8, 14, 0, 2166 },
{ 0x18, 14, 0, 2165 },
{ 0x1, 14, 1, 2170 },
{ 0x2, 14, 0, 2169 },
{ 0x3, 14, 1, 2168 },
{ 0x4, 14, 0, 2167 },
{ 0x1, 109, 1, 2322 },
{ 0x1, 110, 1, 2321 },
{ 0x1, 111, 1, 2320 },
{ 0x1, 112, 1, 2319 },
{ 0x1, 113, 1, 2318 },
{ 0x1, 114, 1, 2317 },
{ 0x1, 115, 1, 2316 },
{ 0x1, 116, 1, 2315 },
{ 0x39, 41, 1, 22 },
{ 0x19, 42, 0, 21 },
{ 0x3, 109, 1, 2314 },
{ 0x3, 110, 1, 2313 },
{ 0x3, 111, 1, 2312 },
{ 0x3, 112, 1, 2311 },
{ 0x3, 113, 1, 2310 },
{ 0x3, 114, 1, 2309 },
{ 0x3, 115, 1, 2308 },
{ 0x3, 116, 1, 2307 },
{ 0x69, 41, 0, 11 },
{ 0x14, 100, 1, 2302 },
{ 0x22, 101, 1, 2299 },
{ 0x44, 101, 1, 2301 },
{ 0xa, 108, 1, 2300 },
{ 0xd1, 41, 0, 9 },
{ 0x34, 100, 1, 2174 },
{ 0xc4, 101, 1, 2173 },
{ 0x1c, 107, 1, 2171 },
{ 0xe, 122, 0, 2172 },
{ 0xc, 100, 1, 2462 },
{ 0xa, 101, 1, 2459 },
{ 0x14, 101, 1, 2461 },
{ 0x6, 108, 0, 2460 },
{ 0x2, 100, 1, 2186 },
{ 0x2, 101, 1, 2185 },
{ 0x2, 106, 1, 2184 },
{ 0x2, 107, 0, 2183 },
{ 0x12, 100, 1, 2182 },
{ 0x42, 101, 1, 2181 },
{ 0x6, 106, 1, 2180 },
{ 0x6, 107, 0, 2179 },
{ 0xa, 100, 1, 2306 },
{ 0x12, 101, 1, 2305 },
{ 0x24, 101, 1, 2303 },
{ 0x5, 108, 1, 2304 },
{ 0x71, 41, 1, 18 },
{ 0x31, 42, 0, 17 },
{ 0x1a, 100, 1, 2178 },
{ 0x32, 101, 1, 2177 },
{ 0x1a, 107, 1, 2175 },
{ 0x7, 122, 0, 2176 },
{ 0x6, 100, 1, 2466 },
{ 0x6, 101, 1, 2465 },
{ 0xc, 101, 1, 2463 },
{ 0x3, 108, 0, 2464 },
{ 0x1, 100, 1, 2482 },
{ 0x1, 101, 1, 2481 },
{ 0x1, 102, 1, 2480 },
{ 0x1, 103, 1, 2479 },
{ 0x1, 104, 1, 2478 },
{ 0x1, 105, 1, 2477 },
{ 0x1, 106, 1, 2476 },
{ 0x1, 107, 0, 2475 },
{ 0x3, 100, 1, 2474 },
{ 0x3, 101, 1, 2473 },
{ 0x3, 102, 1, 2472 },
{ 0x3, 103, 1, 2471 },
{ 0x3, 104, 1, 2470 },
{ 0x3, 105, 1, 2469 },
{ 0x3, 106, 1, 2468 },
{ 0x3, 107, 0, 2467 },
{ 0x8, 67, 1, 2346 },
{ 0x8, 68, 1, 2345 },
{ 0x2, 73, 1, 2340 },
{ 0x2, 74, 1, 2339 },
{ 0x1, 76, 1, 2344 },
{ 0x1, 77, 1, 2343 },
{ 0x1, 78, 1, 2342 },
{ 0x1, 79, 1, 2341 },
{ 0xf, 41, 1, 30 },
{ 0x7, 42, 0, 29 },
{ 0x18, 67, 1, 2338 },
{ 0x18, 68, 1, 2337 },
{ 0x6, 73, 1, 2332 },
{ 0x6, 74, 1, 2331 },
{ 0x3, 76, 1, 2336 },
{ 0x3, 77, 1, 2335 },
{ 0x3, 78, 1, 2334 },
{ 0x3, 79, 1, 2333 },
{ 0x1b, 41, 0, 15 },
{ 0x14, 67, 1, 2326 },
{ 0x22, 68, 1, 2323 },
{ 0x44, 68, 1, 2325 },
{ 0xa, 75, 1, 2324 },
{ 0x35, 41, 0, 13 },
{ 0x34, 67, 1, 2190 },
{ 0xc4, 68, 1, 2189 },
{ 0x38, 74, 1, 2187 },
{ 0xe, 85, 0, 2188 },
{ 0xc, 67, 1, 2486 },
{ 0xa, 68, 1, 2483 },
{ 0x14, 68, 1, 2485 },
{ 0x6, 75, 0, 2484 },
{ 0x2, 67, 1, 2202 },
{ 0x2, 68, 1, 2201 },
{ 0x4, 73, 1, 2200 },
{ 0x4, 74, 0, 2199 },
{ 0x12, 67, 1, 2198 },
{ 0x42, 68, 1, 2197 },
{ 0xc, 73, 1, 2196 },
{ 0xc, 74, 0, 2195 },
{ 0xa, 67, 1, 2330 },
{ 0x12, 68, 1, 2329 },
{ 0x24, 68, 1, 2327 },
{ 0x5, 75, 1, 2328 },
{ 0x1d, 41, 1, 26 },
{ 0xd, 42, 0, 25 },
{ 0x1a, 67, 1, 2194 },
{ 0x32, 68, 1, 2193 },
{ 0x34, 74, 1, 2191 },
{ 0x7, 85, 0, 2192 },
{ 0x6, 67, 1, 2490 },
{ 0x6, 68, 1, 2489 },
{ 0xc, 68, 1, 2487 },
{ 0x3, 75, 0, 2488 },
{ 0x1, 67, 1, 2506 },
{ 0x1, 68, 1, 2505 },
{ 0x1, 69, 1, 2504 },
{ 0x1, 70, 1, 2503 },
{ 0x1, 71, 1, 2502 },
{ 0x1, 72, 1, 2501 },
{ 0x1, 73, 1, 2500 },
{ 0x1, 74, 0, 2499 },
{ 0x3, 67, 1, 2498 },
{ 0x3, 68, 1, 2497 },
{ 0x3, 69, 1, 2496 },
{ 0x3, 70, 1, 2495 },
{ 0x3, 71, 1, 2494 },
{ 0x3, 72, 1, 2493 },
{ 0x3, 73, 1, 2492 },
{ 0x3, 74, 0, 2491 },
{ 0x28, 95, 1, 2354 },
{ 0x44, 96, 1, 2349 },
{ 0x88, 96, 1, 2353 },
{ 0x44, 97, 1, 2348 },
{ 0x88, 97, 1, 2352 },
{ 0x44, 98, 1, 2347 },
{ 0x88, 98, 1, 2351 },
{ 0x28, 99, 0, 2350 },
{ 0x68, 95, 1, 2210 },
{ 0x188, 96, 1, 2209 },
{ 0x188, 97, 1, 2208 },
{ 0x188, 98, 1, 2207 },
{ 0x38, 118, 1, 2206 },
{ 0x38, 119, 1, 2205 },
{ 0x38, 120, 1, 2204 },
{ 0x38, 121, 0, 2203 },
{ 0x18, 95, 1, 2514 },
{ 0x14, 96, 1, 2509 },
{ 0x28, 96, 1, 2513 },
{ 0x14, 97, 1, 2508 },
{ 0x28, 97, 1, 2512 },
{ 0x14, 98, 1, 2507 },
{ 0x28, 98, 1, 2511 },
{ 0x18, 99, 0, 2510 },
{ 0x14, 95, 1, 2362 },
{ 0x24, 96, 1, 2361 },
{ 0x48, 96, 1, 2357 },
{ 0x24, 97, 1, 2360 },
{ 0x48, 97, 1, 2356 },
{ 0x24, 98, 1, 2359 },
{ 0x48, 98, 1, 2355 },
{ 0x14, 99, 0, 2358 },
{ 0x34, 95, 1, 2218 },
{ 0x64, 96, 1, 2217 },
{ 0x64, 97, 1, 2216 },
{ 0x64, 98, 1, 2215 },
{ 0x1c, 118, 1, 2214 },
{ 0x1c, 119, 1, 2213 },
{ 0x1c, 120, 1, 2212 },
{ 0x1c, 121, 0, 2211 },
{ 0xc, 95, 1, 2522 },
{ 0xc, 96, 1, 2521 },
{ 0x18, 96, 1, 2517 },
{ 0xc, 97, 1, 2520 },
{ 0x18, 97, 1, 2516 },
{ 0xc, 98, 1, 2519 },
{ 0x18, 98, 1, 2515 },
{ 0xc, 99, 0, 2518 },
{ 0xa, 95, 1, 2370 },
{ 0x11, 96, 1, 2365 },
{ 0x22, 96, 1, 2369 },
{ 0x11, 97, 1, 2364 },
{ 0x22, 97, 1, 2368 },
{ 0x11, 98, 1, 2363 },
{ 0x22, 98, 1, 2367 },
{ 0xa, 99, 0, 2366 },
{ 0x1a, 95, 1, 2226 },
{ 0x62, 96, 1, 2225 },
{ 0x62, 97, 1, 2224 },
{ 0x62, 98, 1, 2223 },
{ 0xe, 118, 1, 2222 },
{ 0xe, 119, 1, 2221 },
{ 0xe, 120, 1, 2220 },
{ 0xe, 121, 0, 2219 },
{ 0x6, 95, 1, 2530 },
{ 0x5, 96, 1, 2525 },
{ 0xa, 96, 1, 2529 },
{ 0x5, 97, 1, 2524 },
{ 0xa, 97, 1, 2528 },
{ 0x5, 98, 1, 2523 },
{ 0xa, 98, 1, 2527 },
{ 0x6, 99, 0, 2526 },
{ 0x5, 95, 1, 2378 },
{ 0x9, 96, 1, 2377 },
{ 0x12, 96, 1, 2373 },
{ 0x9, 97, 1, 2376 },
{ 0x12, 97, 1, 2372 },
{ 0x9, 98, 1, 2375 },
{ 0x12, 98, 1, 2371 },
{ 0x5, 99, 0, 2374 },
{ 0xd, 95, 1, 2234 },
{ 0x19, 96, 1, 2233 },
{ 0x19, 97, 1, 2232 },
{ 0x19, 98, 1, 2231 },
{ 0x7, 118, 1, 2230 },
{ 0x7, 119, 1, 2229 },
{ 0x7, 120, 1, 2228 },
{ 0x7, 121, 0, 2227 },
{ 0x3, 95, 1, 2538 },
{ 0x3, 96, 1, 2537 },
{ 0x6, 96, 1, 2533 },
{ 0x3, 97, 1, 2536 },
{ 0x6, 97, 1, 2532 },
{ 0x3, 98, 1, 2535 },
{ 0x6, 98, 1, 2531 },
{ 0x3, 99, 0, 2534 },
{ 0x28, 62, 1, 2386 },
{ 0x44, 63, 1, 2381 },
{ 0x88, 63, 1, 2385 },
{ 0x44, 64, 1, 2380 },
{ 0x88, 64, 1, 2384 },
{ 0x44, 65, 1, 2379 },
{ 0x88, 65, 1, 2383 },
{ 0x28, 66, 0, 2382 },
{ 0x68, 62, 1, 2242 },
{ 0x188, 63, 1, 2241 },
{ 0x188, 64, 1, 2240 },
{ 0x188, 65, 1, 2239 },
{ 0x38, 81, 1, 2238 },
{ 0x38, 82, 1, 2237 },
{ 0x38, 83, 1, 2236 },
{ 0x38, 84, 0, 2235 },
{ 0x18, 62, 1, 2546 },
{ 0x14, 63, 1, 2541 },
{ 0x28, 63, 1, 2545 },
{ 0x14, 64, 1, 2540 },
{ 0x28, 64, 1, 2544 },
{ 0x14, 65, 1, 2539 },
{ 0x28, 65, 1, 2543 },
{ 0x18, 66, 0, 2542 },
{ 0x14, 62, 1, 2394 },
{ 0x24, 63, 1, 2393 },
{ 0x48, 63, 1, 2389 },
{ 0x24, 64, 1, 2392 },
{ 0x48, 64, 1, 2388 },
{ 0x24, 65, 1, 2391 },
{ 0x48, 65, 1, 2387 },
{ 0x14, 66, 0, 2390 },
{ 0x34, 62, 1, 2250 },
{ 0x64, 63, 1, 2249 },
{ 0x64, 64, 1, 2248 },
{ 0x64, 65, 1, 2247 },
{ 0x1c, 81, 1, 2246 },
{ 0x1c, 82, 1, 2245 },
{ 0x1c, 83, 1, 2244 },
{ 0x1c, 84, 0, 2243 },
{ 0xc, 62, 1, 2554 },
{ 0xc, 63, 1, 2553 },
{ 0x18, 63, 1, 2549 },
{ 0xc, 64, 1, 2552 },
{ 0x18, 64, 1, 2548 },
{ 0xc, 65, 1, 2551 },
{ 0x18, 65, 1, 2547 },
{ 0xc, 66, 0, 2550 },
{ 0xa, 62, 1, 2402 },
{ 0x11, 63, 1, 2397 },
{ 0x22, 63, 1, 2401 },
{ 0x11, 64, 1, 2396 },
{ 0x22, 64, 1, 2400 },
{ 0x11, 65, 1, 2395 },
{ 0x22, 65, 1, 2399 },
{ 0xa, 66, 0, 2398 },
{ 0x1a, 62, 1, 2258 },
{ 0x62, 63, 1, 2257 },
{ 0x62, 64, 1, 2256 },
{ 0x62, 65, 1, 2255 },
{ 0xe, 81, 1, 2254 },
{ 0xe, 82, 1, 2253 },
{ 0xe, 83, 1, 2252 },
{ 0xe, 84, 0, 2251 },
{ 0x6, 62, 1, 2562 },
{ 0x5, 63, 1, 2557 },
{ 0xa, 63, 1, 2561 },
{ 0x5, 64, 1, 2556 },
{ 0xa, 64, 1, 2560 },
{ 0x5, 65, 1, 2555 },
{ 0xa, 65, 1, 2559 },
{ 0x6, 66, 0, 2558 },
{ 0x5, 62, 1, 2410 },
{ 0x9, 63, 1, 2409 },
{ 0x12, 63, 1, 2405 },
{ 0x9, 64, 1, 2408 },
{ 0x12, 64, 1, 2404 },
{ 0x9, 65, 1, 2407 },
{ 0x12, 65, 1, 2403 },
{ 0x5, 66, 0, 2406 },
{ 0xd, 62, 1, 2266 },
{ 0x19, 63, 1, 2265 },
{ 0x19, 64, 1, 2264 },
{ 0x19, 65, 1, 2263 },
{ 0x7, 81, 1, 2262 },
{ 0x7, 82, 1, 2261 },
{ 0x7, 83, 1, 2260 },
{ 0x7, 84, 0, 2259 },
{ 0x3, 62, 1, 2570 },
{ 0x3, 63, 1, 2569 },
{ 0x6, 63, 1, 2565 },
{ 0x3, 64, 1, 2568 },
{ 0x6, 64, 1, 2564 },
{ 0x3, 65, 1, 2567 },
{ 0x6, 65, 1, 2563 },
{ 0x3, 66, 0, 2566 },
{ 0x8, 86, 1, 2434 },
{ 0x8, 87, 1, 2433 },
{ 0x2, 88, 1, 2432 },
{ 0x2, 89, 1, 2431 },
{ 0x2, 90, 1, 2430 },
{ 0x2, 91, 1, 2429 },
{ 0x2, 92, 1, 2428 },
{ 0x2, 93, 0, 2427 },
{ 0x18, 86, 1, 2426 },
{ 0x18, 87, 1, 2425 },
{ 0x6, 88, 1, 2424 },
{ 0x6, 89, 1, 2423 },
{ 0x6, 90, 1, 2422 },
{ 0x6, 91, 1, 2421 },
{ 0x6, 92, 1, 2420 },
{ 0x6, 93, 0, 2419 },
{ 0x14, 86, 1, 2414 },
{ 0x22, 87, 1, 2411 },
{ 0x44, 87, 1, 2413 },
{ 0xa, 94, 0, 2412 },
{ 0x34, 86, 1, 2270 },
{ 0xc4, 87, 1, 2269 },
{ 0x38, 93, 1, 2267 },
{ 0xe, 117, 0, 2268 },
{ 0xc, 86, 1, 2574 },
{ 0xa, 87, 1, 2571 },
{ 0x14, 87, 1, 2573 },
{ 0x6, 94, 0, 2572 },
{ 0x2, 86, 1, 2282 },
{ 0x2, 87, 1, 2281 },
{ 0x4, 92, 1, 2280 },
{ 0x4, 93, 0, 2279 },
{ 0x12, 86, 1, 2278 },
{ 0x42, 87, 1, 2277 },
{ 0xc, 92, 1, 2276 },
{ 0xc, 93, 0, 2275 },
{ 0xa, 86, 1, 2418 },
{ 0x12, 87, 1, 2417 },
{ 0x24, 87, 1, 2415 },
{ 0x5, 94, 0, 2416 },
{ 0x1a, 86, 1, 2274 },
{ 0x32, 87, 1, 2273 },
{ 0x34, 93, 1, 2271 },
{ 0x7, 117, 0, 2272 },
{ 0x6, 86, 1, 2578 },
{ 0x6, 87, 1, 2577 },
{ 0xc, 87, 1, 2575 },
{ 0x3, 94, 0, 2576 },
{ 0x1, 86, 1, 2594 },
{ 0x1, 87, 1, 2593 },
{ 0x1, 88, 1, 2592 },
{ 0x1, 89, 1, 2591 },
{ 0x1, 90, 1, 2590 },
{ 0x1, 91, 1, 2589 },
{ 0x1, 92, 1, 2588 },
{ 0x1, 93, 0, 2587 },
{ 0x3, 86, 1, 2586 },
{ 0x3, 87, 1, 2585 },
{ 0x3, 88, 1, 2584 },
{ 0x3, 89, 1, 2583 },
{ 0x3, 90, 1, 2582 },
{ 0x3, 91, 1, 2581 },
{ 0x3, 92, 1, 2580 },
{ 0x3, 93, 0, 2579 },
{ 0x8, 53, 1, 2458 },
{ 0x8, 54, 1, 2457 },
{ 0x2, 55, 1, 2456 },
{ 0x2, 56, 1, 2455 },
{ 0x2, 57, 1, 2454 },
{ 0x2, 58, 1, 2453 },
{ 0x2, 59, 1, 2452 },
{ 0x2, 60, 0, 2451 },
{ 0x18, 53, 1, 2450 },
{ 0x18, 54, 1, 2449 },
{ 0x6, 55, 1, 2448 },
{ 0x6, 56, 1, 2447 },
{ 0x6, 57, 1, 2446 },
{ 0x6, 58, 1, 2445 },
{ 0x6, 59, 1, 2444 },
{ 0x6, 60, 0, 2443 },
{ 0x14, 53, 1, 2438 },
{ 0x22, 54, 1, 2435 },
{ 0x44, 54, 1, 2437 },
{ 0xa, 61, 0, 2436 },
{ 0x34, 53, 1, 2286 },
{ 0xc4, 54, 1, 2285 },
{ 0x38, 60, 1, 2283 },
{ 0xe, 80, 0, 2284 },
{ 0xc, 53, 1, 2598 },
{ 0xa, 54, 1, 2595 },
{ 0x14, 54, 1, 2597 },
{ 0x6, 61, 0, 2596 },
{ 0x2, 53, 1, 2298 },
{ 0x2, 54, 1, 2297 },
{ 0x4, 59, 1, 2296 },
{ 0x4, 60, 0, 2295 },
{ 0x12, 53, 1, 2294 },
{ 0x42, 54, 1, 2293 },
{ 0xc, 59, 1, 2292 },
{ 0xc, 60, 0, 2291 },
{ 0xa, 53, 1, 2442 },
{ 0x12, 54, 1, 2441 },
{ 0x24, 54, 1, 2439 },
{ 0x5, 61, 0, 2440 },
{ 0x1a, 53, 1, 2290 },
{ 0x32, 54, 1, 2289 },
{ 0x34, 60, 1, 2287 },
{ 0x7, 80, 0, 2288 },
{ 0x6, 53, 1, 2602 },
{ 0x6, 54, 1, 2601 },
{ 0xc, 54, 1, 2599 },
{ 0x3, 61, 0, 2600 },
{ 0x1, 53, 1, 2618 },
{ 0x1, 54, 1, 2617 },
{ 0x1, 55, 1, 2616 },
{ 0x1, 56, 1, 2615 },
{ 0x1, 57, 1, 2614 },
{ 0x1, 58, 1, 2613 },
{ 0x1, 59, 1, 2612 },
{ 0x1, 60, 0, 2611 },
{ 0x3, 53, 1, 2610 },
{ 0x3, 54, 1, 2609 },
{ 0x3, 55, 1, 2608 },
{ 0x3, 56, 1, 2607 },
{ 0x3, 57, 1, 2606 },
{ 0x3, 58, 1, 2605 },
{ 0x3, 59, 1, 2604 },
{ 0x3, 60, 0, 2603 },
{ 0x1, 4, 0, 2619 },
{ 0x1, 296, 0, 2620 },
{ 0x1, 379, 0, 2621 },
{ 0x1, 374, 0, 2622 },
{ 0x2, 358, 0, 2623 },
{ 0x1, 358, 0, 2626 },
{ 0x2, 357, 0, 2624 },
{ 0x1, 357, 0, 2627 },
{ 0x2, 356, 0, 2625 },
{ 0x1, 356, 0, 2628 },
{ 0x1, 355, 0, 2629 },
{ 0x1, 354, 0, 2630 },
{ 0x2, 353, 0, 2631 },
{ 0x1, 353, 0, 2633 },
{ 0x2, 352, 0, 2632 },
{ 0x1, 352, 0, 2634 },
{ 0x1, 382, 0, 2641 },
{ 0x8, 381, 0, 2635 },
{ 0x4, 381, 0, 2637 },
{ 0x2, 381, 0, 2639 },
{ 0x1, 381, 0, 2642 },
{ 0x8, 380, 0, 2636 },
{ 0x4, 380, 0, 2638 },
{ 0x2, 380, 0, 2640 },
{ 0x1, 380, 0, 2643 },
{ 0x1, 351, 0, 2650 },
{ 0x8, 350, 0, 2644 },
{ 0x4, 350, 0, 2646 },
{ 0x2, 350, 0, 2648 },
{ 0x1, 350, 0, 2651 },
{ 0x8, 349, 0, 2645 },
{ 0x4, 349, 0, 2647 },
{ 0x2, 349, 1, 2649 },
{ 0x4, 143, 0, 1345 },
{ 0x1, 349, 0, 2652 },
{ 0x1, 6, 0, 2653 },
{ 0x1, 7, 0, 2654 },
{ 0x1, 295, 0, 2655 },
{ 0x1, 451, 0, 2656 },
{ 0x1, 346, 0, 2657 },
{ 0x1, 13, 0, 2658 },
{ 0x1, 11, 0, 2659 },
{ 0x1, 422, 0, 2660 },
{ 0x1, 394, 0, 2661 },
{ 0x1, 393, 0, 2662 },
{ 0x1, 450, 0, 2663 },
{ 0x1, 345, 0, 2664 },
{ 0x1, 12, 0, 2665 },
{ 0x1, 10, 0, 2666 },
{ 0x1, 5, 0, 2667 },
{ 0x1, 421, 0, 2668 },
{ 0x1, 420, 0, 2669 },
{ 0x1, 1, 0, 2670 },
{ 0x1, 0, 0, 2671 },
};

