
/*  A Bison parser, made from ldgram.y
 by  GNU Bison version 1.25
  */

#define YYBISON 1  /* Identify Bison output.  */

#define	INT	258
#define	NAME	259
#define	LNAME	260
#define	PLUSEQ	261
#define	MINUSEQ	262
#define	MULTEQ	263
#define	DIVEQ	264
#define	LSHIFTEQ	265
#define	RSHIFTEQ	266
#define	ANDEQ	267
#define	OREQ	268
#define	OROR	269
#define	ANDAND	270
#define	EQ	271
#define	NE	272
#define	LE	273
#define	GE	274
#define	LSHIFT	275
#define	RSHIFT	276
#define	UNARY	277
#define	END	278
#define	ALIGN_K	279
#define	BLOCK	280
#define	BIND	281
#define	QUAD	282
#define	SQUAD	283
#define	LONG	284
#define	SHORT	285
#define	BYTE	286
#define	SECTIONS	287
#define	PHDRS	288
#define	SIZEOF_HEADERS	289
#define	OUTPUT_FORMAT	290
#define	FORCE_COMMON_ALLOCATION	291
#define	OUTPUT_ARCH	292
#define	INCLUDE	293
#define	MEMORY	294
#define	DEFSYMEND	295
#define	NOLOAD	296
#define	DSECT	297
#define	COPY	298
#define	INFO	299
#define	OVERLAY	300
#define	DEFINED	301
#define	TARGET_K	302
#define	SEARCH_DIR	303
#define	MAP	304
#define	ENTRY	305
#define	NEXT	306
#define	SIZEOF	307
#define	ADDR	308
#define	LOADADDR	309
#define	MAX	310
#define	MIN	311
#define	STARTUP	312
#define	HLL	313
#define	SYSLIB	314
#define	FLOAT	315
#define	NOFLOAT	316
#define	NOCROSSREFS	317
#define	ORIGIN	318
#define	FILL	319
#define	LENGTH	320
#define	CREATE_OBJECT_SYMBOLS	321
#define	INPUT	322
#define	GROUP	323
#define	OUTPUT	324
#define	CONSTRUCTORS	325
#define	ALIGNMOD	326
#define	AT	327
#define	PROVIDE	328
#define	CHIP	329
#define	LIST	330
#define	SECT	331
#define	ABSOLUTE	332
#define	LOAD	333
#define	NEWLINE	334
#define	ENDWORD	335
#define	ORDER	336
#define	NAMEWORD	337
#define	FORMAT	338
#define	PUBLIC	339
#define	BASE	340
#define	ALIAS	341
#define	TRUNCATE	342
#define	REL	343
#define	INPUT_SCRIPT	344
#define	INPUT_MRI_SCRIPT	345
#define	INPUT_DEFSYM	346
#define	CASE	347
#define	EXTERN	348
#define	START	349
#define	VERS_TAG	350
#define	VERS_IDENTIFIER	351
#define	GLOBAL	352
#define	LOCAL	353
#define	VERSIONK	354
#define	INPUT_VERSION_SCRIPT	355

#line 21 "ldgram.y"

/*

 */

#define DONTDECLARE_MALLOC

#include "bfd.h"
#include "sysdep.h"
#include "bfdlink.h"
#include "ld.h"    
#include "ldexp.h"
#include "ldver.h"
#include "ldlang.h"
#include "ldemul.h"
#include "ldfile.h"
#include "ldmisc.h"
#include "ldmain.h"
#include "mri.h"
#include "ldlex.h"

#ifndef YYDEBUG
#define YYDEBUG 1
#endif

static enum section_type sectype;

lang_memory_region_type *region;


char *current_file;
boolean ldgram_want_filename = true;
boolean had_script = false;
boolean force_make_executable = false;

boolean ldgram_in_script = false;
boolean ldgram_had_equals = false;


#define ERROR_NAME_MAX 20
static char *error_names[ERROR_NAME_MAX];
static int error_index;
#define PUSH_ERROR(x) if (error_index < ERROR_NAME_MAX) error_names[error_index] = x; error_index++;
#define POP_ERROR()   error_index--;

#line 66 "ldgram.y"
typedef union {
  bfd_vma integer;
  char *name;
  int token;
  union etree_union *etree;
  struct phdr_info
    {
      boolean filehdr;
      boolean phdrs;
      union etree_union *at;
      union etree_union *flags;
    } phdr;
  struct lang_nocrossref *nocrossref;
  struct lang_output_section_phdr_list *section_phdr;
  struct bfd_elf_version_deps *deflist;
  struct bfd_elf_version_expr *versyms;
  struct bfd_elf_version_tree *versnode;
} YYSTYPE;
#include <stdio.h>

#ifndef __cplusplus
#ifndef __STDC__
#define const
#endif
#endif



#define	YYFINAL		542
#define	YYFLAG		-32768
#define	YYNTBASE	124

#define YYTRANSLATE(x) ((unsigned)(x) <= 355 ? yytranslate[x] : 222)

static const char yytranslate[] = {     0,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,   122,     2,     2,     2,    34,    21,     2,    37,
   119,    32,    30,   117,    31,     2,    33,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,    16,   118,    24,
    10,    25,    15,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
   120,     2,   121,    20,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,    48,    19,    49,   123,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     1,     2,     3,     4,     5,
     6,     7,     8,     9,    11,    12,    13,    14,    17,    18,
    22,    23,    26,    27,    28,    29,    35,    36,    38,    39,
    40,    41,    42,    43,    44,    45,    46,    47,    50,    51,
    52,    53,    54,    55,    56,    57,    58,    59,    60,    61,
    62,    63,    64,    65,    66,    67,    68,    69,    70,    71,
    72,    73,    74,    75,    76,    77,    78,    79,    80,    81,
    82,    83,    84,    85,    86,    87,    88,    89,    90,    91,
    92,    93,    94,    95,    96,    97,    98,    99,   100,   101,
   102,   103,   104,   105,   106,   107,   108,   109,   110,   111,
   112,   113,   114,   115,   116
};

#if YYDEBUG != 0
static const short yyprhs[] = {     0,
     0,     3,     6,     9,    12,    14,    15,    20,    21,    24,
    28,    29,    32,    37,    39,    41,    44,    46,    51,    56,
    60,    63,    68,    72,    77,    82,    87,    92,    97,   100,
   103,   106,   111,   116,   119,   122,   125,   128,   129,   135,
   138,   139,   143,   146,   147,   149,   153,   155,   159,   160,
   162,   166,   168,   172,   173,   176,   179,   180,   182,   184,
   186,   188,   190,   192,   194,   196,   198,   200,   205,   210,
   215,   220,   229,   234,   236,   241,   242,   248,   253,   254,
   260,   265,   267,   271,   274,   276,   280,   283,   288,   291,
   294,   295,   300,   303,   305,   307,   309,   313,   317,   321,
   323,   324,   329,   330,   336,   337,   343,   344,   350,   353,
   355,   357,   359,   361,   366,   371,   374,   376,   377,   379,
   381,   383,   385,   387,   389,   392,   393,   395,   397,   399,
   401,   403,   405,   407,   409,   411,   413,   417,   421,   428,
   430,   431,   437,   440,   444,   445,   446,   454,   458,   462,
   466,   467,   472,   477,   481,   485,   487,   492,   496,   497,
   499,   501,   502,   505,   509,   510,   513,   516,   520,   525,
   528,   531,   534,   538,   542,   546,   550,   554,   558,   562,
   566,   570,   574,   578,   582,   586,   590,   594,   598,   604,
   608,   612,   617,   619,   621,   626,   631,   636,   641,   646,
   651,   653,   660,   667,   672,   673,   674,   675,   676,   677,
   678,   694,   695,   696,   697,   698,   699,   716,   717,   718,
   726,   728,   730,   732,   734,   736,   740,   741,   744,   748,
   751,   758,   769,   772,   774,   775,   777,   780,   781,   782,
   786,   787,   788,   789,   790,   802,   807,   808,   811,   812,
   813,   820,   822,   823,   827,   833,   834,   838,   839,   842,
   843,   849,   851,   854,   860,   867,   869,   872,   873,   876,
   881,   886,   895,   897
};

static const short yyrhs[] = {   105,
   138,     0,   106,   128,     0,   116,   213,     0,   107,   126,
     0,     4,     0,     0,   127,     4,    10,   179,     0,     0,
   129,   130,     0,   130,   131,    95,     0,     0,    90,   179,
     0,    90,   179,   117,   179,     0,     4,     0,    91,     0,
    97,   133,     0,    96,     0,   100,     4,    10,   179,     0,
   100,     4,   117,   179,     0,   100,     4,   179,     0,    99,
     4,     0,    92,     4,   117,   179,     0,    92,     4,   179,
     0,    92,     4,    10,   179,     0,    38,     4,    10,   179,
     0,    38,     4,   117,   179,     0,    87,     4,    10,   179,
     0,    87,     4,   117,   179,     0,    93,   135,     0,    94,
   134,     0,    98,     4,     0,   102,     4,   117,     4,     0,
   102,     4,   117,     3,     0,   101,   179,     0,   103,     3,
     0,   108,   136,     0,   109,   137,     0,     0,    54,   125,
   132,   130,    36,     0,   110,     4,     0,     0,   133,   117,
     4,     0,   133,     4,     0,     0,     4,     0,   134,   117,
     4,     0,     4,     0,   135,   117,     4,     0,     0,     4,
     0,   136,   117,     4,     0,     4,     0,   137,   117,     4,
     0,     0,   139,   140,     0,   140,   141,     0,     0,   163,
     0,   145,     0,   205,     0,   170,     0,   171,     0,   173,
     0,   175,     0,   147,     0,   215,     0,   118,     0,    63,
    37,     4,   119,     0,    64,    37,   125,   119,     0,    85,
    37,   125,   119,     0,    51,    37,     4,   119,     0,    51,
    37,     4,   117,     4,   117,     4,   119,     0,    53,    37,
     4,   119,     0,    52,     0,    83,    37,   144,   119,     0,
     0,    84,   142,    37,   144,   119,     0,    65,    37,   125,
   119,     0,     0,    54,   125,   143,   140,    36,     0,    78,
    37,   176,   119,     0,     4,     0,   144,   117,     4,     0,
   144,     4,     0,     5,     0,   144,   117,     5,     0,   144,
     5,     0,    46,    48,   146,    49,     0,   146,   181,     0,
   146,   147,     0,     0,    66,    37,     4,   119,     0,   161,
   160,     0,     4,     0,    32,     0,    15,     0,   148,   162,
     4,     0,   148,   162,    32,     0,   148,   162,    15,     0,
     4,     0,     0,   120,   150,   148,   121,     0,     0,     4,
   151,    37,   148,   119,     0,     0,    15,   152,    37,   148,
   119,     0,     0,    32,   153,    37,   148,   119,     0,   161,
   160,     0,    82,     0,   118,     0,    86,     0,   149,     0,
   157,    37,   177,   119,     0,    80,    37,   177,   119,     0,
   155,   154,     0,   154,     0,     0,   155,     0,    41,     0,
    42,     0,    43,     0,    44,     0,    45,     0,    10,   177,
     0,     0,     6,     0,     7,     0,     8,     0,     9,     0,
    11,     0,    12,     0,    13,     0,    14,     0,   118,     0,
   117,     0,     4,    10,   177,     0,     4,   159,   177,     0,
    89,    37,     4,    10,   177,   119,     0,   117,     0,     0,
    55,    48,   165,   164,    49,     0,   164,   165,     0,   164,
   117,   165,     0,     0,     0,     4,   166,   169,    16,   167,
   162,   168,     0,    79,    10,   177,     0,    81,    10,   177,
     0,    37,     4,   119,     0,     0,    73,    37,   125,   119,
     0,    74,    37,   172,   119,     0,    74,    37,   119,     0,
   172,   162,   125,     0,   125,     0,    75,    37,   174,   119,
     0,   174,   162,   125,     0,     0,    76,     0,    77,     0,
     0,     4,   176,     0,     4,   117,   176,     0,     0,   178,
   179,     0,    31,   179,     0,    37,   179,   119,     0,    67,
    37,   179,   119,     0,   122,   179,     0,    30,   179,     0,
   123,   179,     0,   179,    32,   179,     0,   179,    33,   179,
     0,   179,    34,   179,     0,   179,    30,   179,     0,   179,
    31,   179,     0,   179,    28,   179,     0,   179,    29,   179,
     0,   179,    22,   179,     0,   179,    23,   179,     0,   179,
    26,   179,     0,   179,    27,   179,     0,   179,    24,   179,
     0,   179,    25,   179,     0,   179,    21,   179,     0,   179,
    20,   179,     0,   179,    19,   179,     0,   179,    15,   179,
    16,   179,     0,   179,    18,   179,     0,   179,    17,   179,
     0,    62,    37,     4,   119,     0,     3,     0,    50,     0,
    68,    37,     4,   119,     0,    69,    37,     4,   119,     0,
    70,    37,     4,   119,     0,    93,    37,   179,   119,     0,
    38,    37,   179,   119,     0,    39,    37,   179,   119,     0,
     4,     0,    71,    37,   179,   117,   179,   119,     0,    72,
    37,   179,   117,   179,   119,     0,    88,    37,   179,   119,
     0,     0,     0,     0,     0,     0,     0,     4,   182,   196,
   180,   183,    48,   184,   156,    49,   185,   199,   200,   158,
   186,   162,     0,     0,     0,     0,     0,     0,    61,   187,
   197,   198,   180,   188,    48,   189,   201,    49,   190,   199,
   200,   158,   191,   162,     0,     0,     0,    84,   192,   196,
   193,    48,   146,    49,     0,    57,     0,    58,     0,    59,
     0,    60,     0,    61,     0,    37,   194,   119,     0,     0,
    37,   119,     0,   179,   195,    16,     0,   195,    16,     0,
    40,    37,   179,   119,   195,    16,     0,    40,    37,   179,
   119,    39,    37,   179,   119,   195,    16,     0,   179,    16,
     0,    16,     0,     0,    78,     0,    25,     4,     0,     0,
     0,   200,    16,     4,     0,     0,     0,     0,     0,   201,
     4,   202,    48,   156,    49,   203,   200,   158,   204,   162,
     0,    47,    48,   206,    49,     0,     0,   206,   207,     0,
     0,     0,     4,   208,   210,   211,   209,   118,     0,   179,
     0,     0,     4,   212,   211,     0,    88,    37,   179,   119,
   211,     0,     0,    37,   179,   119,     0,     0,   214,   217,
     0,     0,   216,   115,    48,   217,    49,     0,   218,     0,
   217,   218,     0,   111,    48,   220,    49,   118,     0,   111,
    48,   220,    49,   219,   118,     0,   111,     0,   219,   111,
     0,     0,   221,   118,     0,   113,    16,   221,   118,     0,
   114,    16,   221,   118,     0,   113,    16,   221,   118,   114,
    16,   221,   118,     0,   112,     0,   221,   118,   112,     0
};

#endif

#if YYDEBUG != 0
static const short yyrline[] = { 0,
   142,   144,   145,   146,   150,   153,   155,   162,   168,   175,
   177,   180,   182,   183,   186,   189,   190,   191,   193,   195,
   197,   199,   201,   203,   205,   207,   209,   211,   213,   214,
   215,   217,   219,   221,   223,   225,   226,   227,   228,   229,
   231,   234,   236,   237,   240,   243,   246,   249,   253,   255,
   256,   259,   262,   266,   271,   277,   279,   284,   286,   287,
   288,   289,   290,   291,   292,   293,   294,   295,   297,   299,
   301,   304,   306,   308,   310,   311,   313,   315,   317,   318,
   319,   325,   329,   332,   335,   338,   341,   346,   350,   352,
   353,   356,   359,   364,   367,   369,   371,   373,   375,   379,
   384,   389,   390,   394,   395,   401,   402,   406,   409,   411,
   415,   416,   421,   422,   427,   437,   439,   442,   444,   447,
   450,   452,   454,   456,   460,   468,   473,   476,   478,   480,
   482,   484,   486,   488,   493,   493,   497,   502,   510,   517,
   518,   521,   525,   527,   528,   532,   534,   537,   545,   554,
   559,   563,   568,   570,   574,   577,   582,   584,   587,   590,
   593,   597,   602,   611,   622,   624,   627,   630,   632,   634,
   636,   638,   641,   643,   645,   647,   649,   651,   653,   655,
   657,   659,   661,   663,   665,   667,   669,   671,   673,   675,
   677,   679,   681,   683,   686,   688,   690,   692,   694,   696,
   698,   700,   702,   707,   709,   712,   714,   716,   722,   723,
   729,   729,   731,   734,   738,   740,   746,   746,   752,   756,
   759,   761,   762,   763,   764,   767,   769,   770,   773,   775,
   776,   781,   785,   787,   790,   793,   797,   800,   803,   808,
   821,   823,   829,   831,   837,   839,   843,   845,   848,   850,
   852,   858,   888,   893,   905,   912,   917,   925,   931,   939,
   943,   949,   951,   954,   959,   965,   970,   976,   981,   985,
   989,   993,   999,  1004
};
#endif


#if YYDEBUG != 0 || defined (YYERROR_VERBOSE)

static const char * const yytname[] = {   "$","error","$undefined.","INT","NAME",
"LNAME","PLUSEQ","MINUSEQ","MULTEQ","DIVEQ","'='","LSHIFTEQ","RSHIFTEQ","ANDEQ",
"OREQ","'?'","':'","OROR","ANDAND","'|'","'^'","'&'","EQ","NE","'<'","'>'","LE",
"GE","LSHIFT","RSHIFT","'+'","'-'","'*'","'/'","'%'","UNARY","END","'('","ALIGN_K",
"BLOCK","BIND","QUAD","SQUAD","LONG","SHORT","BYTE","SECTIONS","PHDRS","'{'",
"'}'","SIZEOF_HEADERS","OUTPUT_FORMAT","FORCE_COMMON_ALLOCATION","OUTPUT_ARCH",
"INCLUDE","MEMORY","DEFSYMEND","NOLOAD","DSECT","COPY","INFO","OVERLAY","DEFINED",
"TARGET_K","SEARCH_DIR","MAP","ENTRY","NEXT","SIZEOF","ADDR","LOADADDR","MAX",
"MIN","STARTUP","HLL","SYSLIB","FLOAT","NOFLOAT","NOCROSSREFS","ORIGIN","FILL",
"LENGTH","CREATE_OBJECT_SYMBOLS","INPUT","GROUP","OUTPUT","CONSTRUCTORS","ALIGNMOD",
"AT","PROVIDE","CHIP","LIST","SECT","ABSOLUTE","LOAD","NEWLINE","ENDWORD","ORDER",
"NAMEWORD","FORMAT","PUBLIC","BASE","ALIAS","TRUNCATE","REL","INPUT_SCRIPT",
"INPUT_MRI_SCRIPT","INPUT_DEFSYM","CASE","EXTERN","START","VERS_TAG","VERS_IDENTIFIER",
"GLOBAL","LOCAL","VERSIONK","INPUT_VERSION_SCRIPT","','","';'","')'","'['","']'",
"'!'","'~'","file","filename","defsym_expr","@1","mri_script_file","@2","mri_script_lines",
"mri_script_command","@3","ordernamelist","mri_load_name_list","mri_abs_name_list",
"casesymlist","extern_name_list","script_file","@4","ifile_list","ifile_p1",
"@5","@6","input_list","sections","sec_or_group_p1","statement_anywhere","file_NAME_list",
"input_section_spec","@7","@8","@9","@10","statement","statement_list","statement_list_opt",
"length","fill_opt","assign_op","end","assignment","opt_comma","memory","memory_spec_list",
"memory_spec","@11","origin_spec","length_spec","attributes_opt","startup","high_level_library",
"high_level_library_NAME_list","low_level_library","low_level_library_NAME_list",
"floating_point_support","nocrossref_list","mustbe_exp","@12","exp","opt_at",
"section","@13","@14","@15","@16","@17","@18","@19","@20","@21","@22","@23",
"@24","type","atype","opt_exp_with_type","opt_exp_without_type","opt_nocrossrefs",
"memspec_opt","phdr_opt","overlay_section","@25","@26","@27","phdrs","phdr_list",
"phdr","@28","@29","phdr_type","phdr_qualifiers","phdr_val","version_script_file",
"@30","version","@31","vers_nodes","vers_node","verdep","vers_tag","vers_defns", NULL
};
#endif

static const short yyr1[] = {     0,
   124,   124,   124,   124,   125,   127,   126,   129,   128,   130,
   130,   131,   131,   131,   131,   131,   131,   131,   131,   131,
   131,   131,   131,   131,   131,   131,   131,   131,   131,   131,
   131,   131,   131,   131,   131,   131,   131,   132,   131,   131,
   131,   133,   133,   133,   134,   134,   135,   135,   136,   136,
   136,   137,   137,   139,   138,   140,   140,   141,   141,   141,
   141,   141,   141,   141,   141,   141,   141,   141,   141,   141,
   141,   141,   141,   141,   141,   142,   141,   141,   143,   141,
   141,   144,   144,   144,   144,   144,   144,   145,   146,   146,
   146,   147,   147,   148,   148,   148,   148,   148,   148,   149,
   150,   149,   151,   149,   152,   149,   153,   149,   154,   154,
   154,   154,   154,   154,   154,   155,   155,   156,   156,   157,
   157,   157,   157,   157,   158,   158,   159,   159,   159,   159,
   159,   159,   159,   159,   160,   160,   161,   161,   161,   162,
   162,   163,   164,   164,   164,   166,   165,   167,   168,   169,
   169,   170,   171,   171,   172,   172,   173,   174,   174,   175,
   175,   176,   176,   176,   178,   177,   179,   179,   179,   179,
   179,   179,   179,   179,   179,   179,   179,   179,   179,   179,
   179,   179,   179,   179,   179,   179,   179,   179,   179,   179,
   179,   179,   179,   179,   179,   179,   179,   179,   179,   179,
   179,   179,   179,   180,   180,   182,   183,   184,   185,   186,
   181,   187,   188,   189,   190,   191,   181,   192,   193,   181,
   194,   194,   194,   194,   194,   195,   195,   195,   196,   196,
   196,   196,   197,   197,   198,   198,   199,   199,   200,   200,
   201,   202,   203,   204,   201,   205,   206,   206,   208,   209,
   207,   210,   211,   211,   211,   212,   212,   214,   213,   216,
   215,   217,   217,   218,   218,   219,   219,   220,   220,   220,
   220,   220,   221,   221
};

static const short yyr2[] = {     0,
     2,     2,     2,     2,     1,     0,     4,     0,     2,     3,
     0,     2,     4,     1,     1,     2,     1,     4,     4,     3,
     2,     4,     3,     4,     4,     4,     4,     4,     2,     2,
     2,     4,     4,     2,     2,     2,     2,     0,     5,     2,
     0,     3,     2,     0,     1,     3,     1,     3,     0,     1,
     3,     1,     3,     0,     2,     2,     0,     1,     1,     1,
     1,     1,     1,     1,     1,     1,     1,     4,     4,     4,
     4,     8,     4,     1,     4,     0,     5,     4,     0,     5,
     4,     1,     3,     2,     1,     3,     2,     4,     2,     2,
     0,     4,     2,     1,     1,     1,     3,     3,     3,     1,
     0,     4,     0,     5,     0,     5,     0,     5,     2,     1,
     1,     1,     1,     4,     4,     2,     1,     0,     1,     1,
     1,     1,     1,     1,     2,     0,     1,     1,     1,     1,
     1,     1,     1,     1,     1,     1,     3,     3,     6,     1,
     0,     5,     2,     3,     0,     0,     7,     3,     3,     3,
     0,     4,     4,     3,     3,     1,     4,     3,     0,     1,
     1,     0,     2,     3,     0,     2,     2,     3,     4,     2,
     2,     2,     3,     3,     3,     3,     3,     3,     3,     3,
     3,     3,     3,     3,     3,     3,     3,     3,     5,     3,
     3,     4,     1,     1,     4,     4,     4,     4,     4,     4,
     1,     6,     6,     4,     0,     0,     0,     0,     0,     0,
    15,     0,     0,     0,     0,     0,    16,     0,     0,     7,
     1,     1,     1,     1,     1,     3,     0,     2,     3,     2,
     6,    10,     2,     1,     0,     1,     2,     0,     0,     3,
     0,     0,     0,     0,    11,     4,     0,     2,     0,     0,
     6,     1,     0,     3,     5,     0,     3,     0,     2,     0,
     5,     1,     2,     5,     6,     1,     2,     0,     2,     4,
     4,     8,     1,     3
};

static const short yydefact[] = {     0,
    54,     8,     6,   258,     1,    57,     2,    11,     4,     0,
     3,     0,    55,     9,     0,     0,   259,   262,     0,     0,
     0,     0,    74,     0,     0,     0,     0,     0,     0,     0,
     0,     0,     0,   160,   161,     0,     0,    76,     0,     0,
    67,    56,    59,    65,     0,    58,    61,    62,    63,    64,
    60,    66,     0,    14,     0,     0,     0,     0,    15,     0,
     0,     0,    17,    44,     0,     0,     0,     0,     0,     0,
    49,     0,     0,     0,     0,   268,   263,   127,   128,   129,
   130,   165,   131,   132,   133,   134,   165,    91,   247,     0,
     0,     5,    79,     0,     0,     0,     0,     0,     0,     0,
   159,   162,     0,     0,     0,     0,   136,   135,    93,     0,
     0,    38,     0,   193,   201,     0,     0,     0,     0,     0,
   194,     0,     0,     0,     0,     0,     0,     0,     0,     0,
     0,    12,     0,    47,    29,    45,    30,    16,    31,    21,
     0,    34,     0,    35,    50,    36,    52,    37,    40,    10,
     7,   273,     0,     0,     0,     0,   137,     0,   138,     0,
     0,     0,     0,    57,   146,   145,     0,     0,     0,     0,
     0,   154,   156,   141,   141,   162,     0,    82,    85,     0,
     0,     0,     0,     0,     0,     0,    11,     0,     0,   171,
   167,     0,     0,     0,     0,     0,     0,     0,     0,     0,
     0,     0,   170,   172,     0,     0,     0,     0,     0,     0,
     0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
     0,     0,     0,     0,     0,     0,    23,     0,     0,    43,
     0,     0,     0,    20,     0,     0,     0,     0,     0,     0,
   269,   166,   206,    88,   212,   218,    90,    89,   249,   246,
   248,     0,    71,    73,   260,   151,     0,    68,    69,    78,
    92,   152,   140,   153,     0,   157,     0,   162,   163,    81,
    84,    87,     0,    75,     0,    70,   165,     0,    25,    26,
    41,    27,    28,   168,     0,     0,     0,     0,     0,     0,
     0,     0,     0,     0,     0,   191,   190,   188,   187,   186,
   180,   181,   184,   185,   182,   183,   178,   179,   176,   177,
   173,   174,   175,    13,    24,    22,    48,    46,    42,    18,
    19,    33,    32,    51,    53,     0,     0,   266,   264,     0,
   274,   227,     0,   227,     0,     0,    80,     0,     0,   142,
     0,   143,   155,   158,   164,    83,    86,    77,     0,   261,
    39,   199,   200,   192,   169,   195,   196,   197,     0,     0,
   198,     0,   270,   271,   267,   265,     0,     0,   227,     0,
   205,   234,     0,   235,   219,   252,   253,     0,     0,     0,
   144,   139,     0,     0,   189,     0,   221,   222,   223,   224,
   225,   228,     0,     0,     0,     0,   230,     0,   207,   233,
   236,   205,     0,   256,     0,   250,     0,   150,     0,   141,
   202,   203,     0,   226,     0,   229,     0,     0,   213,    91,
     0,   253,     0,     0,    72,   165,     0,     0,   227,     0,
   208,     0,     0,     0,   254,     0,   251,   148,     0,   147,
   272,     0,     0,   204,   118,   214,   220,   257,   253,   165,
     0,   231,   100,   105,   107,   120,   121,   122,   123,   124,
     0,   110,   112,   111,   101,   113,   117,   119,     0,     0,
     0,   241,   255,   149,     0,     0,     0,     0,   165,     0,
   116,   209,   165,   109,     0,   227,     0,     0,     0,     0,
    94,    96,    95,   141,   238,     0,   242,   215,     0,   141,
   141,   141,   115,   102,     0,     0,   239,   114,     0,   238,
   232,   104,   106,   108,    97,    99,    98,   237,   126,   118,
   239,   165,     0,   210,     0,   126,   125,   240,   141,   243,
   216,   211,   239,   141,   126,   217,   244,   141,   245,     0,
     0,     0
};

static const short yydefgoto[] = {   540,
    93,     9,    10,     7,     8,    14,    74,   187,   138,   137,
   135,   146,   148,     5,     6,    13,    42,   104,   164,   180,
    43,   160,    44,   494,   466,   480,   476,   477,   478,   467,
   468,   469,   470,   524,    87,   109,    45,   505,    46,   257,
   166,   256,   410,   440,   339,    47,    48,   174,    49,   175,
    50,   177,   157,   158,   192,   399,   248,   332,   418,   445,
   495,   529,   333,   432,   472,   510,   534,   334,   403,   393,
   370,   371,   374,   402,   507,   519,   485,   509,   533,   538,
    51,   161,   251,   335,   424,   377,   406,   422,    11,    12,
    52,    53,    17,    18,   330,   155,   156
};

static const short yypact[] = {   -44,
-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,    50,
-32768,   -40,   490,   542,    48,    35,   -40,-32768,   175,    44,
    72,    97,-32768,   105,   173,   148,   162,   166,   178,   186,
   194,   196,   205,-32768,-32768,   211,   221,-32768,   222,   224,
-32768,-32768,-32768,-32768,    29,-32768,-32768,-32768,-32768,-32768,
-32768,-32768,    95,-32768,   258,   173,   262,   439,-32768,   263,
   264,   265,-32768,-32768,   266,   268,   269,   439,   270,   278,
   279,   280,   281,   187,   439,    60,-32768,-32768,-32768,-32768,
-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,   283,
   289,-32768,-32768,   290,   291,   173,   173,   292,   173,    11,
-32768,   293,   236,   251,   173,   297,-32768,-32768,-32768,   256,
     4,-32768,     7,-32768,-32768,   439,   439,   439,   271,   272,
-32768,   273,   282,   287,   288,   298,   299,   301,   303,   439,
   439,   978,    18,-32768,   189,-32768,   190,     6,-32768,-32768,
   261,  1117,   203,-32768,-32768,   209,-32768,   210,-32768,-32768,
  1117,-32768,   325,   326,   285,   225,-32768,   439,-32768,    30,
    26,   -10,   226,-32768,-32768,-32768,   227,   228,   231,   232,
   233,-32768,-32768,    -4,    -1,    16,   234,-32768,-32768,     8,
   236,   240,   334,   -40,   439,   439,-32768,   439,   439,-32768,
-32768,   649,   439,   439,   357,   439,   361,   365,   366,   439,
   439,   439,-32768,-32768,   439,   439,   439,   439,   439,   439,
   439,   439,   439,   439,   439,   439,   439,   439,   439,   439,
   439,   439,   439,   439,   439,   439,  1117,   368,   369,-32768,
   370,   439,   439,  1117,   241,   371,   372,   267,   267,   -14,
   294,  1117,   175,-32768,-32768,-32768,-32768,-32768,-32768,-32768,
-32768,   373,-32768,-32768,   536,   344,    21,-32768,-32768,-32768,
-32768,-32768,-32768,-32768,   173,-32768,   173,   293,-32768,-32768,
-32768,-32768,   242,-32768,    61,-32768,-32768,   -18,  1117,  1117,
   611,  1117,  1117,-32768,   707,   727,   274,   752,   276,   286,
   295,  1016,  1036,   772,  1139,   789,   891,   993,   663,  1056,
  1093,  1093,   284,   284,   284,   284,   161,   161,   168,   168,
-32768,-32768,-32768,  1117,  1117,  1117,-32768,-32768,-32768,  1117,
  1117,-32768,-32768,-32768,-32768,   300,   302,-32768,-32768,   -13,
-32768,   318,   394,   318,   439,   296,-32768,   378,   375,-32768,
   290,-32768,-32768,-32768,-32768,-32768,-32768,-32768,   304,-32768,
-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,   439,   439,
-32768,   439,    99,   294,-32768,-32768,   167,   362,  1079,   384,
   313,-32768,  1159,   324,-32768,  1117,    15,   399,   307,   328,
-32768,-32768,   810,   830,  1117,   388,-32768,-32768,-32768,-32768,
-32768,-32768,   308,   439,   -19,   393,-32768,   379,-32768,-32768,
-32768,   313,   364,   380,   385,-32768,   309,-32768,   405,   312,
-32768,-32768,   267,-32768,   855,-32768,   439,   382,-32768,-32768,
   439,    15,   439,   316,-32768,-32768,   340,   319,   179,   875,
-32768,   390,    33,   913,-32768,   933,-32768,-32768,   429,-32768,
   294,   413,   435,-32768,   404,-32768,-32768,-32768,    15,-32768,
   439,-32768,   243,-32768,-32768,-32768,-32768,-32768,-32768,-32768,
   415,-32768,-32768,-32768,-32768,-32768,-32768,   404,   406,   416,
    29,-32768,-32768,-32768,   958,   417,   420,   421,-32768,    49,
-32768,-32768,-32768,-32768,    28,   422,    49,    49,    49,   341,
-32768,-32768,-32768,   -88,   442,   349,-32768,-32768,   455,   102,
   103,   113,-32768,-32768,    63,   468,-32768,-32768,   425,   442,
-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,    96,   404,
-32768,-32768,   470,-32768,   426,    96,-32768,-32768,   312,-32768,
-32768,-32768,-32768,   312,    96,-32768,-32768,   312,-32768,   479,
   480,-32768
};

static const short yypgoto[] = {-32768,
   -53,-32768,-32768,-32768,-32768,   305,-32768,-32768,-32768,-32768,
-32768,-32768,-32768,-32768,-32768,   317,-32768,-32768,-32768,   310,
-32768,    62,  -154,  -280,-32768,-32768,-32768,-32768,-32768,    17,
-32768,   -37,-32768,  -490,-32768,    24,  -418,  -167,-32768,-32768,
  -231,-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,
-32768,  -160,   -87,-32768,   -57,    86,-32768,-32768,-32768,-32768,
-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,-32768,
  -360,   163,-32768,-32768,   -12,  -498,-32768,-32768,-32768,-32768,
-32768,-32768,-32768,-32768,-32768,-32768,  -398,-32768,-32768,-32768,
-32768,-32768,   315,   -15,-32768,-32768,  -234
};


#define	YYLAST		1193


static const short yytable[] = {   159,
   132,    77,   112,   326,   327,   247,   265,   267,   396,   230,
   142,   271,   272,   185,    92,   269,   188,   151,   404,   176,
   114,   115,   526,   435,   165,   342,   471,   225,   263,   249,
   350,   497,   504,   243,   535,   531,   243,   387,   388,   389,
   390,   391,   168,   169,   537,   171,   173,   116,   117,   471,
   473,   182,   491,    15,   118,   119,   120,    75,   190,   191,
     1,     2,     3,   492,   271,   272,   515,   121,   443,   340,
    16,     4,   203,   204,   250,   227,   498,   516,   244,   122,
   493,   447,    76,   234,   123,   124,   125,   126,   127,   128,
   245,    88,    16,   245,   517,    30,   328,   365,    30,   392,
   242,   471,   405,   329,   366,   522,   252,   345,   253,   381,
   129,   523,   263,   246,   264,   263,   246,   266,    40,    89,
   186,    40,   231,   189,   273,   499,   274,   279,   280,   172,
   282,   283,   268,    90,   226,   285,   286,   341,   288,   130,
   131,    91,   292,   293,   294,   107,   108,   295,   296,   297,
   298,   299,   300,   301,   302,   303,   304,   305,   306,   307,
   308,   309,   310,   311,   312,   313,   314,   315,   316,   114,
   115,   152,   153,   154,   320,   321,    92,   273,   428,   348,
    78,    79,    80,    81,    82,    83,    84,    85,    86,   349,
   219,   220,   221,   222,   223,    94,   116,   117,    95,   221,
   222,   223,    96,   118,   119,   120,   500,   501,   502,   110,
   331,   343,   386,   344,    97,   395,   121,   442,   263,   263,
   512,   513,    98,   387,   388,   389,   390,   391,   122,   263,
    99,   514,   100,   123,   124,   125,   126,   127,   128,   178,
   179,   101,   427,   322,   323,   346,   347,   102,    78,    79,
    80,    81,    82,    83,    84,    85,    86,   103,   105,   129,
   106,   111,    77,   114,   115,   113,   133,   134,   136,   139,
   232,   140,   141,   143,   369,   373,   369,   376,   247,  -103,
   144,   150,   145,   147,   149,   392,   162,   181,   130,   131,
   116,   117,   163,   165,   167,   170,   176,   118,   119,   120,
   183,   383,   384,   184,   385,   228,   229,   193,   194,   195,
   121,   217,   218,   219,   220,   221,   222,   223,   196,   235,
   114,   115,   122,   197,   198,   236,   237,   123,   124,   125,
   126,   127,   128,   240,   199,   200,   415,   201,   438,   202,
   238,   239,   241,   277,   254,   258,   259,   116,   117,   260,
   261,   262,   270,   129,   367,   119,   120,   368,   276,   430,
   287,   532,   474,   434,   289,   436,   536,   121,   290,   291,
   539,   317,   318,   319,   324,   325,   336,   233,   152,   122,
   338,   379,   130,   131,   123,   124,   125,   126,   127,   128,
   380,   490,   354,   475,   356,   496,   114,   115,   394,   397,
   398,   401,   407,   413,   357,   331,   409,   453,   416,   372,
   129,   420,   378,   358,   426,   417,   421,   363,   454,   364,
   439,   423,   382,   116,   117,   408,   414,   425,   263,   431,
   118,   119,   120,   437,   527,   455,   441,   446,   450,   130,
   131,   114,   115,   121,   456,   457,   458,   459,   460,   451,
   452,   479,   483,   487,   482,   122,   488,   489,   395,   503,
   123,   124,   125,   126,   127,   128,   506,   508,   116,   117,
   511,   518,   520,   528,   530,   118,   119,   120,   541,   542,
   255,   433,   525,   461,   481,   462,   129,   419,   121,   463,
   275,   281,    40,    19,   484,     0,   375,   521,   278,     0,
   122,     0,     0,     0,     0,   123,   124,   125,   126,   127,
   128,     0,     0,     0,     0,   130,   131,     0,     0,     0,
     0,   464,     0,   465,     0,     0,     0,     0,     0,     0,
     0,   129,     0,     0,     0,    20,    21,     0,     0,    19,
    22,    23,    24,    25,    26,    54,     0,     0,     0,     0,
     0,     0,    27,    28,    29,    30,     0,     0,     0,     0,
   130,   131,    31,    32,    33,    34,    35,    36,     0,     0,
     0,   337,    37,    38,    39,     0,     0,     0,    40,    55,
     0,    20,    21,     0,     0,     0,    22,    23,    24,    25,
    26,     0,     0,     0,     0,    56,     0,     0,    27,    28,
    29,    30,     0,     0,  -260,     0,     0,    41,    31,    32,
    33,    34,    35,    36,    54,     0,     0,     0,    37,    38,
    39,     0,     0,     0,    40,     0,     0,     0,    57,     0,
     0,    58,    59,    60,    61,    62,   -41,    63,    64,    65,
    66,    67,    68,    69,    70,     0,   351,     0,    55,    71,
    72,    73,     0,    41,     0,     0,     0,     0,     0,     0,
     0,     0,     0,   205,    56,   206,   207,   208,   209,   210,
   211,   212,   213,   214,   215,   216,   217,   218,   219,   220,
   221,   222,   223,   210,   211,   212,   213,   214,   215,   216,
   217,   218,   219,   220,   221,   222,   223,    57,     0,     0,
    58,    59,    60,    61,    62,     0,    63,    64,    65,    66,
    67,    68,    69,    70,     0,     0,     0,     0,    71,    72,
    73,   205,     0,   206,   207,   208,   209,   210,   211,   212,
   213,   214,   215,   216,   217,   218,   219,   220,   221,   222,
   223,   205,     0,   206,   207,   208,   209,   210,   211,   212,
   213,   214,   215,   216,   217,   218,   219,   220,   221,   222,
   223,     0,     0,     0,     0,     0,   205,   284,   206,   207,
   208,   209,   210,   211,   212,   213,   214,   215,   216,   217,
   218,   219,   220,   221,   222,   223,   205,     0,   206,   207,
   208,   209,   210,   211,   212,   213,   214,   215,   216,   217,
   218,   219,   220,   221,   222,   223,   207,   208,   209,   210,
   211,   212,   213,   214,   215,   216,   217,   218,   219,   220,
   221,   222,   223,     0,   205,   352,   206,   207,   208,   209,
   210,   211,   212,   213,   214,   215,   216,   217,   218,   219,
   220,   221,   222,   223,   205,   353,   206,   207,   208,   209,
   210,   211,   212,   213,   214,   215,   216,   217,   218,   219,
   220,   221,   222,   223,     0,     0,     0,     0,     0,   205,
   355,   206,   207,   208,   209,   210,   211,   212,   213,   214,
   215,   216,   217,   218,   219,   220,   221,   222,   223,   205,
   361,   206,   207,   208,   209,   210,   211,   212,   213,   214,
   215,   216,   217,   218,   219,   220,   221,   222,   223,   208,
   209,   210,   211,   212,   213,   214,   215,   216,   217,   218,
   219,   220,   221,   222,   223,     0,     0,   205,   411,   206,
   207,   208,   209,   210,   211,   212,   213,   214,   215,   216,
   217,   218,   219,   220,   221,   222,   223,   205,   412,   206,
   207,   208,   209,   210,   211,   212,   213,   214,   215,   216,
   217,   218,   219,   220,   221,   222,   223,     0,     0,     0,
     0,     0,   205,   429,   206,   207,   208,   209,   210,   211,
   212,   213,   214,   215,   216,   217,   218,   219,   220,   221,
   222,   223,   205,   444,   206,   207,   208,   209,   210,   211,
   212,   213,   214,   215,   216,   217,   218,   219,   220,   221,
   222,   223,   209,   210,   211,   212,   213,   214,   215,   216,
   217,   218,   219,   220,   221,   222,   223,     0,     0,     0,
   205,   448,   206,   207,   208,   209,   210,   211,   212,   213,
   214,   215,   216,   217,   218,   219,   220,   221,   222,   223,
   205,   449,   206,   207,   208,   209,   210,   211,   212,   213,
   214,   215,   216,   217,   218,   219,   220,   221,   222,   223,
     0,     0,     0,     0,     0,     0,   486,   211,   212,   213,
   214,   215,   216,   217,   218,   219,   220,   221,   222,   223,
     0,     0,     0,   205,   224,   206,   207,   208,   209,   210,
   211,   212,   213,   214,   215,   216,   217,   218,   219,   220,
   221,   222,   223,     0,     0,   395,   213,   214,   215,   216,
   217,   218,   219,   220,   221,   222,   223,     0,     0,     0,
     0,   205,   359,   206,   207,   208,   209,   210,   211,   212,
   213,   214,   215,   216,   217,   218,   219,   220,   221,   222,
   223,     0,   360,   205,   362,   206,   207,   208,   209,   210,
   211,   212,   213,   214,   215,   216,   217,   218,   219,   220,
   221,   222,   223,   205,   400,   206,   207,   208,   209,   210,
   211,   212,   213,   214,   215,   216,   217,   218,   219,   220,
   221,   222,   223
};

static const short yycheck[] = {    87,
    58,    17,    56,   238,   239,   160,   174,   175,   369,     4,
    68,     4,     5,    10,     4,   176,    10,    75,     4,     4,
     3,     4,   521,   422,     4,   257,   445,    10,   117,     4,
    49,     4,   121,     4,   533,   526,     4,    57,    58,    59,
    60,    61,    96,    97,   535,    99,   100,    30,    31,   468,
   449,   105,     4,     4,    37,    38,    39,    10,   116,   117,
   105,   106,   107,    15,     4,     5,     4,    50,   429,    49,
   111,   116,   130,   131,    49,   133,    49,    15,    49,    62,
    32,    49,    48,   141,    67,    68,    69,    70,    71,    72,
    61,    48,   111,    61,    32,    66,   111,   111,    66,   119,
   158,   520,    88,   118,   118,    10,   117,   268,   119,   341,
    93,    16,   117,    84,   119,   117,    84,   119,    89,    48,
   117,    89,   117,   117,   117,   486,   119,   185,   186,   119,
   188,   189,   117,    37,   117,   193,   194,   117,   196,   122,
   123,    37,   200,   201,   202,   117,   118,   205,   206,   207,
   208,   209,   210,   211,   212,   213,   214,   215,   216,   217,
   218,   219,   220,   221,   222,   223,   224,   225,   226,     3,
     4,   112,   113,   114,   232,   233,     4,   117,   413,   119,
     6,     7,     8,     9,    10,    11,    12,    13,    14,   277,
    30,    31,    32,    33,    34,    48,    30,    31,    37,    32,
    33,    34,    37,    37,    38,    39,   487,   488,   489,   115,
   112,   265,   114,   267,    37,    37,    50,    39,   117,   117,
   119,   119,    37,    57,    58,    59,    60,    61,    62,   117,
    37,   119,    37,    67,    68,    69,    70,    71,    72,     4,
     5,    37,   410,     3,     4,     4,     5,    37,     6,     7,
     8,     9,    10,    11,    12,    13,    14,    37,    37,    93,
    37,     4,   278,     3,     4,     4,     4,     4,     4,     4,
    10,     4,     4,     4,   332,   333,   334,   335,   433,    37,
     3,    95,     4,     4,     4,   119,     4,    37,   122,   123,
    30,    31,     4,     4,     4,     4,     4,    37,    38,    39,
     4,   359,   360,    48,   362,   117,   117,    37,    37,    37,
    50,    28,    29,    30,    31,    32,    33,    34,    37,   117,
     3,     4,    62,    37,    37,   117,   117,    67,    68,    69,
    70,    71,    72,    49,    37,    37,   394,    37,   426,    37,
    16,    16,   118,    10,   119,   119,   119,    30,    31,   119,
   119,   119,   119,    93,    37,    38,    39,    40,   119,   417,
     4,   529,   450,   421,     4,   423,   534,    50,     4,     4,
   538,     4,     4,     4,     4,     4,     4,   117,   112,    62,
    37,     4,   122,   123,    67,    68,    69,    70,    71,    72,
    16,   479,   119,   451,   119,   483,     3,     4,    37,    16,
    88,    78,     4,    16,   119,   112,    79,     4,    16,    16,
    93,    48,   117,   119,    10,    37,    37,   118,    15,   118,
    81,    37,   119,    30,    31,   119,   119,   119,   117,    48,
    37,    38,    39,   118,   522,    32,   118,    48,    10,   122,
   123,     3,     4,    50,    41,    42,    43,    44,    45,    37,
    16,    37,    37,    37,    49,    62,    37,    37,    37,   119,
    67,    68,    69,    70,    71,    72,    25,   119,    30,    31,
    16,     4,    48,     4,    49,    37,    38,    39,     0,     0,
   164,   420,   520,    80,   468,    82,    93,   402,    50,    86,
   181,   187,    89,     4,   471,    -1,   334,   510,   184,    -1,
    62,    -1,    -1,    -1,    -1,    67,    68,    69,    70,    71,
    72,    -1,    -1,    -1,    -1,   122,   123,    -1,    -1,    -1,
    -1,   118,    -1,   120,    -1,    -1,    -1,    -1,    -1,    -1,
    -1,    93,    -1,    -1,    -1,    46,    47,    -1,    -1,     4,
    51,    52,    53,    54,    55,     4,    -1,    -1,    -1,    -1,
    -1,    -1,    63,    64,    65,    66,    -1,    -1,    -1,    -1,
   122,   123,    73,    74,    75,    76,    77,    78,    -1,    -1,
    -1,    36,    83,    84,    85,    -1,    -1,    -1,    89,    38,
    -1,    46,    47,    -1,    -1,    -1,    51,    52,    53,    54,
    55,    -1,    -1,    -1,    -1,    54,    -1,    -1,    63,    64,
    65,    66,    -1,    -1,   115,    -1,    -1,   118,    73,    74,
    75,    76,    77,    78,     4,    -1,    -1,    -1,    83,    84,
    85,    -1,    -1,    -1,    89,    -1,    -1,    -1,    87,    -1,
    -1,    90,    91,    92,    93,    94,    95,    96,    97,    98,
    99,   100,   101,   102,   103,    -1,    36,    -1,    38,   108,
   109,   110,    -1,   118,    -1,    -1,    -1,    -1,    -1,    -1,
    -1,    -1,    -1,    15,    54,    17,    18,    19,    20,    21,
    22,    23,    24,    25,    26,    27,    28,    29,    30,    31,
    32,    33,    34,    21,    22,    23,    24,    25,    26,    27,
    28,    29,    30,    31,    32,    33,    34,    87,    -1,    -1,
    90,    91,    92,    93,    94,    -1,    96,    97,    98,    99,
   100,   101,   102,   103,    -1,    -1,    -1,    -1,   108,   109,
   110,    15,    -1,    17,    18,    19,    20,    21,    22,    23,
    24,    25,    26,    27,    28,    29,    30,    31,    32,    33,
    34,    15,    -1,    17,    18,    19,    20,    21,    22,    23,
    24,    25,    26,    27,    28,    29,    30,    31,    32,    33,
    34,    -1,    -1,    -1,    -1,    -1,    15,   119,    17,    18,
    19,    20,    21,    22,    23,    24,    25,    26,    27,    28,
    29,    30,    31,    32,    33,    34,    15,    -1,    17,    18,
    19,    20,    21,    22,    23,    24,    25,    26,    27,    28,
    29,    30,    31,    32,    33,    34,    18,    19,    20,    21,
    22,    23,    24,    25,    26,    27,    28,    29,    30,    31,
    32,    33,    34,    -1,    15,   119,    17,    18,    19,    20,
    21,    22,    23,    24,    25,    26,    27,    28,    29,    30,
    31,    32,    33,    34,    15,   119,    17,    18,    19,    20,
    21,    22,    23,    24,    25,    26,    27,    28,    29,    30,
    31,    32,    33,    34,    -1,    -1,    -1,    -1,    -1,    15,
   119,    17,    18,    19,    20,    21,    22,    23,    24,    25,
    26,    27,    28,    29,    30,    31,    32,    33,    34,    15,
   119,    17,    18,    19,    20,    21,    22,    23,    24,    25,
    26,    27,    28,    29,    30,    31,    32,    33,    34,    19,
    20,    21,    22,    23,    24,    25,    26,    27,    28,    29,
    30,    31,    32,    33,    34,    -1,    -1,    15,   119,    17,
    18,    19,    20,    21,    22,    23,    24,    25,    26,    27,
    28,    29,    30,    31,    32,    33,    34,    15,   119,    17,
    18,    19,    20,    21,    22,    23,    24,    25,    26,    27,
    28,    29,    30,    31,    32,    33,    34,    -1,    -1,    -1,
    -1,    -1,    15,   119,    17,    18,    19,    20,    21,    22,
    23,    24,    25,    26,    27,    28,    29,    30,    31,    32,
    33,    34,    15,   119,    17,    18,    19,    20,    21,    22,
    23,    24,    25,    26,    27,    28,    29,    30,    31,    32,
    33,    34,    20,    21,    22,    23,    24,    25,    26,    27,
    28,    29,    30,    31,    32,    33,    34,    -1,    -1,    -1,
    15,   119,    17,    18,    19,    20,    21,    22,    23,    24,
    25,    26,    27,    28,    29,    30,    31,    32,    33,    34,
    15,   119,    17,    18,    19,    20,    21,    22,    23,    24,
    25,    26,    27,    28,    29,    30,    31,    32,    33,    34,
    -1,    -1,    -1,    -1,    -1,    -1,   119,    22,    23,    24,
    25,    26,    27,    28,    29,    30,    31,    32,    33,    34,
    -1,    -1,    -1,    15,   117,    17,    18,    19,    20,    21,
    22,    23,    24,    25,    26,    27,    28,    29,    30,    31,
    32,    33,    34,    -1,    -1,    37,    24,    25,    26,    27,
    28,    29,    30,    31,    32,    33,    34,    -1,    -1,    -1,
    -1,    15,   117,    17,    18,    19,    20,    21,    22,    23,
    24,    25,    26,    27,    28,    29,    30,    31,    32,    33,
    34,    -1,   117,    15,    16,    17,    18,    19,    20,    21,
    22,    23,    24,    25,    26,    27,    28,    29,    30,    31,
    32,    33,    34,    15,    16,    17,    18,    19,    20,    21,
    22,    23,    24,    25,    26,    27,    28,    29,    30,    31,
    32,    33,    34
};
/* -*-C-*-  Note some compilers choke on comments on `#line' lines.  */
#line 3 "/usr/cygnus/progressive-97r2/share/bison.simple"

/* Skeleton output parser for bison,
   Copyright (C) 1984, 1989, 1990 Free Software Foundation, Inc.

   This program is free software; you can redistribute it and/or modify
   it under the terms of the GNU General Public License as published by
   the Free Software Foundation; either version 2, or (at your option)
   any later version.

   This program is distributed in the hope that it will be useful,
   but WITHOUT ANY WARRANTY; without even the implied warranty of
   MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
   GNU General Public License for more details.

   You should have received a copy of the GNU General Public License
   along with this program; if not, write to the Free Software
   Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.  */

/* As a special exception, when this file is copied by Bison into a
   Bison output file, you may use that output file without restriction.
   This special exception was added by the Free Software Foundation
   in version 1.24 of Bison.  */

#ifndef alloca
#ifdef __GNUC__
#define alloca __builtin_alloca
#else /* not GNU C.  */
#if (!defined (__STDC__) && defined (sparc)) || defined (__sparc__) || defined (__sparc) || defined (__sgi)
#include <alloca.h>
#else /* not sparc */
#if defined (MSDOS) && !defined (__TURBOC__)
#include <malloc.h>
#else /* not MSDOS, or __TURBOC__ */
#if defined(_AIX)
#include <malloc.h>
 #pragma alloca
#else /* not MSDOS, __TURBOC__, or _AIX */
#ifdef __hpux
#ifdef __cplusplus
extern "C" {
void *alloca (unsigned int);
};
#else /* not __cplusplus */
void *alloca ();
#endif /* not __cplusplus */
#endif /* __hpux */
#endif /* not _AIX */
#endif /* not MSDOS, or __TURBOC__ */
#endif /* not sparc.  */
#endif /* not GNU C.  */
#endif /* alloca not defined.  */

/* This is the parser code that is written into each bison parser
  when the %semantic_parser declaration is not specified in the grammar.
  It was written by Richard Stallman by simplifying the hairy parser
  used when %semantic_parser is specified.  */

/* Note: there must be only one dollar sign in this file.
   It is replaced by the list of actions, each action
   as one case of the switch.  */

#define yyerrok		(yyerrstatus = 0)
#define yyclearin	(yychar = YYEMPTY)
#define YYEMPTY		-2
#define YYEOF		0
#define YYACCEPT	return(0)
#define YYABORT 	return(1)
#define YYERROR		goto yyerrlab1
/* Like YYERROR except do call yyerror.
   This remains here temporarily to ease the
   transition to the new meaning of YYERROR, for GCC.
   Once GCC version 2 has supplanted version 1, this can go.  */
#define YYFAIL		goto yyerrlab
#define YYRECOVERING()  (!!yyerrstatus)
#define YYBACKUP(token, value) \
do								\
  if (yychar == YYEMPTY && yylen == 1)				\
    { yychar = (token), yylval = (value);			\
      yychar1 = YYTRANSLATE (yychar);				\
      YYPOPSTACK;						\
      goto yybackup;						\
    }								\
  else								\
    { yyerror ("syntax error: cannot back up"); YYERROR; }	\
while (0)

#define YYTERROR	1
#define YYERRCODE	256

#ifndef YYPURE
#define YYLEX		yylex()
#endif

#ifdef YYPURE
#ifdef YYLSP_NEEDED
#ifdef YYLEX_PARAM
#define YYLEX		yylex(&yylval, &yylloc, YYLEX_PARAM)
#else
#define YYLEX		yylex(&yylval, &yylloc)
#endif
#else /* not YYLSP_NEEDED */
#ifdef YYLEX_PARAM
#define YYLEX		yylex(&yylval, YYLEX_PARAM)
#else
#define YYLEX		yylex(&yylval)
#endif
#endif /* not YYLSP_NEEDED */
#endif

/* If nonreentrant, generate the variables here */

#ifndef YYPURE

int	yychar;			/*  the lookahead symbol		*/
YYSTYPE	yylval;			/*  the semantic value of the		*/
				/*  lookahead symbol			*/

#ifdef YYLSP_NEEDED
YYLTYPE yylloc;			/*  location data for the lookahead	*/
				/*  symbol				*/
#endif

int yynerrs;			/*  number of parse errors so far       */
#endif  /* not YYPURE */

#if YYDEBUG != 0
int yydebug;			/*  nonzero means print parse trace	*/
/* Since this is uninitialized, it does not stop multiple parsers
   from coexisting.  */
#endif

/*  YYINITDEPTH indicates the initial size of the parser's stacks	*/

#ifndef	YYINITDEPTH
#define YYINITDEPTH 200
#endif

/*  YYMAXDEPTH is the maximum size the stacks can grow to
    (effective only if the built-in stack extension method is used).  */

#if YYMAXDEPTH == 0
#undef YYMAXDEPTH
#endif

#ifndef YYMAXDEPTH
#define YYMAXDEPTH 10000
#endif

/* Prevent warning if -Wstrict-prototypes.  */
#ifdef __GNUC__
int yyparse (void);
#endif

#if __GNUC__ > 1		/* GNU C and GNU C++ define this.  */
#define __yy_memcpy(TO,FROM,COUNT)	__builtin_memcpy(TO,FROM,COUNT)
#else				/* not GNU C or C++ */
#ifndef __cplusplus

/* This is the most reliable way to avoid incompatibilities
   in available built-in functions on various systems.  */
static void
__yy_memcpy (to, from, count)
     char *to;
     char *from;
     int count;
{
  register char *f = from;
  register char *t = to;
  register int i = count;

  while (i-- > 0)
    *t++ = *f++;
}

#else /* __cplusplus */

/* This is the most reliable way to avoid incompatibilities
   in available built-in functions on various systems.  */
static void
__yy_memcpy (char *to, char *from, int count)
{
  register char *f = from;
  register char *t = to;
  register int i = count;

  while (i-- > 0)
    *t++ = *f++;
}

#endif
#endif

#line 196 "/usr/cygnus/progressive-97r2/share/bison.simple"

/* The user can define YYPARSE_PARAM as the name of an argument to be passed
   into yyparse.  The argument should have type void *.
   It should actually point to an object.
   Grammar actions can access the variable by casting it
   to the proper pointer type.  */

#ifdef YYPARSE_PARAM
#ifdef __cplusplus
#define YYPARSE_PARAM_ARG void *YYPARSE_PARAM
#define YYPARSE_PARAM_DECL
#else /* not __cplusplus */
#define YYPARSE_PARAM_ARG YYPARSE_PARAM
#define YYPARSE_PARAM_DECL void *YYPARSE_PARAM;
#endif /* not __cplusplus */
#else /* not YYPARSE_PARAM */
#define YYPARSE_PARAM_ARG
#define YYPARSE_PARAM_DECL
#endif /* not YYPARSE_PARAM */

int
yyparse(YYPARSE_PARAM_ARG)
     YYPARSE_PARAM_DECL
{
  register int yystate;
  register int yyn;
  register short *yyssp;
  register YYSTYPE *yyvsp;
  int yyerrstatus;	/*  number of tokens to shift before error messages enabled */
  int yychar1 = 0;		/*  lookahead token as an internal (translated) token number */

  short	yyssa[YYINITDEPTH];	/*  the state stack			*/
  YYSTYPE yyvsa[YYINITDEPTH];	/*  the semantic value stack		*/

  short *yyss = yyssa;		/*  refer to the stacks thru separate pointers */
  YYSTYPE *yyvs = yyvsa;	/*  to allow yyoverflow to reallocate them elsewhere */

#ifdef YYLSP_NEEDED
  YYLTYPE yylsa[YYINITDEPTH];	/*  the location stack			*/
  YYLTYPE *yyls = yylsa;
  YYLTYPE *yylsp;

#define YYPOPSTACK   (yyvsp--, yyssp--, yylsp--)
#else
#define YYPOPSTACK   (yyvsp--, yyssp--)
#endif

  int yystacksize = YYINITDEPTH;

#ifdef YYPURE
  int yychar;
  YYSTYPE yylval;
  int yynerrs;
#ifdef YYLSP_NEEDED
  YYLTYPE yylloc;
#endif
#endif

  YYSTYPE yyval;		/*  the variable used to return		*/
				/*  semantic values from the action	*/
				/*  routines				*/

  int yylen;

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Starting parse\n");
#endif

  yystate = 0;
  yyerrstatus = 0;
  yynerrs = 0;
  yychar = YYEMPTY;		/* Cause a token to be read.  */

  /* Initialize stack pointers.
     Waste one element of value and location stack
     so that they stay on the same level as the state stack.
     The wasted elements are never initialized.  */

  yyssp = yyss - 1;
  yyvsp = yyvs;
#ifdef YYLSP_NEEDED
  yylsp = yyls;
#endif

/* Push a new state, which is found in  yystate  .  */
/* In all cases, when you get here, the value and location stacks
   have just been pushed. so pushing a state here evens the stacks.  */
yynewstate:

  *++yyssp = yystate;

  if (yyssp >= yyss + yystacksize - 1)
    {
      /* Give user a chance to reallocate the stack */
      /* Use copies of these so that the &'s don't force the real ones into memory. */
      YYSTYPE *yyvs1 = yyvs;
      short *yyss1 = yyss;
#ifdef YYLSP_NEEDED
      YYLTYPE *yyls1 = yyls;
#endif

      /* Get the current used size of the three stacks, in elements.  */
      int size = yyssp - yyss + 1;

#ifdef yyoverflow
      /* Each stack pointer address is followed by the size of
	 the data in use in that stack, in bytes.  */
#ifdef YYLSP_NEEDED
      /* This used to be a conditional around just the two extra args,
	 but that might be undefined if yyoverflow is a macro.  */
      yyoverflow("parser stack overflow",
		 &yyss1, size * sizeof (*yyssp),
		 &yyvs1, size * sizeof (*yyvsp),
		 &yyls1, size * sizeof (*yylsp),
		 &yystacksize);
#else
      yyoverflow("parser stack overflow",
		 &yyss1, size * sizeof (*yyssp),
		 &yyvs1, size * sizeof (*yyvsp),
		 &yystacksize);
#endif

      yyss = yyss1; yyvs = yyvs1;
#ifdef YYLSP_NEEDED
      yyls = yyls1;
#endif
#else /* no yyoverflow */
      /* Extend the stack our own way.  */
      if (yystacksize >= YYMAXDEPTH)
	{
	  yyerror("parser stack overflow");
	  return 2;
	}
      yystacksize *= 2;
      if (yystacksize > YYMAXDEPTH)
	yystacksize = YYMAXDEPTH;
      yyss = (short *) alloca (yystacksize * sizeof (*yyssp));
      __yy_memcpy ((char *)yyss, (char *)yyss1, size * sizeof (*yyssp));
      yyvs = (YYSTYPE *) alloca (yystacksize * sizeof (*yyvsp));
      __yy_memcpy ((char *)yyvs, (char *)yyvs1, size * sizeof (*yyvsp));
#ifdef YYLSP_NEEDED
      yyls = (YYLTYPE *) alloca (yystacksize * sizeof (*yylsp));
      __yy_memcpy ((char *)yyls, (char *)yyls1, size * sizeof (*yylsp));
#endif
#endif /* no yyoverflow */

      yyssp = yyss + size - 1;
      yyvsp = yyvs + size - 1;
#ifdef YYLSP_NEEDED
      yylsp = yyls + size - 1;
#endif

#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Stack size increased to %d\n", yystacksize);
#endif

      if (yyssp >= yyss + yystacksize - 1)
	YYABORT;
    }

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Entering state %d\n", yystate);
#endif

  goto yybackup;
 yybackup:

/* Do appropriate processing given the current state.  */
/* Read a lookahead token if we need one and don't already have one.  */
/* yyresume: */

  /* First try to decide what to do without reference to lookahead token.  */

  yyn = yypact[yystate];
  if (yyn == YYFLAG)
    goto yydefault;

  /* Not known => get a lookahead token if don't already have one.  */

  /* yychar is either YYEMPTY or YYEOF
     or a valid token in external form.  */

  if (yychar == YYEMPTY)
    {
#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Reading a token: ");
#endif
      yychar = YYLEX;
    }

  /* Convert token to internal form (in yychar1) for indexing tables with */

  if (yychar <= 0)		/* This means end of input. */
    {
      yychar1 = 0;
      yychar = YYEOF;		/* Don't call YYLEX any more */

#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Now at end of input.\n");
#endif
    }
  else
    {
      yychar1 = YYTRANSLATE(yychar);

#if YYDEBUG != 0
      if (yydebug)
	{
	  fprintf (stderr, "Next token is %d (%s", yychar, yytname[yychar1]);
	  /* Give the individual parser a way to print the precise meaning
	     of a token, for further debugging info.  */
#ifdef YYPRINT
	  YYPRINT (stderr, yychar, yylval);
#endif
	  fprintf (stderr, ")\n");
	}
#endif
    }

  yyn += yychar1;
  if (yyn < 0 || yyn > YYLAST || yycheck[yyn] != yychar1)
    goto yydefault;

  yyn = yytable[yyn];

  /* yyn is what to do for this token type in this state.
     Negative => reduce, -yyn is rule number.
     Positive => shift, yyn is new state.
       New state is final state => don't bother to shift,
       just return success.
     0, or most negative number => error.  */

  if (yyn < 0)
    {
      if (yyn == YYFLAG)
	goto yyerrlab;
      yyn = -yyn;
      goto yyreduce;
    }
  else if (yyn == 0)
    goto yyerrlab;

  if (yyn == YYFINAL)
    YYACCEPT;

  /* Shift the lookahead token.  */

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Shifting token %d (%s), ", yychar, yytname[yychar1]);
#endif

  /* Discard the token being shifted unless it is eof.  */
  if (yychar != YYEOF)
    yychar = YYEMPTY;

  *++yyvsp = yylval;
#ifdef YYLSP_NEEDED
  *++yylsp = yylloc;
#endif

  /* count tokens shifted since error; after three, turn off error status.  */
  if (yyerrstatus) yyerrstatus--;

  yystate = yyn;
  goto yynewstate;

/* Do the default action for the current state.  */
yydefault:

  yyn = yydefact[yystate];
  if (yyn == 0)
    goto yyerrlab;

/* Do a reduction.  yyn is the number of a rule to reduce with.  */
yyreduce:
  yylen = yyr2[yyn];
  if (yylen > 0)
    yyval = yyvsp[1-yylen]; /* implement default value of the action */

#if YYDEBUG != 0
  if (yydebug)
    {
      int i;

      fprintf (stderr, "Reducing via rule %d (line %d), ",
	       yyn, yyrline[yyn]);

      /* Print the symbols being reduced, and their result.  */
      for (i = yyprhs[yyn]; yyrhs[i] > 0; i++)
	fprintf (stderr, "%s ", yytname[yyrhs[i]]);
      fprintf (stderr, " -> %s\n", yytname[yyr1[yyn]]);
    }
#endif


  switch (yyn) {

case 6:
#line 154 "ldgram.y"
{ ldlex_defsym(); ;
    break;}
case 7:
#line 156 "ldgram.y"
{
		  ldlex_popstate();
		  lang_add_assignment(exp_assop(yyvsp[-1].token,yyvsp[-2].name,yyvsp[0].etree));
		;
    break;}
case 8:
#line 163 "ldgram.y"
{
		  ldlex_mri_script ();
		  PUSH_ERROR ("MRI style script");
		;
    break;}
case 9:
#line 168 "ldgram.y"
{
		  ldlex_popstate ();
		  mri_draw_tree ();
		  POP_ERROR ();
		;
    break;}
case 14:
#line 183 "ldgram.y"
{
			einfo("%P%F: unrecognised keyword in MRI style script '%s'\n",yyvsp[0].name);
			;
    break;}
case 15:
#line 186 "ldgram.y"
{
			config.map_filename = "-";
			;
    break;}
case 18:
#line 192 "ldgram.y"
{ mri_public(yyvsp[-2].name, yyvsp[0].etree); ;
    break;}
case 19:
#line 194 "ldgram.y"
{ mri_public(yyvsp[-2].name, yyvsp[0].etree); ;
    break;}
case 20:
#line 196 "ldgram.y"
{ mri_public(yyvsp[-1].name, yyvsp[0].etree); ;
    break;}
case 21:
#line 198 "ldgram.y"
{ mri_format(yyvsp[0].name); ;
    break;}
case 22:
#line 200 "ldgram.y"
{ mri_output_section(yyvsp[-2].name, yyvsp[0].etree);;
    break;}
case 23:
#line 202 "ldgram.y"
{ mri_output_section(yyvsp[-1].name, yyvsp[0].etree);;
    break;}
case 24:
#line 204 "ldgram.y"
{ mri_output_section(yyvsp[-2].name, yyvsp[0].etree);;
    break;}
case 25:
#line 206 "ldgram.y"
{ mri_align(yyvsp[-2].name,yyvsp[0].etree); ;
    break;}
case 26:
#line 208 "ldgram.y"
{ mri_align(yyvsp[-2].name,yyvsp[0].etree); ;
    break;}
case 27:
#line 210 "ldgram.y"
{ mri_alignmod(yyvsp[-2].name,yyvsp[0].etree); ;
    break;}
case 28:
#line 212 "ldgram.y"
{ mri_alignmod(yyvsp[-2].name,yyvsp[0].etree); ;
    break;}
case 31:
#line 216 "ldgram.y"
{ mri_name(yyvsp[0].name); ;
    break;}
case 32:
#line 218 "ldgram.y"
{ mri_alias(yyvsp[-2].name,yyvsp[0].name,0);;
    break;}
case 33:
#line 220 "ldgram.y"
{ mri_alias(yyvsp[-2].name,0,(int) yyvsp[0].integer);;
    break;}
case 34:
#line 222 "ldgram.y"
{ mri_base(yyvsp[0].etree); ;
    break;}
case 35:
#line 224 "ldgram.y"
{  mri_truncate((unsigned int) yyvsp[0].integer); ;
    break;}
case 38:
#line 228 "ldgram.y"
{ ldfile_open_command_file (yyvsp[0].name); ;
    break;}
case 40:
#line 230 "ldgram.y"
{ lang_add_entry (yyvsp[0].name, false); ;
    break;}
case 42:
#line 235 "ldgram.y"
{ mri_order(yyvsp[0].name); ;
    break;}
case 43:
#line 236 "ldgram.y"
{ mri_order(yyvsp[0].name); ;
    break;}
case 45:
#line 242 "ldgram.y"
{ mri_load(yyvsp[0].name); ;
    break;}
case 46:
#line 243 "ldgram.y"
{ mri_load(yyvsp[0].name); ;
    break;}
case 47:
#line 248 "ldgram.y"
{ mri_only_load(yyvsp[0].name); ;
    break;}
case 48:
#line 250 "ldgram.y"
{ mri_only_load(yyvsp[0].name); ;
    break;}
case 49:
#line 254 "ldgram.y"
{ yyval.name = NULL; ;
    break;}
case 52:
#line 261 "ldgram.y"
{ ldlang_add_undef (yyvsp[0].name); ;
    break;}
case 53:
#line 263 "ldgram.y"
{ ldlang_add_undef (yyvsp[0].name); ;
    break;}
case 54:
#line 267 "ldgram.y"
{
	 ldlex_both();
	;
    break;}
case 55:
#line 271 "ldgram.y"
{
	ldlex_popstate();
	;
    break;}
case 68:
#line 296 "ldgram.y"
{ lang_add_target(yyvsp[-1].name); ;
    break;}
case 69:
#line 298 "ldgram.y"
{ ldfile_add_library_path (yyvsp[-1].name, false); ;
    break;}
case 70:
#line 300 "ldgram.y"
{ lang_add_output(yyvsp[-1].name, 1); ;
    break;}
case 71:
#line 302 "ldgram.y"
{ lang_add_output_format (yyvsp[-1].name, (char *) NULL,
					    (char *) NULL, 1); ;
    break;}
case 72:
#line 305 "ldgram.y"
{ lang_add_output_format (yyvsp[-5].name, yyvsp[-3].name, yyvsp[-1].name, 1); ;
    break;}
case 73:
#line 307 "ldgram.y"
{ ldfile_set_output_arch(yyvsp[-1].name); ;
    break;}
case 74:
#line 309 "ldgram.y"
{ command_line.force_common_definition = true ; ;
    break;}
case 76:
#line 312 "ldgram.y"
{ lang_enter_group (); ;
    break;}
case 77:
#line 314 "ldgram.y"
{ lang_leave_group (); ;
    break;}
case 78:
#line 316 "ldgram.y"
{ lang_add_map(yyvsp[-1].name); ;
    break;}
case 79:
#line 318 "ldgram.y"
{ ldfile_open_command_file(yyvsp[0].name); ;
    break;}
case 81:
#line 320 "ldgram.y"
{
		  lang_add_nocrossref (yyvsp[-1].nocrossref);
		;
    break;}
case 82:
#line 327 "ldgram.y"
{ lang_add_input_file(yyvsp[0].name,lang_input_file_is_search_file_enum,
				 (char *)NULL); ;
    break;}
case 83:
#line 330 "ldgram.y"
{ lang_add_input_file(yyvsp[0].name,lang_input_file_is_search_file_enum,
				 (char *)NULL); ;
    break;}
case 84:
#line 333 "ldgram.y"
{ lang_add_input_file(yyvsp[0].name,lang_input_file_is_search_file_enum,
				 (char *)NULL); ;
    break;}
case 85:
#line 336 "ldgram.y"
{ lang_add_input_file(yyvsp[0].name,lang_input_file_is_l_enum,
				 (char *)NULL); ;
    break;}
case 86:
#line 339 "ldgram.y"
{ lang_add_input_file(yyvsp[0].name,lang_input_file_is_l_enum,
				 (char *)NULL); ;
    break;}
case 87:
#line 342 "ldgram.y"
{ lang_add_input_file(yyvsp[0].name,lang_input_file_is_l_enum,
				 (char *)NULL); ;
    break;}
case 92:
#line 358 "ldgram.y"
{ lang_add_entry (yyvsp[-1].name, false); ;
    break;}
case 94:
#line 366 "ldgram.y"
{ lang_add_wild (yyvsp[0].name, current_file); ;
    break;}
case 95:
#line 368 "ldgram.y"
{ lang_add_wild ("*", current_file); ;
    break;}
case 96:
#line 370 "ldgram.y"
{ lang_add_wild ("?", current_file); ;
    break;}
case 97:
#line 372 "ldgram.y"
{ lang_add_wild (yyvsp[0].name, current_file); ;
    break;}
case 98:
#line 374 "ldgram.y"
{ lang_add_wild ("*", current_file); ;
    break;}
case 99:
#line 376 "ldgram.y"
{ lang_add_wild ("?", current_file); ;
    break;}
case 100:
#line 381 "ldgram.y"
{
		lang_add_wild((char *)NULL, yyvsp[0].name);
		;
    break;}
case 101:
#line 385 "ldgram.y"
{
			current_file = (char *)NULL;
			;
    break;}
case 103:
#line 391 "ldgram.y"
{
			current_file = yyvsp[0].name;
			;
    break;}
case 105:
#line 398 "ldgram.y"
{
			current_file = "?";
			;
    break;}
case 107:
#line 403 "ldgram.y"
{
			current_file = (char *)NULL;
			;
    break;}
case 110:
#line 412 "ldgram.y"
{
 		lang_add_attribute(lang_object_symbols_statement_enum); 
	      	;
    break;}
case 112:
#line 417 "ldgram.y"
{
 		
		  lang_add_attribute(lang_constructors_statement_enum); 
		;
    break;}
case 114:
#line 423 "ldgram.y"
{
			lang_add_data((int) yyvsp[-3].integer,yyvsp[-1].etree);
			;
    break;}
case 115:
#line 428 "ldgram.y"
{
			  lang_add_fill
			    (exp_get_value_int(yyvsp[-1].etree,
					       0,
					       "fill value",
					       lang_first_phase_enum));
			;
    break;}
case 120:
#line 449 "ldgram.y"
{ yyval.integer = yyvsp[0].token; ;
    break;}
case 121:
#line 451 "ldgram.y"
{ yyval.integer = yyvsp[0].token; ;
    break;}
case 122:
#line 453 "ldgram.y"
{ yyval.integer = yyvsp[0].token; ;
    break;}
case 123:
#line 455 "ldgram.y"
{ yyval.integer = yyvsp[0].token; ;
    break;}
case 124:
#line 457 "ldgram.y"
{ yyval.integer = yyvsp[0].token; ;
    break;}
case 125:
#line 462 "ldgram.y"
{
		  yyval.integer =	 exp_get_value_int(yyvsp[0].etree,
					   0,
					   "fill value",
					   lang_first_phase_enum);
		;
    break;}
case 126:
#line 468 "ldgram.y"
{ yyval.integer = 0; ;
    break;}
case 127:
#line 475 "ldgram.y"
{ yyval.token = '+'; ;
    break;}
case 128:
#line 477 "ldgram.y"
{ yyval.token = '-'; ;
    break;}
case 129:
#line 479 "ldgram.y"
{ yyval.token = '*'; ;
    break;}
case 130:
#line 481 "ldgram.y"
{ yyval.token = '/'; ;
    break;}
case 131:
#line 483 "ldgram.y"
{ yyval.token = LSHIFT; ;
    break;}
case 132:
#line 485 "ldgram.y"
{ yyval.token = RSHIFT; ;
    break;}
case 133:
#line 487 "ldgram.y"
{ yyval.token = '&'; ;
    break;}
case 134:
#line 489 "ldgram.y"
{ yyval.token = '|'; ;
    break;}
case 137:
#line 499 "ldgram.y"
{
		  lang_add_assignment (exp_assop (yyvsp[-1].token, yyvsp[-2].name, yyvsp[0].etree));
		;
    break;}
case 138:
#line 503 "ldgram.y"
{
		  lang_add_assignment (exp_assop ('=', yyvsp[-2].name,
						  exp_binop (yyvsp[-1].token,
							     exp_nameop (NAME,
									 yyvsp[-2].name),
							     yyvsp[0].etree)));
		;
    break;}
case 139:
#line 511 "ldgram.y"
{
		  lang_add_assignment (exp_provide (yyvsp[-3].name, yyvsp[-1].etree));
		;
    break;}
case 146:
#line 533 "ldgram.y"
{ region = lang_memory_region_lookup(yyvsp[0].name); ;
    break;}
case 148:
#line 539 "ldgram.y"
{ region->current =
		 region->origin =
		 exp_get_vma(yyvsp[0].etree, 0L,"origin", lang_first_phase_enum);
;
    break;}
case 149:
#line 547 "ldgram.y"
{ region->length = exp_get_vma(yyvsp[0].etree,
					       ~((bfd_vma)0),
					       "length",
					       lang_first_phase_enum);
		;
    break;}
case 150:
#line 556 "ldgram.y"
{
			lang_set_flags(region, yyvsp[-1].name);
			;
    break;}
case 152:
#line 565 "ldgram.y"
{ lang_startup(yyvsp[-1].name); ;
    break;}
case 154:
#line 571 "ldgram.y"
{ ldemul_hll((char *)NULL); ;
    break;}
case 155:
#line 576 "ldgram.y"
{ ldemul_hll(yyvsp[0].name); ;
    break;}
case 156:
#line 578 "ldgram.y"
{ ldemul_hll(yyvsp[0].name); ;
    break;}
case 158:
#line 586 "ldgram.y"
{ ldemul_syslib(yyvsp[0].name); ;
    break;}
case 160:
#line 592 "ldgram.y"
{ lang_float(true); ;
    break;}
case 161:
#line 594 "ldgram.y"
{ lang_float(false); ;
    break;}
case 162:
#line 599 "ldgram.y"
{
		  yyval.nocrossref = NULL;
		;
    break;}
case 163:
#line 603 "ldgram.y"
{
		  struct lang_nocrossref *n;

		  n = (struct lang_nocrossref *) xmalloc (sizeof *n);
		  n->name = yyvsp[-1].name;
		  n->next = yyvsp[0].nocrossref;
		  yyval.nocrossref = n;
		;
    break;}
case 164:
#line 612 "ldgram.y"
{
		  struct lang_nocrossref *n;

		  n = (struct lang_nocrossref *) xmalloc (sizeof *n);
		  n->name = yyvsp[-2].name;
		  n->next = yyvsp[0].nocrossref;
		  yyval.nocrossref = n;
		;
    break;}
case 165:
#line 622 "ldgram.y"
{ ldlex_expression(); ;
    break;}
case 166:
#line 624 "ldgram.y"
{ ldlex_popstate(); yyval.etree=yyvsp[0].etree;;
    break;}
case 167:
#line 629 "ldgram.y"
{ yyval.etree = exp_unop('-', yyvsp[0].etree); ;
    break;}
case 168:
#line 631 "ldgram.y"
{ yyval.etree = yyvsp[-1].etree; ;
    break;}
case 169:
#line 633 "ldgram.y"
{ yyval.etree = exp_unop((int) yyvsp[-3].integer,yyvsp[-1].etree); ;
    break;}
case 170:
#line 635 "ldgram.y"
{ yyval.etree = exp_unop('!', yyvsp[0].etree); ;
    break;}
case 171:
#line 637 "ldgram.y"
{ yyval.etree = yyvsp[0].etree; ;
    break;}
case 172:
#line 639 "ldgram.y"
{ yyval.etree = exp_unop('~', yyvsp[0].etree);;
    break;}
case 173:
#line 642 "ldgram.y"
{ yyval.etree = exp_binop('*', yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 174:
#line 644 "ldgram.y"
{ yyval.etree = exp_binop('/', yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 175:
#line 646 "ldgram.y"
{ yyval.etree = exp_binop('%', yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 176:
#line 648 "ldgram.y"
{ yyval.etree = exp_binop('+', yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 177:
#line 650 "ldgram.y"
{ yyval.etree = exp_binop('-' , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 178:
#line 652 "ldgram.y"
{ yyval.etree = exp_binop(LSHIFT , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 179:
#line 654 "ldgram.y"
{ yyval.etree = exp_binop(RSHIFT , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 180:
#line 656 "ldgram.y"
{ yyval.etree = exp_binop(EQ , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 181:
#line 658 "ldgram.y"
{ yyval.etree = exp_binop(NE , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 182:
#line 660 "ldgram.y"
{ yyval.etree = exp_binop(LE , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 183:
#line 662 "ldgram.y"
{ yyval.etree = exp_binop(GE , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 184:
#line 664 "ldgram.y"
{ yyval.etree = exp_binop('<' , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 185:
#line 666 "ldgram.y"
{ yyval.etree = exp_binop('>' , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 186:
#line 668 "ldgram.y"
{ yyval.etree = exp_binop('&' , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 187:
#line 670 "ldgram.y"
{ yyval.etree = exp_binop('^' , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 188:
#line 672 "ldgram.y"
{ yyval.etree = exp_binop('|' , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 189:
#line 674 "ldgram.y"
{ yyval.etree = exp_trinop('?' , yyvsp[-4].etree, yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 190:
#line 676 "ldgram.y"
{ yyval.etree = exp_binop(ANDAND , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 191:
#line 678 "ldgram.y"
{ yyval.etree = exp_binop(OROR , yyvsp[-2].etree, yyvsp[0].etree); ;
    break;}
case 192:
#line 680 "ldgram.y"
{ yyval.etree = exp_nameop(DEFINED, yyvsp[-1].name); ;
    break;}
case 193:
#line 682 "ldgram.y"
{ yyval.etree = exp_intop(yyvsp[0].integer); ;
    break;}
case 194:
#line 684 "ldgram.y"
{ yyval.etree = exp_nameop(SIZEOF_HEADERS,0); ;
    break;}
case 195:
#line 687 "ldgram.y"
{ yyval.etree = exp_nameop(SIZEOF,yyvsp[-1].name); ;
    break;}
case 196:
#line 689 "ldgram.y"
{ yyval.etree = exp_nameop(ADDR,yyvsp[-1].name); ;
    break;}
case 197:
#line 691 "ldgram.y"
{ yyval.etree = exp_nameop(LOADADDR,yyvsp[-1].name); ;
    break;}
case 198:
#line 693 "ldgram.y"
{ yyval.etree = exp_unop(ABSOLUTE, yyvsp[-1].etree); ;
    break;}
case 199:
#line 695 "ldgram.y"
{ yyval.etree = exp_unop(ALIGN_K,yyvsp[-1].etree); ;
    break;}
case 200:
#line 697 "ldgram.y"
{ yyval.etree = exp_unop(ALIGN_K,yyvsp[-1].etree); ;
    break;}
case 201:
#line 699 "ldgram.y"
{ yyval.etree = exp_nameop(NAME,yyvsp[0].name); ;
    break;}
case 202:
#line 701 "ldgram.y"
{ yyval.etree = exp_binop (MAX, yyvsp[-3].etree, yyvsp[-1].etree ); ;
    break;}
case 203:
#line 703 "ldgram.y"
{ yyval.etree = exp_binop (MIN, yyvsp[-3].etree, yyvsp[-1].etree ); ;
    break;}
case 204:
#line 708 "ldgram.y"
{ yyval.etree = yyvsp[-1].etree; ;
    break;}
case 205:
#line 709 "ldgram.y"
{ yyval.etree = 0; ;
    break;}
case 206:
#line 712 "ldgram.y"
{ ldlex_expression(); ;
    break;}
case 207:
#line 714 "ldgram.y"
{ ldlex_popstate (); ldlex_script (); ;
    break;}
case 208:
#line 716 "ldgram.y"
{
			  lang_enter_output_section_statement(yyvsp[-5].name, yyvsp[-3].etree,
							      sectype,
							      0, 0, 0, yyvsp[-2].etree);
			;
    break;}
case 209:
#line 722 "ldgram.y"
{ ldlex_popstate (); ldlex_expression (); ;
    break;}
case 210:
#line 724 "ldgram.y"
{
		  ldlex_popstate ();
		  lang_leave_output_section_statement (yyvsp[0].integer, yyvsp[-2].name, yyvsp[-1].section_phdr);
		;
    break;}
case 212:
#line 730 "ldgram.y"
{ ldlex_expression (); ;
    break;}
case 213:
#line 732 "ldgram.y"
{ ldlex_popstate (); ldlex_script (); ;
    break;}
case 214:
#line 734 "ldgram.y"
{
			  lang_enter_overlay (yyvsp[-4].etree, yyvsp[-2].etree, (int) yyvsp[-3].integer);
			;
    break;}
case 215:
#line 739 "ldgram.y"
{ ldlex_popstate (); ldlex_expression (); ;
    break;}
case 216:
#line 741 "ldgram.y"
{
			  ldlex_popstate ();
			  lang_leave_overlay (yyvsp[0].integer, yyvsp[-2].name, yyvsp[-1].section_phdr);
			;
    break;}
case 218:
#line 750 "ldgram.y"
{ ldlex_expression (); ;
    break;}
case 219:
#line 752 "ldgram.y"
{
		  ldlex_popstate ();
		  lang_add_assignment (exp_assop ('=', ".", yyvsp[0].etree));
		;
    break;}
case 221:
#line 760 "ldgram.y"
{ sectype = noload_section; ;
    break;}
case 222:
#line 761 "ldgram.y"
{ sectype = dsect_section; ;
    break;}
case 223:
#line 762 "ldgram.y"
{ sectype = copy_section; ;
    break;}
case 224:
#line 763 "ldgram.y"
{ sectype = info_section; ;
    break;}
case 225:
#line 764 "ldgram.y"
{ sectype = overlay_section; ;
    break;}
case 227:
#line 769 "ldgram.y"
{ sectype = normal_section; ;
    break;}
case 228:
#line 770 "ldgram.y"
{ sectype = normal_section; ;
    break;}
case 229:
#line 774 "ldgram.y"
{ yyval.etree = yyvsp[-2].etree; ;
    break;}
case 230:
#line 775 "ldgram.y"
{ yyval.etree = (etree_type *)NULL;  ;
    break;}
case 231:
#line 780 "ldgram.y"
{ yyval.etree = yyvsp[-3].etree; ;
    break;}
case 232:
#line 782 "ldgram.y"
{ yyval.etree = yyvsp[-7].etree; ;
    break;}
case 233:
#line 786 "ldgram.y"
{ yyval.etree = yyvsp[-1].etree; ;
    break;}
case 234:
#line 787 "ldgram.y"
{ yyval.etree = (etree_type *) NULL;  ;
    break;}
case 235:
#line 792 "ldgram.y"
{ yyval.integer = 0; ;
    break;}
case 236:
#line 794 "ldgram.y"
{ yyval.integer = 1; ;
    break;}
case 237:
#line 799 "ldgram.y"
{ yyval.name = yyvsp[0].name; ;
    break;}
case 238:
#line 800 "ldgram.y"
{ yyval.name = "*default*"; ;
    break;}
case 239:
#line 805 "ldgram.y"
{
		  yyval.section_phdr = NULL;
		;
    break;}
case 240:
#line 809 "ldgram.y"
{
		  struct lang_output_section_phdr_list *n;

		  n = ((struct lang_output_section_phdr_list *)
		       xmalloc (sizeof *n));
		  n->name = yyvsp[0].name;
		  n->used = false;
		  n->next = yyvsp[-2].section_phdr;
		  yyval.section_phdr = n;
		;
    break;}
case 242:
#line 825 "ldgram.y"
{
			  ldlex_script ();
			  lang_enter_overlay_section (yyvsp[0].name);
			;
    break;}
case 243:
#line 830 "ldgram.y"
{ ldlex_popstate (); ldlex_expression (); ;
    break;}
case 244:
#line 832 "ldgram.y"
{
			  ldlex_popstate ();
			  lang_leave_overlay_section (yyvsp[0].integer, yyvsp[-1].section_phdr);
			;
    break;}
case 249:
#line 849 "ldgram.y"
{ ldlex_expression (); ;
    break;}
case 250:
#line 850 "ldgram.y"
{ ldlex_popstate (); ;
    break;}
case 251:
#line 852 "ldgram.y"
{
		  lang_new_phdr (yyvsp[-5].name, yyvsp[-3].etree, yyvsp[-2].phdr.filehdr, yyvsp[-2].phdr.phdrs, yyvsp[-2].phdr.at,
				 yyvsp[-2].phdr.flags);
		;
    break;}
case 252:
#line 860 "ldgram.y"
{
		  yyval.etree = yyvsp[0].etree;

		  if (yyvsp[0].etree->type.node_class == etree_name
		      && yyvsp[0].etree->type.node_code == NAME)
		    {
		      const char *s;
		      unsigned int i;
		      static const char * const phdr_types[] =
			{
			  "PT_NULL", "PT_LOAD", "PT_DYNAMIC",
			  "PT_INTERP", "PT_NOTE", "PT_SHLIB",
			  "PT_PHDR"
			};

		      s = yyvsp[0].etree->name.name;
		      for (i = 0;
			   i < sizeof phdr_types / sizeof phdr_types[0];
			   i++)
			if (strcmp (s, phdr_types[i]) == 0)
			  {
			    yyval.etree = exp_intop (i);
			    break;
			  }
		    }
		;
    break;}
case 253:
#line 890 "ldgram.y"
{
		  memset (&yyval.phdr, 0, sizeof (struct phdr_info));
		;
    break;}
case 254:
#line 894 "ldgram.y"
{
		  yyval.phdr = yyvsp[0].phdr;
		  if (strcmp (yyvsp[-2].name, "FILEHDR") == 0 && yyvsp[-1].etree == NULL)
		    yyval.phdr.filehdr = true;
		  else if (strcmp (yyvsp[-2].name, "PHDRS") == 0 && yyvsp[-1].etree == NULL)
		    yyval.phdr.phdrs = true;
		  else if (strcmp (yyvsp[-2].name, "FLAGS") == 0 && yyvsp[-1].etree != NULL)
		    yyval.phdr.flags = yyvsp[-1].etree;
		  else
		    einfo ("%X%P:%S: PHDRS syntax error at `%s'\n", yyvsp[-2].name);
		;
    break;}
case 255:
#line 906 "ldgram.y"
{
		  yyval.phdr = yyvsp[0].phdr;
		  yyval.phdr.at = yyvsp[-2].etree;
		;
    break;}
case 256:
#line 914 "ldgram.y"
{
		  yyval.etree = NULL;
		;
    break;}
case 257:
#line 918 "ldgram.y"
{
		  yyval.etree = yyvsp[-1].etree;
		;
    break;}
case 258:
#line 926 "ldgram.y"
{
		  ldlex_version_file ();
		  PUSH_ERROR ("VERSION script");
		;
    break;}
case 259:
#line 931 "ldgram.y"
{
		  ldlex_popstate ();
		  POP_ERROR ();
		;
    break;}
case 260:
#line 940 "ldgram.y"
{
		  ldlex_version_script ();
		;
    break;}
case 261:
#line 944 "ldgram.y"
{
		  ldlex_popstate ();
		;
    break;}
case 264:
#line 956 "ldgram.y"
{
		  lang_register_vers_node (yyvsp[-4].name, yyvsp[-2].versnode, NULL);
		;
    break;}
case 265:
#line 960 "ldgram.y"
{
		  lang_register_vers_node (yyvsp[-5].name, yyvsp[-3].versnode, yyvsp[-1].deflist);
		;
    break;}
case 266:
#line 967 "ldgram.y"
{
		  yyval.deflist = lang_add_vers_depend (NULL, yyvsp[0].name);
		;
    break;}
case 267:
#line 971 "ldgram.y"
{
		  yyval.deflist = lang_add_vers_depend (yyvsp[-1].deflist, yyvsp[0].name);
		;
    break;}
case 268:
#line 978 "ldgram.y"
{
		  yyval.versnode = lang_new_vers_node (NULL, NULL);
		;
    break;}
case 269:
#line 982 "ldgram.y"
{
		  yyval.versnode = lang_new_vers_node (yyvsp[-1].versyms, NULL);
		;
    break;}
case 270:
#line 986 "ldgram.y"
{
		  yyval.versnode = lang_new_vers_node (yyvsp[-1].versyms, NULL);
		;
    break;}
case 271:
#line 990 "ldgram.y"
{
		  yyval.versnode = lang_new_vers_node (NULL, yyvsp[-1].versyms);
		;
    break;}
case 272:
#line 994 "ldgram.y"
{
		  yyval.versnode = lang_new_vers_node (yyvsp[-5].versyms, yyvsp[-1].versyms);
		;
    break;}
case 273:
#line 1001 "ldgram.y"
{
		  yyval.versyms = lang_new_vers_regex (NULL, yyvsp[0].name);
		;
    break;}
case 274:
#line 1005 "ldgram.y"
{
		  yyval.versyms = lang_new_vers_regex (yyvsp[-2].versyms, yyvsp[0].name);
		;
    break;}
}
   /* the action file gets copied in in place of this dollarsign */
#line 498 "/usr/cygnus/progressive-97r2/share/bison.simple"

  yyvsp -= yylen;
  yyssp -= yylen;
#ifdef YYLSP_NEEDED
  yylsp -= yylen;
#endif

#if YYDEBUG != 0
  if (yydebug)
    {
      short *ssp1 = yyss - 1;
      fprintf (stderr, "state stack now");
      while (ssp1 != yyssp)
	fprintf (stderr, " %d", *++ssp1);
      fprintf (stderr, "\n");
    }
#endif

  *++yyvsp = yyval;

#ifdef YYLSP_NEEDED
  yylsp++;
  if (yylen == 0)
    {
      yylsp->first_line = yylloc.first_line;
      yylsp->first_column = yylloc.first_column;
      yylsp->last_line = (yylsp-1)->last_line;
      yylsp->last_column = (yylsp-1)->last_column;
      yylsp->text = 0;
    }
  else
    {
      yylsp->last_line = (yylsp+yylen-1)->last_line;
      yylsp->last_column = (yylsp+yylen-1)->last_column;
    }
#endif

  /* Now "shift" the result of the reduction.
     Determine what state that goes to,
     based on the state we popped back to
     and the rule number reduced by.  */

  yyn = yyr1[yyn];

  yystate = yypgoto[yyn - YYNTBASE] + *yyssp;
  if (yystate >= 0 && yystate <= YYLAST && yycheck[yystate] == *yyssp)
    yystate = yytable[yystate];
  else
    yystate = yydefgoto[yyn - YYNTBASE];

  goto yynewstate;

yyerrlab:   /* here on detecting error */

  if (! yyerrstatus)
    /* If not already recovering from an error, report this error.  */
    {
      ++yynerrs;

#ifdef YYERROR_VERBOSE
      yyn = yypact[yystate];

      if (yyn > YYFLAG && yyn < YYLAST)
	{
	  int size = 0;
	  char *msg;
	  int x, count;

	  count = 0;
	  /* Start X at -yyn if nec to avoid negative indexes in yycheck.  */
	  for (x = (yyn < 0 ? -yyn : 0);
	       x < (sizeof(yytname) / sizeof(char *)); x++)
	    if (yycheck[x + yyn] == x)
	      size += strlen(yytname[x]) + 15, count++;
	  msg = (char *) malloc(size + 15);
	  if (msg != 0)
	    {
	      strcpy(msg, "parse error");

	      if (count < 5)
		{
		  count = 0;
		  for (x = (yyn < 0 ? -yyn : 0);
		       x < (sizeof(yytname) / sizeof(char *)); x++)
		    if (yycheck[x + yyn] == x)
		      {
			strcat(msg, count == 0 ? ", expecting `" : " or `");
			strcat(msg, yytname[x]);
			strcat(msg, "'");
			count++;
		      }
		}
	      yyerror(msg);
	      free(msg);
	    }
	  else
	    yyerror ("parse error; also virtual memory exceeded");
	}
      else
#endif /* YYERROR_VERBOSE */
	yyerror("parse error");
    }

  goto yyerrlab1;
yyerrlab1:   /* here on error raised explicitly by an action */

  if (yyerrstatus == 3)
    {
      /* if just tried and failed to reuse lookahead token after an error, discard it.  */

      /* return failure if at end of input */
      if (yychar == YYEOF)
	YYABORT;

#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Discarding token %d (%s).\n", yychar, yytname[yychar1]);
#endif

      yychar = YYEMPTY;
    }

  /* Else will try to reuse lookahead token
     after shifting the error token.  */

  yyerrstatus = 3;		/* Each real token shifted decrements this */

  goto yyerrhandle;

yyerrdefault:  /* current state does not do anything special for the error token. */

#if 0
  /* This is wrong; only states that explicitly want error tokens
     should shift them.  */
  yyn = yydefact[yystate];  /* If its default is to accept any token, ok.  Otherwise pop it.*/
  if (yyn) goto yydefault;
#endif

yyerrpop:   /* pop the current state because it cannot handle the error token */

  if (yyssp == yyss) YYABORT;
  yyvsp--;
  yystate = *--yyssp;
#ifdef YYLSP_NEEDED
  yylsp--;
#endif

#if YYDEBUG != 0
  if (yydebug)
    {
      short *ssp1 = yyss - 1;
      fprintf (stderr, "Error: state stack now");
      while (ssp1 != yyssp)
	fprintf (stderr, " %d", *++ssp1);
      fprintf (stderr, "\n");
    }
#endif

yyerrhandle:

  yyn = yypact[yystate];
  if (yyn == YYFLAG)
    goto yyerrdefault;

  yyn += YYTERROR;
  if (yyn < 0 || yyn > YYLAST || yycheck[yyn] != YYTERROR)
    goto yyerrdefault;

  yyn = yytable[yyn];
  if (yyn < 0)
    {
      if (yyn == YYFLAG)
	goto yyerrpop;
      yyn = -yyn;
      goto yyreduce;
    }
  else if (yyn == 0)
    goto yyerrpop;

  if (yyn == YYFINAL)
    YYACCEPT;

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Shifting error token, ");
#endif

  *++yyvsp = yylval;
#ifdef YYLSP_NEEDED
  *++yylsp = yylloc;
#endif

  yystate = yyn;
  goto yynewstate;
}
#line 1010 "ldgram.y"

void
yyerror(arg) 
     const char *arg;
{ 
  if (ldfile_assumed_script)
    einfo ("%P:%s: file format not recognized; treating as linker script\n",
	   ldfile_input_filename);
  if (error_index > 0 && error_index < ERROR_NAME_MAX)
     einfo ("%P%F:%S: %s in %s\n", arg, error_names[error_index-1]);
  else
     einfo ("%P%F:%S: %s\n", arg);
}
