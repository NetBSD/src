#	$NetBSD: Makefile.inc,v 1.1 2002/01/22 16:55:20 mrg Exp $

DIST=           ${TOP}/dist/toolchain

.include "../../Makefile.inc"
