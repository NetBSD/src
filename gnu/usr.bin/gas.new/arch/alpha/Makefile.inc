#	$NetBSD: Makefile.inc,v 1.2 1999/02/04 23:25:07 tv Exp $

TARG_CPU_C=	tc-alpha.c
OBJ_FORMAT_C=	obj-elf.c
ATOF_TARG_C=	atof-ieee.c
