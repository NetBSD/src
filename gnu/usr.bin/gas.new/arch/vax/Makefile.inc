#	$NetBSD: Makefile.inc,v 1.2 1999/02/04 23:25:09 tv Exp $

TARG_CPU_C=	tc-vax.c
OBJ_FORMAT_C=	obj-aout.c
ATOF_TARG_C=	atof-vax.c
