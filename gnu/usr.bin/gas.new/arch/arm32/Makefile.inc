#	$NetBSD: Makefile.inc,v 1.3 1999/02/04 23:25:07 tv Exp $

TARG_CPU_C=	tc-arm.c
OBJ_FORMAT_C=	obj-aout.c
ATOF_TARG_C=	atof-ieee.c
