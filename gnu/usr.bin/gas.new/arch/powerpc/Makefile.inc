#	$NetBSD: Makefile.inc,v 1.1 1999/02/04 23:24:14 tv Exp $

TARG_CPU_C=	tc-ppc.c
OBJ_FORMAT_C=	obj-elf.c
ATOF_TARG_C=	atof-ieee.c
