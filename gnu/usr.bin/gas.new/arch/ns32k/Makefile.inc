#	$NetBSD: Makefile.inc,v 1.2 1999/02/04 23:25:08 tv Exp $

TARG_CPU_C=	tc-ns32k.c
OBJ_FORMAT_C=	obj-aout.c
ATOF_TARG_C=	atof-ieee.c
