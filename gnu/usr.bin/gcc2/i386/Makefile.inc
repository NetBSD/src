#
#	$Id: Makefile.inc,v 1.1 1993/08/13 10:56:44 cgd Exp $
#

CFLAGS+=	-DWORKING_FPE=0
