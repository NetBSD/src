/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.2 2007/02/19 18:26:22 chs Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

#include "version.h"
const char version[] = "6.5";
const char host_name[] = "mips64el--netbsd";
const char target_name[] = "mips64el--netbsd";
