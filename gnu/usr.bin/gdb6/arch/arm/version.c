/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.1 2006/05/29 19:10:58 nathanw Exp  */
/* Generated from: NetBSD: mknative.common,v 1.8 2006/05/26 19:17:21 mrg Exp  */

#include "version.h"
const char version[] = "6.4";
const char host_name[] = "arm--netbsdelf";
const char target_name[] = "arm--netbsdelf";
