/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD */
/* and from: NetBSD: mknative.common,v 1.6 2006/05/15 21:01:42 mrg Exp  */

#include "version.h"
const char version[] = "6.4";
const char host_name[] = "alpha--netbsd";
const char target_name[] = "alpha--netbsd";
