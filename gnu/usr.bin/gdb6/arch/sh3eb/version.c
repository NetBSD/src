/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.1 2006/05/29 19:10:58 nathanw Exp  */
/* Generated from: NetBSD: mknative.common,v 1.8.4.1 2007/03/06 20:37:28 bouyer Exp  */

#include "version.h"
const char version[] = "6.5";
const char host_name[] = "sh--netbsdelf";
const char target_name[] = "sh--netbsdelf";
