/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.1 2006/05/29 19:10:58 nathanw Exp  */
/* Generated from: NetBSD: mknative.common,v 1.8 2006/05/26 19:17:21 mrg Exp  */

#define BFD_VERSION_DATE 20060514
#define BFD_VERSION 217500000
#define BFD_VERSION_STRING "2.17.50 20060514"
