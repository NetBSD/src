/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gdb,v 1.2 2007/02/19 18:26:22 chs Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

#define BFD_VERSION_DATE 20060514
#define BFD_VERSION 217500000
#define BFD_VERSION_STRING "2.17.50 20060514"
