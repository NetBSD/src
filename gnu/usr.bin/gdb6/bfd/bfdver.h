#define BFD_VERSION_DATE 20051101
#define BFD_VERSION 216910000
#define BFD_VERSION_STRING "2.16.91 20051101"
