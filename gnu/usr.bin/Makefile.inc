#	$NetBSD: Makefile.inc,v 1.2.6.1 1997/11/08 06:52:46 lukem Exp $

BINDIR?=	/usr/bin
