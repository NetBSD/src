/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.11 2001/08/14 05:11:50 tv Exp  */

#include "tc-i386.h"
