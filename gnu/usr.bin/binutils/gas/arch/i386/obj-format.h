/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.4 2001/08/06 15:31:23 tv Exp  */

#include "obj-elf.h"
