/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.12 2001/08/14 05:17:59 tv Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf32ppc_emulation;
extern ld_emulation_xfer_type ld_elf32ppclinux_emulation;
extern ld_emulation_xfer_type ld_elf32ppcsim_emulation;

#define EMULATION_LIST \
  &ld_elf32ppc_emulation, \
  &ld_elf32ppclinux_emulation, \
  &ld_elf32ppcsim_emulation, \
  0
