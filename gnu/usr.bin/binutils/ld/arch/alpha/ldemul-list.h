/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.13 2001/12/05 22:37:40 rafal Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf64alpha_emulation;

#define EMULATION_LIST \
  &ld_elf64alpha_emulation, \
  0
