/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative,v 1.9 2003/02/07 01:52:54 lukem Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf32lmip_emulation;
extern ld_emulation_xfer_type ld_elf32bmip_emulation;

#define EMULATION_LIST \
  &ld_elf32lmip_emulation, \
  &ld_elf32bmip_emulation, \
  0
