/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.7 2001/08/06 23:26:28 tv Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf32_sparc_emulation;
extern ld_emulation_xfer_type ld_sparcnbsd_emulation;

#define EMULATION_LIST \
  &ld_elf32_sparc_emulation, \
  &ld_sparcnbsd_emulation, \
  0
