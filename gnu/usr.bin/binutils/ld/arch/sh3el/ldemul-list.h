/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative,v 1.5 2002/02/27 16:45:11 tv Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_shlelf_nbsd_emulation;
extern ld_emulation_xfer_type ld_shelf_nbsd_emulation;

#define EMULATION_LIST \
  &ld_shlelf_nbsd_emulation, \
  &ld_shelf_nbsd_emulation, \
  0
