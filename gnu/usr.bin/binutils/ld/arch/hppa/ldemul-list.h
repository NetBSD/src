/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_hppanbsd_emulation;

#define EMULATION_LIST \
  &ld_hppanbsd_emulation, \
  0
