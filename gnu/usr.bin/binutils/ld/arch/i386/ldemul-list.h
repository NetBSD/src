/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.11 2001/08/14 05:11:50 tv Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf_i386_emulation;
extern ld_emulation_xfer_type ld_i386nbsd_emulation;

#define EMULATION_LIST \
  &ld_elf_i386_emulation, \
  &ld_i386nbsd_emulation, \
  0
