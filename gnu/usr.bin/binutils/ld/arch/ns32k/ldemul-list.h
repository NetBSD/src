/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-binutils,v 1.3 2003/12/04 14:38:00 mrg Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_ns32knbsd_emulation;

#define EMULATION_LIST \
  &ld_ns32knbsd_emulation, \
  0
