/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.12 2001/08/14 05:17:59 tv Exp  */

/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_elf64_sparc_emulation;
extern ld_emulation_xfer_type ld_elf32_sparc_emulation;
extern ld_emulation_xfer_type ld_sparcnbsd_emulation;

#define EMULATION_LIST \
  &ld_elf64_sparc_emulation, \
  &ld_elf32_sparc_emulation, \
  &ld_sparcnbsd_emulation, \
  0
