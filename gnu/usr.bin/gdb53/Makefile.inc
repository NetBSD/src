# $NetBSD: Makefile.inc,v 1.1 2003/09/26 17:51:18 christos Exp $

USE_LIBEDIT=yes
USE_TUI=no
