/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.14 2002/01/22 13:13:00 mrg Exp  */

#include "version.h"
const char version[] = "5.3nb1";
const char host_name[] = "i386--netbsdelf";
const char target_name[] = "i386--netbsdelf";
