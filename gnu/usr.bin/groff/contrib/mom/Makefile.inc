# $NetBSD: Makefile.inc,v 1.4 2010/01/26 15:11:56 wiz Exp $

# $FreeBSD: src/gnu/usr.bin/groff/contrib/Makefile.inc,v 1.1 2001/04/17 12:36:32 ru Exp $

#DIST_SUBDIR=	contrib/mom

.include "../Makefile.inc"
