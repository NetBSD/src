# $NetBSD: Makefile.inc,v 1.3 2003/06/30 18:47:41 wiz Exp $

# $FreeBSD: src/gnu/usr.bin/groff/contrib/Makefile.inc,v 1.1 2001/04/17 12:36:32 ru Exp $

#DIST_SUBDIR=	contrib

.include "../Makefile.inc"
