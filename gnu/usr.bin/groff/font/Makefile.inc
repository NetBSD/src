# $NetBSD: Makefile.inc,v 1.3 2003/06/30 18:47:42 wiz Exp $

# $FreeBSD: src/gnu/usr.bin/groff/font/Makefile.inc,v 2.1 2001/04/17 12:36:42 ru Exp $

.include "../Makefile.inc"
