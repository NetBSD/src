# $NetBSD: Makefile.inc,v 1.3 2003/06/30 18:47:49 wiz Exp $

# $FreeBSD: src/gnu/usr.bin/groff/src/libs/Makefile.inc,v 1.1 2001/04/17 12:37:08 ru Exp $

.include "../../Makefile.inc"
