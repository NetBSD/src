/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.3 2001/07/24 19:39:52 tv Exp  */

#ifdef IN_GCC
#include "auto-host.h"
#endif
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "arm/xm-arm.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
#ifdef IN_GCC
#include "hwint.h"
#endif
