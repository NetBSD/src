/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.3 2001/07/24 19:39:52 tv Exp  */

#include "cp/cp-tree.def"
#include "objc/objc-tree.def"
