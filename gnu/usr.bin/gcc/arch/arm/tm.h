/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.3 2001/07/24 19:39:52 tv Exp  */

#define TARGET_CPU_DEFAULT (TARGET_CPU_generic)
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "arm/netbsd-elf.h"
#endif
