#include "ns32k/netbsd.h"