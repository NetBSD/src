#include "ns32k/xm-netbsd.h"