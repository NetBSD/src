/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative,v 1.5 2002/02/27 16:45:11 tv Exp  */

#include "cp/lang-specs.h"
#include "f/lang-specs.h"
#include "objc/lang-specs.h"
