/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.1 2001/06/18 16:07:07 tv Exp  */

#ifdef IN_GCC
#include "auto-host.h"
#endif
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "sparc/xm-sp64.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
#ifdef IN_GCC
#include "xm-target64.h"
#endif
#ifdef IN_GCC
#include "hwint.h"
#endif
