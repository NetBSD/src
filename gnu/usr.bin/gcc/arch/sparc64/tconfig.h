/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.12 2001/08/14 05:17:59 tv Exp  */

#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "sparc/xm-sp64.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
