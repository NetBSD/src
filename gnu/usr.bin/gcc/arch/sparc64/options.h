/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.1 2001/06/18 16:07:07 tv Exp  */

#include "cp/lang-options.h"
#include "f/lang-options.h"
