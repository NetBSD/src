/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.7 2001/08/06 23:26:28 tv Exp  */

#define TARGET_CPU_DEFAULT (TARGET_CPU_sparc64)
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "sparc/netbsd64.h"
#endif
