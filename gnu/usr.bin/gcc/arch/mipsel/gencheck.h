/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.1 2001/06/18 16:07:07 tv Exp  */

#include "cp/cp-tree.def"
#include "objc/objc-tree.def"
