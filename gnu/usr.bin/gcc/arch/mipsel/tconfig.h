/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.1 2001/06/18 16:07:07 tv Exp  */

#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "mips/xm-mips.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
