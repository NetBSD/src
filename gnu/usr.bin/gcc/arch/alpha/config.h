/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.13 2001/12/05 22:37:40 rafal Exp  */

#ifdef IN_GCC
#include "auto-host.h"
#endif
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "alpha/xm-alpha.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
#ifdef IN_GCC
#include "xm-target64.h"
#endif
#ifdef IN_GCC
#include "hwint.h"
#endif
