/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.13 2001/12/05 22:37:40 rafal Exp  */

#define TARGET_CPU_DEFAULT ((MASK_GAS|MASK_GAS))
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "alpha/netbsd.h"
#endif
