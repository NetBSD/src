/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD */

#include "cp/cp-tree.def"
#include "objc/objc-tree.def"
