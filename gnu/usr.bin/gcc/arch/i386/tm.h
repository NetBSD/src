/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.14 2002/01/22 13:13:00 mrg Exp  */

#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "i386/netbsd-elf.h"
#endif
