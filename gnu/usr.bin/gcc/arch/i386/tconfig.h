/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD */

#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "i386/xm-i386.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
