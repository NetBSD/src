/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.14 2002/01/22 13:13:00 mrg Exp  */

#include "cp/lang-specs.h"
#include "f/lang-specs.h"
#include "objc/lang-specs.h"
