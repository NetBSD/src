#include "arm32/xm-netbsd.h"