/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.12 2001/08/14 05:17:59 tv Exp  */

#define TARGET_CPU_DEFAULT (MASK_68020|MASK_68881|MASK_BITFIELD)
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "m68k/netbsd-elf.h"
#endif
