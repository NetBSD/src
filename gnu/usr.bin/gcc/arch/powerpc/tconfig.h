/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.7 2001/08/06 23:26:28 tv Exp  */

#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "rs6000/xm-sysv4.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
