/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.12 2001/08/14 05:17:59 tv Exp  */

#ifdef IN_GCC
#include "auto-host.h"
#endif
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "rs6000/xm-sysv4.h"
#endif
#ifdef IN_GCC
#include "xm-netbsd.h"
#endif
#ifdef IN_GCC
#include "hwint.h"
#endif
