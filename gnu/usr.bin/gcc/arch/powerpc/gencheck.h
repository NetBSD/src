/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.2 2001/07/18 18:17:20 tv Exp  */

#include "cp/cp-tree.def"
#include "objc/objc-tree.def"
