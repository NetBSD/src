/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.2 2001/07/18 18:17:20 tv Exp  */

#define TARGET_CPU_DEFAULT (TARGET_CPU_sparc)
#ifdef IN_GCC
#include "gansidecl.h"
#endif
#ifdef IN_GCC
#include "sparc/netbsd-elf.h"
#endif
