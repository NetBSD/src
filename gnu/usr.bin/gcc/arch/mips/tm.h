#include "mips/netbsd.h"