#include "mips/xm-netbsd.h"