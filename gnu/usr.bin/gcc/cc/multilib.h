#define MULTILIB_SELECT ". ;"
