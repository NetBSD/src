/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.45 2009/12/17 15:48:13 uebayasi Exp  */
/* Generated from: NetBSD: mknative.common,v 1.9 2007/02/05 18:26:01 apb Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../gnu/dist/gcc4/configure --target=alpha--netbsd --enable-long-long --enable-threads --enable-__cxa_atexit --disable-multilib --disable-symvers --build=x86_64-unknown-netbsd5.0. --host=alpha--netbsd";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
