/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.17 2006/05/15 22:03:03 mrg Exp  */
/* and from: NetBSD: mknative.common,v 1.7 2006/05/17 03:27:19 mrg Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/usr/src/tools/gcc/../../gnu/dist/gcc4/configure --enable-long-long --disable-multilib --enable-threads --disable-symvers --enable-newlib --build=i386-unknown-netbsdelf3.99.17 --host=sh--netbsdelf --target=sh--netbsdelf";
static const char thread_model[] = "posix";

static const struct {
  const char *name, *value;
} configure_default_options[] = { { NULL, NULL} };
