/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.18 2006/05/23 10:55:55 mrg Exp  */
/* Generated from: NetBSD: mknative.common,v 1.7 2006/05/17 03:27:19 mrg Exp  */

#include "gthr-posix.h"
