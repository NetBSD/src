/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.16 2006/05/12 02:12:37 mrg Exp  */
/* and from: NetBSD: mknative.common,v 1.6 2006/05/15 21:01:42 mrg Exp  */

#ifndef GCC_CONFIG_H
#define GCC_CONFIG_H
#include "auto-host.h"
#ifdef IN_GCC
# include "ansidecl.h"
#endif
#endif /* GCC_CONFIG_H */
