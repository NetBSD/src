/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.17 2006/05/15 22:03:03 mrg Exp  */
/* and from: NetBSD: mknative.common,v 1.7 2006/05/17 03:27:19 mrg Exp  */

#include "gthr-posix.h"
