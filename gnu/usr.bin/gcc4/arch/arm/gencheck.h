/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.17 2006/05/15 22:03:03 mrg Exp  */
/* and from: NetBSD: mknative.common,v 1.6 2006/05/15 21:01:42 mrg Exp  */

#include "cp/cp-tree.def"
#include "objc/objc-tree.def"
