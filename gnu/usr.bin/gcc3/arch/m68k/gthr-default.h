/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.6 2003/08/01 02:44:56 mrg Exp  */

#include "gthr-posix.h"
