/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.11 2004/01/02 11:58:32 skrll Exp  */

#include "gthr-posix.h"
