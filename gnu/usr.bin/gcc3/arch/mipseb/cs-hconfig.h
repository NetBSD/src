/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.1 2003/07/25 16:26:53 mrg Exp  */

timestamp
