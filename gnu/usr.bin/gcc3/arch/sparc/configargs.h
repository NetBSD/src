/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.12 2004/02/10 09:37:58 skrll Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/home/mrg/src/netbsd/rosrc/tools/gcc/../../gnu/dist/gcc/configure --enable-long-long --disable-multilib --enable-threads --build=i386-unknown-netbsdelf --host=sparc--netbsdelf --target=sparc--netbsdelf";
static const char thread_model[] = "posix";
