/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.12 2004/02/10 09:37:58 skrll Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/s1/netbsd/current/tools/gcc/../../gnu/dist/gcc/configure --enable-long-long --disable-multilib --enable-threads --disable-symvers --build=i386-unknown-netbsdelf --host=sh5le--netbsd --target=sh5le--netbsd";
static const char thread_model[] = "posix";
