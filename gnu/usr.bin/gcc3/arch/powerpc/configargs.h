/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.5 2003/07/30 05:10:06 mrg Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/home/mrg/src/netbsd/src/tools/gcc/../../gnu/dist/gcc/configure --disable-multilib --enable-threads --build=i386-unknown-netbsdelf --host=powerpc--netbsd --target=powerpc--netbsd";
static const char thread_model[] = "posix";
