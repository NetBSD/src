/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.5 2003/07/30 05:10:06 mrg Exp  */

timestamp
