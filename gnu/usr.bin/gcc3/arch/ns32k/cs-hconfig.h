/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.10 2003/11/27 10:21:24 mrg Exp  */

timestamp
