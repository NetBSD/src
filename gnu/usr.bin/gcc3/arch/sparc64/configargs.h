/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.1 2003/07/25 16:26:53 mrg Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/home/mrg/src/netbsd/src/tools/gcc/../../gnu/dist/gcc/configure --build=i386-unknown-netbsdelf --host=sparc64--netbsd --target=sparc64--netbsd : (reconfigured) /home/mrg/src/netbsd/src/tools/gcc/../../gnu/dist/gcc/configure --build=i386-unknown-netbsdelf1.6U --host=sparc64--netbsd --target=sparc64--netbsd";
static const char thread_model[] = "single";
