/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.11 2004/01/02 11:58:32 skrll Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/home/nick/work/netbsd/src/tools/gcc/../../gnu/dist/gcc/configure --enable-long-long --disable-multilib --enable-threads --disable-symvers --build=i386-unknown-netbsdelf --host=hppa--netbsd --target=hppa--netbsd";
static const char thread_model[] = "posix";
