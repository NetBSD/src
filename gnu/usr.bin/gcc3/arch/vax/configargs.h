/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.20 2006/06/09 15:30:52 skrll Exp  */
/* Generated from: NetBSD: mknative.common,v 1.8 2006/05/26 19:17:21 mrg Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/home/nick/work/netbsd/src/tools/gcc/../../gnu/dist/gcc/configure --enable-long-long --disable-multilib --enable-threads --disable-symvers --build=i386-unknown-netbsdelf3.99.20 --host=vax--netbsdelf --target=vax--netbsdelf";
static const char thread_model[] = "posix";
