/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative-gcc,v 1.11 2004/01/02 11:58:32 skrll Exp  */

/* Generated automatically. */
static const char configuration_arguments[] = "/home/mrg/src/netbsd/rosrc/tools/gcc/../../gnu/dist/gcc/configure --enable-long-long --disable-multilib --enable-threads --build=i386-unknown-netbsdelf --host=arm--netbsdelf --target=arm--netbsdelf : (reconfigured) /home/mrg/src/netbsd/rosrc/tools/gcc/../../gnu/dist/gcc/configure --enable-long-long --disable-multilib --enable-threads --build=i386-unknown-netbsdelf1.6ZF --host=arm--netbsdelf --target=arm--netbsdelf";
static const char thread_model[] = "posix";
