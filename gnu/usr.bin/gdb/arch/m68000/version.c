/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.12 2001/08/14 05:17:59 tv Exp  */

#include "version.h"
const char version[] = "5.0nb1";
const char host_name[] = "m68010--netbsdelf";
const char target_name[] = "m68010--netbsdelf";
