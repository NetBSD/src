/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.11 2001/08/14 05:11:50 tv Exp  */

#include "version.h"
const char version[] = "5.0-nb1";
const char host_name[] = "i386-unknown-netbsdelf";
const char target_name[] = "i386-unknown-netbsdelf";
