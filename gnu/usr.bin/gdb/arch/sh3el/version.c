/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: mknative,v 1.7 2002/02/27 17:55:32 tv Exp  */

#include "version.h"
const char version[] = "5.0nb1";
const char host_name[] = "shle--netbsdelf";
const char target_name[] = "shle--netbsdelf";
