/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.13 2001/12/05 22:37:40 rafal Exp  */

#include <alpha/xm-nbsd.h>
