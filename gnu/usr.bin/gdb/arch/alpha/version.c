/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.13 2001/12/05 22:37:40 rafal Exp  */

#include "version.h"
const char version[] = "5.0nb1";
const char host_name[] = "alpha-unknown-netbsd";
const char target_name[] = "alpha-unknown-netbsd";
