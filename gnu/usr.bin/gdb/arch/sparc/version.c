/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.7 2001/08/06 23:26:28 tv Exp  */

#include "version.h"
const char version[] = "5.0-nb1";
const char host_name[] = "sparc-unknown-netbsdelf";
const char target_name[] = "sparc-unknown-netbsdelf";
