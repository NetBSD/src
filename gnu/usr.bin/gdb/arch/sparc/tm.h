/* This file is automatically generated.  DO NOT EDIT! */
/* Generated from: 	NetBSD: toolchain2netbsd,v 1.7 2001/08/06 23:26:28 tv Exp  */

#include <sparc/tm-nbsd.h>
