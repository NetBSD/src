# $Id: Makefile.inc,v 1.1 1994/01/28 12:41:59 pk Exp $

SRCS+=	sparc-pinsn.c sparc-tdep.c sparc-nat.c sparc-dis.c sparc-opc.c

