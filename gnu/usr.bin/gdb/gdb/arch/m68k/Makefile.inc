# $Id: Makefile.inc,v 1.3 1995/04/16 03:07:47 gwr Exp $

SRCS+=	m68k-pinsn.c m68k-tdep.c m68k-dis.c m68881-ext.c m68k-nat.c

