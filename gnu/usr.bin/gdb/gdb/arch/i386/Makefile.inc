# $Id: Makefile.inc,v 1.2 1995/08/06 20:38:41 mycroft Exp $

SRCS+=	i386-pinsn.c i386-tdep.c i386-dis.c i386b-nat.c

