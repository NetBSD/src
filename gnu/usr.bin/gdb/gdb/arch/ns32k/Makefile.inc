# $Id: Makefile.inc,v 1.4 1996/09/28 08:41:24 matthias Exp $

CFLAGS+= -DNS32532 -DNS32381
SRCS+=	ns32k-pinsn.c ns32k-tdep.c ns32k-nat.c

